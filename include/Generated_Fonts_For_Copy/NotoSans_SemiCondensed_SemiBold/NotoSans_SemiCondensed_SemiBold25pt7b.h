#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x27, 0xF7, 0xF7, 0xB1,
  0x98, 0xCC, 0x66, 0x33, 0x19, 0x8C, 0x0E, 0x60, 0x63, 0x03, 0x18, 0x18,
  0xC0, 0xCE, 0x7F, 0xFF, 0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x71,
  0xFF, 0xEF, 0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x33, 0x83, 0x98, 0x00,
  0x04, 0x00, 0x80, 0x7F, 0x3F, 0xF7, 0xFD, 0xC8, 0x39, 0x07, 0xA0, 0x7C,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x4E, 0x09, 0xE1, 0x3F, 0xFF, 0xFF, 0xC7,
  0xE0, 0x10, 0x02, 0x00, 0x3C, 0x0E, 0x0F, 0xC1, 0x83, 0x98, 0x70, 0x63,
  0x0C, 0x0C, 0x63, 0x81, 0x8C, 0x60, 0x31, 0x9C, 0x06, 0x33, 0x3C, 0xE6,
  0xEF, 0xCF, 0xD9, 0x98, 0xF7, 0x73, 0x00, 0xCE, 0x70, 0x39, 0xCE, 0x06,
  0x39, 0xC1, 0xC7, 0x38, 0x30, 0xE6, 0x0E, 0x0F, 0xC1, 0x80, 0xF0, 0x1F,
  0x80, 0x3F, 0xC0, 0x3B, 0xC0, 0x71, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x3B,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x7F, 0x0E, 0x77, 0x9C, 0xE3, 0xDC, 0xE1,
  0xFC, 0xE0, 0xF8, 0xE0, 0x70, 0xFB, 0xF8, 0x7F, 0xDC, 0x3F, 0x9F, 0xF6,
  0x66, 0x66, 0x60, 0x1C, 0x63, 0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x18, 0x71, 0xC3, 0x0E, 0x18, 0x70, 0xE1, 0x87, 0x0C, 0x38,
  0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x1C, 0x63,
  0x80, 0x0E, 0x01, 0xC0, 0x30, 0x66, 0x6F, 0xFF, 0xFF, 0xC7, 0x81, 0xF8,
  0x3B, 0x8E, 0x78, 0x44, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1,
  0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x77, 0x7E,
  0xEC, 0xFF, 0xFF, 0xC0, 0x27, 0xF7, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x38, 0x00, 0x1F, 0x07, 0xF1, 0xEF, 0x38, 0xEE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xDC, 0x73, 0xDE, 0x3F, 0x83, 0xE0, 0x0E, 0x3C, 0xFB, 0xFE, 0xF9, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0x0F,
  0xFB, 0xFF, 0x30, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x1F, 0xF9, 0xFF, 0x20, 0xF0, 0x0E, 0x03, 0x80, 0x70, 0x7C, 0x3E, 0x07,
  0xF0, 0x0F, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x7F, 0x1E, 0xFF, 0xDF, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x6E, 0x07, 0x70, 0x33, 0x83,
  0x9C, 0x18, 0xE1, 0x87, 0x1C, 0x38, 0xC1, 0xCF, 0xFF, 0xFF, 0xFC, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xFC, 0x7F, 0xCC, 0x78, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x7F, 0x3E, 0xFF, 0x8F, 0xE0, 0x07, 0xC3, 0xF8, 0xFD, 0x3C,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0x7C, 0xFF, 0xDE, 0x3F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xDC, 0x3B, 0xCF, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x1F, 0x0F, 0xF9,
  0xE7, 0x70, 0x7E, 0x0E, 0xE1, 0xDC, 0x71, 0xFC, 0x1F, 0x07, 0xF1, 0xEF,
  0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0, 0x1F, 0x0F,
  0xF1, 0xEF, 0x78, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xEF, 0xFD,
  0xFB, 0x8C, 0x70, 0x0E, 0x03, 0x80, 0x72, 0x7C, 0x7F, 0x0F, 0xC0, 0x67,
  0xF7, 0x00, 0x00, 0x00, 0x27, 0xF7, 0x67, 0xF7, 0x00, 0x00, 0x00, 0x07,
  0x77, 0xEE, 0xC0, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x3C,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x78, 0x3E, 0x1F, 0x1F, 0x83, 0xC0, 0x40, 0x00, 0x3F,
  0x3F, 0xE7, 0xFD, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x00, 0x00, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0x81, 0xE0, 0x70, 0xE0, 0x0E, 0x30, 0x01, 0x9C, 0x7F, 0x36,
  0x3F, 0xCD, 0x9C, 0x63, 0xE7, 0x18, 0xF9, 0x86, 0x3C, 0x61, 0x8F, 0x18,
  0x63, 0xE7, 0x39, 0xF8, 0xFB, 0xE6, 0x3E, 0xF1, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x01, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x37, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0x98, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0xE0, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0x07, 0x9C, 0x07, 0x38,
  0x0E, 0xF0, 0x1F, 0xC0, 0x1C, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEF, 0xFC, 0xFF, 0x8F, 0xFC, 0xE0, 0xEE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x07, 0xF0, 0xFF, 0xCF,
  0xFC, 0x78, 0x27, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xEE, 0x1F, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3B, 0x83, 0xDF, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x00, 0x07, 0xF8, 0x3F, 0xF3, 0xFF, 0x8F, 0x02, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xDC, 0x07, 0x70,
  0x1D, 0xE0, 0x77, 0x81, 0xCF, 0xCF, 0x1F, 0xFC, 0x3F, 0xE0, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xC0, 0xFF, 0xFD, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0xFF, 0xFC, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x7F, 0xFF, 0xBE, 0x00, 0xE0, 0x7F, 0x07, 0xB8, 0x39, 0xC3, 0x8E,
  0x3C, 0x73, 0xC3, 0x9C, 0x1D, 0xC0, 0xFE, 0x07, 0xF8, 0x3D, 0xC1, 0xCF,
  0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xF7, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0D, 0xFF, 0x07, 0x7E,
  0xC1, 0xDF, 0xB8, 0x67, 0xEE, 0x39, 0xF9, 0x8E, 0x7E, 0x73, 0x1F, 0x9C,
  0xC7, 0xE3, 0x71, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x87, 0x87, 0xE1, 0xC1,
  0xF8, 0x70, 0x70, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0x7E, 0xE1, 0xF9, 0xC7, 0xE7, 0x1F, 0x8E, 0x7E, 0x3D, 0xF8, 0x77,
  0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xF0, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC0, 0xE7, 0x01, 0xEE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00, 0xEE,
  0x03, 0xDE, 0x07, 0x1F, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0x1F, 0xF3,
  0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE3, 0xDF, 0xFB, 0xFE,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xC0, 0xE7, 0x01, 0xEE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00, 0xEE, 0x03,
  0xDE, 0x07, 0x1F, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFE, 0x07, 0xFE, 0x3F, 0xF1, 0xC3, 0xCE, 0x0E,
  0x70, 0x73, 0x83, 0x9C, 0x3C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC1, 0xC7, 0x0E,
  0x38, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xF7, 0x03, 0xC0, 0x1F, 0x8F,
  0xF9, 0xFF, 0x78, 0x2E, 0x01, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x77, 0xBE, 0xFF, 0x8F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC1, 0xEF, 0xBE, 0x3F, 0xE0, 0xFE, 0x00, 0xE0, 0x1F, 0x80, 0x77,
  0x01, 0xDC, 0x0E, 0x70, 0x38, 0xE0, 0xE3, 0x87, 0x0E, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0xCE, 0x07, 0x38, 0x0E, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xE0, 0x70, 0x1F, 0x81, 0xE0, 0xF7, 0x07, 0x83,
  0x9C, 0x1E, 0x0E, 0x70, 0xF8, 0x39, 0xC3, 0xF0, 0xE3, 0x8D, 0xC7, 0x0E,
  0x33, 0x1C, 0x39, 0xCC, 0x70, 0xE7, 0x39, 0xC3, 0x9C, 0xEE, 0x07, 0x63,
  0xB8, 0x1F, 0x86, 0xE0, 0x7E, 0x1B, 0x81, 0xF8, 0x7C, 0x03, 0xC1, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3D, 0xE0, 0xE3, 0x87, 0x0F,
  0x1C, 0x1C, 0xE0, 0x7B, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xFC, 0x03, 0xF0, 0x1C, 0xE0, 0x73, 0xC3, 0x87, 0x1E, 0x1E, 0x70, 0x3B,
  0xC0, 0xF0, 0xF0, 0x3D, 0xC0, 0xE7, 0x07, 0x0E, 0x1C, 0x38, 0xF0, 0x73,
  0x81, 0xDE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F,
  0xFC, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x70,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x3F, 0xFC, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1B, 0x83, 0x98, 0x31,
  0xC7, 0x0C, 0x60, 0xEE, 0x06, 0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3,
  0x87, 0x1F, 0x0F, 0xF8, 0xFF, 0x10, 0xE0, 0x0E, 0x01, 0xCF, 0xFB, 0xFF,
  0xF0, 0xFC, 0x1F, 0x87, 0xF9, 0xF7, 0xFE, 0xFD, 0xC0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xCE, 0x3F, 0xE7, 0xFE, 0xF1, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xDF, 0xFB, 0x3E, 0x00,
  0x0F, 0x8F, 0xF7, 0xF9, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x07, 0x01, 0xF2, 0x3F, 0x87, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0xE7, 0x3F, 0x77, 0xFF, 0x70, 0xFF, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xF7, 0x0F, 0x79, 0xF7, 0xF7, 0x3E, 0x70, 0x0F,
  0x07, 0xF1, 0xFF, 0x38, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x33, 0xFE, 0x3F, 0x80, 0x0F, 0x8F, 0xC7, 0x27, 0x03,
  0x81, 0xFB, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x00, 0x0E, 0x73, 0xF7, 0x7F, 0xF7, 0x0F, 0xF0,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0x70, 0xF7, 0x9F, 0x7F,
  0x73, 0xE7, 0x00, 0x70, 0x0E, 0x80, 0xE7, 0xFE, 0x7F, 0xC3, 0xF8, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xCE, 0x3F, 0xF7, 0xFE, 0xF1, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0x80, 0xDF, 0xA1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x71,
  0xC2, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x7F, 0xFE, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC1, 0xF8, 0x77, 0x1C, 0xE7, 0x9D, 0xE3, 0xB8, 0x7F, 0x0F, 0xE1, 0xEE,
  0x39, 0xC7, 0x1C, 0xE3, 0xDC, 0x3B, 0x83, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xC7, 0x0F, 0x37, 0xF7, 0xEF, 0xFF, 0xFF, 0xC7,
  0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1,
  0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x70,
  0xC7, 0x1B, 0xFB, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x0F, 0x03, 0xFC, 0x7F,
  0xE7, 0x0E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70,
  0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0xC7, 0x1F, 0xFB, 0xFF, 0x78, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF9, 0xEF, 0xFD, 0xDF,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x73, 0xF7,
  0x7F, 0xF7, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0x70, 0xF7, 0x9F, 0x7F, 0x73, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0xC7, 0xCF, 0xFE, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x3F, 0xFF, 0xDC, 0x0E, 0x07, 0xC1,
  0xF8, 0x7E, 0x0F, 0x81, 0xC0, 0xF8, 0xFF, 0xF7, 0xF0, 0x18, 0x0C, 0x06,
  0x07, 0xEF, 0xF7, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xF2, 0x3F, 0x1F, 0x80, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF9, 0xFF, 0xFE, 0xFD,
  0xC0, 0xE0, 0x7F, 0x07, 0x70, 0x77, 0x0E, 0x70, 0xE3, 0x8E, 0x39, 0xC3,
  0x9C, 0x1D, 0xC1, 0xD8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0xE0, 0xE0,
  0xEE, 0x1E, 0x1D, 0xC7, 0xC7, 0x38, 0xD8, 0xE7, 0x1B, 0x1C, 0x63, 0x63,
  0x8E, 0xEE, 0xE1, 0xDC, 0xDC, 0x3B, 0x1B, 0x83, 0x63, 0x70, 0x6C, 0x6C,
  0x0F, 0x8F, 0x81, 0xE0, 0xF0, 0x1C, 0x1C, 0x00, 0xF0, 0x77, 0x0F, 0x38,
  0xE3, 0x9C, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x81, 0xFC, 0x3D,
  0xC3, 0x8E, 0x70, 0xEF, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0x77, 0x0E, 0x70,
  0xE3, 0x8E, 0x39, 0xC1, 0x9C, 0x1D, 0xC1, 0xD8, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x1C, 0x1C,
  0x0F, 0xFF, 0xFC, 0x03, 0x0F, 0x0F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0xF8, 0xF8, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1F, 0x0F, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xE0, 0x30, 0x3F, 0xCF,
  0xFF, 0xC1, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 18, 7, 1, -18 },
  { 10, 9, 7, 11, 1, -18 },
  { 18, 13, 18, 15, 1, -18 },
  { 48, 11, 20, 13, 1, -19 },
  { 76, 19, 18, 21, 1, -18 },
  { 119, 16, 18, 17, 1, -18 },
  { 155, 4, 7, 6, 1, -18 },
  { 159, 6, 22, 8, 1, -18 },
  { 176, 6, 22, 8, 1, -18 },
  { 193, 11, 11, 13, 1, -19 },
  { 209, 11, 12, 13, 1, -15 },
  { 226, 4, 6, 7, 1, -3 },
  { 229, 6, 3, 8, 1, -8 },
  { 232, 4, 4, 7, 1, -4 },
  { 234, 10, 18, 10, 0, -18 },
  { 257, 11, 18, 13, 1, -18 },
  { 282, 7, 18, 13, 2, -18 },
  { 298, 11, 18, 13, 1, -18 },
  { 323, 11, 18, 13, 1, -18 },
  { 348, 13, 18, 13, 0, -18 },
  { 378, 11, 18, 13, 1, -18 },
  { 403, 11, 18, 13, 1, -18 },
  { 428, 11, 18, 13, 1, -18 },
  { 453, 11, 18, 13, 1, -18 },
  { 478, 11, 18, 13, 1, -18 },
  { 503, 4, 14, 7, 1, -14 },
  { 510, 4, 17, 7, 1, -14 },
  { 519, 11, 12, 13, 1, -15 },
  { 536, 11, 7, 13, 1, -12 },
  { 546, 11, 12, 13, 1, -15 },
  { 563, 10, 18, 11, 0, -18 },
  { 586, 18, 20, 21, 1, -18 },
  { 631, 15, 18, 15, 0, -18 },
  { 665, 12, 18, 15, 2, -18 },
  { 692, 13, 18, 14, 1, -18 },
  { 722, 13, 18, 17, 2, -18 },
  { 752, 9, 18, 13, 2, -18 },
  { 773, 9, 18, 12, 2, -18 },
  { 794, 14, 18, 17, 1, -18 },
  { 826, 13, 18, 17, 2, -18 },
  { 856, 7, 18, 9, 1, -18 },
  { 872, 7, 23, 7, -2, -18 },
  { 893, 13, 18, 15, 2, -18 },
  { 923, 10, 18, 12, 2, -18 },
  { 946, 18, 18, 22, 2, -18 },
  { 987, 14, 18, 18, 2, -18 },
  { 1019, 15, 18, 18, 1, -18 },
  { 1053, 11, 18, 14, 2, -18 },
  { 1078, 15, 22, 18, 1, -18 },
  { 1120, 13, 18, 15, 2, -18 },
  { 1150, 11, 18, 13, 1, -18 },
  { 1175, 12, 18, 13, 0, -18 },
  { 1202, 13, 18, 17, 2, -18 },
  { 1232, 14, 18, 14, 0, -18 },
  { 1264, 22, 18, 22, 0, -18 },
  { 1314, 14, 18, 14, 0, -18 },
  { 1346, 14, 18, 14, 0, -18 },
  { 1378, 11, 18, 13, 1, -18 },
  { 1403, 5, 22, 8, 2, -18 },
  { 1417, 10, 18, 10, 0, -18 },
  { 1440, 5, 22, 8, 1, -18 },
  { 1454, 12, 11, 14, 1, -18 },
  { 1471, 11, 2, 11, 0, 2 },
  { 1474, 6, 4, 8, 1, -19 },
  { 1477, 11, 14, 13, 1, -14 },
  { 1497, 11, 19, 14, 2, -19 },
  { 1524, 10, 14, 11, 1, -14 },
  { 1542, 12, 19, 14, 1, -19 },
  { 1571, 11, 14, 13, 1, -14 },
  { 1591, 9, 19, 8, 0, -19 },
  { 1613, 12, 20, 14, 1, -14 },
  { 1643, 11, 19, 15, 2, -19 },
  { 1670, 3, 19, 7, 2, -19 },
  { 1678, 6, 25, 7, -1, -19 },
  { 1697, 11, 19, 13, 2, -19 },
  { 1724, 3, 19, 7, 2, -19 },
  { 1732, 18, 14, 22, 2, -14 },
  { 1764, 11, 14, 15, 2, -14 },
  { 1784, 12, 14, 14, 1, -14 },
  { 1805, 11, 20, 14, 2, -14 },
  { 1833, 12, 20, 14, 1, -14 },
  { 1863, 8, 14, 10, 2, -14 },
  { 1877, 9, 14, 11, 1, -14 },
  { 1893, 9, 17, 9, 0, -17 },
  { 1913, 11, 14, 15, 2, -14 },
  { 1933, 12, 14, 12, 0, -14 },
  { 1954, 19, 14, 19, 0, -14 },
  { 1988, 12, 14, 13, 0, -14 },
  { 2009, 12, 20, 13, 0, -14 },
  { 2039, 9, 14, 11, 1, -14 },
  { 2055, 8, 22, 9, 0, -18 },
  { 2077, 3, 25, 13, 5, -19 },
  { 2087, 8, 22, 9, 1, -18 },
  { 2109, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD25PT7B_H_
