#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x60, 0x06, 0xFE, 0xE7, 0xCF, 0x9B,
  0x36, 0x6C, 0xC0, 0x06, 0x60, 0x46, 0x0C, 0x60, 0xCC, 0x0C, 0xC7, 0xFF,
  0x7F, 0xF0, 0x8C, 0x18, 0x81, 0x98, 0xFF, 0xFF, 0xFF, 0x19, 0x81, 0x18,
  0x33, 0x03, 0x30, 0x08, 0x02, 0x03, 0xF1, 0xFE, 0xE9, 0xBA, 0x0E, 0x83,
  0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x27, 0x09, 0xF2, 0xEF, 0xF9, 0xF8, 0x08,
  0x02, 0x00, 0x78, 0x18, 0x7C, 0x30, 0xCC, 0x30, 0xCC, 0x60, 0xCC, 0x60,
  0xCC, 0xC0, 0xCC, 0xCC, 0xCD, 0x9E, 0x7D, 0xB3, 0x3B, 0x33, 0x03, 0x33,
  0x06, 0x33, 0x06, 0x33, 0x0C, 0x33, 0x0C, 0x3F, 0x18, 0x1E, 0x1E, 0x00,
  0xFC, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x03, 0xF0, 0x0F, 0x00,
  0x7E, 0x3B, 0xDC, 0xCE, 0x7F, 0x38, 0xFC, 0xE1, 0xE3, 0xC7, 0x87, 0xFF,
  0x0F, 0xCF, 0xFF, 0xB6, 0xC0, 0x19, 0xCC, 0xE6, 0x33, 0x9C, 0xC6, 0x31,
  0x8E, 0x71, 0x8C, 0x71, 0x8E, 0xC7, 0x18, 0xE3, 0x18, 0xE7, 0x18, 0xC6,
  0x33, 0x9C, 0xC6, 0x73, 0x38, 0x1C, 0x0E, 0x07, 0x19, 0x3F, 0xF8, 0xE0,
  0xF8, 0x6C, 0x77, 0x11, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x76, 0xEE, 0xCC, 0xFF, 0xC0,
  0x6F, 0xE0, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0x81, 0xC0, 0x1E, 0x1F, 0xC7, 0x7B,
  0x8E, 0xE1, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE1,
  0x9C, 0xE7, 0xF0, 0xF8, 0x06, 0x3C, 0xFB, 0xBE, 0xE9, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x3E, 0x1F, 0xCF, 0x79, 0x0E, 0x01,
  0x80, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0F,
  0xFF, 0xFF, 0x3E, 0x3F, 0xCE, 0x78, 0x0E, 0x01, 0x80, 0xE0, 0x70, 0xF8,
  0x3F, 0x00, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0xEF, 0xFB, 0xF8, 0x01, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0x06, 0x61, 0xCC, 0x31, 0x8C, 0x33,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x60, 0x0C, 0x7F, 0x9F, 0xE7, 0xF9,
  0x80, 0x60, 0x18, 0x07, 0xE3, 0xFC, 0x47, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xA0, 0xEF, 0xF3, 0xF8, 0x0F, 0x8F, 0xE3, 0x89, 0xC0, 0x60, 0x38, 0x0E,
  0xF3, 0x7E, 0xF3, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0xE7, 0xF8, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x1E, 0x1F, 0xCF, 0x3B,
  0x86, 0xE1, 0x98, 0xE7, 0xF0, 0xF8, 0x3F, 0x1D, 0xEE, 0x1F, 0x07, 0xC1,
  0xF8, 0x77, 0xF8, 0xFC, 0x3E, 0x1F, 0xCF, 0x7B, 0x8E, 0xE1, 0xB0, 0x7E,
  0x1F, 0x8F, 0xFF, 0xDF, 0x70, 0x18, 0x06, 0x03, 0x81, 0xC7, 0xE1, 0xF0,
  0x6F, 0xE0, 0x00, 0x00, 0x06, 0xFE, 0x6F, 0x60, 0x00, 0x00, 0x06, 0x6E,
  0xEC, 0xC0, 0x00, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0x38, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x30, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0xF8, 0xF0, 0xF0, 0x30,
  0x08, 0x00, 0x3E, 0x7F, 0x99, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1C,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x70, 0x03, 0xE0, 0x0F, 0xF8,
  0x1C, 0x1C, 0x30, 0x06, 0x61, 0xC6, 0x63, 0xF3, 0xE6, 0x33, 0xCE, 0x33,
  0xCC, 0x33, 0xCC, 0x73, 0xCC, 0x73, 0xCE, 0x76, 0xE7, 0xDE, 0x61, 0x08,
  0x70, 0x00, 0x38, 0x10, 0x1F, 0xF0, 0x07, 0xE0, 0x07, 0x00, 0x3C, 0x03,
  0xE0, 0x1B, 0x00, 0xDC, 0x0E, 0xE0, 0x73, 0x03, 0x1C, 0x38, 0xE1, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE7, 0x07, 0x38, 0x1F, 0x80, 0xFC, 0x07, 0xFE, 0x3F,
  0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFC, 0xFF, 0xB8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0xFF, 0xFB, 0xFC, 0x0F, 0xC3, 0xFC, 0xF3, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xF0, 0x8F, 0xF0, 0x7E, 0xFC, 0x1F, 0xF3, 0xFF, 0x70, 0xEE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x1D, 0xCF, 0xBF,
  0xE7, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xE1,
  0xFF, 0x3E, 0x67, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE0, 0x77, 0x07, 0x70, 0x73, 0x87, 0x3F, 0xF0, 0xFF, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xF7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xFF, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xEF, 0xBC, 0xE0,
  0xFC, 0x3B, 0x8E, 0x71, 0xCE, 0x71, 0xDC, 0x3F, 0x07, 0xE0, 0xFE, 0x1D,
  0xC3, 0x9C, 0x73, 0x8E, 0x39, 0xC7, 0xB8, 0x77, 0x07, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFD, 0x83, 0x7B, 0x06,
  0xF7, 0x1D, 0xE6, 0x33, 0xCC, 0x67, 0x9D, 0xCF, 0x3B, 0x1E, 0x36, 0x3C,
  0x7C, 0x78, 0xF0, 0xF0, 0xE1, 0xE1, 0xC3, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x83, 0xD8, 0x3D, 0xC3, 0xCE, 0x3C, 0xE3, 0xC7, 0x3C, 0x73, 0xC3, 0xBC,
  0x3B, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0x0F, 0x81, 0xFF, 0x0F, 0x3C,
  0xE0, 0xF7, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0E, 0xE0, 0x77, 0x03, 0xBC, 0x78, 0xFF, 0x81, 0xF8, 0xFC, 0x3F, 0xCF,
  0xFB, 0x8E, 0xE1, 0xB8, 0x7E, 0x3B, 0x8E, 0xFF, 0x3F, 0x8E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0F, 0xC1, 0xFF, 0x0F, 0x3C, 0xE0, 0xF7,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0E, 0xE0,
  0x77, 0x03, 0xBC, 0x78, 0xFF, 0x81, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0xFC, 0x1F, 0xE3, 0xFE, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0xE7,
  0x3C, 0xFF, 0x1F, 0xC3, 0x9C, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0x77, 0x0F,
  0x1F, 0x3F, 0xFC, 0xFC, 0x0E, 0x07, 0x01, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0xE0, 0x70, 0x3E, 0x1F, 0xFD, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xE3, 0xDF,
  0xF1, 0xFC, 0xE0, 0x3F, 0x01, 0x98, 0x1C, 0xE0, 0xE7, 0x06, 0x18, 0x70,
  0xE3, 0x87, 0x18, 0x18, 0xC0, 0xCE, 0x07, 0x70, 0x3B, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x00, 0xE0, 0xE0, 0xE0, 0xFC, 0x1C, 0x1D, 0x83, 0x83, 0xB0,
  0x78, 0x67, 0x1B, 0x0C, 0xE3, 0x63, 0x9C, 0x6C, 0x71, 0x8D, 0xCC, 0x3B,
  0x99, 0x87, 0x63, 0x70, 0xEC, 0x6E, 0x0D, 0x8F, 0xC1, 0xF0, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0x70, 0x78, 0xE0, 0x77, 0x0E, 0x38, 0xE3, 0x9C,
  0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x81, 0x9C,
  0x39, 0xC7, 0x0E, 0x70, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x70, 0xE3, 0x0C,
  0x39, 0xC3, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xBF, 0xEF, 0xF8, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC7, 0xFF, 0xF0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0xFF, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0xF0, 0x0C, 0x03,
  0x01, 0xE0, 0x78, 0x37, 0x0C, 0xC6, 0x39, 0x86, 0xC1, 0xF0, 0x30, 0xFF,
  0x80, 0xE3, 0x8C, 0x30, 0x3F, 0x3F, 0xD0, 0xE0, 0x30, 0x1B, 0xFF, 0xC7,
  0xC3, 0xE3, 0xF1, 0xFF, 0xEF, 0xB0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x37, 0xCF, 0xFB, 0x8E, 0xE1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x6E,
  0x3B, 0xFE, 0xDF, 0x00, 0x1F, 0x7F, 0x71, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x71, 0x7F, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCF, 0x77,
  0xED, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x1D, 0xFF,
  0x3E, 0xC0, 0x3F, 0x1F, 0xE7, 0x1B, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x1C, 0x27, 0xF8, 0x7E, 0x0F, 0x1F, 0x39, 0x38, 0x38, 0x7E, 0xFE,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0xDF,
  0xB7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0x77, 0xEC,
  0xF7, 0x01, 0xC0, 0x74, 0x1D, 0xFE, 0x7F, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0xFB, 0xFF, 0xC7, 0xE3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0x80, 0x5D, 0x80, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x11,
  0xC6, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7F,
  0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFC, 0x73, 0x1C, 0xCE,
  0x37, 0x0F, 0xC3, 0xF0, 0xEE, 0x31, 0xCC, 0x73, 0x0E, 0xC3, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xDF, 0x3C, 0xFF, 0x7E, 0xE3, 0xCF, 0xE3, 0x87,
  0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87,
  0xC3, 0x87, 0xC3, 0x87, 0xDF, 0x7F, 0xF8, 0xFC, 0x7C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x3F, 0x1F, 0xE7, 0x1F, 0x87, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xDC, 0x77, 0xF8, 0xFC, 0xDF, 0x3F, 0xEE,
  0x3B, 0x86, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xB8, 0xEF, 0xFB, 0x7C,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3C, 0xDF, 0xB7, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0x77, 0xEC, 0xF7, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xDF, 0xFF, 0x78, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0x7E, 0xFF, 0xE2, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x87,
  0xFE, 0xFC, 0x10, 0x30, 0x30, 0x7E, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x38, 0x3F, 0x1F, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x87, 0x61, 0xDC, 0x77, 0xFC, 0xFB, 0xE0, 0xEC, 0x19, 0xC7,
  0x38, 0xE3, 0x18, 0x63, 0x0E, 0xE0, 0xD8, 0x1B, 0x03, 0xE0, 0x38, 0x07,
  0x00, 0xE1, 0xC3, 0xB0, 0xE1, 0x98, 0xF1, 0xCE, 0x6C, 0xE7, 0x36, 0x61,
  0x9B, 0x30, 0xD9, 0xB8, 0x7C, 0x7C, 0x3E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0x87, 0x80, 0xF0, 0xEE, 0x38, 0xEE, 0x1D, 0xC1, 0xF0, 0x1C, 0x07,
  0xC0, 0xF8, 0x3B, 0x87, 0x31, 0xC7, 0x70, 0x70, 0xE0, 0xEC, 0x19, 0xC7,
  0x38, 0xE3, 0x18, 0x73, 0x0E, 0xE0, 0xD8, 0x1B, 0x03, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x03, 0xE0, 0x78, 0x00, 0xFF, 0xFF, 0x0E, 0x0E,
  0x1C, 0x18, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0x06, 0x1C, 0x70, 0xE1,
  0x83, 0x06, 0x0C, 0x39, 0xE3, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x3C,
  0x38, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xE1, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x38, 0x3C, 0x79, 0xC3, 0x06, 0x0C, 0x18, 0x31, 0xE3,
  0xC4, 0x00, 0xFC, 0x7F, 0xF8, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 7, 6, 10, 1, -16 },
  { 15, 12, 16, 13, 0, -16 },
  { 39, 10, 18, 12, 1, -17 },
  { 62, 16, 16, 18, 1, -16 },
  { 94, 14, 16, 15, 1, -16 },
  { 122, 3, 6, 5, 1, -16 },
  { 125, 5, 19, 7, 1, -16 },
  { 137, 5, 19, 7, 1, -16 },
  { 149, 9, 10, 11, 1, -17 },
  { 161, 10, 11, 12, 1, -13 },
  { 175, 4, 6, 6, 1, -3 },
  { 178, 5, 2, 7, 1, -7 },
  { 180, 4, 3, 6, 1, -3 },
  { 182, 9, 16, 9, 0, -16 },
  { 200, 10, 16, 12, 1, -16 },
  { 220, 7, 16, 12, 1, -16 },
  { 234, 10, 16, 12, 1, -16 },
  { 254, 10, 16, 12, 1, -16 },
  { 274, 11, 16, 12, 0, -16 },
  { 296, 10, 16, 12, 1, -16 },
  { 316, 10, 16, 12, 1, -16 },
  { 336, 10, 16, 12, 1, -16 },
  { 356, 10, 16, 12, 1, -16 },
  { 376, 10, 16, 12, 1, -16 },
  { 396, 4, 12, 6, 1, -12 },
  { 402, 4, 15, 6, 1, -12 },
  { 410, 10, 11, 12, 1, -13 },
  { 424, 10, 6, 12, 1, -11 },
  { 432, 10, 11, 12, 1, -13 },
  { 446, 9, 16, 9, 0, -16 },
  { 464, 16, 18, 18, 1, -16 },
  { 500, 13, 16, 13, 0, -16 },
  { 526, 10, 16, 13, 2, -16 },
  { 546, 11, 16, 13, 1, -16 },
  { 568, 11, 16, 15, 2, -16 },
  { 590, 8, 16, 11, 2, -16 },
  { 606, 8, 16, 11, 2, -16 },
  { 622, 12, 16, 15, 1, -16 },
  { 646, 11, 16, 15, 2, -16 },
  { 668, 6, 16, 8, 1, -16 },
  { 680, 6, 20, 6, -1, -16 },
  { 695, 11, 16, 13, 2, -16 },
  { 717, 8, 16, 11, 2, -16 },
  { 733, 15, 16, 19, 2, -16 },
  { 763, 12, 16, 16, 2, -16 },
  { 787, 13, 16, 16, 1, -16 },
  { 813, 10, 16, 12, 2, -16 },
  { 833, 13, 20, 16, 1, -16 },
  { 866, 11, 16, 13, 2, -16 },
  { 888, 9, 16, 11, 1, -16 },
  { 906, 11, 16, 11, 0, -16 },
  { 928, 11, 16, 15, 2, -16 },
  { 950, 13, 16, 13, 0, -16 },
  { 976, 19, 16, 19, 0, -16 },
  { 1014, 12, 16, 12, 0, -16 },
  { 1038, 12, 16, 12, 0, -16 },
  { 1062, 10, 16, 11, 1, -16 },
  { 1082, 5, 20, 7, 2, -16 },
  { 1095, 9, 16, 9, 0, -16 },
  { 1113, 5, 20, 7, 1, -16 },
  { 1126, 10, 10, 12, 1, -16 },
  { 1139, 9, 1, 9, 0, 2 },
  { 1141, 5, 4, 7, 1, -17 },
  { 1144, 9, 12, 12, 1, -12 },
  { 1158, 10, 17, 13, 2, -17 },
  { 1180, 8, 12, 10, 1, -12 },
  { 1192, 10, 17, 13, 1, -17 },
  { 1214, 10, 12, 12, 1, -12 },
  { 1229, 8, 17, 7, 0, -17 },
  { 1246, 10, 17, 13, 1, -12 },
  { 1268, 9, 17, 13, 2, -17 },
  { 1288, 3, 17, 6, 1, -17 },
  { 1295, 5, 22, 6, -1, -17 },
  { 1309, 10, 17, 12, 2, -17 },
  { 1331, 2, 17, 6, 2, -17 },
  { 1336, 16, 12, 19, 2, -12 },
  { 1360, 9, 12, 13, 2, -12 },
  { 1374, 10, 12, 12, 1, -12 },
  { 1389, 10, 17, 13, 2, -12 },
  { 1411, 10, 17, 13, 1, -12 },
  { 1433, 6, 12, 9, 2, -12 },
  { 1442, 8, 12, 10, 1, -12 },
  { 1454, 8, 15, 8, 0, -15 },
  { 1469, 10, 12, 13, 1, -12 },
  { 1484, 11, 12, 11, 0, -12 },
  { 1501, 17, 12, 17, 0, -12 },
  { 1527, 11, 12, 11, 0, -12 },
  { 1544, 11, 17, 11, 0, -12 },
  { 1568, 8, 12, 9, 1, -12 },
  { 1580, 7, 20, 8, 0, -16 },
  { 1598, 2, 22, 11, 5, -17 },
  { 1604, 7, 20, 8, 1, -16 },
  { 1622, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD22PT7B_H_
