#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x38, 0xF9,
  0xFF, 0xF7, 0xEF, 0x84, 0x00, 0xFC, 0x7D, 0xF1, 0xF7, 0xC7, 0xDE, 0x1F,
  0x78, 0x7D, 0xE1, 0xF7, 0x87, 0xDE, 0x1F, 0x78, 0x79, 0xE1, 0xE7, 0x83,
  0x80, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0,
  0x3C, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC1, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFC, 0xC1,
  0xBE, 0x30, 0x0F, 0x8C, 0x03, 0xE3, 0x00, 0xFC, 0xC0, 0x1F, 0xB0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xCF, 0xC0, 0x31, 0xF0, 0x0C, 0x7C, 0x03, 0x1F, 0x80, 0xC7,
  0xFC, 0x33, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFE, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0xFF, 0x80, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xCF, 0x00, 0xF0,
  0x0F, 0x0F, 0x03, 0xC0, 0x1E, 0x1E, 0x07, 0x80, 0x3C, 0x3C, 0x1E, 0x00,
  0x78, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x01, 0xE1, 0xE1, 0xE0, 0x03,
  0xC3, 0xC7, 0x80, 0x07, 0x87, 0x8F, 0x00, 0x0F, 0x0F, 0x3E, 0x7F, 0x1E,
  0x1E, 0x79, 0xFF, 0x3E, 0x79, 0xF3, 0xFF, 0x3F, 0xF3, 0xCF, 0x9E, 0x3F,
  0xCF, 0x9E, 0x3C, 0x3F, 0x1E, 0x3C, 0x3C, 0x00, 0x7C, 0xF8, 0x78, 0x00,
  0xF1, 0xE0, 0xF0, 0x01, 0xE3, 0xC1, 0xE0, 0x07, 0x87, 0x83, 0xC0, 0x0F,
  0x0F, 0x07, 0x80, 0x3C, 0x1F, 0x0F, 0x00, 0x78, 0x1E, 0x1E, 0x01, 0xE0,
  0x3C, 0x78, 0x03, 0xC0, 0x7C, 0xF0, 0x0F, 0x00, 0x7F, 0xE0, 0x1E, 0x00,
  0xFF, 0x80, 0x78, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xF8, 0xFF, 0xE0, 0x7C, 0x7F, 0xFC,
  0x1F, 0x1F, 0x9F, 0x87, 0xCF, 0xC7, 0xE3, 0xE3, 0xE0, 0xFC, 0xF8, 0xF8,
  0x1F, 0xFE, 0x3E, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xC3, 0xE0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF8, 0x3F, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0xFD, 0xF7, 0xDE, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0xC1, 0xC1, 0x9F, 0x39, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7B, 0xC0, 0x1F, 0x7C, 0x07, 0xC7, 0xC1, 0xF8, 0xFC, 0x0E, 0x0E, 0x00,
  0xC1, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xFB, 0xFF, 0xF7, 0xEF, 0x84, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03,
  0xE7, 0xC0, 0xFB, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7D, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x0F, 0xC1, 0xFE,
  0x1F, 0xF1, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xBF, 0x79, 0xFB, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF,
  0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7C, 0x1F, 0x9C, 0x03, 0xE2, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x78, 0x1F, 0x88, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x07, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3C,
  0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xF3, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xB8,
  0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0xFE, 0x0F, 0xBF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF0,
  0x7E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0xC3,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xC0, 0xF9, 0xF8, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0x78, 0x0F, 0xCF,
  0x81, 0xF1, 0xF8, 0x7E, 0x1F, 0x9F, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xC7, 0xF3, 0xF0, 0x3F, 0x7C,
  0x03, 0xEF, 0x80, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xDF, 0x81, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E,
  0x1F, 0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFB, 0xCF, 0xFD, 0xF0, 0xFE, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x7C, 0xFB,
  0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x71, 0xF3, 0xFF, 0xEF, 0xDF, 0x08, 0x3E, 0x3E, 0x3F, 0x3F, 0x3E,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE7, 0x83, 0xF1, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x04, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x07, 0xFC, 0x3C, 0x78,
  0x3F, 0xF8, 0x79, 0xE0, 0xFF, 0xF0, 0xF3, 0xC3, 0xE1, 0xE0, 0xE7, 0x87,
  0x83, 0xC1, 0xDE, 0x1F, 0x07, 0x83, 0xFC, 0x3C, 0x0F, 0x07, 0xF8, 0x78,
  0x1E, 0x0F, 0xF0, 0xF0, 0x3C, 0x1F, 0xE1, 0xE0, 0x78, 0x3B, 0xC3, 0xC0,
  0xF0, 0xF7, 0x87, 0x83, 0xE1, 0xEF, 0x0F, 0x07, 0xC3, 0xDE, 0x1F, 0x1F,
  0x8F, 0x3C, 0x1F, 0xFB, 0xFE, 0x3C, 0x1F, 0xE7, 0xF8, 0x78, 0x1F, 0x87,
  0xE0, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x10, 0x01, 0xFC, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xE0, 0xFC,
  0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x1F, 0xEF, 0xC0,
  0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0xFC, 0x3F, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFE, 0x0F, 0x1F, 0xC0, 0x08, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x10, 0xFF, 0x03, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xC3, 0xFF, 0x1F, 0x80,
  0xFE, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFB,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFC, 0x07, 0xF1, 0xF8, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0x03, 0xC3, 0xF8, 0x01, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFD, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0x9F,
  0x80, 0x1F, 0x3F, 0x80, 0x3E, 0x3F, 0xC0, 0x7C, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0x38, 0x00, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x1F, 0x8F, 0x80, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7,
  0xE0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xC0, 0x3E, 0x3F,
  0x01, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x01, 0xF9, 0xF0, 0x0F,
  0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0xF0, 0x03, 0xDF, 0xF7, 0x80, 0x1E, 0xFF, 0xBE, 0x01, 0xF7, 0xFC, 0xF0,
  0x0F, 0x3F, 0xE7, 0x80, 0x79, 0xFF, 0x3E, 0x07, 0xCF, 0xF9, 0xF0, 0x3C,
  0x7F, 0xC7, 0x81, 0xE3, 0xFE, 0x3E, 0x0F, 0x1F, 0xF1, 0xF0, 0xF0, 0xFF,
  0x87, 0x87, 0x87, 0xFC, 0x3E, 0x3C, 0x3F, 0xE1, 0xF3, 0xE1, 0xFF, 0x07,
  0x9E, 0x0F, 0xF8, 0x3C, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x07, 0xE0, 0x3F,
  0xE0, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0x7C, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF7, 0xC0,
  0x3F, 0xE7, 0xC0, 0x7F, 0xCF, 0xC0, 0xFF, 0x8F, 0x81, 0xFF, 0x1F, 0x83,
  0xFE, 0x1F, 0x07, 0xFC, 0x3F, 0x0F, 0xF8, 0x3E, 0x1F, 0xF0, 0x7E, 0x3F,
  0xE0, 0x7C, 0x7F, 0xC0, 0xFC, 0xFF, 0x80, 0xF9, 0xFF, 0x01, 0xFB, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x03,
  0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x07,
  0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0xC7, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xBF, 0x1F, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x7F, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xC7, 0xFC, 0x7E, 0x07, 0xF3, 0xF0, 0x1F, 0x9F,
  0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7C, 0x7E, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xC7, 0xE0,
  0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xE7, 0xF0, 0xF7, 0xE0,
  0x0B, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xDF, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00,
  0x3F, 0x7E, 0x01, 0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0,
  0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x9F, 0x00, 0x7E,
  0x00, 0x7C, 0xF8, 0x03, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xC0, 0x3F, 0x3E,
  0x00, 0xFE, 0x01, 0xF0, 0xF8, 0x0F, 0xF0, 0x0F, 0x87, 0xC0, 0x7F, 0xC0,
  0x7C, 0x3E, 0x03, 0xDE, 0x03, 0xE1, 0xF0, 0x1E, 0xF0, 0x3E, 0x07, 0xC1,
  0xF7, 0x81, 0xF0, 0x3E, 0x0F, 0x3E, 0x0F, 0x81, 0xF0, 0x79, 0xF0, 0x7C,
  0x0F, 0x83, 0xC7, 0x87, 0xC0, 0x7C, 0x3E, 0x3C, 0x3E, 0x01, 0xF1, 0xF1,
  0xF1, 0xF0, 0x0F, 0x8F, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x3C, 0x7C, 0x03,
  0xE7, 0xC1, 0xE7, 0xC0, 0x0F, 0x3E, 0x0F, 0x3E, 0x00, 0x7D, 0xE0, 0x7D,
  0xF0, 0x03, 0xEF, 0x01, 0xEF, 0x80, 0x1F, 0x78, 0x0F, 0x78, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xEF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC7,
  0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF1, 0xF0, 0x07,
  0xC3, 0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x8F, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xF3, 0xC0,
  0x07, 0xBC, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x18, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0x8F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xDF, 0xF9, 0xF3, 0xFC, 0x3C,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0x83,
  0xEF, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xF9, 0xFE, 0x1F, 0xBF, 0x01, 0xF7,
  0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0x7F, 0x07, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3C,
  0xFF, 0xC7, 0x8F, 0xF0, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE,
  0x7F, 0x06, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x03, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0xFC, 0x7C, 0x7F, 0xEF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF,
  0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0x07, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFE, 0x78, 0x7F, 0x8F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0,
  0x1E, 0xF8, 0x03, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x02, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xF8, 0x43, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x07, 0xE1, 0xE3, 0xFF, 0x3C, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xF0,
  0xFE, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x9F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x3F, 0xF7, 0xC3, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xA0, 0x03, 0xE7, 0x81, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0xC3, 0xEF, 0xFC, 0x7D, 0xFF,
  0xCF, 0xFF, 0xFD, 0xFE, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0x27, 0xFF, 0xFF, 0xB8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x01, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE3, 0xFF, 0xFB, 0xFE, 0xFF, 0x3F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0,
  0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0xF8, 0x0F, 0xCF,
  0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE1, 0xE7, 0xFE, 0x3F,
  0xF3, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xF1, 0xFF, 0x0F,
  0xDF, 0x81, 0xFC, 0x0F, 0xFF, 0x01, 0xF8, 0x1F, 0xFE, 0x03, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF,
  0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0,
  0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80,
  0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0xF0,
  0xFE, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7F, 0xFF, 0xEF, 0xF0, 0xFD, 0xF8,
  0x0F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF,
  0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x7E, 0x7E, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0xF0, 0xFC, 0x1E, 0x7F, 0xE3, 0xEF, 0xFE, 0x7F,
  0xFF, 0xCF, 0xE0, 0xFD, 0xF8, 0x0F, 0xBF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFB, 0xF8,
  0x3F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xF7, 0xFE, 0x3E, 0x7F, 0x87, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE1, 0xE3, 0xFF, 0x3C, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xF0, 0xFE, 0xFC,
  0x0F, 0xDF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x3F, 0xF7, 0xC3, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xEF, 0x80, 0xDF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFE,
  0x00, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFB, 0xCF, 0xFC, 0xF1, 0xFE, 0x3C, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x7C,
  0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x7E,
  0x0F, 0xF0, 0x3E, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E,
  0x1E, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x7C, 0x1F, 0x1E, 0x78, 0xF8, 0x1F,
  0x1E, 0x78, 0xF8, 0x1F, 0x3E, 0x3C, 0xF8, 0x0F, 0x3C, 0x3C, 0xF8, 0x0F,
  0xBC, 0x3C, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x07,
  0xB8, 0x1D, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3E,
  0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3F, 0x7E, 0x00, 0xFB, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x80,
  0x7C, 0x7C, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0xC3, 0xE0, 0x3E, 0x3F, 0x01,
  0xFB, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xDE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0xFF, 0x07, 0xF0, 0x3E, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x0F, 0xF0,
  0xFF, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFD, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 31, 11, 2, -30 },
  { 29, 14, 11, 18, 2, -30 },
  { 49, 23, 30, 25, 1, -30 },
  { 136, 18, 34, 22, 2, -32 },
  { 213, 31, 30, 35, 2, -30 },
  { 330, 26, 30, 28, 2, -30 },
  { 428, 6, 11, 10, 2, -30 },
  { 437, 10, 37, 13, 2, -30 },
  { 484, 11, 37, 13, 1, -30 },
  { 535, 19, 18, 21, 1, -32 },
  { 578, 18, 20, 22, 2, -25 },
  { 623, 8, 10, 11, 1, -5 },
  { 633, 11, 5, 13, 1, -14 },
  { 640, 7, 7, 11, 2, -6 },
  { 647, 16, 30, 17, 0, -30 },
  { 707, 18, 30, 22, 2, -30 },
  { 775, 13, 30, 22, 3, -30 },
  { 824, 18, 30, 22, 2, -30 },
  { 892, 18, 30, 22, 2, -30 },
  { 960, 20, 30, 22, 1, -30 },
  { 1035, 18, 30, 22, 2, -30 },
  { 1103, 19, 30, 22, 2, -30 },
  { 1175, 20, 30, 22, 1, -30 },
  { 1250, 19, 30, 22, 2, -30 },
  { 1322, 18, 30, 22, 2, -30 },
  { 1390, 7, 24, 11, 2, -23 },
  { 1411, 8, 28, 11, 1, -23 },
  { 1439, 19, 21, 22, 2, -26 },
  { 1489, 18, 12, 22, 2, -21 },
  { 1516, 19, 21, 22, 2, -26 },
  { 1566, 17, 31, 18, 0, -30 },
  { 1632, 31, 33, 35, 2, -30 },
  { 1760, 26, 30, 26, 0, -30 },
  { 1858, 20, 30, 25, 3, -30 },
  { 1933, 21, 30, 24, 2, -30 },
  { 2012, 23, 30, 28, 3, -30 },
  { 2099, 15, 30, 21, 4, -30 },
  { 2156, 15, 30, 21, 4, -30 },
  { 2213, 23, 30, 28, 2, -30 },
  { 2300, 21, 30, 29, 4, -30 },
  { 2379, 12, 30, 14, 1, -30 },
  { 2424, 12, 39, 12, -3, -30 },
  { 2483, 21, 30, 25, 4, -30 },
  { 2562, 17, 30, 21, 3, -30 },
  { 2626, 29, 30, 36, 4, -30 },
  { 2735, 23, 30, 30, 4, -30 },
  { 2822, 26, 30, 30, 2, -30 },
  { 2920, 19, 30, 24, 3, -30 },
  { 2992, 26, 37, 30, 2, -30 },
  { 3113, 21, 30, 25, 3, -30 },
  { 3192, 17, 30, 21, 2, -30 },
  { 3256, 20, 30, 21, 1, -30 },
  { 3331, 22, 30, 28, 3, -30 },
  { 3414, 24, 30, 24, 0, -30 },
  { 3504, 37, 30, 37, 0, -30 },
  { 3643, 24, 30, 24, 0, -30 },
  { 3733, 23, 30, 23, 0, -30 },
  { 3820, 19, 30, 21, 1, -30 },
  { 3892, 10, 37, 14, 3, -30 },
  { 3939, 16, 30, 17, 0, -30 },
  { 3999, 10, 37, 14, 1, -30 },
  { 4046, 21, 19, 23, 1, -30 },
  { 4096, 18, 3, 18, 0, 4 },
  { 4103, 10, 7, 13, 2, -32 },
  { 4112, 18, 23, 22, 2, -23 },
  { 4164, 19, 32, 24, 3, -32 },
  { 4240, 16, 23, 19, 2, -23 },
  { 4286, 19, 32, 24, 2, -32 },
  { 4362, 19, 23, 22, 2, -23 },
  { 4417, 15, 32, 14, 1, -32 },
  { 4477, 19, 33, 24, 2, -23 },
  { 4556, 19, 32, 24, 3, -32 },
  { 4632, 5, 32, 11, 3, -32 },
  { 4652, 10, 42, 11, -2, -32 },
  { 4705, 20, 32, 23, 3, -32 },
  { 4785, 5, 32, 11, 3, -32 },
  { 4805, 31, 23, 37, 3, -23 },
  { 4895, 19, 23, 24, 3, -23 },
  { 4950, 20, 23, 24, 2, -23 },
  { 5008, 19, 33, 24, 3, -23 },
  { 5087, 19, 33, 24, 2, -23 },
  { 5166, 13, 23, 17, 3, -23 },
  { 5204, 15, 23, 19, 2, -23 },
  { 5248, 13, 28, 16, 1, -28 },
  { 5294, 18, 23, 24, 3, -23 },
  { 5346, 21, 23, 21, 0, -23 },
  { 5407, 32, 23, 32, 0, -23 },
  { 5499, 21, 23, 21, 0, -23 },
  { 5560, 21, 33, 21, 0, -23 },
  { 5647, 16, 23, 18, 1, -23 },
  { 5693, 13, 37, 16, 1, -30 },
  { 5754, 4, 42, 21, 9, -32 },
  { 5775, 13, 37, 16, 2, -30 },
  { 5836, 19, 6, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD42PT7B_H_
