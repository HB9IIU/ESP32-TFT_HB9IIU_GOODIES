#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x01, 0x1F, 0xFF, 0xFF, 0xDE, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3E, 0xF1, 0xF7, 0x8F, 0xBC, 0x7D, 0xE3, 0xCF, 0x0E, 0x78,
  0x73, 0x83, 0x80, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0xF0, 0x03,
  0x87, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x0E, 0x00, 0x78,
  0x70, 0x03, 0xC3, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x07,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xE1, 0xE0, 0x07, 0x0F,
  0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07,
  0x0F, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x01, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFC, 0xF9, 0xC2,
  0x78, 0xE0, 0x3C, 0x70, 0x1F, 0x38, 0x0F, 0xDC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3B, 0xF0,
  0x1C, 0xF8, 0x0E, 0x7E, 0x07, 0x3F, 0x83, 0xBE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x07, 0xFE, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x1F, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFE, 0x01, 0xE0,
  0x1E, 0x78, 0x0F, 0x00, 0x78, 0xF0, 0x3C, 0x01, 0xC3, 0xC1, 0xE0, 0x0F,
  0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x03, 0xC3,
  0xC7, 0x80, 0x07, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0xF1, 0xF0, 0x78, 0xF3,
  0xCF, 0xF1, 0xE7, 0x9E, 0x7F, 0xC3, 0xFE, 0x79, 0xE7, 0x8F, 0xF3, 0xCF,
  0x1E, 0x1F, 0x8F, 0x3C, 0x38, 0x00, 0x78, 0xF0, 0xF0, 0x01, 0xE3, 0xC3,
  0xC0, 0x0F, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0xF0,
  0x07, 0x83, 0xC3, 0x80, 0x1C, 0x0F, 0x1E, 0x00, 0xF0, 0x1E, 0x78, 0x03,
  0x80, 0x7F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x7C, 0x7F, 0xF8, 0x7C,
  0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x07, 0xDF, 0x0F, 0x01, 0xFF,
  0x8F, 0x80, 0xFF, 0x83, 0xE0, 0x3F, 0xC1, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xC0, 0xFF,
  0x83, 0xF0, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0x80, 0x07, 0x87, 0x83,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0x78, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F,
  0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0x0E, 0x0D, 0xF7, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xF7, 0x80, 0xF9,
  0xE0, 0xF8, 0xF8, 0x3C, 0x38, 0x04, 0x18, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x9E, 0x3C, 0x79, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x11, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xC3, 0xE3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF7,
  0xC0, 0xF9, 0xE0, 0x7C, 0xF8, 0x7E, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x1F, 0xF3, 0xFF,
  0x7E, 0xFF, 0xCF, 0x38, 0xF1, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xF0, 0x1F,
  0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0x83, 0xF3, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x38, 0x1F, 0x88, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFB, 0x00, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0xF3, 0xE0,
  0x1E, 0x7C, 0x07, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0xC1,
  0xE0, 0xF8, 0x78, 0x1F, 0x1E, 0x03, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x20, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xF1, 0xF7, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7D, 0x80, 0x7E, 0xFF, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC3, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x7C, 0x1E, 0x7F, 0x8F, 0x7F, 0xE7, 0xFF,
  0xFB, 0xF0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x3E, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x01, 0xE7,
  0xC0, 0x79, 0xF0, 0x1E, 0x7C, 0x0F, 0x8F, 0x83, 0xE3, 0xF1, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3E, 0x1F,
  0x9F, 0x03, 0xE7, 0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xF7,
  0x80, 0x7D, 0xF0, 0x1F, 0x7F, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F,
  0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F,
  0x1F, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x0F, 0xDF, 0x07, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xF7, 0xC1, 0xF9, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x11, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x11, 0xFF, 0xFF, 0xFD, 0xE0, 0x08, 0x7D, 0xFB,
  0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0xF9, 0xF3, 0xCF, 0x9F, 0x3C, 0x78, 0xE3, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x70, 0x3E, 0x40, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x07, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x38, 0x1E, 0x78,
  0x1F, 0xF8, 0xE7, 0x87, 0xFF, 0x8F, 0x70, 0x7C, 0x78, 0xFF, 0x0F, 0x07,
  0x87, 0xF0, 0xF0, 0x70, 0x7F, 0x1E, 0x07, 0x07, 0xF1, 0xE0, 0x70, 0x7F,
  0x1E, 0x07, 0x07, 0xE1, 0xE0, 0xF0, 0x7E, 0x1E, 0x0F, 0x0F, 0xE1, 0xE0,
  0xF0, 0xFF, 0x0E, 0x0F, 0x0E, 0xF0, 0xFB, 0xFB, 0xEF, 0x0F, 0xFB, 0xFC,
  0x70, 0x7F, 0x1F, 0x87, 0x80, 0xC0, 0x60, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x04, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xC7, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0x83, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81, 0xFD, 0xF0, 0x1F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x1F,
  0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xC3, 0xFC, 0xF8, 0x0F,
  0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xF7, 0xC0, 0x7E, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xF8, 0x0C, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x02,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x83, 0xFC, 0x7C,
  0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x3F, 0x9F, 0x07,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x07, 0x1F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0x7C, 0xFC, 0x03, 0xE7, 0xF0,
  0x1F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x7E, 0xFF, 0xDF, 0xF3,
  0xFC, 0x7E, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80,
  0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8,
  0xFC, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0xF8, 0x0F, 0x8F, 0xC0,
  0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFD, 0xE0, 0x07, 0xFF, 0xBC, 0x01, 0xEF, 0xFF, 0xC0, 0x3D,
  0xFF, 0x78, 0x07, 0xBF, 0xEF, 0x01, 0xE7, 0xFD, 0xF0, 0x3C, 0xFF, 0x9E,
  0x07, 0x9F, 0xF3, 0xC1, 0xE3, 0xFE, 0x78, 0x3C, 0x7F, 0xC7, 0x87, 0x8F,
  0xF8, 0xF1, 0xE1, 0xFF, 0x1E, 0x3C, 0x3F, 0xE1, 0xE7, 0x87, 0xFC, 0x3D,
  0xE0, 0xFF, 0x87, 0xBC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xE0, 0x7F,
  0xC1, 0xFC, 0x0F, 0xF8, 0x3F, 0x81, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x7C,
  0x07, 0xFC, 0x0F, 0x80, 0xF0, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFD, 0xF0, 0x0F, 0xFB, 0xE0, 0x3F, 0xEF, 0x80, 0xFF, 0x9F, 0x03, 0xFE,
  0x7C, 0x0F, 0xF8, 0xF8, 0x3F, 0xE3, 0xE0, 0xFF, 0x87, 0xC3, 0xFE, 0x1F,
  0x8F, 0xF8, 0x3E, 0x3F, 0xE0, 0xFC, 0xFF, 0x81, 0xF3, 0xFE, 0x07, 0xEF,
  0xF8, 0x0F, 0xBF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81,
  0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0xC3, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81,
  0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xEF, 0x80, 0x3F, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFE, 0xFC, 0x0E, 0xF8, 0x02, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C,
  0x03, 0xF7, 0xE0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1E, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C,
  0x1E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x0F,
  0x03, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xC7,
  0x80, 0x1F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFE,
  0x00, 0xFC, 0x01, 0xF7, 0x80, 0x3F, 0x00, 0x7D, 0xF0, 0x0F, 0xC0, 0x3E,
  0x7C, 0x03, 0xF0, 0x0F, 0x9F, 0x01, 0xFE, 0x03, 0xE3, 0xC0, 0x7F, 0x80,
  0xF8, 0xF0, 0x1F, 0xE0, 0x3C, 0x3E, 0x07, 0xF8, 0x1F, 0x0F, 0x83, 0xCF,
  0x07, 0xC3, 0xE0, 0xF3, 0xC1, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x1F, 0x0F,
  0x3C, 0x3E, 0x07, 0xC7, 0xCF, 0x8F, 0x81, 0xF1, 0xE1, 0xE3, 0xE0, 0x3C,
  0x78, 0x78, 0xF0, 0x0F, 0x1E, 0x1E, 0x3C, 0x03, 0xEF, 0x87, 0xDF, 0x00,
  0xFB, 0xC0, 0xF7, 0xC0, 0x1E, 0xF0, 0x3D, 0xE0, 0x07, 0xBC, 0x0F, 0x78,
  0x01, 0xEF, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F,
  0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xF8,
  0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x1E,
  0x01, 0xC3, 0xC0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x0F,
  0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x00, 0x40,
  0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xE1, 0xF8, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7,
  0xF0, 0xFB, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x0F,
  0xDF, 0x8F, 0xEF, 0xFE, 0xF3, 0xFF, 0x78, 0xFE, 0x1C, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x60, 0x3C, 0xFF, 0x0F, 0x7F, 0xE3, 0xDF, 0xFC,
  0xFF, 0x7F, 0x3F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBF, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xF7, 0xFE, 0x3C, 0x7F, 0x00, 0x00, 0x60, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFB, 0xCF, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x09, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0x07, 0xC3, 0xF9, 0xF3, 0xFF, 0x7C,
  0xFF, 0xFF, 0x7F, 0x7F, 0xDF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xF7, 0xC3, 0xF8, 0xF0, 0x00, 0x80, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0xE1, 0xF3, 0xE0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x8F, 0xE7, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87,
  0xFE, 0x1F, 0x08, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xFF, 0xCF,
  0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x01,
  0x00, 0x03, 0xF8, 0xF3, 0xFF, 0x7C, 0xFF, 0xFF, 0x7F, 0x3F, 0xDF, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xDF, 0x03, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xF7, 0xC3, 0xF9,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE6, 0x01, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x20, 0x79, 0xFE, 0x3D, 0xFF, 0x9E, 0xFF, 0xEF, 0xF7,
  0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7C, 0xF7, 0xFF, 0xF7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x81, 0xF0, 0x7C,
  0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC3, 0xEF, 0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8,
  0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0,
  0x0F, 0x7C, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0x8F, 0x83,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x83, 0xF3, 0xE0, 0x7C, 0xF8,
  0x0F, 0xBE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x20, 0x04, 0x0F, 0x3F, 0xC3, 0xFC, 0xF7, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x1F, 0x81, 0xFF,
  0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F,
  0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x0F,
  0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x80,
  0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x00,
  0xFF, 0x80, 0xF0, 0x0F, 0x00, 0x20, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF,
  0xEF, 0xF7, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7C, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0x3F, 0x9F, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x20, 0x3C, 0xFF, 0x0F, 0x7F, 0xE3,
  0xDF, 0xFC, 0xFE, 0x7F, 0x3F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBF, 0x07, 0xEF, 0xFF, 0xF3,
  0xDF, 0xFC, 0xF7, 0xFE, 0x3C, 0x7F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0x00, 0x03, 0xF8, 0xF3, 0xFF, 0x7C, 0xFF, 0xFF,
  0x7F, 0x7F, 0xDF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xF7, 0xC3, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x6F, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0x00,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0xF8, 0x3B, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xFF, 0x9F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x80, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xDF, 0xFD, 0xEF, 0xFC, 0xF1, 0xFC,
  0x78, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3, 0xC0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x03, 0xE1,
  0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7B, 0xC0, 0x7E, 0x07, 0xDF, 0x03,
  0xF0, 0x3E, 0xF8, 0x3F, 0x81, 0xE3, 0xC1, 0xFE, 0x0F, 0x1E, 0x0F, 0xF0,
  0xF8, 0xF8, 0x77, 0x87, 0xC7, 0xC7, 0x9C, 0x3C, 0x1E, 0x3C, 0xF1, 0xE0,
  0xF1, 0xE7, 0x9F, 0x07, 0xCE, 0x3C, 0xF8, 0x3E, 0xF0, 0xE7, 0x80, 0xF7,
  0x87, 0x3C, 0x07, 0xBC, 0x3D, 0xE0, 0x3D, 0xE1, 0xFF, 0x01, 0xEE, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE7, 0xC0,
  0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x1F, 0x1F,
  0x87, 0xE1, 0xF0, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x3C, 0x7C,
  0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x0F, 0xF0, 0xFC, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xC1, 0xFE, 0x1F, 0x80, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x5F,
  0xF0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 13, 10, 17, 2, -28 },
  { 39, 21, 28, 23, 1, -28 },
  { 113, 17, 32, 21, 2, -30 },
  { 181, 30, 28, 32, 1, -28 },
  { 286, 25, 28, 26, 1, -28 },
  { 374, 5, 10, 9, 2, -28 },
  { 381, 9, 34, 12, 2, -28 },
  { 420, 10, 34, 12, 1, -28 },
  { 463, 17, 17, 20, 1, -30 },
  { 500, 17, 19, 21, 2, -23 },
  { 541, 7, 10, 10, 1, -5 },
  { 550, 10, 5, 12, 1, -13 },
  { 557, 6, 6, 10, 2, -6 },
  { 562, 15, 28, 15, 0, -28 },
  { 615, 17, 28, 21, 2, -28 },
  { 675, 12, 28, 21, 2, -28 },
  { 717, 17, 28, 21, 2, -28 },
  { 777, 18, 28, 21, 1, -28 },
  { 840, 19, 28, 21, 1, -28 },
  { 907, 17, 28, 21, 2, -28 },
  { 967, 17, 28, 21, 2, -28 },
  { 1027, 18, 28, 21, 1, -28 },
  { 1090, 18, 28, 21, 1, -28 },
  { 1153, 18, 28, 21, 1, -28 },
  { 1216, 6, 22, 10, 2, -22 },
  { 1233, 7, 27, 10, 1, -22 },
  { 1257, 17, 20, 21, 2, -24 },
  { 1300, 17, 11, 21, 2, -19 },
  { 1324, 17, 20, 21, 2, -24 },
  { 1367, 16, 28, 16, 0, -28 },
  { 1423, 28, 31, 32, 2, -28 },
  { 1532, 24, 28, 24, 0, -28 },
  { 1616, 19, 28, 24, 3, -28 },
  { 1683, 19, 28, 22, 2, -28 },
  { 1750, 21, 28, 26, 3, -28 },
  { 1824, 15, 28, 20, 3, -28 },
  { 1877, 15, 28, 19, 3, -28 },
  { 1930, 21, 28, 26, 2, -28 },
  { 2004, 20, 28, 27, 3, -28 },
  { 2074, 11, 28, 13, 1, -28 },
  { 2113, 11, 36, 11, -3, -28 },
  { 2163, 20, 28, 23, 3, -28 },
  { 2233, 15, 28, 19, 3, -28 },
  { 2286, 27, 28, 34, 3, -28 },
  { 2381, 22, 28, 28, 3, -28 },
  { 2458, 24, 28, 28, 2, -28 },
  { 2542, 17, 28, 22, 3, -28 },
  { 2602, 24, 35, 28, 2, -28 },
  { 2707, 20, 28, 23, 3, -28 },
  { 2777, 16, 28, 20, 2, -28 },
  { 2833, 18, 28, 20, 1, -28 },
  { 2896, 20, 28, 26, 3, -28 },
  { 2966, 22, 28, 22, 0, -28 },
  { 3043, 34, 28, 34, 0, -28 },
  { 3162, 22, 28, 22, 0, -28 },
  { 3239, 21, 28, 21, 0, -28 },
  { 3313, 18, 28, 20, 1, -28 },
  { 3376, 9, 34, 13, 3, -28 },
  { 3415, 15, 28, 15, 0, -28 },
  { 3468, 9, 34, 13, 1, -28 },
  { 3507, 19, 17, 21, 1, -28 },
  { 3548, 17, 3, 16, 0, 3 },
  { 3555, 9, 6, 12, 2, -30 },
  { 3562, 17, 22, 21, 1, -22 },
  { 3609, 18, 30, 22, 3, -30 },
  { 3677, 15, 22, 18, 2, -22 },
  { 3719, 18, 30, 22, 2, -30 },
  { 3787, 17, 22, 21, 2, -22 },
  { 3834, 14, 30, 13, 1, -30 },
  { 3887, 18, 31, 22, 2, -22 },
  { 3957, 17, 30, 23, 3, -30 },
  { 4021, 5, 29, 10, 3, -29 },
  { 4040, 10, 38, 10, -2, -29 },
  { 4088, 18, 30, 21, 3, -30 },
  { 4156, 5, 30, 10, 3, -30 },
  { 4175, 28, 22, 34, 3, -22 },
  { 4252, 17, 22, 23, 3, -22 },
  { 4299, 18, 22, 22, 2, -22 },
  { 4349, 18, 31, 22, 3, -22 },
  { 4419, 18, 31, 22, 2, -22 },
  { 4489, 12, 22, 15, 3, -22 },
  { 4522, 14, 22, 17, 2, -22 },
  { 4561, 12, 26, 14, 1, -26 },
  { 4600, 17, 21, 23, 3, -21 },
  { 4645, 19, 21, 19, 0, -21 },
  { 4695, 29, 21, 30, 0, -21 },
  { 4772, 19, 21, 20, 0, -21 },
  { 4822, 19, 30, 20, 0, -21 },
  { 4894, 15, 21, 17, 1, -21 },
  { 4934, 12, 34, 15, 1, -28 },
  { 4985, 4, 39, 20, 8, -30 },
  { 5005, 13, 34, 15, 1, -28 },
  { 5061, 18, 6, 21, 1, -17 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD39PT7B_H_
