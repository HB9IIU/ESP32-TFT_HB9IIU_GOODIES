#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xD0, 0x5F, 0x3C, 0xD7, 0x8A, 0xB0, 0xE4, 0xBF,
  0x80, 0xEA, 0x40, 0x95, 0x80, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x5A, 0xF6, 0xB0, 0xD5, 0xE5, 0x70, 0xE8, 0xF0, 0x6F, 0x90, 0xF8, 0xF0,
  0xFE, 0xB0, 0xE5, 0x20, 0xEA, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xD5, 0x77, 0xF7, 0x47, 0x00, 0x66, 0xE9, 0xFE, 0xF0,
  0x72, 0x30, 0xE9, 0x9E, 0xFB, 0xFA, 0x7A, 0x97, 0xBE, 0xD0, 0xD7, 0xF8,
  0xF3, 0x70, 0x92, 0x70, 0xBB, 0xBD, 0xB7, 0xD0, 0x79, 0x96, 0xF7, 0x40,
  0x79, 0x96, 0x30, 0xEA, 0xEB, 0xF8, 0xF0, 0xE9, 0x20, 0x99, 0x96, 0xB5,
  0xA0, 0xAD, 0x76, 0xA0, 0xA9, 0xD0, 0xA9, 0x20, 0xE9, 0x70, 0xEA, 0xC0,
  0x95, 0xD5, 0xC0, 0x54, 0xE0, 0xC0, 0x7F, 0x80, 0x93, 0xDE, 0xF1, 0x80,
  0x27, 0xD6, 0xFD, 0x80, 0x6E, 0x80, 0xF5, 0xF0, 0x93, 0xDA, 0xB8, 0xBC,
  0x92, 0xEA, 0xF8, 0xFD, 0x6A, 0xF6, 0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF5,
  0x90, 0xE8, 0xDC, 0xB9, 0xB5, 0x80, 0xB5, 0x00, 0xBA, 0x94, 0xAA, 0x80,
  0xB5, 0x60, 0xDC, 0x59, 0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 0, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 2, 0, -3 },
  { 45, 1, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 4, 3, 0, -4 },
  { 52, 5, 5, 5, 0, -4 },
  { 56, 4, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 2, 4, 3, 1, -4 },
  { 65, 2, 4, 3, 1, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 1, -4 },
  { 70, 2, 4, 2, 0, -4 },
  { 71, 1, 5, 2, 0, -4 },
  { 72, 3, 4, 4, 1, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 4, 4, 5, 1, -4 },
  { 78, 3, 4, 4, 1, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 4, 5, 4, 0, -4 },
  { 87, 4, 4, 4, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 4, 4, 4, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 5, 4, 5, 0, -4 },
  { 100, 3, 4, 3, 0, -4 },
  { 102, 3, 4, 3, 0, -4 },
  { 104, 3, 4, 3, 0, -4 },
  { 106, 2, 5, 2, 0, -4 },
  { 108, 2, 4, 2, 0, -4 },
  { 109, 2, 5, 2, 0, -4 },
  { 111, 3, 2, 3, 0, -4 },
  { 112, 3, 1, 3, 0, 0 },
  { 113, 2, 1, 2, 0, -5 },
  { 114, 3, 3, 3, 0, -3 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 3, 5, 3, 0, -5 },
  { 122, 3, 3, 3, 0, -3 },
  { 124, 2, 5, 2, 0, -5 },
  { 126, 3, 4, 3, 0, -3 },
  { 128, 3, 5, 3, 0, -5 },
  { 130, 1, 5, 2, 0, -5 },
  { 131, 1, 6, 2, 0, -5 },
  { 132, 3, 5, 3, 0, -5 },
  { 134, 1, 5, 2, 0, -5 },
  { 135, 5, 3, 5, 0, -3 },
  { 137, 3, 3, 3, 0, -3 },
  { 139, 3, 3, 3, 0, -3 },
  { 141, 3, 4, 3, 0, -3 },
  { 143, 3, 4, 3, 0, -3 },
  { 145, 2, 3, 2, 0, -3 },
  { 146, 2, 3, 3, 0, -3 },
  { 147, 2, 4, 2, 0, -4 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 3, 3, 3, 0, -3 },
  { 152, 5, 3, 5, 0, -3 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 3, 4, 3, 0, -3 },
  { 158, 2, 3, 3, 0, -3 },
  { 159, 2, 5, 2, 0, -4 },
  { 161, 1, 6, 3, 1, -5 },
  { 162, 2, 5, 2, 0, -4 },
  { 164, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD6PT7B_H_
