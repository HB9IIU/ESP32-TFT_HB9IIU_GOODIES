#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x18, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE,
  0x0F, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC0, 0xF3, 0xE0, 0x78, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFC, 0xFC, 0x7F, 0x3C,
  0x08, 0x7E, 0x3C, 0x00, 0x7E, 0x3C, 0x00, 0x7E, 0x3C, 0x00, 0x7E, 0x3C,
  0x00, 0x7F, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0xFE, 0x00, 0x3C,
  0x7E, 0x00, 0x3C, 0x7F, 0x00, 0x3C, 0x7F, 0x00, 0x3C, 0x7F, 0xC0, 0x3C,
  0x7E, 0xF8, 0x3C, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x3F,
  0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x7E, 0x00,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x1F, 0x0F, 0xE0, 0xFC, 0x3E, 0x3F,
  0x1F, 0xF0, 0x7C, 0x3E, 0x3E, 0x3F, 0xF8, 0x7E, 0x7E, 0x7E, 0x7F, 0xFC,
  0x3F, 0xFC, 0x7C, 0x7E, 0x7C, 0x3F, 0xFC, 0xFC, 0xFC, 0x3E, 0x1F, 0xF8,
  0xF8, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x3F, 0x00,
  0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x07, 0xC0,
  0xF8, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0xE0, 0x0F, 0xC1, 0xFF, 0xF8,
  0x0F, 0xE1, 0xFE, 0xFE, 0x07, 0xF1, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x1F,
  0xE3, 0xF8, 0xFE, 0x07, 0xF9, 0xFC, 0x7F, 0x01, 0xFE, 0xFC, 0x3F, 0x80,
  0x7F, 0xFE, 0x1F, 0xC0, 0x1F, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0x07, 0xF0,
  0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFC,
  0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x10, 0x1F,
  0x03, 0x7E, 0x3C, 0x3E, 0xFF, 0xFB, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81,
  0xFC, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0x60, 0x30, 0x00, 0x40, 0x40, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC,
  0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xBF, 0xFF, 0x9F, 0xDF, 0x8F, 0xE7, 0x87, 0xF1, 0x83, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0x87, 0xFC, 0x3E,
  0x01, 0xFC, 0x18, 0x00, 0xFC, 0x10, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3E, 0x07, 0xFC, 0x38, 0x01, 0xFC, 0x10, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0xC0, 0x01, 0xFE, 0xF8,
  0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00,
  0xF9, 0xFC, 0x00, 0x7C, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0x87, 0xF0,
  0x07, 0xE1, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0xF8, 0x1F, 0xC0, 0x7E, 0x07,
  0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xE0, 0x1F, 0xC1, 0xF0,
  0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0xF0, 0x0F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x04, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0xFC, 0x7F, 0xF0,
  0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFE,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0xFE,
  0x3F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE,
  0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xE7, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xF8, 0x3F, 0x83, 0xFC,
  0x7F, 0x01, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x28, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0x7F, 0x03, 0xFF, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0x7E, 0x07, 0xFC, 0x7E,
  0x00, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x06, 0x80, 0x00, 0x7E, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x18, 0x1F, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFC, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3,
  0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0x03, 0xFC, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xC3,
  0xF0, 0x0F, 0xF8, 0x0F, 0x8F, 0x80, 0xFF, 0xFC, 0x3E, 0x7C, 0x07, 0xFF,
  0xF0, 0xF9, 0xF0, 0x3F, 0xFF, 0xC1, 0xF7, 0xC1, 0xFC, 0x1F, 0x07, 0xFE,
  0x07, 0xC0, 0x7C, 0x1F, 0xF8, 0x3F, 0x01, 0xF0, 0x7F, 0xE0, 0xF8, 0x0F,
  0xC1, 0xFF, 0x83, 0xE0, 0x3E, 0x07, 0xFE, 0x1F, 0x80, 0xF8, 0x1F, 0xF0,
  0x7C, 0x03, 0xE0, 0x7F, 0xC1, 0xF0, 0x0F, 0x81, 0xFF, 0x07, 0xC0, 0x3E,
  0x07, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0xF0, 0x7E, 0x03, 0xE0, 0x7B, 0xE0,
  0xF8, 0x1F, 0x83, 0xEF, 0x83, 0xE0, 0x7E, 0x0F, 0xBE, 0x0F, 0xC3, 0xFC,
  0x7C, 0xF8, 0x1F, 0xFE, 0xFF, 0xF3, 0xE0, 0x3F, 0xF9, 0xFF, 0x87, 0xC0,
  0xFF, 0xC7, 0xFC, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xF8,
  0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB,
  0xF8, 0x03, 0xF9, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xF0, 0x0F,
  0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xE1, 0xFF,
  0x00, 0x30, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x02, 0x1F,
  0xFC, 0x0F, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0x8F, 0xE0,
  0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x1F, 0xF8, 0x00, 0xC1, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7F,
  0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0xC0, 0x03, 0xF1, 0xFE, 0x00,
  0x3F, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x81, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF7,
  0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0x3E, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0xCF, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F,
  0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xE7, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFD, 0xF0, 0x00, 0x3F, 0xFF, 0xEF, 0xC0, 0x03, 0xFF, 0xFF, 0x7E,
  0x00, 0x1F, 0x7F, 0xFB, 0xF0, 0x00, 0xFB, 0xFF, 0xCF, 0x80, 0x0F, 0xDF,
  0xFE, 0x7E, 0x00, 0x7C, 0xFF, 0xF3, 0xF0, 0x03, 0xE7, 0xFF, 0x8F, 0x80,
  0x3F, 0x3F, 0xFC, 0x7E, 0x01, 0xF1, 0xFF, 0xE3, 0xF0, 0x0F, 0x8F, 0xFF,
  0x8F, 0x80, 0xFC, 0x7F, 0xFC, 0x7E, 0x07, 0xC3, 0xFF, 0xE3, 0xF0, 0x3E,
  0x1F, 0xFF, 0x0F, 0x83, 0xF0, 0xFF, 0xF8, 0x7E, 0x1F, 0x07, 0xFF, 0xC3,
  0xF0, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0xC1, 0xFF, 0xF0, 0x7C, 0x7C, 0x0F,
  0xFF, 0x83, 0xF3, 0xE0, 0x7F, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x7D,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xDF, 0xC0,
  0x0F, 0xFF, 0x3F, 0x80, 0x3F, 0xFC, 0xFE, 0x00, 0xFF, 0xF1, 0xFC, 0x03,
  0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x0F, 0xE0, 0x3F, 0xFC, 0x3F, 0x80, 0xFF,
  0xF0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x83, 0xF8, 0x3F, 0xFE,
  0x07, 0xF0, 0xFF, 0xF8, 0x1F, 0xC3, 0xFF, 0xE0, 0x3F, 0x8F, 0xFF, 0x80,
  0xFE, 0x3F, 0xFE, 0x01, 0xFC, 0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0xE0, 0x0F,
  0xEF, 0xFF, 0x80, 0x3F, 0xBF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x03,
  0xFE, 0xFE, 0x3F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC1, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFC, 0x7F, 0x1F,
  0xE0, 0x0E, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xA0, 0x00, 0x7F, 0x78,
  0x00, 0xFE, 0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF8,
  0x01, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xE0, 0x01, 0xF9,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0x07, 0xE0,
  0x1F, 0xBE, 0x01, 0xFC, 0x1F, 0x80, 0x7C, 0xF8, 0x07, 0xE0, 0x7F, 0x01,
  0xF3, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xCF, 0xC0, 0xFE, 0x03, 0xF0, 0x3F,
  0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xE1,
  0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0x87, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x1F,
  0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0xF8,
  0x7E, 0x00, 0x7F, 0x1F, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x0F, 0xCF,
  0xE0, 0x03, 0xF3, 0xF0, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x7C, 0xFC,
  0x00, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x00, 0x7C, 0xF8, 0x07, 0xEF, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7E, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xC7,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1,
  0xE0, 0x3F, 0x82, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFC, 0x7F, 0x7F, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0x7F, 0xDF, 0xFE, 0xFF, 0xFE, 0xFC,
  0xFF, 0xFD, 0xF9, 0xFF, 0xF1, 0xF0, 0xFF, 0x83, 0xE0, 0x10, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xC0,
  0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC3, 0xFC, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x81, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xF8, 0xF8, 0xFF, 0xF0, 0xF8, 0x7F, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF0, 0x70, 0xFF, 0x00, 0x87, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x47, 0xFC, 0x0E, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xC7, 0xF0,
  0x7F, 0xF3, 0xF8, 0x7F, 0xFD, 0xFC, 0x7F, 0xFF, 0x7E, 0x3F, 0xFF, 0xFF,
  0x3F, 0xE1, 0xFF, 0x9F, 0xC0, 0x7F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0xFC, 0x1F, 0xFC, 0x7E,
  0x07, 0xFC, 0x3F, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1,
  0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x02, 0x3F, 0xC0, 0x0E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0x83, 0xFF, 0x8F, 0xC3, 0xFF, 0xE7,
  0xE3, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xF9, 0xFE, 0x0F, 0xFC, 0xFE, 0x03,
  0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0x80,
  0x0F, 0xEF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFC,
  0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xEF, 0xE0, 0xFF, 0xE7, 0xF0, 0x3F, 0xE3, 0xF8, 0x03, 0x81,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x88, 0x00, 0x1F, 0xC7, 0x00, 0x1F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00,
  0xBE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1,
  0xFE, 0x0F, 0xCF, 0xFF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xC3, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x3C, 0x7E,
  0x7E, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF1, 0xFF, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00, 0xFC,
  0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xF1, 0xFF, 0xE1, 0xFF, 0xE3, 0xE7, 0xFF, 0xC7,
  0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xF8, 0x7F, 0xF8, 0x7F, 0xBF, 0xC0, 0x7F, 0xC0, 0x7F, 0x7F, 0x00, 0xFF,
  0x80, 0x7E, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x3F,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0xF8, 0x3F, 0xC1,
  0xF1, 0xFF, 0xE3, 0xE7, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x81, 0xFE,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xF8, 0x3F, 0xC0, 0xF8, 0xFF,
  0xE0, 0xFD, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x83,
  0xFC, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFD, 0xFF, 0xF8, 0xFC, 0xFF, 0xF0, 0xFC, 0x7F, 0xC0, 0xFC, 0x04,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x1F, 0x83, 0xFF, 0x8F, 0xC3, 0xFF, 0xE7, 0xE3, 0xFF,
  0xFB, 0xF1, 0xFF, 0xFF, 0xF9, 0xFE, 0x0F, 0xFC, 0xFE, 0x03, 0xFE, 0xFE,
  0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x0F, 0xEF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F,
  0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFC, 0xFE, 0x01,
  0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xEF, 0xE0, 0xFF, 0xE7, 0xF0, 0x3F, 0xE3, 0xF8, 0x03, 0x81, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xE0, 0x1C, 0xFC, 0x00, 0x4F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xEF, 0x00, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x04, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFD,
  0xF8, 0xFF, 0xF1, 0xF0, 0xFF, 0x83, 0xE0, 0x10, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC,
  0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0xFF, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x00, 0x7E,
  0x7F, 0x00, 0xFF, 0x80, 0x7E, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x3F, 0x01,
  0xFF, 0x80, 0xFE, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xF7, 0xC0,
  0xFC, 0x1F, 0x81, 0xF7, 0xC0, 0xFC, 0x1F, 0x83, 0xE7, 0xC1, 0xFC, 0x1F,
  0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0xC3, 0xE3, 0xE1, 0xF8, 0x0F, 0xC3, 0xE3,
  0xE1, 0xF8, 0x0F, 0xC7, 0xE3, 0xE3, 0xF8, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0,
  0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x07, 0xE7,
  0xC1, 0xF3, 0xF0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7,
  0xE0, 0x03, 0xEF, 0x80, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x7F, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 39, 14, 3, -38 },
  { 40, 17, 14, 23, 3, -38 },
  { 70, 29, 38, 31, 1, -38 },
  { 208, 24, 43, 28, 2, -40 },
  { 337, 40, 38, 44, 2, -38 },
  { 527, 33, 39, 35, 2, -38 },
  { 688, 7, 14, 13, 3, -38 },
  { 701, 13, 46, 17, 2, -38 },
  { 776, 14, 46, 17, 1, -38 },
  { 857, 23, 23, 27, 2, -40 },
  { 924, 24, 25, 28, 2, -31 },
  { 999, 9, 13, 14, 2, -6 },
  { 1014, 13, 6, 16, 2, -17 },
  { 1024, 8, 8, 14, 3, -7 },
  { 1032, 20, 38, 21, 1, -38 },
  { 1127, 24, 39, 28, 2, -38 },
  { 1244, 17, 38, 28, 3, -38 },
  { 1325, 24, 38, 28, 2, -38 },
  { 1439, 24, 39, 28, 2, -38 },
  { 1556, 26, 38, 28, 1, -38 },
  { 1680, 22, 39, 28, 3, -38 },
  { 1788, 24, 39, 28, 2, -38 },
  { 1905, 24, 38, 28, 2, -38 },
  { 2019, 24, 39, 28, 2, -38 },
  { 2136, 24, 39, 28, 2, -38 },
  { 2253, 8, 30, 14, 3, -29 },
  { 2283, 9, 36, 14, 2, -29 },
  { 2324, 24, 26, 28, 2, -32 },
  { 2402, 24, 15, 28, 2, -26 },
  { 2447, 24, 26, 28, 2, -32 },
  { 2525, 21, 39, 22, 0, -38 },
  { 2628, 38, 42, 44, 3, -38 },
  { 2828, 32, 38, 32, 0, -38 },
  { 2980, 25, 38, 32, 4, -38 },
  { 3099, 26, 39, 31, 3, -38 },
  { 3226, 28, 38, 35, 4, -38 },
  { 3359, 20, 38, 27, 4, -38 },
  { 3454, 20, 38, 26, 4, -38 },
  { 3549, 28, 39, 35, 3, -38 },
  { 3686, 28, 38, 36, 4, -38 },
  { 3819, 15, 38, 18, 2, -38 },
  { 3891, 15, 49, 15, -4, -38 },
  { 3983, 27, 38, 31, 4, -38 },
  { 4112, 21, 38, 26, 4, -38 },
  { 4212, 37, 38, 46, 4, -38 },
  { 4388, 30, 38, 38, 4, -38 },
  { 4531, 32, 39, 38, 3, -38 },
  { 4687, 24, 38, 30, 4, -38 },
  { 4801, 32, 47, 38, 3, -38 },
  { 4989, 27, 38, 31, 4, -38 },
  { 5118, 23, 39, 27, 2, -38 },
  { 5231, 25, 38, 27, 1, -38 },
  { 5350, 28, 39, 36, 4, -38 },
  { 5487, 31, 38, 31, 0, -38 },
  { 5635, 46, 38, 46, 0, -38 },
  { 5854, 30, 38, 30, 0, -38 },
  { 5997, 29, 38, 29, 0, -38 },
  { 6135, 25, 38, 27, 1, -38 },
  { 6254, 12, 46, 17, 4, -38 },
  { 6323, 21, 38, 21, 0, -38 },
  { 6423, 12, 46, 17, 1, -38 },
  { 6492, 27, 24, 29, 1, -38 },
  { 6573, 22, 3, 22, 0, 5 },
  { 6582, 13, 9, 17, 2, -41 },
  { 6597, 23, 30, 28, 2, -29 },
  { 6684, 24, 41, 30, 4, -40 },
  { 6807, 21, 30, 24, 2, -29 },
  { 6886, 25, 41, 30, 2, -40 },
  { 7015, 24, 30, 28, 2, -29 },
  { 7105, 19, 41, 18, 1, -41 },
  { 7203, 25, 42, 30, 2, -29 },
  { 7335, 23, 40, 31, 4, -40 },
  { 7450, 8, 40, 14, 3, -40 },
  { 7490, 13, 53, 14, -2, -40 },
  { 7577, 24, 40, 29, 4, -40 },
  { 7697, 6, 40, 14, 4, -40 },
  { 7727, 39, 29, 46, 4, -29 },
  { 7869, 23, 29, 31, 4, -29 },
  { 7953, 25, 30, 30, 2, -29 },
  { 8047, 24, 42, 30, 4, -29 },
  { 8173, 25, 42, 30, 2, -29 },
  { 8305, 16, 29, 21, 4, -29 },
  { 8363, 20, 30, 24, 2, -29 },
  { 8438, 17, 36, 20, 1, -35 },
  { 8515, 23, 30, 31, 4, -29 },
  { 8602, 26, 29, 26, 0, -29 },
  { 8697, 40, 29, 40, 0, -29 },
  { 8842, 26, 29, 27, 0, -29 },
  { 8937, 26, 42, 27, 0, -29 },
  { 9074, 19, 29, 23, 2, -29 },
  { 9143, 17, 46, 20, 1, -38 },
  { 9241, 5, 52, 27, 11, -40 },
  { 9274, 17, 46, 20, 2, -38 },
  { 9372, 24, 8, 28, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD53PT7B_H_
