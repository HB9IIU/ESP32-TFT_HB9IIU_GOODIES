#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x0E, 0xEF, 0xE0, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0x06, 0x30, 0x38, 0xC0, 0xE7, 0x03,
  0x9C, 0x0C, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0xE0, 0x73, 0x81,
  0x8E, 0x3F, 0xFF, 0xFF, 0xFC, 0xE3, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x03, 0xFF, 0x7F, 0xE7,
  0xEE, 0xF6, 0x0E, 0x60, 0xF6, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x6F, 0x06, 0x70, 0x67, 0xC6, 0xFF, 0xFE, 0xFF, 0xC1, 0xF0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x10, 0x00, 0x07, 0xE0, 0x70, 0x7E, 0x06, 0x0E, 0x70,
  0xE0, 0xE7, 0x0C, 0x0E, 0x71, 0xC0, 0xE7, 0x18, 0x0E, 0x73, 0x80, 0xE7,
  0x33, 0xCE, 0x77, 0x7E, 0x7E, 0x67, 0xF7, 0xEE, 0xE7, 0x08, 0xCE, 0x30,
  0x1C, 0xE3, 0x01, 0x8E, 0x30, 0x38, 0xE3, 0x03, 0x0E, 0x70, 0x70, 0x67,
  0x06, 0x07, 0xE0, 0xE0, 0x3C, 0x02, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x07,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x7B, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC1, 0xCF, 0xF1, 0xEF, 0x3C, 0xE7, 0x8F, 0x73, 0x83,
  0xF9, 0xE0, 0xF8, 0xF0, 0x7C, 0x3F, 0xFF, 0x1F, 0xFB, 0xC3, 0xF9, 0xF0,
  0xFF, 0xFF, 0xF0, 0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x80,
  0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x73, 0x8E, 0x71, 0xCE, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0xE6, 0xEF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83, 0xB8, 0x79, 0xC1, 0x18,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x7B, 0x9C, 0xEE, 0x73,
  0x00, 0xFF, 0xFF, 0xF8, 0xEE, 0xFE, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x00, 0x02, 0x01, 0xF8, 0x3F, 0xC7, 0x9E,
  0x70, 0xEF, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x77, 0x0F, 0x70, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8,
  0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x02, 0x03, 0xFC, 0x7F, 0xEF,
  0x9E, 0x60, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x04, 0x07, 0xFC, 0xFF, 0xE7, 0x1E, 0x40, 0xE0, 0x0F, 0x00, 0xE0,
  0x0E, 0x03, 0xC1, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x0F, 0x80, 0xFF, 0x7E, 0xFF, 0xC7, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x07, 0xF0, 0x1B, 0xC0, 0xEF, 0x07, 0x3C, 0x1C, 0xF0, 0xE3,
  0xC3, 0x0F, 0x1C, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0xF8, 0x0E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x00, 0x80,
  0xFE, 0x1F, 0xE3, 0xE0, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xEF, 0xCE,
  0xFE, 0xF8, 0xFF, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x77, 0x07, 0x70, 0xF7,
  0xFE, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x00, 0x02, 0x03, 0xFC,
  0x7F, 0xE7, 0x8E, 0x70, 0xF7, 0x0F, 0x70, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8,
  0x1F, 0x87, 0xFE, 0x70, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x9F,
  0x7F, 0xE1, 0xFC, 0x04, 0x03, 0xF8, 0x7F, 0xC7, 0x9E, 0xF0, 0xEE, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xF7, 0xF7, 0x3E, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xE4, 0xFC, 0x7F, 0x87, 0xE0, 0xEF, 0xFE, 0x00,
  0x00, 0x00, 0x0E, 0xEF, 0xE0, 0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xB9, 0xCE, 0xE7, 0x30, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0xC0, 0x0F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x3F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x04, 0x0F, 0xF3, 0xFF,
  0x39, 0xF0, 0x1E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x1E, 0x03, 0xC1, 0xC0, 0x1C, 0x38, 0x00,
  0xE7, 0x0F, 0xE6, 0x71, 0xFE, 0x76, 0x38, 0xE7, 0xE3, 0x0E, 0x3E, 0x70,
  0xE3, 0xE7, 0x0C, 0x7E, 0x70, 0xC7, 0xE7, 0x1C, 0x6E, 0x39, 0xEE, 0x63,
  0xF7, 0xC7, 0x1E, 0x38, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x02, 0x00,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C,
  0x38, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x78, 0x1E, 0x78,
  0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xBC, 0xFD,
  0xE0, 0xEF, 0x07, 0xF8, 0x3B, 0xC1, 0xDE, 0x3E, 0xFF, 0xC7, 0xFF, 0x3C,
  0x7D, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xFF, 0xF7, 0xFF,
  0x3F, 0xF0, 0x00, 0x80, 0x1F, 0xF1, 0xFF, 0x8F, 0xCE, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x04, 0xFF, 0xE1, 0xFF, 0x81,
  0xFE, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x07, 0xBC, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00,
  0x40, 0x0F, 0xFC, 0x3F, 0xF8, 0xF8, 0xE3, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE1, 0xFF, 0xC3, 0xFB, 0x87, 0xF7, 0x00, 0xEE,
  0x01, 0xDE, 0x03, 0xBC, 0x07, 0x3C, 0x0E, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xE0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xC0, 0xFF,
  0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x7D, 0xFF, 0xF8, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0E, 0xBE, 0xFE, 0xFC, 0xF0, 0x3F, 0xC1, 0xEF, 0x0F, 0x3C, 0x78, 0xF1,
  0xC3, 0xCF, 0x0F, 0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3C,
  0xF0, 0xF3, 0xC3, 0xC7, 0x8F, 0x0E, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xEF,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFE, 0xC0, 0x7F, 0xDC, 0x0D, 0xFB, 0x83, 0xBF, 0x70, 0x77,
  0xE7, 0x0C, 0xFC, 0xE3, 0x9F, 0x9C, 0x73, 0xF1, 0xCC, 0x7E, 0x3B, 0x8F,
  0xC7, 0x71, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x1C, 0x1F,
  0x83, 0x83, 0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFD, 0xC1, 0xFB, 0xC3, 0xF3, 0xC7, 0xE3, 0x8F, 0xC7, 0x9F, 0x87, 0x3F,
  0x0F, 0x7E, 0x0E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x78, 0x01, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xCF, 0xC3,
  0xC0, 0xF3, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0F, 0x70, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x39, 0xE0, 0x1C, 0xF0,
  0x1E, 0x3C, 0x1E, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x8F,
  0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF,
  0xFE, 0xFF, 0xCF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xCF, 0xC3,
  0xC0, 0xF3, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0F, 0x70, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x39, 0xE0, 0x1C, 0xF0,
  0x1E, 0x3C, 0x1E, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFF, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xF1,
  0xE3, 0xFF, 0x0F, 0xF8, 0x3C, 0xE0, 0xF1, 0xC3, 0xC7, 0x8F, 0x0E, 0x3C,
  0x3C, 0xF0, 0x73, 0xC1, 0xEF, 0x03, 0xC0, 0x06, 0x03, 0xFE, 0x7F, 0xE7,
  0xDE, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0E, 0x80, 0xEF, 0xFE, 0xFF, 0xC7,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xDE, 0x0F,
  0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x1E,
  0x70, 0x1C, 0x78, 0x1C, 0x38, 0x3C, 0x38, 0x38, 0x3C, 0x38, 0x1C, 0x38,
  0x1C, 0x78, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7C, 0x1E, 0x70, 0x7E, 0x1C, 0x78,
  0x7E, 0x1C, 0x38, 0x6E, 0x1C, 0x38, 0xEE, 0x3C, 0x38, 0xE6, 0x3C, 0x3C,
  0xE7, 0x38, 0x1C, 0xC7, 0x38, 0x1D, 0xC7, 0x38, 0x1D, 0xC3, 0x78, 0x1D,
  0xC3, 0xF0, 0x0D, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xE0, 0x0F, 0x01, 0xE0, 0xF8, 0x1E, 0xF0, 0x78, 0xF0, 0xE0, 0xE3,
  0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7F, 0x00, 0xEF, 0x03, 0xCE, 0x07, 0x1E, 0x1E, 0x1C, 0x78,
  0x3C, 0xF0, 0x3B, 0xC0, 0x78, 0xF0, 0x1E, 0xE0, 0x79, 0xE0, 0xE1, 0xC3,
  0xC3, 0xC7, 0x03, 0x8E, 0x07, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0xFF, 0xC0, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x03, 0xC0, 0x70, 0x1C, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00,
  0x78, 0x03, 0xC0, 0x3F, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0x06, 0x1C, 0x70,
  0x63, 0x03, 0xB8, 0x0D, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0x1F, 0x87, 0xFC, 0x3F, 0xE2, 0x0E, 0x00, 0xF0, 0x0F, 0x1F,
  0xF7, 0xFF, 0x78, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xF1, 0xF7, 0xF7, 0x3E,
  0x70, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E,
  0xFC, 0xFF, 0xEF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0xEF, 0xFE, 0xEF, 0xC0, 0x0F, 0xC3, 0xFC,
  0xFF, 0x3C, 0x27, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0xFC, 0x7F, 0x87, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x79, 0xE7, 0xFF, 0x7F, 0xFB, 0xC7, 0xDC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0x83, 0xDF,
  0x7E, 0x7F, 0x71, 0xF3, 0x80, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0x0F, 0x70,
  0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x7C,
  0x73, 0xFF, 0x0F, 0xE0, 0x03, 0x83, 0xF1, 0xFC, 0x70, 0x3C, 0x0F, 0x03,
  0xFB, 0xFE, 0xFF, 0x87, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFE,
  0xF1, 0xF7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1E, 0xE0, 0xF7, 0xDF, 0x9F, 0xFC, 0x7D, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x98, 0x7C, 0xFF, 0xC7, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE7, 0x8E, 0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x70, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x71,
  0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xEF, 0xFF, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x0E, 0xE1, 0xCE, 0x3C, 0xE7, 0x8E, 0xF0,
  0xEE, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0F,
  0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE7, 0x87,
  0x8E, 0xFC, 0xFE, 0xFF, 0xFF, 0xEF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFE, 0x0F,
  0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0,
  0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xF0,
  0xE7, 0x8E, 0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x0F,
  0x81, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xDC, 0x1E, 0xE0, 0xE7, 0xDF, 0x1F, 0xF0, 0x7F, 0x00,
  0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0xEF, 0xFE, 0xEF, 0xCE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x39, 0xFD, 0xDF,
  0xFE, 0xF1, 0xF7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1E, 0xE0, 0xF7, 0xDF, 0x9F, 0xFC, 0x7D, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xC7, 0xEF, 0xFF, 0xF8, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x1F,
  0xFF, 0xFB, 0x82, 0xE0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x1E,
  0x07, 0xE7, 0xFF, 0xEF, 0xF0, 0x1C, 0x0E, 0x07, 0x07, 0xFF, 0xFF, 0xFC,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7D, 0x1F,
  0x87, 0xC0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFF, 0xF7, 0xF7, 0x3E,
  0x70, 0xF0, 0x3F, 0x81, 0xDC, 0x1E, 0xE0, 0xE7, 0x87, 0x1C, 0x78, 0xE3,
  0x87, 0x9C, 0x1C, 0xE0, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0xF0, 0xF0, 0x77, 0x0F, 0x07, 0x70, 0xF8, 0x77, 0x0F, 0x8F,
  0x79, 0xD8, 0xE3, 0x9D, 0x8E, 0x39, 0xDC, 0xE3, 0x99, 0xDE, 0x39, 0x8D,
  0xC1, 0xF8, 0xDC, 0x1F, 0x8D, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x7B, 0xC3, 0x8E, 0x3C, 0x79, 0xC1, 0xDE,
  0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0x78, 0x79, 0xC3,
  0x8F, 0x3C, 0x3B, 0xC1, 0xE0, 0xF0, 0x3F, 0x81, 0xDC, 0x1E, 0xE0, 0xE3,
  0x87, 0x1C, 0x78, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0xEE, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0xFC, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xE0, 0xF8,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7C, 0x1E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x0E, 0x07, 0xE0, 0xF1, 0xF8, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x87, 0xC3, 0xC0, 0x30, 0x1F, 0xE1, 0xFF, 0xF8,
  0x7F, 0x80, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 19, 7, 2, -19 },
  { 11, 8, 7, 12, 2, -19 },
  { 18, 14, 19, 16, 1, -19 },
  { 52, 12, 23, 14, 1, -21 },
  { 87, 20, 20, 22, 1, -20 },
  { 137, 17, 20, 18, 1, -20 },
  { 180, 3, 7, 7, 2, -19 },
  { 183, 7, 23, 9, 1, -19 },
  { 204, 6, 23, 9, 1, -19 },
  { 222, 12, 12, 14, 1, -21 },
  { 240, 12, 13, 14, 1, -16 },
  { 260, 5, 7, 7, 1, -3 },
  { 265, 7, 3, 8, 1, -9 },
  { 268, 4, 4, 7, 2, -4 },
  { 270, 10, 19, 11, 0, -19 },
  { 294, 12, 20, 14, 1, -20 },
  { 324, 8, 19, 14, 2, -19 },
  { 343, 12, 20, 14, 1, -20 },
  { 373, 12, 20, 14, 1, -20 },
  { 403, 14, 19, 14, 0, -19 },
  { 437, 12, 19, 14, 1, -19 },
  { 466, 12, 20, 14, 1, -20 },
  { 496, 12, 19, 14, 1, -19 },
  { 525, 12, 20, 14, 1, -20 },
  { 555, 12, 20, 14, 1, -20 },
  { 585, 4, 15, 7, 2, -15 },
  { 593, 5, 19, 7, 1, -15 },
  { 605, 12, 13, 14, 1, -16 },
  { 625, 12, 7, 14, 1, -13 },
  { 636, 12, 13, 14, 1, -16 },
  { 656, 11, 20, 11, 0, -20 },
  { 684, 20, 21, 22, 1, -19 },
  { 737, 16, 19, 16, 0, -19 },
  { 775, 13, 19, 16, 2, -19 },
  { 806, 14, 20, 16, 1, -20 },
  { 841, 14, 19, 18, 2, -19 },
  { 875, 10, 19, 14, 2, -19 },
  { 899, 10, 19, 13, 2, -19 },
  { 923, 15, 20, 18, 1, -20 },
  { 961, 14, 19, 19, 2, -19 },
  { 995, 7, 19, 9, 1, -19 },
  { 1012, 8, 24, 8, -2, -19 },
  { 1036, 14, 19, 16, 2, -19 },
  { 1070, 11, 19, 13, 2, -19 },
  { 1097, 19, 19, 23, 2, -19 },
  { 1143, 15, 19, 20, 2, -19 },
  { 1179, 17, 20, 19, 1, -20 },
  { 1222, 12, 19, 15, 2, -19 },
  { 1251, 17, 25, 19, 1, -20 },
  { 1305, 14, 19, 16, 2, -19 },
  { 1339, 12, 20, 14, 1, -20 },
  { 1369, 13, 19, 14, 0, -19 },
  { 1400, 14, 19, 18, 2, -19 },
  { 1434, 16, 19, 16, 0, -19 },
  { 1472, 24, 19, 24, 0, -19 },
  { 1529, 15, 19, 15, 0, -19 },
  { 1565, 15, 19, 15, 0, -19 },
  { 1601, 12, 19, 14, 1, -19 },
  { 1630, 6, 23, 9, 2, -19 },
  { 1648, 10, 19, 11, 0, -19 },
  { 1672, 6, 23, 9, 1, -19 },
  { 1690, 13, 12, 15, 1, -19 },
  { 1710, 11, 2, 11, 0, 2 },
  { 1713, 7, 5, 9, 1, -21 },
  { 1718, 12, 15, 14, 1, -15 },
  { 1741, 12, 21, 16, 2, -21 },
  { 1773, 11, 15, 12, 1, -15 },
  { 1794, 13, 21, 16, 1, -21 },
  { 1829, 12, 15, 14, 1, -15 },
  { 1852, 10, 21, 9, 0, -21 },
  { 1879, 13, 21, 16, 1, -15 },
  { 1914, 12, 21, 16, 2, -21 },
  { 1946, 3, 20, 7, 2, -20 },
  { 1954, 6, 26, 7, -1, -20 },
  { 1974, 12, 21, 15, 2, -21 },
  { 2006, 3, 21, 7, 2, -21 },
  { 2014, 20, 15, 24, 2, -15 },
  { 2052, 12, 15, 16, 2, -15 },
  { 2075, 13, 15, 15, 1, -15 },
  { 2100, 12, 21, 16, 2, -15 },
  { 2132, 13, 21, 16, 1, -15 },
  { 2167, 8, 15, 11, 2, -15 },
  { 2182, 10, 15, 12, 1, -15 },
  { 2201, 9, 18, 10, 0, -18 },
  { 2222, 12, 15, 16, 2, -15 },
  { 2245, 13, 15, 13, 0, -15 },
  { 2270, 20, 15, 21, 0, -15 },
  { 2308, 13, 15, 14, 0, -15 },
  { 2333, 13, 21, 14, 0, -15 },
  { 2368, 10, 15, 12, 1, -15 },
  { 2387, 8, 23, 10, 1, -19 },
  { 2410, 2, 27, 14, 6, -21 },
  { 2417, 9, 23, 10, 1, -19 },
  { 2443, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD27PT7B_H_
