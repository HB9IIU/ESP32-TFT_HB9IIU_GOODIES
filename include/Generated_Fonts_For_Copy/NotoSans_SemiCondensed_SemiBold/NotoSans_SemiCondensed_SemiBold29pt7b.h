#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xE0, 0x0E, 0xFF, 0xF0,
  0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x07, 0x18, 0x0E,
  0x30, 0x18, 0xE0, 0x31, 0xC0, 0xE3, 0x81, 0xC6, 0x1F, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0x01, 0xC6, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8C, 0x70, 0x38, 0xE0, 0x71, 0x80, 0xE3, 0x01, 0xCE, 0x03, 0x1C,
  0x00, 0x03, 0x00, 0x18, 0x01, 0xF0, 0x7F, 0xF7, 0xFF, 0x3D, 0x9B, 0xCC,
  0x1E, 0x60, 0x73, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0D, 0xE0, 0x67, 0x83, 0x7F, 0x1F, 0xFF, 0xFD, 0xFF, 0xC0, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x3C, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0x70, 0x70,
  0x38, 0xC1, 0xC0, 0xE3, 0x8E, 0x03, 0x8E, 0x38, 0x0E, 0x38, 0xC0, 0x38,
  0xE7, 0x00, 0xE3, 0x98, 0xC3, 0x8C, 0xEF, 0xC7, 0x73, 0x3F, 0x9F, 0xDD,
  0xC6, 0x3C, 0x67, 0x1C, 0x03, 0x9C, 0x70, 0x0C, 0x71, 0xC0, 0x71, 0xC7,
  0x01, 0x87, 0x1C, 0x0E, 0x1C, 0x70, 0x30, 0x3B, 0x81, 0xC0, 0xFE, 0x0F,
  0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xE3, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x1F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x39, 0xFF, 0x1E, 0x7B, 0xE7, 0xBC, 0x79, 0xCF, 0x0F, 0xF3,
  0xC1, 0xF8, 0xF0, 0x3E, 0x3E, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xDE, 0x1F,
  0xC7, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x71, 0xE3, 0x8F, 0x1C, 0x38,
  0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x83, 0x87,
  0x0F, 0x0E, 0x0E, 0x1C, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0E, 0x1E,
  0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x0E,
  0x38, 0xF1, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x0E, 0x2F, 0x6F, 0x7F,
  0xFB, 0xFF, 0xE1, 0xF0, 0x1F, 0x81, 0xEE, 0x1E, 0x78, 0x31, 0x80, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x7B, 0xDC,
  0xEF, 0x73, 0x80, 0xFF, 0xFF, 0xF8, 0xEF, 0xFF, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F,
  0x00, 0x0F, 0x80, 0xFF, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x38, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0xC1, 0xEE, 0x0F, 0x70, 0x73, 0xC7, 0x8F, 0xFC, 0x7F, 0xC0, 0xFC, 0x00,
  0x03, 0x87, 0xC7, 0xE7, 0xF7, 0xFF, 0xBD, 0x9E, 0x8F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x0F, 0x81, 0xFF, 0x3F, 0xFC, 0xE1, 0xE2, 0x07, 0x00, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0x83, 0xFF, 0x3F, 0xFC, 0xC1, 0xE4, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x07, 0xFF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x6E, 0x01, 0xDC, 0x07,
  0x38, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0x87, 0x07, 0x0E, 0x0E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0x8F, 0xFC, 0xFF, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0x03, 0xF0,
  0x7F, 0x87, 0xFC, 0x7C, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF7,
  0xE7, 0xFF, 0xBF, 0xFD, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0x70, 0x7B, 0xC3, 0xCF, 0xFC, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xF0, 0xE7, 0x07, 0xB8, 0x3D, 0xC1, 0xCF, 0x1E, 0x3F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0xC7, 0x8F, 0x78, 0x3F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F,
  0x83, 0xDF, 0x7C, 0xFF, 0xE1, 0xFC, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF8,
  0xF1, 0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xDE,
  0x7E, 0xFF, 0x73, 0xFB, 0x86, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x1F, 0xF8, 0xFF, 0x87, 0xF0, 0x00, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0xFF, 0x73, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEE,
  0x77, 0xB9, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x1E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x8F, 0xFC, 0x7F, 0xE6, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0xFC, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x0F, 0xF3, 0x9C, 0x7F, 0xC6,
  0x71, 0xC7, 0x19, 0x8E, 0x1C, 0x6E, 0x38, 0x71, 0xF8, 0xE1, 0xC6, 0xE3,
  0x87, 0x1B, 0x8E, 0x1C, 0x6E, 0x38, 0xF3, 0x98, 0xFF, 0xFC, 0x71, 0xFB,
  0xF1, 0xC1, 0xC3, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0x80,
  0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0x73, 0x80, 0x3C, 0xE0,
  0x0E, 0x3C, 0x03, 0x8F, 0x01, 0xE1, 0xC0, 0x78, 0x78, 0x1F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x78, 0x0F, 0x1E, 0x01, 0xE7, 0x80,
  0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xC0, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xBC,
  0x3E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0xFB, 0xFF, 0xCF,
  0xFE, 0x3F, 0xFE, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xF3, 0xFF,
  0x9F, 0x86, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x23, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xF0, 0xFC, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xF0, 0x67, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x78, 0x0E, 0xF8, 0x1C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7E, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x9F, 0xFE, 0xFC, 0xF8, 0xF0, 0x1F, 0xE0, 0x7B,
  0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0x70, 0x79, 0xE0, 0xF7,
  0x81, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xBC, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0x78, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF7, 0x81, 0xEF, 0x01, 0xE0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFE,
  0xE0, 0xEF, 0xF7, 0x07, 0x7F, 0xB8, 0x3B, 0xFC, 0xE3, 0x9F, 0xE7, 0x1C,
  0xFF, 0x38, 0xE7, 0xF9, 0xEE, 0x3F, 0xC7, 0x71, 0xFE, 0x3B, 0x8F, 0xF1,
  0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xE0, 0xFF, 0x07, 0x07,
  0x80, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xEF, 0x0F, 0xF7, 0x87, 0xF9, 0xE3, 0xFC, 0x71,
  0xFE, 0x3C, 0xFF, 0x0E, 0x7F, 0x87, 0xBF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0x87, 0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1E, 0x78, 0x0F, 0x3E, 0x0F,
  0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0x3F, 0xFD,
  0xE3, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFF,
  0xFD, 0xFF, 0xCF, 0xFC, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0x87, 0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1E, 0x78, 0x0F, 0x3E, 0x0F, 0x8F, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0x8F, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xE3, 0xFF, 0xC7, 0xFE,
  0x0F, 0xFC, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0xF3,
  0xC1, 0xE7, 0x81, 0xEF, 0x01, 0xE0, 0x0F, 0xC3, 0xFF, 0x7F, 0xF7, 0x86,
  0x70, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x03, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFE,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x70, 0x1E, 0xF0,
  0x7D, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0x9C,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x78, 0x38,
  0x1C, 0x1C, 0x0E, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0x73,
  0xC0, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x1C, 0x03, 0xF8, 0x0F, 0x03, 0xDC, 0x0F,
  0x81, 0xEE, 0x07, 0xC0, 0xF7, 0x83, 0xE0, 0x73, 0xC1, 0xF8, 0x39, 0xE1,
  0xDC, 0x3C, 0x70, 0xEE, 0x1E, 0x38, 0x77, 0x0E, 0x1E, 0x39, 0xC7, 0x0F,
  0x3C, 0xE7, 0x83, 0x9C, 0x73, 0xC1, 0xCE, 0x39, 0xC0, 0xE7, 0x1E, 0xE0,
  0x7B, 0x87, 0x70, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x0F,
  0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0F, 0x78,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x1E, 0x38, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x1E, 0x78, 0x1E, 0x70, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xF0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x1C,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x01, 0xCE, 0x0E, 0x38, 0x38,
  0x71, 0xC1, 0xC7, 0x03, 0xB8, 0x0E, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0xF0, 0x70, 0x0F, 0xC3, 0xFE, 0x3F, 0xF2, 0x0F, 0x00, 0x70, 0x07,
  0x03, 0xF3, 0xFF, 0x7F, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xBF,
  0x7F, 0xB3, 0xF3, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xDF, 0x1D, 0xFC, 0xFF, 0xF7, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xFF, 0xEE,
  0xFF, 0x73, 0xF0, 0x0F, 0xE3, 0xFC, 0xFF, 0xBE, 0x17, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x82, 0x7F, 0xCF, 0xF8,
  0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0xF3, 0xCF, 0xFF, 0x3F, 0xFD, 0xE1, 0xF7, 0x83, 0xDC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xC0, 0xF7, 0x87, 0xDF, 0xFF,
  0x3F, 0xFC, 0x7E, 0x70, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x07,
  0xB8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x9F, 0xF8, 0xFF, 0xC1, 0xFE, 0x07, 0xE1, 0xFC, 0x7F, 0x0F, 0x01,
  0xC0, 0x38, 0x0F, 0xF7, 0xFE, 0xFF, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x00, 0x0F, 0x1C, 0xFF, 0xF3, 0xFF, 0xDE, 0x1F, 0x78, 0x3D, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x7D,
  0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x98, 0x1E,
  0x7F, 0xF1, 0xFF, 0xC1, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xDF, 0x1D, 0xFE, 0xFF, 0xF7, 0xC7, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3C, 0x6F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x07, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3B, 0xF7, 0xEF, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xBC, 0x3C, 0xF1, 0xE3, 0xC7,
  0x8F, 0x3C, 0x3D, 0xE0, 0xFF, 0x03, 0xBC, 0x0F, 0xF8, 0x3E, 0xE0, 0xF3,
  0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xC3, 0xE7,
  0x7F, 0x3F, 0xBF, 0xFF, 0xFF, 0xF1, 0xF8, 0xFF, 0x07, 0x83, 0xF8, 0x3C,
  0x1F, 0xC1, 0xC0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xFC,
  0x1C, 0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38, 0x1F, 0xC1, 0xC0,
  0xFE, 0x0E, 0x07, 0xE7, 0xC7, 0x7F, 0xBF, 0xFD, 0xF1, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E,
  0x78, 0x39, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03,
  0xDC, 0x0F, 0x78, 0x78, 0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0xE7, 0xC7, 0x7F,
  0x3F, 0xFD, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0xFB, 0xBF, 0xDE, 0xFC, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F,
  0x1C, 0xFF, 0xF3, 0xFF, 0xDE, 0x1F, 0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x7D, 0xFF, 0xF3,
  0xFF, 0xC7, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0xE3, 0xF7, 0xFB, 0xFF, 0xDF, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1F, 0x8F,
  0xFD, 0xFF, 0x78, 0x2F, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xC0, 0xF8,
  0x07, 0x80, 0xF8, 0x1F, 0xFF, 0xBF, 0xF7, 0xFC, 0x38, 0x1C, 0x0E, 0x0F,
  0xFF, 0xFF, 0xFD, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x3F, 0x9F, 0xC7, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xFF, 0xFD, 0xFE, 0xE7, 0xE7, 0xF0, 0x1F, 0xC0, 0xF7,
  0x03, 0xDE, 0x0E, 0x78, 0x78, 0xE1, 0xE3, 0xC7, 0x0F, 0x1C, 0x1C, 0xF0,
  0x73, 0x81, 0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0,
  0xF0, 0x78, 0x3D, 0xC1, 0xE0, 0xF7, 0x07, 0xC3, 0x9E, 0x3F, 0x0E, 0x78,
  0xFC, 0x78, 0xE3, 0xB1, 0xE3, 0x8C, 0xE7, 0x0F, 0x73, 0x9C, 0x3D, 0xCE,
  0xF0, 0x77, 0x3B, 0x81, 0xD8, 0x6E, 0x07, 0x61, 0xF8, 0x1F, 0x87, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0xF8, 0x3D, 0xE0, 0xE3,
  0xC7, 0x8F, 0x3C, 0x1E, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFE, 0x07, 0xBC, 0x3C, 0xF0, 0xF1, 0xE7, 0x83, 0xBC, 0x0F,
  0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0xDE, 0x0E, 0x38, 0x78, 0xE1, 0xE3, 0xC7,
  0x07, 0x1C, 0x1C, 0xF0, 0x7B, 0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0x80, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x87, 0xC7, 0xE3, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x1F, 0x8F, 0x07, 0xC1, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3F, 0x0F, 0x80, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x7C, 0x3F, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF0, 0x78, 0x7C,
  0x7C, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF1, 0xF8, 0xF8,
  0x40, 0x00, 0x7E, 0x0F, 0xFF, 0xF9, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 9, 8, 13, 2, -21 },
  { 21, 15, 21, 17, 1, -21 },
  { 61, 13, 24, 15, 1, -22 },
  { 100, 22, 21, 24, 1, -21 },
  { 158, 18, 21, 19, 1, -21 },
  { 206, 3, 8, 7, 2, -21 },
  { 209, 7, 26, 9, 1, -21 },
  { 232, 7, 26, 9, 1, -21 },
  { 255, 13, 12, 15, 1, -22 },
  { 275, 13, 14, 15, 1, -17 },
  { 298, 5, 7, 8, 1, -3 },
  { 303, 7, 3, 9, 1, -9 },
  { 306, 4, 4, 8, 2, -4 },
  { 308, 11, 21, 11, 0, -21 },
  { 337, 13, 21, 15, 1, -21 },
  { 372, 9, 21, 15, 2, -21 },
  { 396, 13, 21, 15, 1, -21 },
  { 431, 13, 21, 15, 1, -21 },
  { 466, 15, 21, 15, 0, -21 },
  { 506, 12, 21, 15, 2, -21 },
  { 538, 13, 21, 15, 1, -21 },
  { 573, 13, 21, 15, 1, -21 },
  { 608, 13, 21, 15, 1, -21 },
  { 643, 13, 21, 15, 1, -21 },
  { 678, 4, 16, 8, 2, -16 },
  { 686, 5, 20, 8, 1, -16 },
  { 699, 13, 15, 15, 1, -18 },
  { 724, 13, 8, 15, 1, -14 },
  { 737, 13, 15, 15, 1, -18 },
  { 762, 12, 21, 12, 0, -21 },
  { 794, 22, 23, 24, 1, -21 },
  { 858, 18, 21, 18, 0, -21 },
  { 906, 14, 21, 18, 2, -21 },
  { 943, 14, 21, 17, 2, -21 },
  { 980, 16, 21, 19, 2, -21 },
  { 1022, 11, 21, 15, 2, -21 },
  { 1051, 11, 21, 14, 2, -21 },
  { 1080, 15, 21, 19, 2, -21 },
  { 1120, 15, 21, 20, 2, -21 },
  { 1160, 8, 21, 10, 1, -21 },
  { 1181, 8, 27, 8, -2, -21 },
  { 1208, 15, 21, 17, 2, -21 },
  { 1248, 11, 21, 14, 2, -21 },
  { 1277, 21, 21, 25, 2, -21 },
  { 1333, 17, 21, 21, 2, -21 },
  { 1378, 17, 21, 21, 2, -21 },
  { 1423, 13, 21, 16, 2, -21 },
  { 1458, 17, 26, 21, 2, -21 },
  { 1514, 15, 21, 17, 2, -21 },
  { 1554, 12, 21, 15, 1, -21 },
  { 1586, 14, 21, 15, 0, -21 },
  { 1623, 15, 21, 20, 2, -21 },
  { 1663, 17, 21, 17, 0, -21 },
  { 1708, 25, 21, 25, 0, -21 },
  { 1774, 16, 21, 16, 0, -21 },
  { 1816, 16, 21, 16, 0, -21 },
  { 1858, 13, 21, 15, 1, -21 },
  { 1893, 7, 26, 9, 2, -21 },
  { 1916, 11, 21, 11, 0, -21 },
  { 1945, 6, 26, 9, 1, -21 },
  { 1965, 14, 13, 16, 1, -21 },
  { 1988, 12, 2, 12, 0, 3 },
  { 1991, 7, 4, 9, 1, -22 },
  { 1995, 12, 16, 15, 1, -16 },
  { 2019, 13, 22, 17, 2, -22 },
  { 2055, 11, 16, 13, 1, -16 },
  { 2077, 14, 22, 17, 1, -22 },
  { 2116, 13, 16, 15, 1, -16 },
  { 2142, 11, 22, 10, 0, -22 },
  { 2173, 14, 23, 17, 1, -16 },
  { 2214, 13, 22, 17, 2, -22 },
  { 2250, 4, 22, 8, 2, -22 },
  { 2261, 7, 29, 8, -1, -22 },
  { 2287, 14, 22, 16, 2, -22 },
  { 2326, 4, 22, 8, 2, -22 },
  { 2337, 21, 16, 25, 2, -16 },
  { 2379, 13, 16, 17, 2, -16 },
  { 2405, 14, 16, 16, 1, -16 },
  { 2433, 13, 23, 17, 2, -16 },
  { 2471, 14, 23, 17, 1, -16 },
  { 2512, 9, 16, 11, 2, -16 },
  { 2530, 11, 16, 13, 1, -16 },
  { 2552, 9, 19, 11, 1, -19 },
  { 2574, 13, 16, 17, 2, -16 },
  { 2600, 14, 16, 14, 0, -16 },
  { 2628, 22, 16, 22, 0, -16 },
  { 2672, 14, 16, 15, 0, -16 },
  { 2700, 14, 23, 15, 0, -16 },
  { 2741, 11, 16, 13, 1, -16 },
  { 2763, 9, 26, 11, 1, -21 },
  { 2793, 3, 29, 15, 6, -22 },
  { 2804, 9, 26, 11, 1, -21 },
  { 2834, 13, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD29PT7B_H_
