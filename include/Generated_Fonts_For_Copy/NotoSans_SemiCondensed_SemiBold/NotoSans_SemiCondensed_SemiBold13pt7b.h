#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xA3, 0xC0, 0xBB, 0x90, 0x14, 0x69, 0xF9, 0x22, 0xDF, 0xCA,
  0x34, 0x48, 0x23, 0xFF, 0x4E, 0x38, 0xF5, 0xF9, 0x08, 0x71, 0x14, 0x8D,
  0x21, 0x56, 0x75, 0x42, 0xD0, 0xB4, 0x4D, 0x31, 0xC0, 0x3C, 0x36, 0x1B,
  0x07, 0x07, 0x92, 0x5B, 0x38, 0xCC, 0x7F, 0x80, 0xE0, 0x7A, 0x49, 0x24,
  0xD9, 0x80, 0xC6, 0x22, 0x33, 0x32, 0x26, 0xC0, 0x10, 0x4F, 0xCC, 0x68,
  0xA0, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x69, 0x60, 0xF0, 0xB0, 0x18, 0x84,
  0x62, 0x31, 0x88, 0xC0, 0x79, 0xB4, 0x51, 0xC5, 0x14, 0x5B, 0x38, 0x3F,
  0xB3, 0x33, 0x33, 0x30, 0x7D, 0x30, 0xC3, 0x18, 0x42, 0x10, 0xFC, 0xFD,
  0x30, 0xC6, 0x38, 0x30, 0x63, 0xF8, 0x0C, 0x38, 0xF1, 0x64, 0xD9, 0xBF,
  0x86, 0x0C, 0xFE, 0x21, 0xEF, 0x84, 0x33, 0xF0, 0x7E, 0x21, 0x6D, 0xC6,
  0x3B, 0x70, 0xFC, 0x10, 0xC2, 0x18, 0x43, 0x0C, 0x60, 0x7D, 0x14, 0xDE,
  0x39, 0x3C, 0x51, 0x78, 0x79, 0x3C, 0x51, 0x7C, 0xD0, 0xC2, 0x78, 0xE0,
  0x3C, 0x68, 0x00, 0xD2, 0xC0, 0x04, 0x33, 0x30, 0x38, 0x30, 0x40, 0xF8,
  0x3E, 0x86, 0x0C, 0x37, 0x62, 0x00, 0xFC, 0x42, 0x33, 0x10, 0x04, 0x60,
  0x3E, 0x20, 0xA7, 0xB6, 0xDA, 0x4D, 0x26, 0xFF, 0x24, 0x42, 0x1F, 0x00,
  0x18, 0x38, 0x3C, 0x24, 0x64, 0x7E, 0x7E, 0xC2, 0xC3, 0xFB, 0x3C, 0xF7,
  0xFB, 0x3C, 0x73, 0xF8, 0x7F, 0x0C, 0x20, 0x82, 0x0C, 0x39, 0x7C, 0xF9,
  0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0xEE, 0xF8, 0xFE, 0x31, 0xFF, 0xE3, 0x18,
  0xF8, 0xFE, 0x31, 0x8F, 0xE3, 0x18, 0xC0, 0x7F, 0x83, 0x04, 0x09, 0xF0,
  0xF1, 0xF3, 0x7E, 0xC7, 0x8F, 0x1F, 0xFF, 0xF8, 0xF1, 0xE3, 0xC6, 0xF6,
  0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xEC, 0xCF, 0x93,
  0x67, 0x8F, 0x1B, 0x36, 0x66, 0xC6, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xF8,
  0xE1, 0xF1, 0xF8, 0xBE, 0x5F, 0x6E, 0xA7, 0x53, 0xB9, 0xC8, 0x80, 0xC3,
  0xC7, 0xCF, 0x9D, 0xBB, 0x73, 0xE3, 0xC6, 0x7C, 0xC6, 0xC2, 0x83, 0x83,
  0x82, 0xC6, 0xE6, 0x7C, 0xFB, 0x3C, 0xF3, 0xFB, 0x8C, 0x30, 0xC0, 0x7C,
  0xC6, 0xC2, 0x83, 0x83, 0x82, 0xC6, 0xE6, 0x7C, 0x0C, 0x06, 0xF9, 0x9B,
  0x36, 0x6F, 0x9B, 0x36, 0x66, 0xCE, 0xFC, 0x61, 0x87, 0x0C, 0x73, 0xF0,
  0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE6, 0x7C, 0xC2, 0x8D, 0x1B, 0x26, 0xC5, 0x8E, 0x1C, 0x18, 0xC6,
  0x39, 0xCD, 0x39, 0xA5, 0x26, 0xB4, 0xF7, 0x8E, 0x71, 0x8C, 0x31, 0x80,
  0xC6, 0xD8, 0xB1, 0xC1, 0x87, 0x1B, 0x32, 0xC6, 0xC6, 0xC9, 0xB1, 0x43,
  0x82, 0x04, 0x08, 0x10, 0xFC, 0x30, 0x86, 0x30, 0x86, 0x10, 0xFC, 0xF2,
  0x49, 0x24, 0x93, 0x80, 0xC2, 0x18, 0x42, 0x18, 0x42, 0x18, 0xE4, 0x92,
  0x49, 0x27, 0x80, 0x10, 0x70, 0xA3, 0x6C, 0x60, 0xFC, 0xCC, 0x7D, 0x30,
  0xDF, 0xCD, 0x37, 0x40, 0xC3, 0x0C, 0x2E, 0xCF, 0x3C, 0xF3, 0xCE, 0xE0,
  0x7E, 0x21, 0x08, 0x65, 0xC0, 0x0C, 0x30, 0xFF, 0xCE, 0x38, 0xE3, 0xCD,
  0xF0, 0x76, 0x63, 0xF8, 0x65, 0xE0, 0x3B, 0x59, 0xE6, 0x31, 0x8C, 0x63,
  0x00, 0xFF, 0x38, 0xE3, 0x8F, 0x37, 0xC3, 0x9B, 0xE0, 0xC3, 0x0C, 0x2E,
  0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0xB3, 0xFF, 0xF0, 0x23, 0x03, 0x33, 0x33,
  0x33, 0x32, 0xE0, 0xC3, 0x0C, 0x33, 0xDA, 0xCF, 0x34, 0xDB, 0x30, 0xFF,
  0xFF, 0xF0, 0xBB, 0xE6, 0x73, 0x39, 0x1C, 0x8E, 0x47, 0x22, 0xBB, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0x7B, 0x28, 0xE3, 0x8F, 0x27, 0x80, 0xBB, 0x3C,
  0xF3, 0xCF, 0x3B, 0xB0, 0xC3, 0x00, 0xFF, 0x38, 0xE3, 0x8F, 0x37, 0xC3,
  0x0C, 0x30, 0xBC, 0xCC, 0xCC, 0xC0, 0xF8, 0xC7, 0x39, 0xF0, 0x26, 0xF6,
  0x66, 0x66, 0x30, 0x8E, 0x38, 0xE3, 0x8F, 0x7F, 0xC0, 0xC5, 0x34, 0xDA,
  0x38, 0xE3, 0x00, 0xCC, 0xD3, 0x25, 0xC9, 0xDE, 0x73, 0x8C, 0xC3, 0x30,
  0xCD, 0xA3, 0x8C, 0x39, 0xBC, 0xC0, 0xC5, 0x34, 0xDA, 0x38, 0xE3, 0x0C,
  0x33, 0x80, 0x78, 0xC4, 0x66, 0x23, 0xE0, 0x32, 0x22, 0x6C, 0x22, 0x22,
  0x30, 0xFF, 0xF8, 0xE1, 0x08, 0x42, 0x0C, 0x84, 0x23, 0x38, 0x27, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 6, 1, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 5, 11, 7, 1, -10 },
  { 21, 10, 9, 11, 0, -9 },
  { 33, 9, 9, 9, 0, -9 },
  { 44, 1, 3, 3, 1, -9 },
  { 45, 3, 11, 4, 1, -9 },
  { 50, 4, 11, 4, 0, -9 },
  { 56, 6, 6, 7, 0, -10 },
  { 61, 5, 7, 7, 1, -8 },
  { 66, 3, 4, 3, 0, -2 },
  { 68, 4, 1, 4, 0, -4 },
  { 69, 2, 2, 3, 1, -2 },
  { 70, 5, 9, 5, 0, -9 },
  { 76, 6, 9, 7, 0, -9 },
  { 83, 4, 9, 7, 1, -9 },
  { 88, 6, 9, 7, 0, -9 },
  { 95, 6, 9, 7, 0, -9 },
  { 102, 7, 9, 7, 0, -9 },
  { 110, 5, 9, 7, 1, -9 },
  { 116, 5, 9, 7, 1, -9 },
  { 122, 6, 9, 7, 0, -9 },
  { 129, 6, 9, 7, 0, -9 },
  { 136, 6, 9, 7, 0, -9 },
  { 143, 2, 7, 3, 1, -7 },
  { 145, 3, 9, 3, 0, -7 },
  { 149, 6, 7, 7, 0, -8 },
  { 155, 5, 3, 7, 1, -6 },
  { 157, 5, 7, 7, 1, -8 },
  { 162, 5, 9, 5, 0, -9 },
  { 168, 9, 10, 11, 1, -9 },
  { 180, 8, 9, 8, 0, -9 },
  { 189, 6, 9, 8, 1, -9 },
  { 196, 6, 9, 7, 1, -9 },
  { 203, 7, 9, 9, 1, -9 },
  { 211, 5, 9, 7, 1, -9 },
  { 217, 5, 9, 6, 1, -9 },
  { 223, 7, 9, 9, 1, -9 },
  { 231, 7, 9, 9, 1, -9 },
  { 239, 4, 9, 4, 0, -9 },
  { 244, 4, 12, 4, -1, -9 },
  { 250, 7, 9, 8, 1, -9 },
  { 258, 5, 9, 6, 1, -9 },
  { 264, 9, 9, 11, 1, -9 },
  { 275, 7, 9, 9, 1, -9 },
  { 283, 8, 9, 9, 1, -9 },
  { 292, 6, 9, 7, 1, -9 },
  { 299, 8, 11, 9, 1, -9 },
  { 310, 7, 9, 8, 1, -9 },
  { 318, 5, 9, 7, 1, -9 },
  { 324, 6, 9, 7, 0, -9 },
  { 331, 7, 9, 9, 1, -9 },
  { 339, 7, 9, 7, 0, -9 },
  { 347, 11, 9, 11, 0, -9 },
  { 360, 7, 9, 7, 0, -9 },
  { 368, 7, 9, 7, 0, -9 },
  { 376, 6, 9, 7, 0, -9 },
  { 383, 3, 11, 4, 1, -9 },
  { 388, 5, 9, 5, 0, -9 },
  { 394, 3, 11, 4, 0, -9 },
  { 399, 7, 5, 7, 0, -9 },
  { 404, 6, 1, 5, 0, 1 },
  { 405, 3, 2, 4, 1, -10 },
  { 406, 6, 7, 7, 0, -7 },
  { 412, 6, 10, 7, 1, -10 },
  { 420, 5, 7, 6, 1, -7 },
  { 425, 6, 10, 7, 1, -10 },
  { 433, 5, 7, 7, 1, -7 },
  { 438, 5, 10, 4, 0, -10 },
  { 445, 6, 10, 7, 1, -7 },
  { 453, 6, 10, 8, 1, -10 },
  { 461, 2, 10, 3, 1, -10 },
  { 464, 4, 13, 3, -1, -10 },
  { 471, 6, 10, 7, 1, -10 },
  { 479, 2, 10, 3, 1, -10 },
  { 482, 9, 7, 11, 1, -7 },
  { 490, 6, 7, 8, 1, -7 },
  { 496, 6, 7, 7, 1, -7 },
  { 502, 6, 10, 7, 1, -7 },
  { 510, 6, 10, 7, 1, -7 },
  { 518, 4, 7, 5, 1, -7 },
  { 522, 4, 7, 6, 1, -7 },
  { 526, 4, 9, 5, 0, -9 },
  { 531, 6, 7, 8, 1, -7 },
  { 537, 6, 7, 6, 0, -7 },
  { 543, 10, 7, 10, 0, -7 },
  { 552, 6, 7, 7, 0, -7 },
  { 558, 6, 10, 7, 0, -7 },
  { 566, 5, 7, 6, 0, -7 },
  { 571, 4, 11, 5, 0, -9 },
  { 577, 1, 13, 7, 3, -10 },
  { 579, 5, 11, 5, 0, -9 },
  { 586, 6, 2, 7, 0, -6 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD13PT7B_H_
