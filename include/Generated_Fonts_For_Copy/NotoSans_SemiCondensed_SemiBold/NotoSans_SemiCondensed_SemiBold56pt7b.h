#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x18, 0x00,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF,
  0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xC0,
  0xFD, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0x3C, 0x1C, 0xFE, 0x3C, 0x00, 0xFC, 0x3C,
  0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFE, 0x3C, 0x00, 0xFF, 0x3C,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3D, 0xFF, 0x00, 0x3C, 0x7F, 0x00, 0x3C,
  0x7F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x80, 0x3C, 0x7F, 0xE0, 0x3C,
  0xFF, 0xFC, 0x3D, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x07,
  0xE0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07, 0xE0,
  0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x1F, 0x00,
  0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0x40, 0x3F, 0x07, 0xE3, 0xE1, 0xFF, 0x07,
  0xC1, 0xF1, 0xF8, 0xFF, 0xE1, 0xF0, 0xFC, 0x7C, 0x7F, 0xFC, 0x7E, 0x3F,
  0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0x8F, 0xC7, 0xE3, 0xFF, 0xE3, 0xE3,
  0xF0, 0xF8, 0x7F, 0xF1, 0xF0, 0xF8, 0x3E, 0x0F, 0xF0, 0x7C, 0x7E, 0x0F,
  0xC0, 0x20, 0x3F, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x83, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0x07, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF,
  0xFF, 0x01, 0xFC, 0x7F, 0xCF, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1,
  0xFC, 0x0F, 0xF1, 0xFC, 0x7F, 0x80, 0xFF, 0x7F, 0x0F, 0xE0, 0x0F, 0xFF,
  0xE1, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x0F, 0xFF, 0x07, 0xF0, 0x01,
  0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0xC3,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xE0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x40, 0x3C, 0x02, 0x7C, 0x3C, 0x3F, 0xFF, 0xBD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0x81, 0xF0,
  0x03, 0x80, 0xC0, 0x00, 0x80, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xF8, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x3F,
  0x9F, 0xDF, 0xEF, 0xFF, 0xF9, 0xFC, 0xFE, 0x18, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0x8F, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xFB, 0xF0,
  0x01, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x00,
  0x7F, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0x83, 0xFE, 0x7F, 0xC1, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F,
  0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xEF, 0x87, 0xF3, 0x83, 0xF8, 0x81, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF1, 0xFF, 0x9F, 0xF8, 0x7C, 0x01, 0xFE, 0x1C, 0x00, 0xFF, 0x0C,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFE,
  0x0F, 0xF8, 0x78, 0x01, 0xFE, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xB8, 0x00, 0x3F, 0xDF, 0x80, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFC,
  0xFE, 0x00, 0x0F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xC0, 0xFE, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE,
  0x03, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x80, 0x01, 0xFE, 0xE0, 0x03, 0xFE, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF0, 0x10, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x1E, 0x00, 0xFC, 0x7F, 0xE0, 0x7E, 0x7F, 0xF8, 0x7F, 0x7F, 0xFE, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0xF7, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xE0,
  0x3F, 0x87, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF9,
  0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F,
  0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xE7, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0x9F, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0x80, 0x3F, 0xDF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xF1, 0xFE, 0x03, 0xF8,
  0xFE, 0x01, 0xFE, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0,
  0x3F, 0xEF, 0xF0, 0x3F, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFE, 0xFC, 0x7F,
  0xFF, 0x7E, 0x1F, 0xFF, 0x3F, 0x07, 0xFE, 0x3F, 0x80, 0x7C, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x08, 0x07, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C,
  0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x7F, 0x3F, 0xBF, 0xFF, 0xFF, 0xFB, 0xF9, 0xFC, 0x30, 0x1E,
  0x0F, 0xE3, 0xF9, 0xFF, 0x7F, 0xDF, 0xF3, 0xF8, 0xFE, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE3, 0xF0, 0x7F, 0xCE, 0x00, 0x7F, 0x20, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x0E, 0x00, 0x7E,
  0x3F, 0x00, 0xFF, 0xF8, 0x3E, 0x3E, 0x03, 0xFF, 0xFC, 0x3E, 0x7E, 0x07,
  0xFF, 0xF8, 0x1F, 0x7C, 0x07, 0xFF, 0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0x00, 0xF8, 0x1F,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0xF8, 0x3F,
  0x01, 0xF8, 0x1F, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0xF8, 0x1F, 0x03, 0xF8,
  0x3E, 0xF8, 0x1F, 0x83, 0xFC, 0x7E, 0xF8, 0x1F, 0xFF, 0xBF, 0xFC, 0xFC,
  0x0F, 0xFF, 0xBF, 0xF8, 0x7C, 0x07, 0xFF, 0x1F, 0xF8, 0x7C, 0x03, 0xFE,
  0x0F, 0xE0, 0x7E, 0x00, 0xF0, 0x03, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xE0, 0x0F, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0x1F, 0xC1, 0xFF, 0x80, 0x1C, 0x1F, 0xF0, 0x00, 0x43, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xC0, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0x1F, 0xC0, 0x0F, 0xF8, 0xFE, 0x00,
  0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x07,
  0xF8, 0xFE, 0x00, 0x7F, 0xC7, 0xF0, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFC, 0x7F, 0x83, 0xFF, 0x00, 0x1C, 0x1F, 0xF0, 0x00, 0x10,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFF, 0x80,
  0x1F, 0xC3, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF9, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF7, 0xE0, 0x00, 0xFB, 0xFF, 0xEF, 0xC0, 0x03, 0xF7, 0xFF, 0xDF,
  0x80, 0x07, 0xEF, 0xFF, 0x9F, 0x80, 0x0F, 0x9F, 0xFF, 0x3F, 0x00, 0x3F,
  0x3F, 0xFE, 0x7E, 0x00, 0x7E, 0x7F, 0xFC, 0x7C, 0x00, 0xF8, 0xFF, 0xF8,
  0xFC, 0x03, 0xF1, 0xFF, 0xF1, 0xF8, 0x07, 0xE3, 0xFF, 0xE3, 0xF0, 0x0F,
  0x87, 0xFF, 0xC3, 0xF0, 0x3F, 0x0F, 0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0xFF,
  0x0F, 0xC0, 0xF8, 0x3F, 0xFE, 0x0F, 0xC3, 0xF0, 0x7F, 0xFC, 0x1F, 0x87,
  0xE0, 0xFF, 0xF8, 0x3F, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x3F, 0x03, 0xFF,
  0xE0, 0x7E, 0x7E, 0x07, 0xFF, 0xC0, 0xFC, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xF0, 0x01, 0xFF, 0xEF, 0xE0,
  0x03, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF, 0x1F, 0xC0,
  0x1F, 0xFE, 0x3F, 0xC0, 0x3F, 0xFC, 0x3F, 0x80, 0x7F, 0xF8, 0x7F, 0x80,
  0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xC0, 0xFE, 0x07,
  0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0x01, 0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x3F,
  0xFC, 0x03, 0xF8, 0x7F, 0xF8, 0x03, 0xF8, 0xFF, 0xF0, 0x07, 0xF9, 0xFF,
  0xE0, 0x07, 0xF3, 0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0x80, 0x0F, 0xEF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFE, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFE,
  0x03, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0, 0x3C, 0x7F, 0x80,
  0x04, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0xF8, 0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x8F, 0xFF,
  0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0x03,
  0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xF9, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x7C, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x3F, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0x8F, 0xC0, 0xFE,
  0x00, 0xFC, 0x1F, 0x83, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F,
  0xC0, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x0F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x03, 0xF3,
  0xF8, 0x00, 0x3F, 0x3E, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE3,
  0xFE, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC0,
  0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x03,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x3F, 0xFF, 0x3F, 0x1F, 0xFE,
  0x1F, 0x0F, 0xFC, 0x1F, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x3F, 0x8F, 0xFC, 0x0F, 0xEF, 0xFF, 0x83, 0xFB, 0xFF, 0xF0, 0xFD,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFC, 0x0F, 0xF3, 0xFE, 0x01, 0xFC,
  0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x03,
  0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x3F, 0xF8, 0x7F, 0xCF, 0xFF,
  0xFF, 0xE3, 0xF7, 0xFF, 0xF8, 0xFC, 0xFF, 0xFC, 0x3F, 0x1F, 0xFE, 0x0F,
  0x83, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x81,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x01,
  0x8F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x11,
  0xFF, 0x07, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F,
  0xF9, 0xFC, 0x3F, 0xFE, 0x7E, 0x3F, 0xFF, 0xBF, 0x3F, 0xFF, 0xDF, 0x9F,
  0xFF, 0xFF, 0xDF, 0xF0, 0x7F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8,
  0x0F, 0xFB, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x1F,
  0xFF, 0x9F, 0x87, 0xFF, 0x8F, 0xC0, 0xFF, 0x83, 0xE0, 0x04, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x02, 0x3F, 0xE0, 0x1E, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0x8F, 0xC3, 0xFF, 0xE7, 0xE3, 0xFF, 0xFB,
  0xF3, 0xFF, 0xFD, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFB, 0xF1, 0xFF, 0xFB, 0xF8, 0x7F, 0xF9, 0xFC, 0x0F, 0xF8,
  0xFE, 0x00, 0x60, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF3, 0x80, 0x07, 0xF9, 0xF8,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x07, 0xF1,
  0xFF, 0xC3, 0xFB, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xBF, 0xF0, 0x3F, 0xDF, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x7D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xFC, 0x7F, 0xBF, 0xFD, 0xFF, 0xEF, 0xFE,
  0x7F, 0xE3, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xEF, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF9, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x3F, 0xF8, 0x1F, 0xFC,
  0x3F, 0x3F, 0xFE, 0x1F, 0xFF, 0x9F, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x1F, 0xFC, 0x3F,
  0x3F, 0xFF, 0x1F, 0xBF, 0xFF, 0xCF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB,
  0xFF, 0x03, 0xFD, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x87, 0xF8, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xFC, 0x0F, 0xCF, 0xFF, 0x83,
  0xF3, 0xFF, 0xF0, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFC, 0x0F,
  0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x3F,
  0xF8, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0xF8, 0xFE, 0xFF, 0xFC,
  0x3F, 0x9F, 0xFE, 0x0F, 0xE3, 0xFE, 0x03, 0xF8, 0x08, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x8F, 0xC3, 0xFF, 0xE7, 0xE3, 0xFF,
  0xFB, 0xF3, 0xFF, 0xFD, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0x03, 0xFE, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xE0, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFB, 0xF1, 0xFF, 0xFB, 0xF8, 0x7F, 0xF9, 0xFC, 0x0F,
  0xF8, 0xFE, 0x00, 0x60, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xEF,
  0xC7, 0xFB, 0xF3, 0xFE, 0xFD, 0xFF, 0xBF, 0x7F, 0xEF, 0xFF, 0xFB, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xC3, 0xF3, 0xF8, 0x01, 0x9F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC1, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x06, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xFF,
  0xF1, 0xF8, 0x3F, 0xE0, 0xFC, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xDF, 0xC0,
  0x1F, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFF,
  0x00, 0x7E, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xE3, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0x7E, 0x03, 0xEF, 0x80, 0xFC, 0x1F,
  0x81, 0xFB, 0xE0, 0x7F, 0x07, 0xF0, 0x7C, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xC7, 0xC1, 0xF8, 0x0F, 0xC3, 0xF1, 0xF0,
  0xFE, 0x03, 0xF8, 0xFC, 0x7E, 0x3F, 0x80, 0xFE, 0x3E, 0x1F, 0x8F, 0xC0,
  0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0xF8, 0xFC, 0x01, 0xF9,
  0xF8, 0x3E, 0x7F, 0x00, 0x7F, 0x7C, 0x0F, 0xDF, 0x80, 0x0F, 0xDF, 0x01,
  0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x00, 0xFD, 0xF0, 0x1F, 0x7E,
  0x00, 0x3F, 0x7C, 0x07, 0xDF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE3, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x04, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xFC, 0x00,
  0x5F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x80, 0x7F, 0xFD, 0x00, 0x07, 0xFC, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 41, 15, 3, -40 },
  { 48, 18, 14, 25, 3, -40 },
  { 80, 31, 40, 33, 1, -40 },
  { 235, 24, 46, 30, 3, -43 },
  { 373, 42, 42, 46, 2, -41 },
  { 594, 35, 42, 37, 2, -41 },
  { 778, 7, 14, 14, 3, -40 },
  { 791, 14, 49, 18, 2, -40 },
  { 877, 14, 49, 18, 1, -40 },
  { 963, 24, 25, 28, 2, -43 },
  { 1038, 25, 27, 30, 2, -33 },
  { 1123, 9, 14, 15, 2, -7 },
  { 1139, 14, 6, 17, 2, -18 },
  { 1150, 9, 9, 15, 3, -8 },
  { 1161, 21, 40, 22, 1, -40 },
  { 1266, 25, 42, 30, 2, -41 },
  { 1398, 17, 40, 30, 4, -40 },
  { 1483, 25, 41, 30, 2, -41 },
  { 1612, 25, 42, 30, 2, -41 },
  { 1744, 28, 40, 30, 1, -40 },
  { 1884, 24, 41, 30, 3, -40 },
  { 2007, 25, 41, 30, 2, -40 },
  { 2136, 25, 40, 30, 2, -40 },
  { 2261, 25, 41, 30, 2, -40 },
  { 2390, 25, 41, 30, 2, -40 },
  { 2519, 9, 32, 15, 3, -31 },
  { 2555, 10, 38, 15, 2, -31 },
  { 2603, 25, 28, 30, 2, -34 },
  { 2691, 25, 16, 30, 2, -28 },
  { 2741, 25, 28, 30, 2, -34 },
  { 2829, 22, 42, 24, 0, -41 },
  { 2945, 40, 45, 46, 3, -40 },
  { 3170, 34, 40, 34, 0, -40 },
  { 3340, 26, 40, 34, 5, -40 },
  { 3470, 28, 42, 32, 3, -41 },
  { 3617, 29, 40, 37, 5, -40 },
  { 3762, 20, 40, 29, 5, -40 },
  { 3862, 20, 40, 28, 5, -40 },
  { 3962, 30, 42, 37, 3, -41 },
  { 4120, 29, 40, 38, 5, -40 },
  { 4265, 16, 40, 19, 2, -40 },
  { 4345, 16, 51, 16, -4, -40 },
  { 4447, 28, 40, 33, 5, -40 },
  { 4587, 21, 40, 27, 5, -40 },
  { 4692, 39, 40, 48, 5, -40 },
  { 4887, 31, 40, 41, 5, -40 },
  { 5042, 34, 42, 40, 3, -41 },
  { 5221, 24, 40, 32, 5, -40 },
  { 5341, 34, 51, 40, 3, -41 },
  { 5558, 28, 40, 33, 5, -40 },
  { 5698, 24, 42, 28, 2, -41 },
  { 5824, 27, 40, 29, 1, -40 },
  { 5959, 29, 41, 38, 4, -40 },
  { 6108, 32, 40, 32, 0, -40 },
  { 6268, 49, 40, 49, 0, -40 },
  { 6513, 32, 40, 32, 0, -40 },
  { 6673, 30, 40, 30, 0, -40 },
  { 6823, 26, 40, 29, 1, -40 },
  { 6953, 13, 49, 18, 4, -40 },
  { 7033, 22, 40, 22, 0, -40 },
  { 7143, 13, 49, 18, 1, -40 },
  { 7223, 28, 25, 31, 1, -40 },
  { 7311, 24, 4, 24, 0, 5 },
  { 7323, 14, 9, 18, 2, -43 },
  { 7339, 24, 32, 30, 2, -31 },
  { 7435, 26, 44, 32, 4, -43 },
  { 7578, 21, 32, 26, 3, -31 },
  { 7662, 25, 44, 32, 3, -43 },
  { 7800, 24, 32, 30, 3, -31 },
  { 7896, 20, 43, 19, 1, -43 },
  { 8004, 25, 44, 32, 3, -31 },
  { 8142, 25, 43, 33, 4, -43 },
  { 8277, 7, 42, 15, 4, -42 },
  { 8314, 13, 55, 15, -2, -42 },
  { 8404, 26, 43, 30, 4, -43 },
  { 8544, 7, 43, 15, 4, -43 },
  { 8582, 41, 31, 49, 4, -31 },
  { 8741, 25, 31, 33, 4, -31 },
  { 8838, 26, 32, 32, 3, -31 },
  { 8942, 26, 44, 32, 4, -31 },
  { 9085, 25, 44, 32, 3, -31 },
  { 9223, 18, 31, 22, 4, -31 },
  { 9293, 21, 32, 25, 2, -31 },
  { 9377, 18, 38, 21, 1, -37 },
  { 9463, 25, 31, 33, 4, -30 },
  { 9560, 28, 30, 28, 0, -30 },
  { 9665, 42, 30, 43, 0, -30 },
  { 9823, 28, 30, 28, 0, -30 },
  { 9928, 28, 43, 28, 0, -30 },
  { 10079, 21, 30, 24, 2, -30 },
  { 10158, 18, 49, 21, 1, -40 },
  { 10269, 6, 56, 28, 11, -43 },
  { 10311, 18, 49, 21, 2, -40 },
  { 10422, 25, 9, 30, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD56PT7B_H_
