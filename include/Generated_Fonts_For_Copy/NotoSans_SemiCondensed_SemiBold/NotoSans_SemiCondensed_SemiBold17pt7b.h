#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x03, 0xE0, 0xDF, 0x6C, 0xB2, 0x09, 0x06, 0x41,
  0xB1, 0xFF, 0x7F, 0xC4, 0x81, 0x23, 0xFE, 0xFF, 0x8D, 0x82, 0x60, 0x90,
  0x10, 0x33, 0xFE, 0x9D, 0x1E, 0x1E, 0x0F, 0x16, 0x2F, 0x7F, 0xE1, 0x02,
  0x00, 0xF0, 0xCD, 0x18, 0x99, 0x09, 0xB0, 0x9A, 0x0D, 0x6F, 0xF7, 0xB0,
  0xD9, 0x0D, 0x91, 0x99, 0x18, 0xB3, 0x0E, 0x7C, 0x1B, 0x86, 0x61, 0xB0,
  0x7C, 0x0E, 0x0F, 0x9F, 0x36, 0xC7, 0xB0, 0xCF, 0xF9, 0xF7, 0xFF, 0x36,
  0x6C, 0xCC, 0xCC, 0xCC, 0xCC, 0x66, 0x30, 0xE3, 0x0C, 0x63, 0x0C, 0x63,
  0x18, 0x8C, 0x63, 0x33, 0x00, 0x30, 0x62, 0x5F, 0xF3, 0x8D, 0x33, 0x00,
  0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08, 0xFE, 0xF0, 0xF8, 0x0E, 0x18,
  0x30, 0xC1, 0x82, 0x0C, 0x18, 0x60, 0xC1, 0x86, 0x00, 0x7D, 0xDB, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8D, 0xF3, 0xE0, 0x19, 0xFE, 0xB1, 0x8C,
  0x63, 0x18, 0xC6, 0x30, 0x7D, 0xFE, 0x18, 0x30, 0x61, 0x86, 0x1C, 0x70,
  0xC3, 0xFF, 0xF0, 0xFD, 0x9C, 0x18, 0x30, 0xCF, 0x1F, 0x03, 0x06, 0x0F,
  0xFF, 0xE0, 0x06, 0x07, 0x03, 0x83, 0xC3, 0x61, 0x31, 0x98, 0x8C, 0xFF,
  0x83, 0x01, 0x80, 0xC0, 0xFD, 0xFB, 0x06, 0x0F, 0x9F, 0x83, 0x83, 0x06,
  0x0F, 0xF7, 0xC0, 0x3E, 0xE7, 0x06, 0x0D, 0xDF, 0xF1, 0xE3, 0xC7, 0x8D,
  0xFB, 0xE0, 0xFF, 0xFC, 0x18, 0x60, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0xC3,
  0x00, 0x7D, 0xDF, 0x1E, 0x36, 0xC7, 0x1F, 0x63, 0xC7, 0x8F, 0xBB, 0xE0,
  0x7D, 0xDB, 0x1E, 0x3C, 0x78, 0xFF, 0x9B, 0x06, 0x1B, 0xF7, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x06, 0xDA, 0x00, 0x02, 0x1C, 0xE7, 0x0E,
  0x07, 0x03, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x81, 0xC0, 0xE0, 0x70, 0xE7,
  0x38, 0x40, 0xFC, 0xDC, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0x00, 0x00, 0xC1,
  0x80, 0x1F, 0x83, 0x0E, 0x60, 0x24, 0x7B, 0xCD, 0x99, 0x99, 0x99, 0x99,
  0x99, 0x99, 0xBC, 0xEE, 0x40, 0x06, 0x04, 0x3F, 0x80, 0x0E, 0x07, 0x81,
  0xE0, 0x6C, 0x33, 0x0C, 0xC3, 0x39, 0xFE, 0x7F, 0x98, 0x7E, 0x0F, 0x03,
  0xFE, 0xFF, 0xE3, 0xE3, 0xE7, 0xFC, 0xFF, 0xE3, 0xE3, 0xE3, 0xFF, 0xFE,
  0x3F, 0x7F, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x7F, 0x3F,
  0xFE, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFF,
  0xDF, 0x80, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xBF, 0x70, 0xE1, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xBF, 0x70, 0xE1, 0xC3, 0x87, 0x00,
  0x3F, 0xBF, 0xD8, 0x1C, 0x0C, 0x06, 0x3F, 0x1F, 0x83, 0xE1, 0xB0, 0xDF,
  0xE7, 0xF0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x30, 0xF6, 0x66, 0x66, 0x66, 0x66, 0xFF, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x5B, 0xC0, 0xE3, 0xF3, 0xB9, 0x9D,
  0x8F, 0xC7, 0xC3, 0xF1, 0xD8, 0xE6, 0x73, 0xB8, 0xDC, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xF0, 0x7F, 0x07,
  0xF0, 0xFD, 0x8F, 0xD8, 0xFD, 0x8B, 0xC9, 0xBC, 0xDB, 0xCD, 0x3C, 0x73,
  0xC7, 0x3C, 0x63, 0xE0, 0xFC, 0x3F, 0x0F, 0x63, 0xDC, 0xF3, 0x3C, 0xEF,
  0x1B, 0xC7, 0xF0, 0xFC, 0x1F, 0x07, 0x3F, 0x1F, 0xEE, 0x1F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x67, 0xF8, 0xFC, 0xFC, 0xFE, 0xE3,
  0xE3, 0xE3, 0xE7, 0xFE, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x1F, 0xEE,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x77, 0xF8, 0xFC,
  0x03, 0x00, 0xE0, 0x1C, 0xFE, 0x7F, 0xB8, 0xDC, 0x6E, 0x37, 0xF3, 0xF1,
  0xD8, 0xE6, 0x73, 0x38, 0xDC, 0x70, 0x7F, 0xFB, 0x06, 0x0E, 0x0F, 0x0F,
  0x07, 0x07, 0x0F, 0xF7, 0xC0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE1, 0xB0, 0xDF, 0xC7, 0xC0, 0xC1, 0xD8, 0x66, 0x19, 0x86,
  0x63, 0x0C, 0xC3, 0x30, 0xD8, 0x1E, 0x07, 0x81, 0xC0, 0x30, 0xC3, 0x87,
  0x87, 0x19, 0x8E, 0x33, 0x14, 0x66, 0x6C, 0xCC, 0xDB, 0x8D, 0xB6, 0x1A,
  0x6C, 0x3C, 0x58, 0x78, 0xF0, 0x71, 0xC0, 0xC3, 0x80, 0xE1, 0x98, 0xC3,
  0x30, 0xF8, 0x1E, 0x07, 0x01, 0xC0, 0x78, 0x37, 0x1C, 0xC6, 0x3B, 0x87,
  0xE1, 0xB1, 0x98, 0xC6, 0xE3, 0x60, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x7F, 0x7F, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60,
  0xFF, 0xFF, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0xC1,
  0x81, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x70, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x3F, 0xF0, 0x08, 0x0E, 0x05, 0x06, 0xC2, 0x23, 0x1B,
  0x86, 0xFF, 0xFC, 0xC6, 0x30, 0x7C, 0x9C, 0x19, 0xFF, 0xF8, 0xF1, 0xE7,
  0xF6, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3,
  0xFE, 0xDE, 0x7F, 0x9C, 0x30, 0xC3, 0x0C, 0x3F, 0x7C, 0x07, 0x07, 0x07,
  0x03, 0x7B, 0xE7, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0x7D, 0xCF,
  0x1F, 0xFF, 0xF8, 0x30, 0x3B, 0x3E, 0x1C, 0xF3, 0x0C, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x7B, 0xE7, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF,
  0x7B, 0x07, 0x06, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xE7, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF4, 0xFF, 0xFF, 0xC0, 0x33, 0x10,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7,
  0xCC, 0xDC, 0xD8, 0xF8, 0xEC, 0xCC, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xC0,
  0xDE, 0xF7, 0x39, 0xF9, 0xC7, 0x8C, 0x3C, 0x61, 0xE3, 0x0F, 0x18, 0x78,
  0xC3, 0xC6, 0x18, 0xDE, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x7C, 0xE6, 0xC7, 0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x3C, 0xDE, 0xE7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0xFE, 0xDE, 0xC0, 0xC0, 0xC0, 0xC0, 0x7B, 0xE7,
  0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0x07, 0x07, 0x07, 0x07, 0xDF,
  0xEE, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0xFF, 0x2C, 0x38, 0x78, 0x70, 0xF7,
  0xF8, 0x20, 0x8F, 0xD8, 0x61, 0x86, 0x18, 0x60, 0xF3, 0xC0, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0xC3, 0x63, 0x67, 0x66, 0x36,
  0x36, 0x3C, 0x1C, 0x1C, 0xC7, 0x1B, 0x39, 0x99, 0x4C, 0xDB, 0x66, 0xDB,
  0x1E, 0xF0, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xE3, 0x76, 0x3E, 0x1C, 0x1C,
  0x3C, 0x36, 0x66, 0xE3, 0xC3, 0x63, 0x63, 0x66, 0x36, 0x36, 0x3C, 0x1C,
  0x1C, 0x18, 0x18, 0xF0, 0xF0, 0x7E, 0x1C, 0x30, 0xC3, 0x86, 0x18, 0x3F,
  0xFE, 0x1C, 0xE3, 0x0C, 0x30, 0xCF, 0x38, 0x30, 0xC3, 0x0C, 0x30, 0x70,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0x18, 0xC6, 0x30, 0xE7, 0x63,
  0x18, 0xC6, 0x72, 0x00, 0xF3, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 6, 4, 7, 1, -12 },
  { 9, 10, 12, 10, 0, -12 },
  { 24, 7, 14, 9, 1, -13 },
  { 37, 12, 12, 14, 1, -12 },
  { 55, 10, 12, 11, 1, -12 },
  { 70, 2, 4, 4, 1, -12 },
  { 71, 4, 15, 5, 1, -12 },
  { 79, 5, 15, 5, 0, -12 },
  { 89, 7, 7, 9, 1, -13 },
  { 96, 7, 8, 9, 1, -10 },
  { 103, 2, 4, 4, 1, -2 },
  { 104, 4, 1, 5, 1, -5 },
  { 105, 3, 2, 4, 1, -2 },
  { 106, 7, 12, 7, 0, -12 },
  { 117, 7, 12, 9, 1, -12 },
  { 128, 5, 12, 9, 1, -12 },
  { 136, 7, 12, 9, 1, -12 },
  { 147, 7, 12, 9, 1, -12 },
  { 158, 9, 12, 9, 0, -12 },
  { 172, 7, 12, 9, 1, -12 },
  { 183, 7, 12, 9, 1, -12 },
  { 194, 7, 12, 9, 1, -12 },
  { 205, 7, 12, 9, 1, -12 },
  { 216, 7, 12, 9, 1, -12 },
  { 227, 3, 9, 5, 1, -9 },
  { 231, 3, 11, 5, 1, -9 },
  { 236, 7, 8, 9, 1, -10 },
  { 243, 7, 4, 9, 1, -8 },
  { 247, 7, 8, 9, 1, -10 },
  { 254, 7, 12, 7, 0, -12 },
  { 265, 12, 13, 14, 1, -12 },
  { 285, 10, 12, 10, 0, -12 },
  { 300, 8, 12, 10, 1, -12 },
  { 312, 8, 12, 10, 1, -12 },
  { 324, 9, 12, 11, 1, -12 },
  { 338, 7, 12, 9, 1, -12 },
  { 349, 7, 12, 8, 1, -12 },
  { 360, 9, 12, 11, 1, -12 },
  { 374, 9, 12, 12, 1, -12 },
  { 388, 4, 12, 6, 1, -12 },
  { 394, 5, 15, 5, -1, -12 },
  { 404, 9, 12, 10, 1, -12 },
  { 418, 7, 12, 8, 1, -12 },
  { 429, 12, 12, 15, 1, -12 },
  { 447, 10, 12, 12, 1, -12 },
  { 462, 10, 12, 12, 1, -12 },
  { 477, 8, 12, 10, 1, -12 },
  { 489, 10, 15, 12, 1, -12 },
  { 508, 9, 12, 10, 1, -12 },
  { 522, 7, 12, 9, 1, -12 },
  { 533, 8, 12, 9, 0, -12 },
  { 545, 9, 12, 11, 1, -12 },
  { 559, 10, 12, 10, 0, -12 },
  { 574, 15, 12, 15, 0, -12 },
  { 597, 10, 12, 10, 0, -12 },
  { 612, 9, 12, 9, 0, -12 },
  { 626, 8, 12, 9, 0, -12 },
  { 638, 4, 15, 5, 1, -12 },
  { 646, 7, 12, 7, 0, -12 },
  { 657, 4, 15, 5, 0, -12 },
  { 665, 9, 7, 9, 0, -12 },
  { 673, 7, 2, 7, 0, 1 },
  { 675, 4, 3, 5, 1, -13 },
  { 677, 7, 9, 9, 1, -9 },
  { 685, 8, 13, 10, 1, -13 },
  { 698, 6, 9, 8, 1, -9 },
  { 705, 8, 13, 10, 1, -13 },
  { 718, 7, 9, 9, 1, -9 },
  { 726, 6, 13, 6, 0, -13 },
  { 736, 8, 13, 10, 1, -9 },
  { 749, 8, 13, 10, 1, -13 },
  { 762, 2, 13, 4, 1, -13 },
  { 766, 4, 17, 4, -1, -13 },
  { 775, 8, 13, 9, 1, -13 },
  { 788, 2, 13, 4, 1, -13 },
  { 792, 13, 9, 15, 1, -9 },
  { 807, 8, 9, 10, 1, -9 },
  { 816, 8, 9, 10, 1, -9 },
  { 825, 8, 13, 10, 1, -9 },
  { 838, 8, 13, 10, 1, -9 },
  { 851, 6, 9, 7, 1, -9 },
  { 858, 6, 9, 8, 1, -9 },
  { 865, 6, 11, 6, 0, -11 },
  { 874, 8, 9, 10, 1, -9 },
  { 883, 8, 9, 8, 0, -9 },
  { 892, 13, 9, 13, 0, -9 },
  { 907, 8, 9, 9, 0, -9 },
  { 916, 8, 13, 9, 0, -9 },
  { 929, 7, 9, 7, 0, -9 },
  { 937, 6, 15, 6, 0, -12 },
  { 949, 2, 17, 9, 3, -13 },
  { 954, 5, 15, 6, 1, -12 },
  { 964, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD17PT7B_H_
