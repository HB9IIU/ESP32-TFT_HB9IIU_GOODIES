#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xF1, 0xC0, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8,
  0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x78,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x01, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xF8,
  0xC1, 0xCF, 0xC3, 0x00, 0x3F, 0x0C, 0x00, 0xFC, 0x30, 0x03, 0xF0, 0xC0,
  0x07, 0xE3, 0x00, 0x1F, 0xEC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x0C, 0xFE, 0x00, 0x31, 0xFC, 0x00, 0xC3, 0xF0, 0x03, 0x0F,
  0xE0, 0x0C, 0x3F, 0xE0, 0x31, 0xFB, 0xF0, 0xCF, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x1F, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0x80, 0x0F, 0xFE, 0x00,
  0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xC7, 0xC0, 0x3E, 0x00, 0x7C,
  0x3E, 0x01, 0xE0, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0xF0,
  0x00, 0xF8, 0x3C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x78, 0x00, 0x3E, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x3C, 0x00, 0x0F, 0x83, 0xC3, 0xE0, 0x00,
  0x7C, 0x1E, 0x1E, 0x02, 0x03, 0xE1, 0xF1, 0xF1, 0xFE, 0x1F, 0x0F, 0x8F,
  0x1F, 0xF8, 0x7C, 0x7C, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0x8F, 0xFF, 0x0F,
  0xFE, 0x7C, 0x78, 0x7C, 0x7F, 0xE3, 0xE7, 0xC3, 0xE0, 0xFE, 0x3E, 0x3E,
  0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x83, 0xC0, 0x00,
  0xF8, 0x78, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0xF8, 0x00, 0x7C, 0x1E, 0x07,
  0x80, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0x3E, 0x07, 0xC1, 0xE0, 0x03, 0xE0,
  0x3E, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0x87, 0xC0,
  0x0F, 0x80, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x07,
  0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x03, 0xF0, 0x7F, 0xFC, 0x07, 0xE1, 0xFF, 0xF8, 0x1F, 0x87,
  0xF3, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x3F, 0x83, 0xF9, 0xF8, 0x7E,
  0x03, 0xFB, 0xF0, 0xFC, 0x03, 0xFF, 0xC1, 0xF8, 0x03, 0xFF, 0x83, 0xF0,
  0x03, 0xFE, 0x07, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF7, 0xF0, 0x3F, 0xFF, 0x87, 0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x79, 0xE7, 0x9E, 0x78, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC3, 0xC1,
  0xDF, 0xDE, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x01, 0xF3, 0xF0,
  0x1F, 0x8F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x0E, 0x0E, 0x00, 0x20,
  0x20, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x18, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7,
  0xFF, 0xBF, 0xFF, 0xFE, 0x7E, 0xF8, 0xFC, 0xE1, 0xF8, 0x83, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F, 0xC3, 0x80,
  0x3F, 0x84, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xE0, 0x1F, 0xC3,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x80, 0x03, 0xFB, 0x80, 0x1F, 0xEF, 0xF7, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7B, 0xF0, 0x00,
  0xFB, 0xF0, 0x00, 0xF3, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x03,
  0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x1F,
  0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0C, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE8, 0x00, 0x7F, 0x60, 0x07, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFE, 0xF0, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF1, 0xFE, 0x0F, 0xDF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0x3F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0x01, 0xF8, 0xFE, 0x0F, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x87, 0xF1, 0xF8, 0x0F, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0x9F, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x3F, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x0F,
  0xF7, 0xF8, 0x3F, 0x8F, 0xF1, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xE7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F,
  0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFD, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xBF, 0x1F, 0xFC, 0xF8, 0x3F, 0xE3, 0xE0, 0x08, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x83, 0x9F, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x7D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xF1, 0xC0, 0x3E, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0x80,
  0x7E, 0x20, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x0F, 0xF0,
  0x3E, 0x3E, 0x03, 0xFF, 0xC3, 0xE3, 0xE0, 0x7F, 0xFC, 0x1E, 0x3C, 0x0F,
  0xFF, 0xC1, 0xF7, 0xC1, 0xF8, 0x3C, 0x1F, 0x7C, 0x1F, 0x03, 0xC1, 0xF7,
  0x83, 0xE0, 0x3C, 0x0F, 0x78, 0x3E, 0x03, 0xC0, 0xF7, 0x83, 0xC0, 0x7C,
  0x0F, 0xF8, 0x7C, 0x07, 0xC0, 0xFF, 0x87, 0xC0, 0x7C, 0x0F, 0xF8, 0x7C,
  0x07, 0xC1, 0xFF, 0x87, 0xC0, 0x7C, 0x1F, 0xF8, 0x3C, 0x07, 0xC1, 0xEF,
  0x83, 0xE0, 0xFC, 0x1E, 0x78, 0x3E, 0x0F, 0xC3, 0xE7, 0x83, 0xF3, 0xFE,
  0x7C, 0x7C, 0x1F, 0xFD, 0xFF, 0xC7, 0xC0, 0xFF, 0x8F, 0xF8, 0x7C, 0x07,
  0xF0, 0x7F, 0x03, 0xE0, 0x08, 0x01, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0x00, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x1F, 0xDF, 0x80, 0x7F, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F, 0xEF, 0xC0, 0x1F,
  0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x1C, 0x3F,
  0xC0, 0x04, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x0E, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x01, 0xFF, 0x8F, 0xC0, 0x1F,
  0xE3, 0xF0, 0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF,
  0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xFC, 0xFC, 0x01, 0xFE,
  0x3F, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xFC, 0x01, 0xC3, 0xFC, 0x00, 0x10, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xF0,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0xC0, 0x0F, 0xC7, 0xF8, 0x03, 0xF1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xF1, 0xFE,
  0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F,
  0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F,
  0xF3, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x7F,
  0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xEF, 0x80, 0x07, 0xDF, 0xFB, 0xE0, 0x01,
  0xF7, 0xFE, 0xFC, 0x00, 0x7D, 0xFF, 0x9F, 0x00, 0x3E, 0x7F, 0xF7, 0xC0,
  0x0F, 0x9F, 0xFD, 0xF0, 0x03, 0xEF, 0xFF, 0x3E, 0x01, 0xF3, 0xFF, 0xCF,
  0x80, 0x7C, 0xFF, 0xF3, 0xE0, 0x1F, 0x3F, 0xFC, 0xFC, 0x0F, 0x8F, 0xFF,
  0x1F, 0x03, 0xE3, 0xFF, 0xC7, 0xC0, 0xF8, 0xFF, 0xF1, 0xF8, 0x7C, 0x3F,
  0xFC, 0x3E, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xC3, 0xFF, 0xC3, 0xF3, 0xF0,
  0xFF, 0xF0, 0x7C, 0xF8, 0x3F, 0xFC, 0x1F, 0x3E, 0x0F, 0xFF, 0x07, 0xCF,
  0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFB, 0xF0, 0x03, 0xFF, 0x7F,
  0x00, 0x7F, 0xE7, 0xE0, 0x0F, 0xFC, 0xFE, 0x01, 0xFF, 0xCF, 0xC0, 0x3F,
  0xF9, 0xFC, 0x07, 0xFF, 0x1F, 0x80, 0xFF, 0xE3, 0xF8, 0x1F, 0xFC, 0x3F,
  0x03, 0xFF, 0x83, 0xF0, 0x7F, 0xF0, 0x7F, 0x0F, 0xFE, 0x07, 0xE1, 0xFF,
  0xC0, 0xFE, 0x3F, 0xF8, 0x0F, 0xC7, 0xFF, 0x01, 0xFC, 0xFF, 0xE0, 0x1F,
  0x9F, 0xFC, 0x03, 0xFB, 0xFF, 0x80, 0x3F, 0x7F, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC, 0x0F,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xE0,
  0x7F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E,
  0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0xFC,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0x80,
  0xF1, 0xF8, 0x00, 0x8F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0x7C, 0x03, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xF7, 0xF0, 0x07, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE7, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x3F, 0x00,
  0xFB, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xEF,
  0x80, 0xFC, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xBE, 0x03,
  0xF0, 0x3F, 0x03, 0xE7, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x7C, 0x1F, 0x80,
  0x7E, 0x0F, 0x8F, 0x83, 0xF0, 0x0F, 0xC3, 0xF1, 0xF0, 0x7E, 0x01, 0xF8,
  0x7C, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x03, 0xE1, 0xF0,
  0x7C, 0x7E, 0x00, 0x7E, 0x7E, 0x0F, 0x8F, 0xC0, 0x0F, 0xCF, 0x81, 0xF1,
  0xF8, 0x01, 0xF9, 0xF0, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xBF, 0x00, 0x0F,
  0xFE, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7E,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x06, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xC7, 0xEF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFC, 0xF9, 0xFF,
  0xC7, 0xC7, 0xFC, 0x3E, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x07,
  0xE3, 0xFE, 0x0F, 0xDF, 0xFF, 0x1F, 0xBF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F,
  0xC1, 0xFC, 0xFF, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0xC0, 0x7F, 0x7F, 0xC0, 0xFE,
  0xFF, 0xE7, 0xF9, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0xC7, 0xE7, 0xFF, 0x0F,
  0x87, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0x83, 0x8F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0xF3, 0xF0, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0x7F, 0x01, 0xFE, 0xFC, 0x01, 0xFD,
  0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xBF, 0xC0, 0xFF, 0x3F, 0xEF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFD,
  0xF8, 0x7F, 0xF1, 0xF0, 0x3F, 0xC3, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0xFE, 0x0F, 0xE7,
  0xF0, 0x1F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x63, 0xFE, 0x1F, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0x70, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x8F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x0F, 0xFC, 0xFC, 0x3F,
  0xFD, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xF0, 0x7F, 0xDF, 0xC0,
  0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xCF, 0xF3, 0xFF, 0x9F,
  0xFF, 0xFF, 0x1F, 0xFF, 0x7E, 0x1F, 0xFC, 0xFC, 0x0F, 0xF1, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x20, 0x01, 0xFC, 0x7C, 0x0F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC3, 0xF8, 0x3F, 0x3F, 0xF8, 0xFD, 0xFF, 0xF3, 0xF7, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFC, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00,
  0x03, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xC0, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE8, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF,
  0xF0, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0xFE,
  0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x83, 0xF1, 0xFC, 0x0F, 0x8F, 0xE0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8,
  0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0x8F, 0xFE, 0x1F, 0xFC, 0xFD, 0xFF,
  0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0xF8, 0x3F, 0x83, 0xE3, 0xFF, 0x8F, 0xDF, 0xFF, 0x3F,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x9F,
  0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xF9, 0xFE,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0xF8, 0x3F, 0x81, 0xF8, 0xFF, 0xC3, 0xF7, 0xFF, 0xC7, 0xEF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0x7E, 0xFE,
  0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xEF, 0xF0, 0x1F,
  0xDF, 0xF0, 0x3F, 0xBF, 0xFB, 0xFE, 0x7F, 0xFF, 0xFC, 0xFD, 0xFF, 0xF1,
  0xF9, 0xFF, 0xC3, 0xF1, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3E, 0x0F, 0xFC, 0xFC, 0x3F,
  0xFD, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xF0, 0x7F, 0xDF, 0xC0,
  0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB,
  0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xCF, 0xFB, 0xFF, 0x9F,
  0xFF, 0xFF, 0x1F, 0xFF, 0x7E, 0x1F, 0xFC, 0xFC, 0x0F, 0xF1, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF8, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFE, 0xFF, 0xBF, 0xBF, 0x00, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC3, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE7, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0x7C, 0x7F, 0xF9, 0xF0, 0xFF, 0x87, 0xC0,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0,
  0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xF7, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x80, 0x7C, 0xFC,
  0x03, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0xE0, 0x3F, 0x1F, 0x81, 0xFF, 0x01,
  0xF8, 0xFC, 0x0F, 0x7C, 0x0F, 0x87, 0xE0, 0x7B, 0xE0, 0xFC, 0x1F, 0x07,
  0xDF, 0x07, 0xE0, 0xFC, 0x3E, 0x78, 0x3F, 0x07, 0xE1, 0xF3, 0xC1, 0xF0,
  0x3F, 0x0F, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0xF8, 0xFC, 0x07, 0xC7, 0xC7,
  0xC7, 0xE0, 0x3F, 0x3E, 0x1E, 0x3E, 0x01, 0xF9, 0xE0, 0xF9, 0xF0, 0x07,
  0xCF, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0xF7,
  0xC0, 0x0F, 0xFE, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x3D, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07,
  0xE7, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x07,
  0xE7, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x1F,
  0x80, 0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x03,
  0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x47, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x01, 0xFC, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE8, 0x00,
  0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 36, 13, 3, -35 },
  { 33, 16, 13, 22, 3, -35 },
  { 59, 27, 35, 29, 1, -35 },
  { 178, 22, 40, 26, 2, -37 },
  { 288, 37, 35, 40, 2, -35 },
  { 450, 31, 35, 33, 2, -35 },
  { 586, 6, 13, 12, 3, -35 },
  { 596, 12, 43, 16, 2, -35 },
  { 661, 12, 43, 16, 1, -35 },
  { 726, 21, 21, 25, 2, -37 },
  { 782, 22, 23, 26, 2, -29 },
  { 846, 8, 12, 13, 2, -6 },
  { 858, 12, 5, 15, 2, -16 },
  { 866, 7, 8, 13, 3, -7 },
  { 873, 19, 35, 19, 0, -35 },
  { 957, 22, 36, 26, 2, -36 },
  { 1056, 15, 35, 26, 3, -35 },
  { 1122, 22, 35, 26, 2, -35 },
  { 1219, 22, 35, 26, 2, -35 },
  { 1316, 24, 35, 26, 1, -35 },
  { 1421, 21, 35, 26, 3, -35 },
  { 1513, 22, 35, 26, 2, -35 },
  { 1610, 23, 35, 26, 1, -35 },
  { 1711, 22, 35, 26, 2, -35 },
  { 1808, 22, 35, 26, 2, -35 },
  { 1905, 7, 28, 13, 3, -27 },
  { 1930, 8, 33, 13, 2, -27 },
  { 1963, 22, 24, 26, 2, -30 },
  { 2029, 22, 14, 26, 2, -24 },
  { 2068, 22, 24, 26, 2, -30 },
  { 2134, 20, 36, 21, 0, -35 },
  { 2224, 36, 39, 40, 2, -35 },
  { 2400, 30, 35, 30, 0, -35 },
  { 2532, 23, 35, 30, 4, -35 },
  { 2633, 24, 35, 28, 3, -35 },
  { 2738, 26, 35, 32, 4, -35 },
  { 2852, 18, 35, 25, 4, -35 },
  { 2931, 18, 35, 24, 4, -35 },
  { 3010, 26, 35, 32, 3, -35 },
  { 3124, 26, 35, 34, 4, -35 },
  { 3238, 13, 35, 17, 2, -35 },
  { 3295, 13, 45, 14, -3, -35 },
  { 3369, 25, 35, 29, 4, -35 },
  { 3479, 19, 35, 24, 4, -35 },
  { 3563, 34, 35, 42, 4, -35 },
  { 3712, 27, 35, 36, 4, -35 },
  { 3831, 29, 36, 35, 3, -36 },
  { 3962, 22, 35, 28, 4, -35 },
  { 4059, 29, 44, 35, 3, -36 },
  { 4219, 25, 35, 29, 4, -35 },
  { 4329, 21, 35, 25, 2, -35 },
  { 4421, 23, 35, 25, 1, -35 },
  { 4522, 25, 35, 33, 4, -35 },
  { 4632, 28, 35, 28, 0, -35 },
  { 4755, 43, 35, 43, 0, -35 },
  { 4944, 28, 35, 28, 0, -35 },
  { 5067, 27, 35, 27, 0, -35 },
  { 5186, 23, 35, 25, 1, -35 },
  { 5287, 12, 43, 16, 3, -35 },
  { 5352, 19, 35, 19, 0, -35 },
  { 5436, 11, 43, 16, 1, -35 },
  { 5496, 24, 22, 27, 1, -35 },
  { 5562, 21, 4, 21, 0, 4 },
  { 5573, 12, 8, 16, 2, -38 },
  { 5585, 21, 27, 26, 2, -27 },
  { 5656, 23, 37, 28, 3, -37 },
  { 5763, 19, 27, 22, 2, -27 },
  { 5828, 23, 37, 28, 2, -37 },
  { 5935, 22, 27, 26, 2, -27 },
  { 6010, 17, 37, 17, 1, -37 },
  { 6089, 23, 39, 28, 2, -27 },
  { 6202, 22, 37, 28, 3, -37 },
  { 6304, 7, 37, 13, 3, -37 },
  { 6337, 12, 49, 13, -2, -37 },
  { 6411, 22, 37, 26, 4, -37 },
  { 6513, 6, 37, 13, 3, -37 },
  { 6541, 36, 27, 43, 3, -27 },
  { 6663, 22, 27, 28, 3, -27 },
  { 6738, 23, 27, 28, 2, -27 },
  { 6816, 23, 39, 28, 3, -27 },
  { 6929, 23, 39, 28, 2, -27 },
  { 7042, 16, 27, 19, 3, -27 },
  { 7096, 18, 27, 22, 2, -27 },
  { 7157, 16, 32, 18, 1, -32 },
  { 7221, 22, 27, 28, 3, -27 },
  { 7296, 24, 27, 24, 0, -27 },
  { 7377, 37, 27, 37, 0, -27 },
  { 7502, 24, 27, 25, 0, -27 },
  { 7583, 24, 39, 25, 0, -27 },
  { 7700, 19, 27, 21, 1, -27 },
  { 7765, 16, 43, 18, 1, -35 },
  { 7851, 5, 48, 25, 10, -37 },
  { 7881, 15, 43, 18, 2, -35 },
  { 7962, 22, 7, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD49PT7B_H_
