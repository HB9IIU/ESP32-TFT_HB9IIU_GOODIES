#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x01, 0x8F, 0xDF, 0xFF, 0xFF, 0xFE, 0xF8, 0x40, 0xFC, 0x7F, 0xF8, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1E, 0xF8,
  0x3D, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x1E, 0x0F, 0x00, 0x07, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xF3, 0x87, 0x3F, 0x1C, 0x01, 0xF8, 0xE0, 0x0F, 0xC7, 0x00, 0x7E, 0x38,
  0x01, 0xF9, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xDF,
  0xC0, 0x0E, 0x7F, 0x00, 0x71, 0xF8, 0x03, 0x8F, 0xC0, 0x1C, 0x7F, 0x80,
  0xE3, 0xEF, 0x07, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xFC, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x3F, 0xF8, 0x01, 0xE0,
  0x07, 0x8F, 0x80, 0x7C, 0x01, 0xF0, 0xF0, 0x0F, 0x00, 0x3E, 0x1F, 0x03,
  0xE0, 0x07, 0x83, 0xE0, 0x78, 0x00, 0xF0, 0x7C, 0x1F, 0x00, 0x1E, 0x0F,
  0x83, 0xC0, 0x03, 0xC1, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x1E, 0x00, 0x0F,
  0x07, 0xC7, 0xC0, 0x01, 0xE0, 0xF8, 0xF0, 0x70, 0x3E, 0x1F, 0x3E, 0x3F,
  0xC7, 0xC3, 0xC7, 0x8F, 0xFC, 0x78, 0xF9, 0xF3, 0xFF, 0x8F, 0xFF, 0x3C,
  0x7D, 0xF8, 0xFF, 0xCF, 0x9F, 0x0F, 0x0F, 0xF1, 0xE3, 0xE1, 0xE0, 0xF8,
  0x7C, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x07, 0xC0, 0x03, 0xE1, 0xE0, 0xF8,
  0x00, 0x78, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF0,
  0x7C, 0x00, 0xF8, 0x1E, 0x0F, 0x80, 0x1F, 0x03, 0xE1, 0xF0, 0x03, 0xC0,
  0x7C, 0x3C, 0x00, 0xF8, 0x07, 0x8F, 0x80, 0x1E, 0x00, 0xFF, 0xF0, 0x07,
  0xC0, 0x0F, 0xFC, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0x81, 0xF8, 0xFE, 0xFE, 0x0F,
  0xC7, 0xE3, 0xF8, 0x7E, 0x7F, 0x0F, 0xE7, 0xE3, 0xF0, 0x3F, 0xBF, 0x1F,
  0x80, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0x87, 0xE0, 0x0F, 0xF8, 0x3F, 0x00,
  0x3F, 0xC1, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xEF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xC7, 0xF0,
  0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7,
  0x9E, 0x78, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xC1, 0xE0,
  0xCF, 0xCF, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0,
  0x0F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xC1, 0xF0, 0x06, 0x06, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x31, 0xFB, 0xF7, 0xFF, 0xFF,
  0x9F, 0x08, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0x87, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC0, 0x7E, 0x7C, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0xFC, 0x01,
  0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x1F,
  0xEF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1,
  0xFF, 0xDF, 0xDF, 0xFE, 0x7D, 0xF1, 0xF3, 0x87, 0xCC, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0x07, 0xF0, 0xE0, 0x1F, 0xC6, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3C, 0x07, 0xF0, 0xC0,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xEC, 0x00, 0x7F, 0x7E,
  0x1F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0x3F, 0x00,
  0x3E, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F,
  0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xE0, 0x3F, 0x07, 0xC0,
  0x7E, 0x1F, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xEE, 0x00, 0xFE, 0x7F, 0x1F, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC1, 0xC0, 0x7E, 0x7F, 0xC3, 0xE7, 0xFF,
  0x1F, 0x7F, 0xFC, 0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0xBF, 0x80, 0xFD, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0xE7, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFD, 0xFE, 0x3F, 0x03, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xC3, 0xF0, 0xFE, 0x0F,
  0xEF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xF0, 0x7F, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xF9, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x87, 0xF3, 0xF8,
  0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFB, 0xF1,
  0xFF, 0x9F, 0x03, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x10,
  0x7F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8F, 0xDF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x40, 0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1,
  0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x70, 0x1F, 0x88, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x3F, 0x81,
  0xE3, 0xE0, 0x7F, 0xF8, 0x78, 0xF0, 0x3F, 0xFE, 0x1F, 0x7C, 0x1F, 0xFF,
  0x83, 0xDF, 0x0F, 0xC1, 0xE0, 0xF7, 0x83, 0xE0, 0x78, 0x3D, 0xE0, 0xF0,
  0x1E, 0x0F, 0xF8, 0x7C, 0x07, 0x83, 0xFE, 0x1F, 0x03, 0xE0, 0xFF, 0x87,
  0x80, 0xF8, 0x3F, 0xE1, 0xE0, 0x3E, 0x0F, 0xF8, 0x78, 0x0F, 0x83, 0xFE,
  0x1F, 0x03, 0xE0, 0xFF, 0x87, 0xC0, 0xF8, 0x7F, 0xE1, 0xF0, 0x7E, 0x1E,
  0x78, 0x3E, 0x1F, 0x8F, 0x9E, 0x0F, 0xFE, 0xFF, 0xC7, 0x81, 0xFF, 0x9F,
  0xF1, 0xF0, 0x3F, 0xC7, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x20, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0,
  0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0xEF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0x00, 0xFE, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x1C, 0x1F, 0xC0, 0x04, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x06, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87,
  0xE1, 0xFF, 0xC3, 0xF0, 0x0F, 0xF1, 0xF8, 0x03, 0xFC, 0xFC, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFC,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x7F, 0x8F,
  0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0xF0, 0xFF, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x07, 0xE7, 0xF0, 0x03,
  0xF3, 0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x87, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0,
  0x20, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFB, 0xE0,
  0x03, 0xFF, 0xFD, 0xF0, 0x01, 0xEF, 0xFE, 0xF8, 0x01, 0xF7, 0xFF, 0x3C,
  0x00, 0xFB, 0xFF, 0x9F, 0x00, 0x79, 0xFF, 0xCF, 0x80, 0x7C, 0xFF, 0xE7,
  0xC0, 0x3E, 0x7F, 0xF1, 0xF0, 0x1F, 0x3F, 0xF8, 0xF8, 0x1F, 0x1F, 0xFC,
  0x7C, 0x0F, 0x8F, 0xFE, 0x1F, 0x07, 0xC7, 0xFF, 0x0F, 0x87, 0xC3, 0xFF,
  0x87, 0xC3, 0xE1, 0xFF, 0xC1, 0xF1, 0xF0, 0xFF, 0xE0, 0xF9, 0xF0, 0x7F,
  0xF0, 0x7C, 0xF8, 0x3F, 0xF8, 0x1F, 0x7C, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xF0, 0x0F, 0xC0,
  0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x07, 0xFE, 0xFC, 0x01, 0xFF, 0xBF, 0x80, 0x7F, 0xE7, 0xE0,
  0x1F, 0xF9, 0xFC, 0x07, 0xFE, 0x3F, 0x01, 0xFF, 0x87, 0xE0, 0x7F, 0xE1,
  0xF8, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x7F,
  0xE0, 0x7E, 0x1F, 0xF8, 0x0F, 0xC7, 0xFE, 0x03, 0xF1, 0xFF, 0x80, 0x7E,
  0x7F, 0xE0, 0x1F, 0xDF, 0xF8, 0x03, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x1F, 0xFB, 0xF0, 0x1F, 0xDF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC,
  0x3F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x7F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x83,
  0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x01, 0xFC, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF0,
  0x3C, 0x7E, 0x00, 0x4F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0xF0, 0x0F, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x03,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xDF, 0x00, 0x1F, 0xC0,
  0x07, 0xEF, 0xC0, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF0, 0x03, 0xF3,
  0xF0, 0x03, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x7C, 0x01,
  0xFF, 0x00, 0x7C, 0x3F, 0x00, 0xF7, 0x80, 0x7E, 0x1F, 0x80, 0x7B, 0xC0,
  0x3F, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x3E, 0x07, 0xE0, 0x7E, 0x0F,
  0x8F, 0x83, 0xF0, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x0F, 0x83, 0xE3, 0xE0,
  0xF8, 0x07, 0xE1, 0xF1, 0xF0, 0xFC, 0x03, 0xF1, 0xF0, 0x7C, 0x7E, 0x00,
  0xF8, 0xF8, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x0F, 0x8F, 0x80, 0x1F, 0xBE, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x01, 0xF7,
  0xE0, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x00,
  0xFB, 0xC0, 0x1E, 0xF8, 0x00, 0x7D, 0xE0, 0x0F, 0x7C, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF0,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xFE, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x9F, 0xE0, 0xC0, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0x3F, 0xF9, 0xF1, 0xFE,
  0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x3F, 0xE0, 0xFD, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xC0, 0xFE, 0xFE, 0x01, 0xFB,
  0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF,
  0xF0, 0x3F, 0xBF, 0xF1, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0x9F,
  0xFC, 0x3E, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x3F, 0xFF, 0x8F, 0xE0, 0x67, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x4F, 0xF1, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x0F, 0xC3, 0xFF, 0x3F,
  0x1F, 0xFE, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0x7F,
  0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x07, 0xF7, 0xF0, 0x3F, 0xCF, 0xE3, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFB,
  0xF0, 0xFF, 0xE7, 0xC1, 0xFE, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFC, 0xFE, 0x1F, 0x81, 0xF9, 0xF8, 0x07,
  0xCF, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x01, 0x1F, 0xE0, 0x78, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x3F,
  0xF1, 0xF1, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFC, 0x0F,
  0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x7F, 0x7F, 0x03, 0xFC, 0xFE, 0x3F, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xBF, 0x0F, 0xFC, 0xFC, 0x1F, 0xE3, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x8C, 0x00, 0xFE,
  0x3F, 0x9F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC1, 0xF9, 0xFF, 0x8F, 0xDF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xFB, 0xFF, 0xFF, 0x7F, 0xEF, 0xF9, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0,
  0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x1F, 0xF8, 0x7F, 0xE3, 0xE7,
  0xFF, 0x9F, 0xFE, 0x7D, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x0F, 0xFC, 0x1F, 0xBF, 0x80, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xC0,
  0x3F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xF0, 0x07,
  0xE0, 0x1F, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xF8,
  0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x3F,
  0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xF0, 0x07, 0xC0,
  0x1F, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xF8, 0x03,
  0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0xFC,
  0x01, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0xFC, 0xF8, 0x3F, 0x07, 0xC7,
  0xFE, 0x3E, 0x7F, 0xF9, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7E,
  0x3F, 0x01, 0xF8, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x3F, 0x03, 0xE3, 0xFF, 0x0F, 0x9F,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F,
  0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E,
  0xFF, 0x03, 0xFB, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFD,
  0xFF, 0xC3, 0xF1, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x7C, 0x1F, 0xF1, 0xF1, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFD, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0x03, 0xFC, 0xFE, 0x1F, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x0F, 0xFC, 0xFC, 0x1F, 0xE3, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0xF8, 0x3F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF,
  0xEF, 0xFF, 0xEF, 0xF3, 0xF7, 0xE0, 0x13, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F,
  0xFC, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x08, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0xBF, 0xCF, 0xFD, 0xFF,
  0xFF, 0xE7, 0xFF, 0xDF, 0x1F, 0xFC, 0xF8, 0x7F, 0xC7, 0xC0, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F,
  0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF8,
  0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xFC, 0x3E, 0x01,
  0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x07,
  0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x00, 0x7D, 0xF8, 0x0F,
  0xF0, 0x1F, 0xBF, 0x01, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0xC0, 0x7C, 0x7C,
  0x07, 0xF8, 0x0F, 0x8F, 0xC1, 0xFF, 0x83, 0xF1, 0xF8, 0x3D, 0xF0, 0x7E,
  0x3F, 0x07, 0x9E, 0x0F, 0x83, 0xE0, 0xF3, 0xC1, 0xF0, 0x7E, 0x3E, 0x7C,
  0x7E, 0x0F, 0xC7, 0xCF, 0x8F, 0xC0, 0xF8, 0xF0, 0xF1, 0xF0, 0x1F, 0x1E,
  0x1E, 0x3E, 0x03, 0xE7, 0xC3, 0xCF, 0xC0, 0x7E, 0xF8, 0x7D, 0xF8, 0x07,
  0xDE, 0x0F, 0xBE, 0x00, 0xFB, 0xC0, 0xF7, 0xC0, 0x1F, 0x78, 0x1E, 0xF8,
  0x03, 0xEF, 0x03, 0xDF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x7E, 0x03,
  0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC,
  0x01, 0xF9, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF1, 0xF8, 0x03, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01,
  0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x1F, 0xFA, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 35, 13, 3, -34 },
  { 32, 15, 13, 21, 3, -34 },
  { 57, 26, 34, 28, 1, -34 },
  { 168, 21, 39, 25, 2, -36 },
  { 271, 35, 34, 39, 2, -34 },
  { 420, 29, 34, 31, 2, -34 },
  { 544, 6, 13, 11, 3, -34 },
  { 554, 12, 41, 15, 2, -34 },
  { 616, 12, 41, 15, 1, -34 },
  { 678, 21, 20, 24, 1, -36 },
  { 731, 21, 23, 25, 2, -28 },
  { 792, 8, 11, 12, 2, -5 },
  { 803, 12, 5, 15, 1, -15 },
  { 811, 7, 8, 12, 3, -7 },
  { 818, 18, 34, 19, 0, -34 },
  { 895, 21, 34, 25, 2, -34 },
  { 985, 14, 34, 25, 3, -34 },
  { 1045, 21, 34, 25, 2, -34 },
  { 1135, 21, 34, 25, 2, -34 },
  { 1225, 23, 34, 25, 1, -34 },
  { 1323, 21, 34, 25, 2, -34 },
  { 1413, 21, 34, 25, 2, -34 },
  { 1503, 22, 34, 25, 1, -34 },
  { 1597, 21, 34, 25, 2, -34 },
  { 1687, 21, 34, 25, 2, -34 },
  { 1777, 7, 27, 13, 3, -26 },
  { 1801, 9, 32, 13, 1, -26 },
  { 1837, 21, 24, 25, 2, -29 },
  { 1900, 21, 13, 25, 2, -23 },
  { 1935, 21, 24, 25, 2, -29 },
  { 1998, 19, 35, 20, 0, -34 },
  { 2082, 34, 38, 39, 2, -34 },
  { 2244, 29, 34, 29, 0, -34 },
  { 2368, 22, 34, 28, 4, -34 },
  { 2462, 24, 34, 27, 2, -34 },
  { 2564, 25, 34, 31, 4, -34 },
  { 2671, 17, 34, 24, 4, -34 },
  { 2744, 17, 34, 23, 4, -34 },
  { 2817, 25, 34, 31, 3, -34 },
  { 2924, 24, 34, 32, 4, -34 },
  { 3026, 14, 34, 16, 1, -34 },
  { 3086, 13, 44, 14, -3, -34 },
  { 3158, 24, 34, 28, 4, -34 },
  { 3260, 18, 34, 23, 4, -34 },
  { 3337, 33, 34, 41, 4, -34 },
  { 3478, 26, 34, 34, 4, -34 },
  { 3589, 29, 34, 33, 2, -34 },
  { 3713, 21, 34, 26, 4, -34 },
  { 3803, 29, 42, 33, 2, -34 },
  { 3956, 23, 34, 28, 4, -34 },
  { 4054, 20, 34, 24, 2, -34 },
  { 4139, 22, 34, 24, 1, -34 },
  { 4233, 24, 34, 32, 4, -34 },
  { 4335, 27, 34, 27, 0, -34 },
  { 4450, 41, 34, 41, 0, -34 },
  { 4625, 27, 34, 27, 0, -34 },
  { 4740, 26, 34, 26, 0, -34 },
  { 4851, 22, 34, 24, 1, -34 },
  { 4945, 11, 41, 15, 3, -34 },
  { 5002, 18, 34, 19, 0, -34 },
  { 5079, 11, 41, 15, 1, -34 },
  { 5136, 23, 21, 26, 1, -34 },
  { 5197, 20, 3, 20, 0, 4 },
  { 5205, 11, 8, 15, 2, -36 },
  { 5216, 20, 26, 25, 2, -26 },
  { 5281, 22, 36, 27, 3, -36 },
  { 5380, 18, 26, 21, 2, -26 },
  { 5439, 22, 36, 27, 2, -36 },
  { 5538, 21, 26, 25, 2, -26 },
  { 5607, 17, 36, 16, 1, -36 },
  { 5684, 22, 37, 27, 2, -26 },
  { 5786, 21, 36, 27, 3, -36 },
  { 5881, 6, 35, 12, 3, -35 },
  { 5908, 11, 46, 12, -2, -35 },
  { 5972, 22, 36, 25, 3, -36 },
  { 6071, 6, 36, 12, 3, -36 },
  { 6098, 35, 26, 41, 3, -26 },
  { 6212, 21, 26, 27, 3, -26 },
  { 6281, 22, 26, 27, 2, -26 },
  { 6353, 22, 37, 27, 3, -26 },
  { 6455, 22, 37, 27, 2, -26 },
  { 6557, 15, 26, 19, 3, -26 },
  { 6606, 17, 26, 21, 2, -26 },
  { 6662, 15, 31, 17, 1, -31 },
  { 6721, 21, 26, 27, 3, -26 },
  { 6790, 23, 26, 23, 0, -26 },
  { 6865, 35, 26, 36, 0, -26 },
  { 6979, 23, 25, 24, 0, -25 },
  { 7051, 23, 37, 24, 0, -26 },
  { 7158, 18, 26, 20, 1, -26 },
  { 7217, 15, 41, 18, 1, -34 },
  { 7294, 4, 47, 24, 10, -36 },
  { 7318, 15, 41, 18, 2, -34 },
  { 7395, 21, 7, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD47PT7B_H_
