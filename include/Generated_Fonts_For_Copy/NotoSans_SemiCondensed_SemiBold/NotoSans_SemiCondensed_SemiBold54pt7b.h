#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFB,
  0xF8, 0x7E, 0xFE, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x7E, 0x7C,
  0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xF8, 0xE0, 0xE7,
  0xE1, 0xC0, 0x4F, 0xC3, 0x80, 0x1F, 0x87, 0x00, 0x3F, 0x0E, 0x00, 0x7F,
  0x1C, 0x00, 0xFF, 0x38, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x77, 0xF8, 0x00, 0xE7, 0xF8, 0x01, 0xC7,
  0xF0, 0x03, 0x87, 0xE0, 0x07, 0x0F, 0xC0, 0x0E, 0x1F, 0xE0, 0x1C, 0x7F,
  0xF8, 0x39, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x1F,
  0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x0F, 0x83, 0xC0, 0xFC, 0x1F, 0x1F, 0x0F, 0xF0,
  0x7C, 0x3F, 0x1F, 0x1F, 0xFC, 0x7C, 0x3E, 0x3E, 0x3F, 0xFC, 0x7E, 0x7E,
  0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0xFC, 0x7C, 0x7C,
  0x3F, 0x1F, 0xF8, 0xF8, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0xFC, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x0F,
  0x80, 0xFC, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3,
  0xFD, 0xFE, 0x07, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF8, 0xFE,
  0x3F, 0x80, 0xFF, 0x7F, 0x0F, 0xE0, 0x1F, 0xDF, 0xC3, 0xF8, 0x03, 0xFF,
  0xE0, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xE0, 0x03,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x50, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x10, 0x1F,
  0x00, 0xBC, 0x3E, 0x0F, 0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x80, 0xF0, 0x38, 0x00, 0x40, 0x60, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xDF, 0xDF, 0xCF, 0xE7, 0xC7, 0xF1, 0x83, 0xF8, 0x81, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0x01,
  0xFE, 0x3C, 0x00, 0xFE, 0x10, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xCF, 0xFC, 0x3C, 0x01, 0xFE, 0x10, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x01,
  0xFB, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xC1,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0xC0, 0x03, 0xFD,
  0xF0, 0x1F, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x50, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0x0C, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x7E, 0x3F, 0xE0, 0xFE, 0xFF, 0xF8, 0xFD,
  0xFF, 0xFC, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0xFE, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0xFE, 0x3F,
  0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x1F,
  0xC3, 0xFC, 0x1F, 0xF7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xC7, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x28, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F,
  0x81, 0xFC, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0xFF, 0x7F, 0x83, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F,
  0xFF, 0xBF, 0x0F, 0xFF, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18,
  0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC,
  0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0x7F, 0xE3, 0x80, 0x3F, 0x88, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x30, 0x03, 0xE1, 0xF0, 0x0F, 0xFF, 0x87,
  0xE3, 0xE0, 0x3F, 0xFF, 0x07, 0xCF, 0x80, 0xFF, 0xFE, 0x0F, 0x9F, 0x03,
  0xFD, 0xFC, 0x0F, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xF0,
  0x3F, 0xF0, 0x7E, 0x03, 0xE0, 0x7F, 0xE0, 0xF8, 0x07, 0xC0, 0xFF, 0xC1,
  0xF0, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x1F, 0x03, 0xFF, 0x07, 0xC0, 0x3E,
  0x07, 0xFE, 0x0F, 0x80, 0x7C, 0x0F, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0xF8,
  0x3E, 0x03, 0xF0, 0x3D, 0xF0, 0x7C, 0x07, 0xE0, 0xFB, 0xE0, 0xF8, 0x0F,
  0xC1, 0xF7, 0xC1, 0xF8, 0x3F, 0x87, 0xCF, 0x81, 0xF8, 0xFF, 0x9F, 0x9F,
  0x03, 0xFF, 0xEF, 0xFE, 0x3F, 0x03, 0xFF, 0x9F, 0xF8, 0x3E, 0x03, 0xFE,
  0x1F, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01,
  0xFE, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xFB,
  0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xE0, 0x0F, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFE, 0x01, 0xE0, 0xFF, 0x00, 0x04, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x83,
  0xFF, 0xC1, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xFE,
  0x1F, 0xC0, 0x0F, 0xF8, 0xFE, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F,
  0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x0F, 0xF8, 0xFE, 0x01, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x03, 0x83, 0xFE, 0x00,
  0x04, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x0F,
  0xE7, 0xFC, 0x00, 0x7F, 0x1F, 0xF0, 0x03, 0xF8, 0x7F, 0xF0, 0x3F, 0xC3,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0,
  0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFB, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xF1, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xF0, 0x0F, 0xC3, 0xFC, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE7, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0xBF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0x83, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0x07, 0xE0,
  0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xE3, 0xF0, 0x01, 0xFC,
  0x7E, 0x00, 0x3F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0xBF, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFB, 0xE0,
  0x00, 0x7F, 0xFF, 0xDF, 0x80, 0x03, 0xEF, 0xFE, 0xFC, 0x00, 0x1F, 0x7F,
  0xF3, 0xE0, 0x01, 0xFB, 0xFF, 0x9F, 0x80, 0x0F, 0x9F, 0xFE, 0xFC, 0x00,
  0x7C, 0xFF, 0xF7, 0xE0, 0x07, 0xE7, 0xFF, 0x9F, 0x80, 0x3E, 0x3F, 0xFC,
  0xFC, 0x01, 0xF1, 0xFF, 0xE7, 0xE0, 0x1F, 0x8F, 0xFF, 0x1F, 0x00, 0xFC,
  0x7F, 0xF8, 0xFC, 0x07, 0xC3, 0xFF, 0xC7, 0xE0, 0x7E, 0x1F, 0xFE, 0x1F,
  0x03, 0xF0, 0xFF, 0xF0, 0xFC, 0x1F, 0x07, 0xFF, 0x87, 0xE1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x0F, 0xC1, 0xFF, 0xE0, 0xFC, 0x7C, 0x0F, 0xFF, 0x07, 0xE7,
  0xE0, 0x7F, 0xF8, 0x1F, 0x3F, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xE0, 0x07, 0xFF,
  0xBF, 0x80, 0x1F, 0xFE, 0x7F, 0x00, 0x7F, 0xF9, 0xFC, 0x01, 0xFF, 0xE3,
  0xF8, 0x07, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x1F, 0xC0, 0x7F, 0xFC, 0x7F,
  0x01, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0x07, 0xF0,
  0x7F, 0xFC, 0x1F, 0xE1, 0xFF, 0xF0, 0x3F, 0x87, 0xFF, 0xC0, 0x7F, 0x1F,
  0xFF, 0x01, 0xFC, 0x3F, 0xFC, 0x03, 0xF8, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF,
  0xC0, 0x1F, 0xCF, 0xFF, 0x00, 0x7F, 0x3F, 0xFC, 0x00, 0xFE, 0xFF, 0xF0,
  0x03, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE,
  0x03, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE,
  0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0x80,
  0xFF, 0x87, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xE0, 0x1E, 0x3F, 0x80,
  0x04, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x01,
  0xFD, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x50, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0xC0, 0x1F, 0xE3,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0,
  0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xCF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0xF8, 0x01,
  0xF8, 0x7F, 0x00, 0x7D, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFB, 0xE0, 0x0F,
  0xE0, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x03, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xBF, 0x01, 0xFC,
  0x07, 0xE0, 0x3E, 0x3E, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x80,
  0x3F, 0x07, 0xC1, 0xF0, 0x7F, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0x01,
  0xF8, 0xF8, 0x0F, 0x8F, 0xE0, 0x03, 0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x00, 0x1F,
  0xDF, 0x00, 0x7D, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0xFB, 0xF0, 0x00, 0x3F,
  0x7C, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC,
  0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x03,
  0xF0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1,
  0xF8, 0x7F, 0x83, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xF0, 0x7E, 0xFF, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF9, 0xFF, 0xF9, 0xF1, 0xFF, 0xE3, 0xE1, 0xFF, 0x07, 0xC0,
  0x20, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF0, 0x0F, 0xC7, 0xFE, 0x07, 0xE7, 0xFF, 0x83, 0xF7,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB,
  0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x01,
  0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x80,
  0x3F, 0xBF, 0xC0, 0x3F, 0x9F, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE3, 0xF7, 0xFF, 0xE1, 0xF1, 0xFF, 0xE0, 0xF8, 0x7F, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x00, 0xC7, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0x3F, 0xE0, 0x78, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x3F, 0xF1, 0xF8, 0x3F, 0xFC, 0xFC, 0x3F, 0xFF, 0x7E,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0xCF, 0xE0, 0x1F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xCF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0x7E, 0x0F, 0xFF, 0x1F, 0x03, 0xFE, 0x0F, 0x80, 0x10, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0x7E, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x02, 0x3F, 0xE0, 0x0E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xE0,
  0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x03, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xC1, 0xFF, 0xE7, 0xE1, 0xFF, 0xFB,
  0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0x00,
  0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7,
  0xE1, 0xFF, 0xFB, 0xF0, 0x7F, 0xF9, 0xF8, 0x1F, 0xF0, 0xFC, 0x00, 0x80,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE4, 0x00, 0x0F, 0xE3, 0x80, 0x0F, 0xF1, 0xFF, 0x7F, 0xF8, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0xFC, 0x7F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x31, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x00, 0xC0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x7F, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x0F, 0xF7, 0xE0, 0x07, 0xF3, 0xF0, 0x07, 0xF1, 0xF8, 0x07, 0xF0,
  0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF8, 0x3F, 0x07, 0xF8, 0x1F, 0x83, 0xF8,
  0x0F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8,
  0x00, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFB, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F,
  0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xF3, 0xF0, 0x03, 0xF9,
  0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0xFF, 0xC0, 0xFF, 0xE3,
  0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x7F, 0xF0, 0xF8,
  0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x3F, 0xF0, 0x3F, 0x3F,
  0xFC, 0x1F, 0xBF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFE,
  0x07, 0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03,
  0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0xFF, 0xC1, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xBF, 0xFF, 0x0F, 0xCF, 0xFF, 0x07, 0xE1,
  0xFF, 0x03, 0xF0, 0x10, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0x8F, 0xC1, 0xFF, 0xE7, 0xE1, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xF0, 0x03,
  0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0xC0,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0xE1, 0xFF, 0xFB, 0xF0, 0x7F,
  0xF9, 0xF8, 0x1F, 0xF0, 0xFC, 0x01, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0x1F, 0xEF, 0xDF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xF0, 0x7C, 0xFE, 0x00, 0xCF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x04, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0x3F, 0xFF, 0x3F, 0x1F, 0xFE, 0x3F, 0x0F, 0xFC, 0x3F, 0x00,
  0x40, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xBF, 0x00, 0x3F,
  0xC0, 0x1F, 0x9F, 0xC0, 0x3F, 0xE0, 0x0F, 0xCF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xE3, 0xF0, 0x0F, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xFE, 0x03, 0xF0, 0xFE,
  0x07, 0xDF, 0x01, 0xF8, 0x7F, 0x03, 0xEF, 0x81, 0xFC, 0x1F, 0x81, 0xF7,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF9, 0xF0, 0x7E, 0x07, 0xF0, 0xF8, 0xF8, 0x3F,
  0x01, 0xF8, 0x7C, 0x7C, 0x3F, 0x80, 0xFC, 0x3E, 0x3E, 0x1F, 0x80, 0x7E,
  0x1F, 0x1F, 0x8F, 0xC0, 0x3F, 0x9F, 0x87, 0xC7, 0xE0, 0x0F, 0xCF, 0x83,
  0xE3, 0xF0, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x03, 0xF3, 0xE0, 0xF9, 0xF8,
  0x01, 0xF9, 0xF0, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x1F, 0x7E, 0x00, 0x3F,
  0xF8, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F,
  0xC7, 0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F,
  0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC,
  0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x7F,
  0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 40, 14, 3, -39 },
  { 41, 18, 14, 24, 3, -39 },
  { 73, 30, 39, 32, 1, -39 },
  { 220, 23, 44, 29, 3, -41 },
  { 347, 40, 39, 44, 2, -39 },
  { 542, 34, 40, 36, 2, -39 },
  { 712, 7, 14, 13, 3, -39 },
  { 725, 14, 48, 17, 2, -39 },
  { 809, 14, 48, 17, 1, -39 },
  { 893, 23, 23, 27, 2, -41 },
  { 960, 24, 26, 29, 2, -32 },
  { 1038, 9, 13, 14, 2, -6 },
  { 1053, 13, 5, 17, 2, -17 },
  { 1062, 8, 9, 14, 3, -8 },
  { 1071, 20, 39, 21, 1, -39 },
  { 1169, 24, 40, 28, 2, -39 },
  { 1289, 17, 39, 28, 3, -39 },
  { 1372, 24, 39, 28, 2, -39 },
  { 1489, 24, 40, 28, 2, -39 },
  { 1609, 27, 39, 28, 1, -39 },
  { 1741, 23, 40, 28, 3, -39 },
  { 1856, 24, 40, 28, 2, -39 },
  { 1976, 24, 39, 28, 2, -39 },
  { 2093, 24, 40, 28, 2, -39 },
  { 2213, 24, 40, 28, 2, -39 },
  { 2333, 8, 31, 14, 3, -30 },
  { 2364, 9, 37, 14, 2, -30 },
  { 2406, 24, 27, 29, 2, -33 },
  { 2487, 24, 16, 29, 2, -27 },
  { 2535, 24, 27, 29, 2, -33 },
  { 2616, 22, 40, 23, 0, -39 },
  { 2726, 39, 43, 45, 3, -39 },
  { 2936, 33, 39, 33, 0, -39 },
  { 3097, 26, 39, 33, 4, -39 },
  { 3224, 27, 40, 31, 3, -39 },
  { 3359, 29, 39, 36, 4, -39 },
  { 3501, 20, 39, 27, 5, -39 },
  { 3599, 19, 39, 27, 5, -39 },
  { 3692, 29, 40, 36, 3, -39 },
  { 3837, 28, 39, 37, 5, -39 },
  { 3974, 15, 39, 19, 2, -39 },
  { 4048, 15, 50, 16, -4, -39 },
  { 4142, 27, 39, 32, 5, -39 },
  { 4274, 21, 39, 26, 4, -39 },
  { 4377, 37, 39, 47, 5, -39 },
  { 4558, 30, 39, 39, 5, -39 },
  { 4705, 32, 40, 38, 3, -39 },
  { 4865, 24, 39, 30, 4, -39 },
  { 4982, 32, 48, 38, 3, -39 },
  { 5174, 27, 39, 32, 4, -39 },
  { 5306, 23, 40, 27, 2, -39 },
  { 5421, 26, 39, 28, 1, -39 },
  { 5548, 28, 40, 37, 4, -39 },
  { 5688, 31, 39, 31, 0, -39 },
  { 5840, 47, 39, 47, 0, -39 },
  { 6070, 30, 39, 31, 0, -39 },
  { 6217, 29, 39, 29, 0, -39 },
  { 6359, 25, 39, 27, 1, -39 },
  { 6481, 12, 48, 17, 4, -39 },
  { 6553, 21, 39, 21, 0, -39 },
  { 6656, 13, 48, 17, 1, -39 },
  { 6734, 27, 24, 29, 1, -39 },
  { 6815, 23, 3, 23, 0, 5 },
  { 6824, 13, 8, 17, 2, -41 },
  { 6837, 23, 31, 29, 2, -30 },
  { 6927, 25, 42, 31, 4, -41 },
  { 7059, 21, 31, 25, 2, -30 },
  { 7141, 25, 42, 31, 2, -41 },
  { 7273, 24, 31, 29, 2, -30 },
  { 7366, 19, 41, 18, 1, -41 },
  { 7464, 25, 43, 31, 2, -30 },
  { 7599, 24, 41, 31, 4, -41 },
  { 7722, 7, 41, 14, 4, -41 },
  { 7758, 13, 54, 14, -2, -41 },
  { 7846, 25, 41, 29, 4, -41 },
  { 7975, 6, 41, 14, 4, -41 },
  { 8006, 39, 30, 47, 4, -30 },
  { 8153, 24, 30, 31, 4, -30 },
  { 8243, 26, 31, 30, 2, -30 },
  { 8344, 25, 43, 31, 4, -30 },
  { 8479, 25, 43, 31, 2, -30 },
  { 8614, 17, 30, 21, 4, -30 },
  { 8678, 20, 31, 24, 2, -30 },
  { 8756, 18, 37, 20, 1, -36 },
  { 8840, 24, 30, 31, 4, -29 },
  { 8930, 27, 29, 27, 0, -29 },
  { 9028, 41, 29, 41, 0, -29 },
  { 9177, 27, 29, 27, 0, -29 },
  { 9275, 27, 42, 27, 0, -29 },
  { 9417, 20, 29, 23, 2, -29 },
  { 9490, 17, 48, 20, 1, -39 },
  { 9592, 5, 54, 27, 11, -41 },
  { 9626, 17, 48, 20, 2, -39 },
  { 9728, 24, 8, 29, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD54PT7B_H_
