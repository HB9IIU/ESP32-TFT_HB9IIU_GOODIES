#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xF7, 0xA0, 0x1A, 0x09, 0x04, 0x8F, 0xF7,
  0xF9, 0xB0, 0xD1, 0xFE, 0x24, 0x12, 0x1B, 0x00, 0x21, 0xFE, 0x68, 0xE1,
  0xE1, 0xCB, 0xAF, 0xE2, 0x08, 0x61, 0x96, 0x62, 0x48, 0x4B, 0x09, 0x49,
  0x6B, 0x9A, 0xD8, 0x5B, 0x13, 0x62, 0x2C, 0xC7, 0x00, 0x38, 0x3E, 0x33,
  0x09, 0x87, 0x83, 0x8F, 0x6D, 0x9E, 0xCE, 0x67, 0x9E, 0xE0, 0xFF, 0x2F,
  0x6D, 0x24, 0x9B, 0x26, 0xC6, 0x23, 0x33, 0x33, 0x33, 0x36, 0xE0, 0x19,
  0x27, 0xF8, 0xC2, 0xCC, 0x80, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0xFA,
  0xFF, 0xF0, 0x0C, 0x21, 0x86, 0x10, 0xC2, 0x18, 0x61, 0x0C, 0x00, 0x73,
  0xEC, 0xF3, 0x8E, 0x38, 0xF3, 0xCF, 0x77, 0x80, 0x19, 0xFF, 0xB1, 0x8C,
  0x63, 0x18, 0xC6, 0x7B, 0xF8, 0xC3, 0x0C, 0x63, 0x18, 0x63, 0xFF, 0xC0,
  0x7B, 0xF0, 0xC3, 0x19, 0xC1, 0xC3, 0x0E, 0x7F, 0x80, 0x0C, 0x0C, 0x1C,
  0x14, 0x34, 0x64, 0x44, 0xFF, 0xFF, 0x04, 0x04, 0xFF, 0xFC, 0x30, 0xF3,
  0xF0, 0xC3, 0x0E, 0x7F, 0x80, 0x3D, 0xFC, 0x30, 0xBB, 0xFC, 0xE1, 0xCF,
  0x37, 0x80, 0xFF, 0xFC, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x18, 0x60, 0xC0,
  0x7B, 0xFC, 0xF3, 0xF9, 0xCD, 0xE3, 0x87, 0x37, 0x80, 0x73, 0xEC, 0xE3,
  0x8F, 0x3F, 0x43, 0x0E, 0x6F, 0x00, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x58,
  0x04, 0x77, 0x30, 0xE0, 0xF0, 0x40, 0xFC, 0x0F, 0xFF, 0x83, 0x83, 0x83,
  0x1F, 0xC8, 0x00, 0x7B, 0xF0, 0xC3, 0x18, 0xE3, 0x08, 0x00, 0xC3, 0x00,
  0x0E, 0x07, 0x71, 0x83, 0x67, 0xA9, 0xB7, 0x26, 0xEC, 0xDC, 0x9A, 0x9D,
  0xD8, 0x01, 0x82, 0x1F, 0x80, 0x1C, 0x0E, 0x05, 0x06, 0xC3, 0x61, 0x91,
  0x8C, 0xFE, 0x63, 0x60, 0xF0, 0x60, 0xF9, 0xFF, 0x1E, 0x3C, 0x7F, 0xB1,
  0xE3, 0xC7, 0xFF, 0xF0, 0x1E, 0xFF, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC0,
  0xEC, 0xF8, 0xF8, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE,
  0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0xFC, 0x30, 0xC3, 0xFF, 0xC0, 0xFF, 0xFC,
  0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0C, 0x00, 0x1E, 0x7F, 0x60, 0xC0, 0xC0,
  0xCF, 0xCF, 0xC3, 0xC3, 0x77, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFB, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xBE,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3, 0xC6, 0xCC, 0xD8, 0xD8,
  0xF8, 0xF8, 0xCC, 0xCC, 0xC6, 0xC7, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xFF, 0xC0, 0xE0, 0xFC, 0x1F, 0xC7, 0xF8, 0xFD, 0x17, 0xA6, 0xF6,
  0xDE, 0xD3, 0xCE, 0x79, 0xCF, 0x31, 0x80, 0xE1, 0xF0, 0xFC, 0x7E, 0x3D,
  0x9E, 0xCF, 0x37, 0x9B, 0xC7, 0xE1, 0xF0, 0xE0, 0x3C, 0x3F, 0xB8, 0xD8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x3B, 0x8F, 0x80, 0xF9, 0xFB, 0x1E,
  0x3C, 0x7F, 0xBE, 0x60, 0xC1, 0x83, 0x00, 0x3C, 0x3F, 0xB8, 0xD8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x3B, 0x8F, 0x80, 0xC0, 0x30, 0x1C, 0xF8,
  0xFC, 0xC6, 0xC6, 0xC6, 0xFC, 0xF8, 0xCC, 0xCC, 0xC6, 0xC7, 0x7B, 0xFC,
  0x30, 0xE1, 0xE1, 0xC3, 0x0F, 0x7F, 0x80, 0xFF, 0xFC, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x76, 0x3C, 0xC1, 0xE1, 0x98, 0xCC, 0x66, 0x21, 0x30, 0xD8,
  0x68, 0x1C, 0x0E, 0x06, 0x00, 0xC2, 0x1E, 0x38, 0xD1, 0xC6, 0xCA, 0x26,
  0x53, 0x36, 0xD9, 0xB6, 0xC5, 0x14, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0xC3,
  0x63, 0x66, 0x34, 0x1C, 0x18, 0x1C, 0x34, 0x66, 0x63, 0xC3, 0xC3, 0x63,
  0x66, 0x26, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x18,
  0x61, 0x83, 0x0C, 0x18, 0x61, 0xFF, 0xF8, 0xFF, 0x6D, 0xB6, 0xDB, 0x6E,
  0xC1, 0x06, 0x18, 0x20, 0xC3, 0x04, 0x18, 0x20, 0xC0, 0xFF, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xF0, 0x18, 0x18, 0x3C, 0x24, 0x26, 0x62, 0xC3, 0xFC,
  0xCC, 0xF9, 0x30, 0xDF, 0xCE, 0x3D, 0xFD, 0xC1, 0x83, 0x07, 0xEE, 0xF8,
  0xF1, 0xE3, 0xC7, 0xDB, 0xF0, 0x7E, 0x71, 0x8C, 0x63, 0xAF, 0x06, 0x0C,
  0x1B, 0xBC, 0xF8, 0xF1, 0xE3, 0xC7, 0x9D, 0xD8, 0x7B, 0x3C, 0x7F, 0xC3,
  0x0E, 0x5F, 0x3D, 0x86, 0x3E, 0x61, 0x86, 0x18, 0x61, 0x86, 0x00, 0x77,
  0x9F, 0x1E, 0x3C, 0x78, 0xF3, 0xBB, 0x07, 0x1B, 0xF1, 0x80, 0xC1, 0x83,
  0x07, 0xEE, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xF3, 0xFF, 0xFC, 0x33,
  0x03, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x40, 0xC1, 0x83, 0x06, 0x7C, 0xDB,
  0x3C, 0x7C, 0xD9, 0x9B, 0x18, 0xFF, 0xFF, 0xFC, 0xFD, 0xFD, 0xCF, 0x19,
  0xE2, 0x3C, 0x47, 0x88, 0xF1, 0x1E, 0x23, 0xFD, 0xDF, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0x7D, 0x9B, 0x1E, 0x3C, 0x78, 0xF3, 0x3C, 0xFD, 0xDF, 0x1E,
  0x3C, 0x78, 0xFB, 0x7E, 0xC1, 0x83, 0x06, 0x00, 0x77, 0x9F, 0x1E, 0x3C,
  0x78, 0xF3, 0xBB, 0x06, 0x0C, 0x18, 0x30, 0xFF, 0x71, 0x8C, 0x63, 0x18,
  0xFC, 0x71, 0xE3, 0x8E, 0x7E, 0x23, 0x3E, 0xC6, 0x31, 0x8C, 0x69, 0xC0,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xBB, 0xC6, 0x8D, 0x9B, 0x62, 0xC7,
  0x8E, 0x0C, 0xC6, 0x69, 0xCD, 0xA9, 0xB5, 0xA6, 0xBC, 0x73, 0x8E, 0x71,
  0x8C, 0xE6, 0xD8, 0xF1, 0xC3, 0x87, 0x99, 0xE3, 0xC6, 0x8D, 0x9B, 0x62,
  0xC7, 0x8E, 0x0C, 0x18, 0x63, 0xC6, 0x00, 0x7C, 0x31, 0x84, 0x31, 0x86,
  0x3F, 0x19, 0xCC, 0x63, 0x1B, 0x9C, 0x31, 0x8C, 0x63, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x8C, 0x66, 0x66, 0x37, 0x66, 0x66, 0xC0, 0xFE, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 9, 11, 9, 0, -11 },
  { 20, 6, 12, 8, 1, -11 },
  { 29, 11, 11, 12, 1, -11 },
  { 45, 9, 11, 10, 1, -11 },
  { 58, 2, 4, 4, 1, -11 },
  { 59, 3, 13, 5, 1, -11 },
  { 64, 4, 13, 5, 0, -11 },
  { 71, 7, 6, 8, 0, -11 },
  { 77, 6, 7, 8, 1, -9 },
  { 83, 2, 4, 4, 1, -2 },
  { 84, 4, 2, 5, 0, -5 },
  { 85, 2, 2, 4, 1, -2 },
  { 86, 6, 11, 6, 0, -11 },
  { 95, 6, 11, 8, 1, -11 },
  { 104, 5, 11, 8, 1, -11 },
  { 111, 6, 11, 8, 1, -11 },
  { 120, 6, 11, 8, 1, -11 },
  { 129, 8, 11, 8, 0, -11 },
  { 140, 6, 11, 8, 1, -11 },
  { 149, 6, 11, 8, 1, -11 },
  { 158, 7, 11, 8, 0, -11 },
  { 168, 6, 11, 8, 1, -11 },
  { 177, 6, 11, 8, 1, -11 },
  { 186, 2, 8, 4, 1, -8 },
  { 188, 3, 10, 4, 0, -8 },
  { 192, 6, 7, 8, 1, -9 },
  { 198, 6, 4, 8, 1, -7 },
  { 201, 6, 7, 8, 1, -9 },
  { 207, 6, 11, 6, 0, -11 },
  { 216, 11, 12, 12, 1, -11 },
  { 233, 9, 11, 9, 0, -11 },
  { 246, 7, 11, 9, 1, -11 },
  { 256, 7, 11, 9, 1, -11 },
  { 266, 8, 11, 10, 1, -11 },
  { 277, 6, 11, 8, 1, -11 },
  { 286, 6, 11, 7, 1, -11 },
  { 295, 8, 11, 10, 1, -11 },
  { 306, 8, 11, 10, 1, -11 },
  { 317, 5, 11, 5, 0, -11 },
  { 324, 4, 14, 4, -1, -11 },
  { 331, 8, 11, 9, 1, -11 },
  { 342, 6, 11, 7, 1, -11 },
  { 351, 11, 11, 13, 1, -11 },
  { 367, 9, 11, 11, 1, -11 },
  { 380, 9, 11, 11, 1, -11 },
  { 393, 7, 11, 8, 1, -11 },
  { 403, 9, 14, 11, 1, -11 },
  { 419, 8, 11, 9, 1, -11 },
  { 430, 6, 11, 8, 1, -11 },
  { 439, 7, 11, 8, 0, -11 },
  { 449, 8, 11, 10, 1, -11 },
  { 460, 9, 11, 9, 0, -11 },
  { 473, 13, 11, 13, 0, -11 },
  { 491, 8, 11, 9, 0, -11 },
  { 502, 8, 11, 8, 0, -11 },
  { 513, 7, 11, 8, 0, -11 },
  { 523, 3, 13, 5, 1, -11 },
  { 528, 6, 11, 6, 0, -11 },
  { 537, 4, 13, 5, 0, -11 },
  { 544, 8, 7, 8, 0, -11 },
  { 551, 6, 1, 6, 0, 1 },
  { 552, 3, 2, 5, 1, -11 },
  { 553, 6, 8, 8, 1, -8 },
  { 559, 7, 11, 9, 1, -11 },
  { 569, 5, 8, 7, 1, -8 },
  { 574, 7, 11, 9, 1, -11 },
  { 584, 6, 8, 8, 1, -8 },
  { 590, 6, 11, 5, 0, -11 },
  { 599, 7, 12, 9, 1, -8 },
  { 610, 7, 11, 9, 1, -11 },
  { 620, 2, 11, 4, 1, -11 },
  { 623, 4, 15, 4, -1, -11 },
  { 631, 7, 11, 8, 1, -11 },
  { 641, 2, 11, 4, 1, -11 },
  { 644, 11, 8, 13, 1, -8 },
  { 655, 7, 8, 9, 1, -8 },
  { 662, 7, 8, 8, 1, -8 },
  { 669, 7, 12, 9, 1, -8 },
  { 680, 7, 12, 9, 1, -8 },
  { 691, 5, 8, 6, 1, -8 },
  { 696, 5, 8, 7, 1, -8 },
  { 701, 5, 10, 6, 0, -10 },
  { 708, 7, 8, 9, 1, -8 },
  { 715, 7, 8, 7, 0, -8 },
  { 722, 11, 8, 11, 0, -8 },
  { 733, 7, 8, 8, 0, -8 },
  { 740, 7, 12, 8, 0, -8 },
  { 751, 6, 8, 6, 0, -8 },
  { 757, 5, 13, 6, 0, -11 },
  { 766, 2, 15, 8, 3, -11 },
  { 770, 4, 13, 6, 1, -11 },
  { 777, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD15PT7B_H_
