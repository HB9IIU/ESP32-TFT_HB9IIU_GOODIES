#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF,
  0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF,
  0x88, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7B, 0xE1, 0xEF,
  0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC1, 0xE0,
  0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFC, 0xE0, 0x9F, 0x1C, 0x03, 0xE3, 0x80, 0x7C, 0x70, 0x0F, 0xCE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0E, 0xFE, 0x01, 0xCF, 0xC0, 0x38,
  0xF8, 0x07, 0x1F, 0x80, 0xE3, 0xF8, 0x1C, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x40,
  0x1F, 0xE0, 0x03, 0xC0, 0x1F, 0xF8, 0x01, 0xE0, 0x0F, 0xFE, 0x01, 0xE0,
  0x0F, 0x8F, 0x00, 0xF0, 0x07, 0x87, 0x80, 0xF0, 0x03, 0xC3, 0xE0, 0x78,
  0x01, 0xE1, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x3E,
  0x00, 0x3C, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x1F, 0x00, 0x0F, 0x0F, 0x8F,
  0x00, 0x07, 0x87, 0xCF, 0x8F, 0xC3, 0xC3, 0xC7, 0x8F, 0xF1, 0xF1, 0xE7,
  0xCF, 0xFC, 0x7F, 0xF3, 0xCF, 0xBE, 0x3F, 0xF3, 0xE7, 0x87, 0x8F, 0xF1,
  0xE3, 0xC3, 0xC1, 0xE1, 0xF3, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0xF0, 0x00,
  0xF8, 0xF8, 0x7C, 0x00, 0x78, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x1F, 0x00,
  0x3C, 0x1F, 0x0F, 0x00, 0x3E, 0x0F, 0x87, 0x80, 0x1E, 0x03, 0xC3, 0xC0,
  0x1F, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0xF9, 0xF0, 0x0F, 0x80, 0x3F, 0xF0,
  0x07, 0x80, 0x0F, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xC7, 0xFF, 0x81, 0xF1, 0xFD, 0xF8, 0x3E,
  0x7F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF9, 0xF1, 0xF0, 0x3F, 0xFE, 0x3E, 0x03,
  0xFF, 0xC7, 0xC0, 0x3F, 0xF0, 0xF8, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0x83,
  0xF0, 0x0F, 0xF0, 0x7F, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xC7, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF7, 0xBC, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0x0F, 0x0E, 0x7E, 0xF7, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x79, 0xF0,
  0x0F, 0x9F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0x60, 0x60, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7B, 0xFF, 0xFF, 0xFF, 0xE2, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F, 0x83,
  0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x3F,
  0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0xF8, 0x0F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x9F, 0xFD, 0xFB, 0xFF,
  0x9F, 0x78, 0xF9, 0x87, 0xC8, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF,
  0xCF, 0xFF, 0xFC, 0xF8, 0x1F, 0x8C, 0x01, 0xF1, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xF0, 0x1F, 0x88, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x0F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x9F, 0x80, 0x7C, 0xFC, 0x03, 0xC7, 0xE0,
  0x3C, 0x3F, 0x03, 0xE1, 0xF8, 0x1E, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x03,
  0xF0, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01,
  0xFB, 0xC0, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFE, 0x0F, 0x9F, 0xF0,
  0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xFC, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x1F, 0xC7, 0xE0, 0x7C, 0x7C, 0x07,
  0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xE0,
  0xFC, 0x3F, 0x9F, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0x3F, 0x87, 0xE0, 0xFC, 0xFC, 0x07, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0xFC, 0x03, 0xEF, 0xE0, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xFF, 0xF8, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xEF,
  0x8F, 0xF9, 0xF0, 0x7C, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x83, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF,
  0xFE, 0x20, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8E, 0x07, 0xE2, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x07, 0xFE, 0x1E, 0x3C, 0x0F,
  0xFF, 0x1E, 0x7C, 0x1F, 0xFF, 0x0F, 0x78, 0x3E, 0x1E, 0x0F, 0x78, 0x7C,
  0x1E, 0x0F, 0x78, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0xF8,
  0x1E, 0x0F, 0xF0, 0xF8, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0,
  0x1E, 0x0F, 0xF0, 0xF8, 0x1E, 0x0F, 0xF0, 0xF8, 0x3E, 0x1E, 0xF0, 0x78,
  0x3E, 0x1E, 0xF8, 0x7E, 0xFF, 0x3C, 0x78, 0x3F, 0xF7, 0xFC, 0x78, 0x1F,
  0xE7, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x0F, 0xE0,
  0x07, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x3E, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0,
  0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xF8, 0x0F, 0xEF, 0x80, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E,
  0xF8, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0x80, 0xE1, 0xF8, 0x00, 0x8F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x87, 0xFE, 0x3E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0x81, 0xFF, 0x1F, 0x00, 0xFF, 0x3E, 0x00, 0x7E,
  0x7C, 0x00, 0xFE, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x7C, 0x00,
  0xFC, 0xF8, 0x03, 0xF9, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x0E, 0x1F, 0xC0, 0x02, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x80, 0x1F, 0x1F, 0xC0, 0x1F, 0x1F,
  0xF0, 0x7F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xCF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F,
  0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x8F,
  0xC0, 0x3E, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xC7, 0xE0, 0x3E,
  0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x07,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x00, 0xFC,
  0xF8, 0x03, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x78, 0x00,
  0xFF, 0xFD, 0xF0, 0x03, 0xFF, 0xF7, 0xC0, 0x0F, 0x7F, 0xEF, 0x00, 0x3D,
  0xFF, 0xBE, 0x01, 0xF7, 0xFE, 0xF8, 0x07, 0x9F, 0xF9, 0xE0, 0x1E, 0x7F,
  0xE7, 0xC0, 0xF9, 0xFF, 0x9F, 0x03, 0xC7, 0xFE, 0x3C, 0x0F, 0x1F, 0xF8,
  0xF8, 0x7C, 0x7F, 0xE3, 0xE1, 0xE1, 0xFF, 0x8F, 0x87, 0x87, 0xFE, 0x1E,
  0x3E, 0x1F, 0xF8, 0x7C, 0xF0, 0x7F, 0xE1, 0xF3, 0xC1, 0xFF, 0x83, 0xDF,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81,
  0xFF, 0x81, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F,
  0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xC0, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF7, 0xE0, 0x1F, 0xF7, 0xE0, 0x1F, 0xF3,
  0xF0, 0x1F, 0xFB, 0xF0, 0x1F, 0xF9, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8,
  0xFC, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3F, 0x1F, 0xF8,
  0x3F, 0x1F, 0xF8, 0x1F, 0x9F, 0xF8, 0x1F, 0x9F, 0xF8, 0x0F, 0xDF, 0xF8,
  0x0F, 0xDF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0x83, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xBE, 0x0F, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBE,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8, 0x1F, 0xC3, 0xE0, 0x3F, 0x8F,
  0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80,
  0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3E,
  0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x00, 0xFC,
  0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x03,
  0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0x81, 0xEF, 0xC0,
  0x0B, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFE, 0x01, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0xC0,
  0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x80, 0x3E, 0x7E, 0x01, 0xFE,
  0x00, 0xF9, 0xF8, 0x07, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xE0, 0x1F, 0x8F,
  0x80, 0x7F, 0xC0, 0x7E, 0x3E, 0x03, 0xEF, 0x01, 0xF0, 0xFC, 0x0F, 0xBC,
  0x07, 0xC1, 0xF0, 0x3C, 0xF0, 0x3F, 0x07, 0xC0, 0xF3, 0xE0, 0xFC, 0x1F,
  0x07, 0xCF, 0x83, 0xE0, 0x7E, 0x1F, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x78,
  0x3E, 0x03, 0xE1, 0xE1, 0xF1, 0xF8, 0x0F, 0x8F, 0x87, 0xC7, 0xC0, 0x3E,
  0x3E, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x3C, 0x7C, 0x01, 0xF3, 0xC0, 0xF9,
  0xF0, 0x07, 0xCF, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x7B, 0xE0, 0x03, 0xFE, 0x01, 0xEF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7E, 0x0F,
  0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x07,
  0xE3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xF7, 0xC0, 0x07, 0xCF, 0x00, 0x1E, 0x3E, 0x00, 0x78, 0x78,
  0x03, 0xC1, 0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x1E, 0x0F,
  0x80, 0x7C, 0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0x87,
  0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3C, 0x07, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x1C, 0x0F, 0xC4, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x1F, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFE, 0xF7, 0xFF, 0x3C, 0x7F, 0x8F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x8F,
  0xE0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0xFE,
  0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0xFF, 0x0F,
  0xEF, 0xFF, 0xFC, 0xFB, 0xFF, 0xCF, 0x9F, 0xF8, 0xF0, 0xFE, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xF8, 0x73, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x2F, 0xF0, 0x63, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x7F, 0x1F, 0x0F, 0xF9, 0xF1, 0xFF, 0xDF, 0x3F, 0xFF, 0xF7, 0xF0,
  0xFF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F,
  0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0xDF, 0x07, 0xF0,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x23, 0xF0, 0x0C, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x70, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0xF0,
  0xFF, 0xDF, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0x0F, 0xF7, 0xE0, 0x7F,
  0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x3F,
  0xFF, 0xF3, 0xFF, 0xDF, 0x1F, 0xFD, 0xF0, 0x7F, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x40, 0x03, 0xF7, 0x00, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x40,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE,
  0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF0,
  0x7B, 0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x03, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xF8, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF7, 0xFE, 0xFF, 0x9F, 0xF3, 0xFC,
  0x08, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xCF,
  0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF0, 0x1F, 0xCF, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07,
  0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x9F,
  0x80, 0x7E, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0xFF, 0x07, 0xF8, 0xF9, 0xFF, 0x8F, 0xFC, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xFE, 0x07,
  0xF0, 0x3F, 0xFC, 0x07, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x03,
  0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x03,
  0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03,
  0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03,
  0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03,
  0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03,
  0xE0, 0x1F, 0xF0, 0xFF, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFF, 0x8F, 0xEF, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC,
  0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0xF8, 0xFE, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xEF, 0xF0, 0xFE, 0xFF, 0xFF, 0xCF, 0xBF, 0xFC,
  0xF9, 0xFF, 0x8F, 0x8F, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0xF0,
  0xFF, 0xDF, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0x0F, 0xF7, 0xE0, 0x7F,
  0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x3F,
  0xFF, 0xF3, 0xFF, 0xDF, 0x1F, 0xFD, 0xF0, 0x7F, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0xF0, 0x7F, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFC, 0x0C, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x84, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFB, 0xCF, 0xFE, 0x78, 0xFF, 0x8F, 0xFC, 0x00, 0xFD, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x80, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x07, 0xDF, 0x01, 0xFC,
  0x07, 0xEF, 0xC0, 0xFF, 0x03, 0xE3, 0xE0, 0x7F, 0x81, 0xF1, 0xF0, 0x3F,
  0xC0, 0xF8, 0xF8, 0x3D, 0xE0, 0xFC, 0x7E, 0x1E, 0xF8, 0x7C, 0x1F, 0x0F,
  0x3C, 0x3E, 0x0F, 0x87, 0x9E, 0x1F, 0x07, 0xC7, 0xCF, 0x1F, 0x83, 0xE3,
  0xC7, 0xCF, 0x80, 0xF9, 0xE1, 0xE7, 0xC0, 0x7C, 0xF0, 0xF3, 0xE0, 0x3E,
  0xF8, 0x79, 0xE0, 0x1F, 0x78, 0x3D, 0xF0, 0x07, 0xBC, 0x1E, 0xF8, 0x03,
  0xDE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0x80,
  0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0xFC, 0x00,
  0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E,
  0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x17, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xF8, 0x07, 0xFC, 0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 32, 12, 3, -31 },
  { 25, 14, 11, 19, 3, -31 },
  { 45, 24, 31, 26, 1, -31 },
  { 138, 19, 36, 23, 2, -33 },
  { 224, 33, 32, 36, 2, -32 },
  { 356, 27, 32, 29, 2, -32 },
  { 464, 5, 11, 11, 3, -31 },
  { 471, 11, 38, 14, 2, -31 },
  { 524, 11, 38, 14, 1, -31 },
  { 577, 20, 18, 22, 1, -33 },
  { 622, 19, 21, 23, 2, -26 },
  { 672, 8, 11, 12, 1, -5 },
  { 683, 11, 5, 14, 1, -14 },
  { 690, 6, 7, 12, 3, -6 },
  { 696, 17, 32, 17, 0, -32 },
  { 764, 19, 32, 23, 2, -32 },
  { 840, 13, 31, 23, 3, -31 },
  { 891, 19, 32, 23, 2, -32 },
  { 967, 19, 32, 23, 2, -32 },
  { 1043, 21, 32, 23, 1, -32 },
  { 1127, 19, 31, 23, 2, -31 },
  { 1201, 20, 32, 23, 2, -32 },
  { 1281, 21, 31, 23, 1, -31 },
  { 1363, 20, 32, 23, 2, -32 },
  { 1443, 19, 32, 23, 2, -32 },
  { 1519, 6, 25, 12, 3, -24 },
  { 1538, 8, 30, 12, 1, -24 },
  { 1568, 19, 22, 23, 2, -27 },
  { 1621, 19, 13, 23, 2, -22 },
  { 1652, 20, 22, 23, 2, -27 },
  { 1707, 18, 33, 18, 0, -32 },
  { 1782, 32, 36, 36, 2, -32 },
  { 1926, 27, 32, 27, 0, -32 },
  { 2034, 20, 31, 27, 4, -31 },
  { 2112, 22, 32, 25, 2, -32 },
  { 2200, 23, 31, 29, 4, -31 },
  { 2290, 16, 31, 22, 4, -31 },
  { 2352, 16, 31, 22, 4, -31 },
  { 2414, 24, 32, 29, 2, -32 },
  { 2510, 22, 31, 30, 4, -31 },
  { 2596, 13, 31, 15, 1, -31 },
  { 2647, 12, 40, 13, -3, -31 },
  { 2707, 22, 31, 26, 4, -31 },
  { 2793, 16, 31, 22, 4, -31 },
  { 2855, 30, 31, 38, 4, -31 },
  { 2972, 24, 31, 32, 4, -31 },
  { 3065, 27, 32, 31, 2, -32 },
  { 3173, 19, 31, 25, 4, -31 },
  { 3247, 27, 39, 31, 2, -32 },
  { 3379, 22, 31, 26, 4, -31 },
  { 3465, 18, 32, 22, 2, -32 },
  { 3537, 21, 31, 22, 1, -31 },
  { 3619, 23, 31, 30, 3, -31 },
  { 3709, 25, 31, 25, 0, -31 },
  { 3806, 38, 31, 38, 0, -31 },
  { 3954, 25, 31, 25, 0, -31 },
  { 4051, 24, 31, 24, 0, -31 },
  { 4144, 20, 31, 22, 1, -31 },
  { 4222, 10, 38, 14, 3, -31 },
  { 4270, 17, 32, 17, 0, -32 },
  { 4338, 10, 38, 14, 1, -31 },
  { 4386, 22, 20, 24, 1, -32 },
  { 4441, 19, 3, 19, 0, 4 },
  { 4449, 10, 7, 14, 2, -34 },
  { 4458, 18, 24, 24, 2, -24 },
  { 4512, 20, 33, 25, 3, -33 },
  { 4595, 17, 24, 20, 2, -24 },
  { 4646, 20, 33, 25, 2, -33 },
  { 4729, 20, 24, 23, 2, -24 },
  { 4789, 16, 34, 15, 1, -34 },
  { 4857, 20, 35, 25, 2, -24 },
  { 4945, 20, 33, 26, 3, -33 },
  { 5028, 6, 33, 12, 3, -33 },
  { 5053, 11, 44, 12, -2, -33 },
  { 5114, 21, 33, 24, 3, -33 },
  { 5201, 5, 33, 12, 3, -33 },
  { 5222, 32, 24, 38, 3, -24 },
  { 5318, 20, 24, 26, 3, -24 },
  { 5378, 21, 24, 25, 2, -24 },
  { 5441, 20, 35, 25, 3, -24 },
  { 5529, 20, 35, 25, 2, -24 },
  { 5617, 14, 24, 17, 3, -24 },
  { 5659, 16, 24, 20, 2, -24 },
  { 5707, 14, 29, 16, 1, -29 },
  { 5758, 19, 24, 26, 3, -24 },
  { 5815, 22, 24, 22, 0, -24 },
  { 5881, 33, 24, 34, 0, -24 },
  { 5980, 22, 24, 22, 0, -24 },
  { 6046, 22, 35, 22, 0, -24 },
  { 6143, 17, 24, 19, 1, -24 },
  { 6194, 14, 38, 17, 1, -31 },
  { 6261, 4, 43, 22, 9, -33 },
  { 6283, 14, 38, 17, 2, -31 },
  { 6350, 20, 7, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD44PT7B_H_
