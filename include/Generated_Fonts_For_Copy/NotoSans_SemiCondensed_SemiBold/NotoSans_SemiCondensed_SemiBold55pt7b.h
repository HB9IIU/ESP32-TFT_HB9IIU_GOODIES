#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7F, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0x7E, 0x1F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xB8,
  0xFC, 0xFE, 0x38, 0x08, 0xFC, 0x38, 0x00, 0xFC, 0x38, 0x00, 0xFC, 0x38,
  0x00, 0xFC, 0x38, 0x00, 0xFE, 0x38, 0x00, 0xFF, 0xB8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x39,
  0xFE, 0x00, 0x38, 0xFE, 0x00, 0x38, 0x7F, 0x00, 0x38, 0x7F, 0x00, 0x38,
  0x7F, 0x80, 0x38, 0x7E, 0xC0, 0x38, 0xFE, 0xF8, 0x39, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xFF,
  0x80, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xF1, 0xF0, 0x03,
  0xE0, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07,
  0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x3E,
  0x00, 0x07, 0xC0, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0x8F, 0xC7, 0xFE, 0x1F, 0x0F, 0xC7, 0xC7, 0xFF, 0x8F, 0xC7, 0xE7, 0xE7,
  0xFF, 0xC3, 0xFF, 0xE3, 0xE3, 0xFF, 0xF1, 0xFF, 0xF3, 0xF1, 0xF0, 0xF8,
  0x7F, 0xF1, 0xF1, 0xF8, 0x7E, 0x1F, 0xF1, 0xF8, 0xF8, 0x3F, 0x03, 0xC0,
  0xF8, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0xF8,
  0x00, 0x3F, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x80, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x01, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0xFF,
  0x80, 0x7E, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0x7F,
  0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0x1F, 0xC3, 0xF8, 0x0F, 0xF3, 0xF8,
  0x7F, 0x00, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0xC1, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0x80, 0x0F, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF9, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x70, 0x7C, 0x0E, 0xFE, 0x3C, 0x7E, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0,
  0x1F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0x81, 0xC0,
  0x01, 0x01, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xF8,
  0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7E, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x1F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB,
  0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF8,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xBF, 0xFF, 0x3F, 0xFC, 0x3F, 0x78,
  0x3F, 0x30, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0x7C, 0x01, 0xFC, 0x18, 0x00, 0xFE, 0x08,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF8, 0x70, 0x01,
  0xFC, 0x10, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x60, 0x00, 0xFF, 0xBF, 0x01,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3E,
  0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x9F, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFD, 0xF0, 0x1F, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x7E, 0x7F, 0xF8, 0x7F, 0x7F, 0xFE,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xF7, 0xFC, 0x03,
  0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0xFE, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC7, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0x80, 0x7F,
  0x9F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0x9F, 0xE0, 0x3F, 0xCF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF0, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0,
  0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x3F, 0xEF,
  0xF0, 0x3F, 0xF7, 0xFE, 0x7F, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0xFC,
  0x3F, 0xFF, 0x7E, 0x07, 0xFF, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x08, 0x07,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7F, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x18, 0x1F, 0x1F, 0xDF, 0xEF, 0xF7, 0xF9, 0xFC, 0xFE,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3,
  0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xE0, 0x3F, 0x8C, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xE0, 0x7C, 0x3E, 0x01, 0xFF, 0xF8, 0x7E,
  0x7E, 0x03, 0xFF, 0xF8, 0x3E, 0x7C, 0x07, 0xFF, 0xF8, 0x3E, 0x7C, 0x0F,
  0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0xF8, 0x1F, 0x01, 0xF8,
  0x1F, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xF8,
  0x3E, 0x01, 0xF8, 0x1F, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0xF8, 0x3E, 0x01,
  0xF8, 0x1F, 0xF8, 0x3E, 0x01, 0xF0, 0x1E, 0xF8, 0x3E, 0x01, 0xF0, 0x3E,
  0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0xF8, 0x3F,
  0x03, 0xF0, 0x7C, 0xF8, 0x1F, 0x07, 0xF8, 0x7C, 0xF8, 0x1F, 0xCF, 0xFD,
  0xFC, 0xFC, 0x0F, 0xFF, 0x7F, 0xF8, 0x7C, 0x0F, 0xFE, 0x3F, 0xF0, 0x7C,
  0x07, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x07, 0xFC,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0x3F,
  0x80, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0xF0, 0xFF, 0x80, 0x0C,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x18, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x02, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x0F, 0xF8, 0xFE, 0x00,
  0x1F, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01,
  0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE,
  0x3F, 0x80, 0x1F, 0xF0, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0x07, 0xFE, 0x00, 0x08, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x1F,
  0xE0, 0x01, 0xFC, 0x7F, 0xC0, 0x07, 0xF0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x81,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x7F,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0xFC, 0x3F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xF1,
  0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x0F, 0xF0,
  0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC,
  0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0xCF,
  0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xFF, 0xFB, 0xF0, 0x00,
  0x3E, 0xFF, 0xFF, 0xC0, 0x01, 0xFB, 0xFF, 0xDF, 0x00, 0x07, 0xEF, 0xFF,
  0x7E, 0x00, 0x1F, 0x3F, 0xFD, 0xF8, 0x00, 0xFC, 0xFF, 0xF3, 0xE0, 0x03,
  0xF7, 0xFF, 0xCF, 0xC0, 0x0F, 0x9F, 0xFF, 0x3F, 0x00, 0x7E, 0x7F, 0xFC,
  0xFC, 0x01, 0xF9, 0xFF, 0xF1, 0xF8, 0x07, 0xC7, 0xFF, 0xC7, 0xE0, 0x3F,
  0x1F, 0xFF, 0x1F, 0x80, 0xFC, 0x7F, 0xFC, 0x3F, 0x03, 0xE1, 0xFF, 0xF0,
  0xFC, 0x1F, 0x87, 0xFF, 0xC3, 0xF0, 0x7E, 0x1F, 0xFF, 0x07, 0xE1, 0xF0,
  0x7F, 0xFC, 0x1F, 0x8F, 0xC1, 0xFF, 0xF0, 0x7E, 0x3F, 0x07, 0xFF, 0xC0,
  0xF8, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x81,
  0xFF, 0xF0, 0x1F, 0x7C, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xEF,
  0xE0, 0x03, 0xFF, 0xDF, 0xC0, 0x0F, 0xFF, 0x7F, 0x00, 0x3F, 0xFC, 0xFE,
  0x00, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x1F, 0xE0,
  0x3F, 0xFC, 0x3F, 0x80, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xC1, 0xFC, 0x0F,
  0xFF, 0x07, 0xF8, 0x3F, 0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0xC3, 0xFF,
  0xC0, 0x7F, 0x0F, 0xFF, 0x00, 0xFE, 0x3F, 0xFC, 0x03, 0xF8, 0xFF, 0xF0,
  0x07, 0xF3, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0x00, 0x3F, 0xBF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF3, 0xF8, 0x07, 0xFD, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0xFF, 0xBF, 0x81, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x02, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xE0, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0x3F, 0xC0, 0x0C, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xA0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x01,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x3E, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3E, 0x7C, 0x03, 0xF8,
  0x1F, 0xC0, 0x7E, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x7C, 0x7E, 0x07, 0xF0,
  0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0,
  0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0,
  0x07, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF0, 0x0F, 0x9F, 0xC0, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x80,
  0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0x01, 0xFE, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC0,
  0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x3F, 0xFF, 0x3F, 0x1F, 0xFE,
  0x3F, 0x0F, 0xFC, 0x1F, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xFE, 0x07,
  0xF3, 0xFF, 0x83, 0xF3, 0xFF, 0xE1, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x7F, 0xE1, 0xFF, 0x3F, 0xE0, 0x3F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xF0, 0x1F, 0xEF,
  0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFB, 0xFF, 0xF0,
  0xFC, 0xFF, 0xF0, 0x7C, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xF0, 0xF1, 0xFE, 0x00, 0x8F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x02, 0x7F, 0xC0, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC3,
  0xF8, 0x7F, 0xF9, 0xFC, 0x7F, 0xFE, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xBF, 0xE1, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xE0, 0x1F,
  0xF7, 0xFC, 0x1F, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0x3F, 0x0F, 0xFF, 0x1F, 0x81, 0xFF, 0x0F, 0xC0, 0x08, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x02, 0x3F,
  0xC0, 0x1C, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x14, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xDC, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0x87, 0xFF, 0x8F, 0xC7,
  0xFF, 0xE7, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xFD,
  0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0x7F, 0xC1, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF7, 0xF0, 0xFF, 0xF3, 0xF8,
  0x1F, 0xF1, 0xFC, 0x00, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC8, 0x00, 0x0F, 0xE7, 0x00, 0x0F,
  0xF3, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0xFC,
  0x7F, 0xF8, 0xFC, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x9F, 0xF7, 0xFF, 0xBF,
  0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07,
  0xF1, 0xFC, 0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFE, 0x00,
  0x7E, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFD, 0xFC, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0xF8, 0xFF, 0xF0, 0x7F, 0xF8, 0xFD, 0xFF, 0xF8, 0xFF, 0xFC, 0xFD, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x3F, 0xE0, 0xF8, 0x7F, 0xF8, 0xFC, 0xFF, 0xFC, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE,
  0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0xC1,
  0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xF8, 0x3F, 0xE0, 0x7E,
  0x3F, 0xF8, 0x3F, 0x3F, 0xFE, 0x1F, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xFE, 0x0F, 0xF3, 0xFE, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFF, 0x01, 0xFE, 0xFF,
  0xC1, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0x7F, 0xFF, 0x1F, 0xBF, 0xFF, 0x0F,
  0xCF, 0xFF, 0x07, 0xF1, 0xFF, 0x03, 0xF8, 0x0C, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0x87, 0xFF, 0x8F, 0xC7, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xFD, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFE,
  0x01, 0xFF, 0x7F, 0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xF7, 0xF0, 0xFF, 0xF3, 0xF8, 0x1F, 0xF1, 0xFC, 0x01, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0x1E, 0xFE, 0x00, 0x4F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x40, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x04, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x30, 0x00,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x3F, 0xFF, 0xBF,
  0x1F, 0xFF, 0x3F, 0x0F, 0xFC, 0x1F, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x0F,
  0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE3, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x80,
  0x3F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xDF, 0x80, 0x1F, 0xE0,
  0x07, 0xE7, 0xF0, 0x07, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFF, 0x00, 0xFE,
  0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC3, 0xF8,
  0x0F, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xFF, 0x81, 0xFC, 0x1F, 0x81, 0xF3,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0x3E, 0x0F,
  0xE0, 0x7F, 0x07, 0xCF, 0x83, 0xF8, 0x0F, 0xC3, 0xF3, 0xF0, 0xFC, 0x03,
  0xF0, 0xF8, 0x7C, 0x3F, 0x00, 0xFE, 0x3E, 0x1F, 0x1F, 0xC0, 0x3F, 0x8F,
  0x87, 0xC7, 0xF0, 0x07, 0xE7, 0xE1, 0xF9, 0xF8, 0x01, 0xF9, 0xF0, 0x3E,
  0x7E, 0x00, 0x7E, 0x7C, 0x0F, 0x9F, 0x80, 0x1F, 0x9F, 0x03, 0xEF, 0xC0,
  0x03, 0xF7, 0xC0, 0xFB, 0xF0, 0x00, 0xFD, 0xE0, 0x3E, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x03, 0xF8,
  0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC1,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE0, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80,
  0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF7,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xCF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFD, 0x80, 0x0F, 0xFC, 0x80,
  0x00, 0xF8, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 40, 15, 3, -39 },
  { 41, 18, 14, 24, 3, -39 },
  { 73, 30, 39, 32, 1, -39 },
  { 220, 24, 45, 29, 3, -42 },
  { 355, 41, 41, 45, 2, -40 },
  { 566, 35, 41, 37, 2, -40 },
  { 746, 7, 14, 13, 3, -39 },
  { 759, 14, 48, 17, 2, -39 },
  { 843, 14, 48, 17, 1, -39 },
  { 927, 24, 24, 28, 2, -42 },
  { 999, 25, 27, 29, 2, -33 },
  { 1084, 9, 13, 15, 2, -6 },
  { 1099, 13, 6, 17, 2, -18 },
  { 1109, 8, 9, 15, 3, -8 },
  { 1118, 20, 39, 22, 1, -39 },
  { 1216, 25, 41, 29, 2, -40 },
  { 1345, 16, 39, 29, 4, -39 },
  { 1423, 25, 40, 29, 2, -40 },
  { 1548, 25, 41, 29, 2, -40 },
  { 1677, 27, 39, 29, 1, -39 },
  { 1809, 23, 40, 29, 3, -39 },
  { 1924, 25, 41, 29, 2, -40 },
  { 2053, 25, 39, 29, 2, -39 },
  { 2175, 25, 41, 29, 2, -40 },
  { 2304, 25, 41, 29, 2, -40 },
  { 2433, 8, 31, 15, 3, -30 },
  { 2464, 9, 37, 15, 2, -30 },
  { 2506, 25, 27, 29, 2, -33 },
  { 2591, 25, 16, 29, 2, -27 },
  { 2641, 25, 27, 29, 2, -33 },
  { 2726, 22, 41, 23, 0, -40 },
  { 2839, 40, 45, 45, 3, -40 },
  { 3064, 33, 39, 33, 0, -39 },
  { 3225, 27, 39, 33, 4, -39 },
  { 3357, 27, 41, 32, 3, -40 },
  { 3496, 30, 39, 36, 4, -39 },
  { 3643, 20, 39, 28, 5, -39 },
  { 3741, 20, 39, 27, 5, -39 },
  { 3839, 30, 41, 36, 3, -40 },
  { 3993, 28, 39, 38, 5, -39 },
  { 4130, 15, 39, 19, 2, -39 },
  { 4204, 15, 50, 16, -4, -39 },
  { 4298, 28, 39, 32, 5, -39 },
  { 4435, 22, 39, 27, 4, -39 },
  { 4543, 38, 39, 48, 5, -39 },
  { 4729, 30, 39, 40, 5, -39 },
  { 4876, 33, 41, 39, 3, -40 },
  { 5046, 25, 39, 31, 4, -39 },
  { 5168, 33, 49, 39, 3, -40 },
  { 5371, 28, 39, 32, 4, -39 },
  { 5508, 23, 41, 28, 2, -40 },
  { 5626, 26, 39, 28, 1, -39 },
  { 5753, 29, 40, 37, 4, -39 },
  { 5898, 32, 39, 32, 0, -39 },
  { 6054, 48, 39, 48, 0, -39 },
  { 6288, 31, 39, 31, 0, -39 },
  { 6440, 30, 39, 30, 0, -39 },
  { 6587, 26, 39, 28, 1, -39 },
  { 6714, 12, 48, 18, 4, -39 },
  { 6786, 21, 39, 22, 0, -39 },
  { 6889, 13, 48, 18, 1, -39 },
  { 6967, 28, 24, 30, 1, -39 },
  { 7051, 23, 4, 23, 0, 5 },
  { 7063, 13, 9, 18, 2, -42 },
  { 7078, 24, 31, 29, 2, -30 },
  { 7171, 25, 43, 32, 4, -42 },
  { 7306, 21, 31, 25, 3, -30 },
  { 7388, 25, 43, 32, 3, -42 },
  { 7523, 24, 31, 29, 3, -30 },
  { 7616, 20, 42, 19, 1, -42 },
  { 7721, 25, 43, 32, 3, -30 },
  { 7856, 24, 42, 32, 4, -42 },
  { 7982, 7, 41, 15, 4, -41 },
  { 8018, 13, 54, 15, -2, -41 },
  { 8106, 25, 42, 30, 4, -42 },
  { 8238, 7, 42, 14, 4, -42 },
  { 8275, 40, 30, 48, 4, -30 },
  { 8425, 24, 30, 32, 4, -30 },
  { 8515, 25, 31, 31, 3, -30 },
  { 8612, 25, 43, 32, 4, -30 },
  { 8747, 25, 43, 32, 3, -30 },
  { 8882, 17, 30, 22, 4, -30 },
  { 8946, 20, 31, 24, 2, -30 },
  { 9024, 18, 37, 20, 1, -36 },
  { 9108, 24, 31, 32, 4, -30 },
  { 9201, 27, 30, 27, 0, -30 },
  { 9303, 42, 30, 42, 0, -30 },
  { 9461, 27, 30, 28, 0, -30 },
  { 9563, 27, 43, 28, 0, -30 },
  { 9709, 20, 30, 24, 2, -30 },
  { 9784, 18, 48, 21, 1, -39 },
  { 9892, 6, 55, 28, 11, -42 },
  { 9934, 18, 48, 21, 2, -39 },
  { 10042, 25, 9, 29, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD55PT7B_H_
