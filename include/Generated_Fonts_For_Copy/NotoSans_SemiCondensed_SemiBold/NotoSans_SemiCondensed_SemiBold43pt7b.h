#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF,
  0x88, 0xFC, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7,
  0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xC0, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x83, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0xE3,
  0x9F, 0x1C, 0x13, 0xE3, 0x80, 0x7C, 0x70, 0x0F, 0x8E, 0x01, 0xFD, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xCF, 0xC0, 0x38, 0xF8, 0x07, 0x1F,
  0x00, 0xE3, 0xF8, 0x1C, 0xFF, 0xE3, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x3F, 0xC0, 0x0F,
  0x80, 0x7F, 0xE0, 0x0F, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0xF0, 0xF0, 0x1E,
  0x00, 0xF0, 0xF0, 0x1E, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF0, 0xF0, 0x3C,
  0x00, 0xF0, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0xF0,
  0x00, 0xF0, 0xF0, 0xF0, 0x00, 0xF0, 0xF1, 0xE1, 0xE0, 0xF0, 0xF1, 0xE7,
  0xF8, 0xF0, 0xF3, 0xC7, 0xFC, 0x7F, 0xE3, 0xCF, 0xFE, 0x7F, 0xE7, 0x8F,
  0x1E, 0x3F, 0xC7, 0x9E, 0x1E, 0x1F, 0x8F, 0x1E, 0x1F, 0x00, 0x0F, 0x1E,
  0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x1F, 0x00, 0x78, 0x1E,
  0x1E, 0x00, 0xF0, 0x1F, 0x1E, 0x00, 0xF0, 0x0F, 0x3E, 0x01, 0xE0, 0x0F,
  0xFC, 0x01, 0xE0, 0x07, 0xFC, 0x03, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x7C, 0x3F, 0xF8, 0x0F, 0x8F, 0xFF, 0x83, 0xF1, 0xF9, 0xF8,
  0x7C, 0x7E, 0x1F, 0x8F, 0x8F, 0x81, 0xFB, 0xF1, 0xF0, 0x1F, 0xFC, 0x3E,
  0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xE0, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x7F,
  0x83, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFE, 0x3F, 0x03, 0xFF, 0x03, 0xF8, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E,
  0x79, 0xE7, 0x80, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x81, 0xE0, 0x5E, 0x3C, 0x7B, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x7C, 0x03, 0xE7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xC1, 0xC0, 0x08, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xFD, 0xFF, 0xF7, 0xEF,
  0x84, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF3, 0xF8, 0xFC, 0x1F, 0x1F, 0x03,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xF7, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0xC1, 0xF9, 0xFC, 0x7E,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x9F, 0xFD, 0xFB, 0xFF, 0x9F, 0xF8,
  0xFB, 0x87, 0xC8, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF7,
  0xF8, 0xF0, 0x1F, 0x88, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xC3, 0xF8, 0xE0, 0x1F, 0x88, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xD0, 0x01, 0xFB, 0x80, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x78, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xE0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x30, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xD0, 0x01, 0xFB, 0xC0, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFE, 0x08, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x1C, 0x0F, 0x9F, 0xE1,
  0xF7, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x0F, 0xDF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xC0, 0xF9, 0xFC, 0x3F, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0,
  0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xF8, 0x3E, 0x1F, 0x8F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xF1, 0xF8, 0x7F, 0x7E, 0x07,
  0xEF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF,
  0x87, 0xF3, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0x7C, 0x7F, 0xCF,
  0x87, 0xF1, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x73, 0xEF, 0xFF, 0xFF, 0xE7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFE, 0x20,
  0x1C, 0x3E, 0x3F, 0x3F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xC3, 0xF9, 0x80, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x03, 0xF0, 0x3C, 0x78, 0x1F,
  0xFC, 0x79, 0xF0, 0x7F, 0xF8, 0x7B, 0xC1, 0xFF, 0xF0, 0xF7, 0x87, 0xC1,
  0xE1, 0xEF, 0x0F, 0x03, 0xC3, 0xFC, 0x3E, 0x07, 0x83, 0xF8, 0x78, 0x0F,
  0x07, 0xF0, 0xF0, 0x1E, 0x1F, 0xE1, 0xE0, 0x7C, 0x3F, 0xC3, 0xC0, 0xF8,
  0x7F, 0x87, 0x81, 0xF0, 0xFF, 0x0F, 0x03, 0xE1, 0xFE, 0x1F, 0x0F, 0xC7,
  0xBC, 0x1F, 0x1F, 0x8F, 0x3C, 0x3F, 0xF7, 0xFC, 0x78, 0x3F, 0xC7, 0xF0,
  0xF0, 0x3F, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x03, 0xF8, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7E,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0,
  0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0xFF, 0xE8, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x03, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xE0, 0x7F, 0xBF, 0x00, 0xFD, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x07, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xF9, 0xF0, 0x7F, 0x00, 0xC3, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x21, 0xFE, 0x07, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x80,
  0xFF, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0xFC, 0x1F, 0xE0, 0x0C, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0xE0, 0x3F,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x07,
  0xC0, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF,
  0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x7E,
  0x07, 0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7D,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x83, 0xE0,
  0xFC, 0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x01, 0xF9,
  0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFD, 0xE0, 0x03, 0xDF, 0xF7,
  0xC0, 0x1F, 0x7F, 0xDF, 0x00, 0x7D, 0xFF, 0x3C, 0x01, 0xE7, 0xFC, 0xF8,
  0x0F, 0xBF, 0xF3, 0xE0, 0x3E, 0xFF, 0xE7, 0x80, 0xF3, 0xFF, 0x9E, 0x03,
  0xCF, 0xFE, 0x7C, 0x1F, 0x3F, 0xF9, 0xF0, 0x78, 0xFF, 0xE3, 0xC1, 0xE3,
  0xFF, 0x8F, 0x8F, 0x8F, 0xFE, 0x3E, 0x3C, 0x3F, 0xF8, 0x78, 0xF0, 0xFF,
  0xE1, 0xF7, 0xC3, 0xFF, 0x87, 0xDE, 0x0F, 0xFE, 0x0F, 0x78, 0x3F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x07,
  0xF0, 0x3F, 0xF8, 0x1F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x1F, 0xF7, 0xE0, 0x1F, 0xF7, 0xE0, 0x1F, 0xF3, 0xF0, 0x1F, 0xF1,
  0xF0, 0x1F, 0xF1, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0xFC, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3F, 0x1F, 0xF8,
  0x1F, 0x9F, 0xF8, 0x1F, 0x9F, 0xF8, 0x0F, 0xDF, 0xF8, 0x0F, 0xDF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFB, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFB, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x8F, 0xC7, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3E,
  0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xC0,
  0x03, 0xFC, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0x80, 0xCF, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xEF, 0x87,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBE, 0x00,
  0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xC0,
  0x0F, 0x9F, 0x00, 0x7F, 0x00, 0x7E, 0x7C, 0x01, 0xFC, 0x01, 0xF9, 0xF0,
  0x07, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0xE0, 0x1F, 0x0F, 0x80, 0x7F, 0x80,
  0x7C, 0x3E, 0x03, 0xDE, 0x03, 0xF0, 0xF8, 0x0F, 0x78, 0x0F, 0x83, 0xF0,
  0x3D, 0xF0, 0x3E, 0x07, 0xC0, 0xF3, 0xC0, 0xF8, 0x1F, 0x07, 0xCF, 0x07,
  0xE0, 0x7C, 0x1F, 0x3C, 0x1F, 0x01, 0xF0, 0x78, 0xF8, 0x7C, 0x03, 0xE1,
  0xE3, 0xE1, 0xF0, 0x0F, 0x8F, 0x87, 0x87, 0xC0, 0x3E, 0x3E, 0x1E, 0x3E,
  0x00, 0xF8, 0xF0, 0x7C, 0xF8, 0x01, 0xF3, 0xC1, 0xF3, 0xE0, 0x07, 0xDF,
  0x03, 0xCF, 0x80, 0x1F, 0x7C, 0x0F, 0x3E, 0x00, 0x7D, 0xE0, 0x3F, 0xF0,
  0x00, 0xF7, 0x80, 0xFF, 0xC0, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0,
  0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3,
  0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x3E,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x07, 0x87, 0x80, 0x3C,
  0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x01, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x1F, 0x84,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7F,
  0xFC, 0x7F, 0xFF, 0x7F, 0xFF, 0xDF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFE, 0xF7, 0xFF, 0x3C, 0x7F, 0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0xF9, 0xFF, 0x0F, 0xBF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03,
  0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0xE0, 0x7E, 0xFF, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xBF, 0xF0, 0xF0, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFE, 0x7F, 0x02, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0x7F, 0x03, 0x3F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x3C, 0x3F, 0x0F, 0xF3, 0xF1, 0xFF, 0xDF, 0x3F,
  0xFD, 0xF3, 0xFF, 0xFF, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03,
  0xF7, 0xE0, 0x7F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF,
  0x9F, 0x07, 0xF1, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xF1, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x63, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F,
  0xF8, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xFC, 0xC3, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF,
  0xDF, 0x3F, 0xFF, 0xF7, 0xE0, 0x7F, 0x7C, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F,
  0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xDF, 0x1F, 0xFB,
  0xF0, 0xFF, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x40, 0x07, 0xE7, 0x80, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFF, 0x01, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x07, 0x83, 0xE7, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0xFB,
  0xEF, 0xFE, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x07,
  0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x07,
  0xEF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x87,
  0xE0, 0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFC, 0x7E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xFC,
  0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0xF1, 0xFF, 0x0F,
  0xF8, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x0F, 0xF0, 0x7E, 0xFC, 0x07, 0xE0, 0x3E, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x3C, 0x1E, 0x3F, 0xE3, 0xEF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0xDF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E,
  0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x3C, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFE,
  0x07, 0xEF, 0xF0, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF, 0xF8, 0xFB, 0xFF, 0x0F,
  0x8F, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF,
  0xDF, 0x3F, 0xFF, 0xF7, 0xE0, 0x7F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F,
  0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xDF, 0x1F, 0xFB,
  0xF0, 0xFF, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xC3, 0xEF, 0x1F, 0xBE, 0xFE, 0xFF,
  0xFB, 0xFF, 0x2F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xC0,
  0x1F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x3C, 0xF8, 0x04, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3E,
  0xC0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x7F, 0xF3, 0xC7, 0xF8, 0x78, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xDF,
  0x00, 0x7C, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0,
  0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x7C,
  0x07, 0xF0, 0x1F, 0x7C, 0x07, 0xF0, 0x1F, 0x7E, 0x07, 0xF0, 0x3E, 0x3E,
  0x0F, 0x78, 0x3E, 0x3E, 0x0F, 0x78, 0x3E, 0x3E, 0x0F, 0x78, 0x3E, 0x3E,
  0x0F, 0x78, 0x7C, 0x1F, 0x1E, 0x78, 0x7C, 0x1F, 0x1E, 0x3C, 0x7C, 0x1F,
  0x1E, 0x3C, 0x7C, 0x1F, 0x1E, 0x3C, 0xF8, 0x0F, 0xBE, 0x3C, 0xF8, 0x0F,
  0xBC, 0x1E, 0xF8, 0x0F, 0xBC, 0x1E, 0xF8, 0x0F, 0xBC, 0x1E, 0xF0, 0x07,
  0xBC, 0x1E, 0xF0, 0x07, 0xB8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03,
  0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F,
  0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xF0, 0x0F, 0xCF, 0x80,
  0x7C, 0x7E, 0x07, 0xE1, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3F, 0x3F, 0x00,
  0xFB, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C,
  0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x83, 0xFC,
  0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x07,
  0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x87, 0xE0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0x78, 0x00,
  0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFD,
  0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 32, 11, 3, -31 },
  { 25, 14, 11, 19, 2, -31 },
  { 45, 23, 31, 25, 1, -31 },
  { 135, 19, 36, 23, 2, -33 },
  { 221, 32, 31, 35, 2, -31 },
  { 345, 27, 31, 29, 2, -31 },
  { 450, 6, 11, 10, 2, -31 },
  { 459, 11, 38, 14, 2, -31 },
  { 512, 11, 38, 14, 1, -31 },
  { 565, 19, 19, 22, 1, -33 },
  { 611, 19, 21, 23, 2, -26 },
  { 661, 8, 11, 11, 1, -5 },
  { 672, 11, 5, 13, 1, -14 },
  { 679, 7, 7, 11, 2, -6 },
  { 686, 17, 31, 17, 0, -31 },
  { 752, 19, 31, 23, 2, -31 },
  { 826, 13, 31, 23, 3, -31 },
  { 877, 19, 31, 23, 2, -31 },
  { 951, 19, 31, 23, 2, -31 },
  { 1025, 21, 31, 23, 1, -31 },
  { 1107, 19, 31, 23, 2, -31 },
  { 1181, 19, 31, 23, 2, -31 },
  { 1255, 20, 31, 23, 1, -31 },
  { 1333, 19, 31, 23, 2, -31 },
  { 1407, 19, 31, 23, 2, -31 },
  { 1481, 6, 25, 11, 3, -24 },
  { 1500, 8, 30, 11, 1, -24 },
  { 1530, 19, 21, 23, 2, -26 },
  { 1580, 19, 12, 23, 2, -21 },
  { 1609, 19, 21, 23, 2, -26 },
  { 1659, 17, 32, 18, 0, -31 },
  { 1727, 31, 35, 35, 2, -31 },
  { 1863, 26, 31, 26, 0, -31 },
  { 1964, 21, 31, 26, 3, -31 },
  { 2046, 22, 31, 25, 2, -31 },
  { 2132, 23, 31, 28, 3, -31 },
  { 2222, 16, 31, 22, 4, -31 },
  { 2284, 15, 31, 21, 4, -31 },
  { 2343, 24, 31, 29, 2, -31 },
  { 2436, 22, 31, 30, 4, -31 },
  { 2522, 12, 31, 15, 1, -31 },
  { 2569, 12, 40, 12, -3, -31 },
  { 2629, 21, 31, 25, 4, -31 },
  { 2711, 17, 31, 21, 3, -31 },
  { 2777, 30, 31, 37, 4, -31 },
  { 2894, 24, 31, 31, 4, -31 },
  { 2987, 26, 31, 31, 2, -31 },
  { 3088, 19, 31, 24, 3, -31 },
  { 3162, 26, 38, 31, 2, -31 },
  { 3286, 22, 31, 25, 3, -31 },
  { 3372, 18, 31, 22, 2, -31 },
  { 3442, 20, 31, 22, 1, -31 },
  { 3520, 23, 31, 29, 3, -31 },
  { 3610, 25, 31, 25, 0, -31 },
  { 3707, 38, 31, 38, 0, -31 },
  { 3855, 24, 31, 24, 0, -31 },
  { 3948, 23, 31, 23, 0, -31 },
  { 4038, 20, 31, 22, 1, -31 },
  { 4116, 10, 38, 14, 3, -31 },
  { 4164, 17, 31, 17, 0, -31 },
  { 4230, 10, 38, 14, 1, -31 },
  { 4278, 21, 19, 23, 1, -31 },
  { 4328, 18, 3, 18, 0, 4 },
  { 4335, 10, 7, 14, 2, -33 },
  { 4344, 18, 24, 23, 2, -24 },
  { 4398, 20, 33, 25, 3, -33 },
  { 4481, 16, 24, 20, 2, -24 },
  { 4529, 20, 33, 25, 2, -33 },
  { 4612, 19, 24, 23, 2, -24 },
  { 4669, 15, 33, 15, 1, -33 },
  { 4731, 20, 34, 25, 2, -24 },
  { 4816, 19, 33, 25, 3, -33 },
  { 4895, 6, 32, 11, 3, -32 },
  { 4919, 11, 42, 11, -2, -32 },
  { 4977, 20, 33, 23, 3, -33 },
  { 5060, 5, 33, 11, 3, -33 },
  { 5081, 32, 24, 38, 3, -24 },
  { 5177, 19, 24, 25, 3, -24 },
  { 5234, 20, 24, 24, 2, -24 },
  { 5294, 20, 34, 25, 3, -24 },
  { 5379, 20, 34, 25, 2, -24 },
  { 5464, 14, 24, 17, 3, -24 },
  { 5506, 16, 24, 19, 2, -24 },
  { 5554, 14, 28, 16, 1, -28 },
  { 5603, 19, 23, 25, 3, -23 },
  { 5658, 21, 23, 21, 0, -23 },
  { 5719, 32, 23, 33, 0, -23 },
  { 5811, 21, 23, 22, 0, -23 },
  { 5872, 21, 33, 22, 0, -23 },
  { 5959, 16, 23, 19, 1, -23 },
  { 6005, 14, 38, 16, 1, -31 },
  { 6072, 4, 43, 22, 9, -33 },
  { 6094, 13, 38, 16, 2, -31 },
  { 6156, 19, 6, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD43PT7B_H_
