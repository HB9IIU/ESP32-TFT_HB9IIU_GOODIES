#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x01, 0xCF, 0xDF, 0xFF, 0xFF, 0xFE, 0xF8, 0x40, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3E, 0xF0, 0x7D, 0xE0, 0xFB, 0xC1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00,
  0x3E, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x71, 0xE7, 0xF3, 0x81,
  0x3F, 0x1C, 0x01, 0xF8, 0xE0, 0x0F, 0xC7, 0x00, 0x3F, 0x38, 0x01, 0xFD,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xDF, 0xE0, 0x0E,
  0x3F, 0x00, 0x71, 0xF8, 0x03, 0x87, 0xC0, 0x1C, 0x3F, 0x80, 0xE3, 0xFF,
  0x87, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x7C,
  0xF8, 0x03, 0xE0, 0x0F, 0x87, 0x80, 0x7C, 0x00, 0xF8, 0x7C, 0x07, 0xC0,
  0x0F, 0x87, 0xC0, 0xF8, 0x00, 0xF0, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xC1,
  0xF0, 0x00, 0xF0, 0x3C, 0x1F, 0x00, 0x0F, 0x03, 0xC3, 0xE0, 0x00, 0xF0,
  0x3C, 0x3E, 0x00, 0x0F, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x7C, 0x7C, 0x3E,
  0x0F, 0x87, 0xC7, 0x8F, 0xF8, 0xF8, 0x7C, 0xF9, 0xFF, 0xC7, 0xCF, 0x8F,
  0x1F, 0xFC, 0x7F, 0xF9, 0xF3, 0xE3, 0xE3, 0xFF, 0x1E, 0x3E, 0x3E, 0x1F,
  0xE3, 0xE3, 0xC1, 0xE0, 0x78, 0x3C, 0x7C, 0x1F, 0x00, 0x07, 0xC7, 0xC1,
  0xF0, 0x00, 0x78, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x00, 0xF0,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x1F, 0x00,
  0x3E, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x7C, 0x03, 0xE3,
  0xE0, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x00,
  0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x0F, 0xC1, 0xFF, 0xE0, 0x3F, 0x0F, 0xFF, 0xC0, 0xFC, 0x7F, 0x3F,
  0x83, 0xF1, 0xF8, 0x7F, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x3F, 0x01, 0xFB,
  0xF0, 0xFC, 0x07, 0xFF, 0xC3, 0xF0, 0x0F, 0xFE, 0x0F, 0xC0, 0x1F, 0xF8,
  0x3F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xEF, 0xF0, 0x7F,
  0xFF, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF,
  0xBE, 0xF9, 0xE7, 0x9E, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81,
  0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x06, 0x07, 0x80, 0x9F, 0x1E, 0x3E, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xAF, 0xFF, 0xFD, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x3E, 0x1F, 0x01,
  0xF8, 0x7E, 0x01, 0xC0, 0xE0, 0x01, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F,
  0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x08, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xC7, 0xF1, 0xFC, 0x1F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x1F, 0x83, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xBF, 0xFE, 0x7E,
  0xF8, 0xFC, 0xC1, 0xF8, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0x8F, 0xF9, 0xF0, 0x1F, 0xC6, 0x00, 0x7E, 0x10, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0x07, 0xF8, 0xC0,
  0x1F, 0xC4, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xFB, 0xF1, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE2, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE1, 0xF1, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xEE, 0x00, 0x7F, 0x7F, 0xBF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7F, 0xC0, 0x41, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF1,
  0xFC, 0x0F, 0xCF, 0xFC, 0x3F, 0x7F, 0xF8, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0,
  0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xFD, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x3F,
  0x07, 0xF0, 0xFE, 0x3F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x8F, 0xE1,
  0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3E, 0xFC, 0x01, 0xFB, 0xF8, 0x07,
  0xE7, 0xF0, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF1, 0xF8, 0x1F, 0xDF, 0x80, 0x7E,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFB,
  0xF8, 0x3F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFD, 0xF1, 0xFF, 0xCF, 0x87, 0xFC,
  0x7C, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0xC3, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x10,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF0, 0x80,
  0x08, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x7C, 0x3F, 0xCC, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x00, 0xF8, 0x78, 0x0F, 0xFE, 0x0F, 0x1F, 0x03, 0xFF, 0xE1, 0xE3, 0xC0,
  0xFF, 0xFC, 0x3E, 0xF8, 0x3F, 0x0F, 0x83, 0xDF, 0x0F, 0xC1, 0xF0, 0x7B,
  0xC1, 0xF0, 0x3E, 0x0F, 0x78, 0x3C, 0x07, 0xC1, 0xFF, 0x0F, 0x80, 0xF8,
  0x3F, 0xE1, 0xF0, 0x1F, 0x07, 0xFC, 0x3E, 0x03, 0xE0, 0xFF, 0x87, 0xC0,
  0x78, 0x1F, 0xF0, 0xF8, 0x0F, 0x03, 0xFE, 0x1F, 0x03, 0xE0, 0xFF, 0xC3,
  0xE0, 0x7C, 0x1E, 0xF8, 0x3E, 0x0F, 0xC3, 0xCF, 0x07, 0xE3, 0xF8, 0xF9,
  0xE0, 0x7F, 0xF7, 0xFE, 0x3E, 0x0F, 0xFC, 0xFF, 0x87, 0xC0, 0xFF, 0x0F,
  0xE0, 0x7C, 0x03, 0x00, 0x20, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x04, 0x00, 0x1F,
  0xE0, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF9, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0x80, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0x8F, 0xF0, 0x03, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFC, 0x01, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xE0, 0x1F, 0xE3, 0xF0, 0x07, 0xF9, 0xF8, 0x01, 0xFE, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0xCF,
  0xC0, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0xF8,
  0x7F, 0x80, 0x0C, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xBF,
  0x00, 0x07, 0xDF, 0xC0, 0x03, 0xEF, 0xE0, 0x01, 0xF3, 0xF8, 0x00, 0xF9,
  0xFF, 0x00, 0x7C, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x81, 0xFB, 0x7F, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF7, 0xC0, 0x03, 0xFF, 0xFB, 0xE0,
  0x03, 0xEF, 0xFD, 0xF0, 0x01, 0xF7, 0xFE, 0x7C, 0x00, 0xFB, 0xFF, 0x3E,
  0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x7C, 0xFF, 0xCF, 0xC0, 0x3E, 0x7F, 0xE3,
  0xE0, 0x3E, 0x3F, 0xF1, 0xF0, 0x1F, 0x1F, 0xFC, 0xFC, 0x0F, 0x8F, 0xFE,
  0x3E, 0x0F, 0x87, 0xFF, 0x1F, 0x07, 0xC3, 0xFF, 0x8F, 0x83, 0xE1, 0xFF,
  0xC3, 0xE3, 0xE0, 0xFF, 0xE1, 0xF1, 0xF0, 0x7F, 0xF0, 0xF8, 0xF8, 0x3F,
  0xF8, 0x3E, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x0F, 0xFE, 0x0F, 0xBE, 0x07,
  0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xC0, 0x3F, 0xF8, 0x0F, 0xE0,
  0x1F, 0xFC, 0x07, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFB, 0xF0, 0x07, 0xFF, 0x7F, 0x00, 0xFF, 0xE7, 0xE0, 0x1F, 0xFC,
  0xFE, 0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0xF1, 0xFC, 0x0F, 0xFE, 0x1F, 0x81,
  0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xFF, 0x83, 0xF0, 0xFF, 0xF0,
  0x7E, 0x1F, 0xFE, 0x07, 0xE3, 0xFF, 0xC0, 0xFE, 0x7F, 0xF8, 0x0F, 0xCF,
  0xFF, 0x01, 0xFD, 0xFF, 0xE0, 0x1F, 0xBF, 0xFC, 0x03, 0xFB, 0xFF, 0x80,
  0x3F, 0x7F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xDF, 0x81, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF8,
  0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x07, 0xF0, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFC, 0xFE, 0x7F, 0x00, 0xC7, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF8, 0x0F,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFE, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xE0, 0x07, 0xE3,
  0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x3F, 0x00,
  0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0x7C,
  0x03, 0xE0, 0x7E, 0x07, 0xCF, 0x81, 0xF8, 0x1F, 0x81, 0xF3, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0x3E,
  0x0F, 0x8F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x03, 0xF0, 0xF8,
  0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xC0, 0xF9, 0xF8, 0x01, 0xF9, 0xF0, 0x3E, 0x7E, 0x00,
  0x7E, 0x7C, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x01,
  0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xC7, 0xC0, 0x07, 0xC3,
  0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xE0, 0x7F, 0x08, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFD, 0xF3, 0xFF, 0x8F, 0x1F, 0xF0, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x10, 0x0F, 0xC7, 0xF8, 0x3F, 0x3F, 0xF8, 0xFD, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFC, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xBF,
  0xF1, 0xFE, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x1F,
  0xE0, 0x00, 0x10, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xCF, 0x0F, 0xE0, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x8F, 0xFB, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0x03, 0xF0, 0x7F, 0xCF,
  0xC3, 0xFF, 0xBF, 0x1F, 0xFF, 0x7C, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0xDF,
  0xC0, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xF3, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFD, 0xF0, 0xFF, 0xE7, 0xC1, 0xFF, 0x1F, 0x00, 0x10, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x08, 0xFF, 0x03, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0x08, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xF1, 0xF0, 0xFF, 0xE7, 0xC7,
  0xFF, 0xDF, 0x3F, 0xFF, 0xFC, 0xFF, 0x1F, 0xF7, 0xF0, 0x1F, 0xDF, 0x80,
  0x7F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01,
  0xFD, 0xFC, 0x07, 0xF3, 0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFB, 0xF0, 0x7F, 0x8F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x20, 0x03, 0xF8, 0xF8, 0x3F,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x10, 0x0F, 0xC7, 0xFC, 0x3F, 0x3F, 0xF8,
  0xFD, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xBF, 0xC0, 0x7E, 0xFF,
  0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x80,
  0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xE0, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x8F, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF,
  0x01, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0xBE, 0x01, 0xFC, 0xF8,
  0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0xE0, 0xF8, 0x7F,
  0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x7E, 0x00, 0xFB, 0xF0, 0x03,
  0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xF9,
  0xF8, 0x0F, 0xC7, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7F,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xCF,
  0x80, 0x3F, 0xBE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x10,
  0x0F, 0x87, 0xF8, 0x1F, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF, 0x8F, 0xDF, 0xFF,
  0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0xF9, 0xFE, 0xFF,
  0x03, 0xFE, 0x07, 0xEF, 0xE0, 0x1F, 0xC0, 0x7E, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x04,
  0x03, 0xE1, 0xFF, 0x0F, 0x8F, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xFB,
  0xFF, 0x3F, 0xEF, 0xF0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x04, 0x03, 0xE1, 0xFE,
  0x0F, 0xCF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xEF,
  0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xEF, 0xFE, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFD, 0xFF, 0xE3, 0xF3, 0xFF, 0x8F, 0xC7, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF1,
  0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xFF, 0xFC, 0xFF, 0x1F, 0xF7,
  0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xFC, 0x07, 0xF3, 0xFC, 0x7F, 0xCF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFB, 0xF0, 0x7F, 0x8F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0D, 0xF0, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x40,
  0x03, 0xFF, 0x83, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0x81, 0xCF,
  0xC0, 0x13, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xB0, 0x07, 0xEF,
  0x83, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xE3, 0x0F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFE, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0xEF,
  0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xDF, 0x1F, 0xFC, 0x78, 0x7F, 0xC3, 0xC0,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xC0, 0x3F, 0x7E, 0x01, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xC0, 0x3E,
  0x3E, 0x03, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xE0, 0x7E, 0x3F, 0x03, 0xDE,
  0x07, 0xE3, 0xF0, 0x7D, 0xE0, 0x7C, 0x1F, 0x07, 0xDF, 0x0F, 0xC1, 0xF8,
  0x79, 0xF0, 0xFC, 0x1F, 0x87, 0x8F, 0x0F, 0x81, 0xF8, 0xF8, 0xF0, 0xF8,
  0x0F, 0x8F, 0x8F, 0x9F, 0x80, 0xF8, 0xF0, 0xF9, 0xF8, 0x0F, 0xCF, 0x0F,
  0x9F, 0x00, 0xFD, 0xF0, 0x79, 0xF0, 0x07, 0xDF, 0x07, 0x9F, 0x00, 0x7D,
  0xF0, 0x7F, 0xF0, 0x07, 0xDE, 0x07, 0xFE, 0x00, 0x7D, 0xE0, 0x3F, 0xE0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xE7, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC,
  0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0,
  0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x47, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x80,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x83,
  0xFF, 0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07,
  0xE0, 0x3F, 0xC1, 0xFF, 0x83, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFC, 0x01, 0x80, 0x00, 0x04, 0x00, 0x09, 0xFE, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0xD0, 0x00,
  0x78,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 35, 13, 3, -34 },
  { 32, 15, 12, 21, 3, -34 },
  { 55, 26, 34, 28, 1, -34 },
  { 166, 21, 39, 25, 2, -36 },
  { 269, 36, 35, 39, 2, -35 },
  { 427, 30, 35, 32, 2, -35 },
  { 559, 6, 12, 12, 3, -34 },
  { 568, 12, 42, 15, 2, -34 },
  { 631, 12, 42, 15, 1, -34 },
  { 694, 22, 21, 24, 1, -37 },
  { 752, 21, 24, 25, 2, -29 },
  { 815, 8, 12, 13, 2, -6 },
  { 827, 12, 5, 15, 1, -15 },
  { 835, 7, 8, 13, 3, -7 },
  { 842, 19, 34, 19, 0, -34 },
  { 923, 21, 35, 25, 2, -35 },
  { 1015, 15, 34, 25, 3, -34 },
  { 1079, 21, 35, 25, 2, -35 },
  { 1171, 21, 35, 25, 2, -35 },
  { 1263, 23, 34, 25, 1, -34 },
  { 1361, 21, 34, 25, 2, -34 },
  { 1451, 22, 35, 25, 2, -35 },
  { 1548, 23, 34, 25, 1, -34 },
  { 1646, 22, 35, 25, 2, -35 },
  { 1743, 21, 35, 25, 2, -35 },
  { 1835, 7, 28, 13, 3, -27 },
  { 1860, 8, 33, 13, 2, -27 },
  { 1893, 21, 24, 25, 2, -29 },
  { 1956, 21, 14, 25, 2, -24 },
  { 1993, 21, 24, 25, 2, -29 },
  { 2056, 19, 36, 20, 0, -35 },
  { 2142, 35, 39, 40, 2, -35 },
  { 2313, 29, 34, 29, 0, -34 },
  { 2437, 23, 34, 29, 4, -34 },
  { 2535, 23, 35, 28, 3, -35 },
  { 2636, 25, 34, 32, 4, -34 },
  { 2743, 18, 34, 24, 4, -34 },
  { 2820, 18, 34, 24, 4, -34 },
  { 2897, 25, 35, 32, 3, -35 },
  { 3007, 25, 34, 33, 4, -34 },
  { 3114, 13, 34, 17, 2, -34 },
  { 3170, 13, 44, 14, -3, -34 },
  { 3242, 24, 34, 28, 4, -34 },
  { 3344, 18, 34, 24, 4, -34 },
  { 3421, 33, 34, 41, 4, -34 },
  { 3562, 27, 34, 35, 4, -34 },
  { 3677, 29, 35, 34, 3, -35 },
  { 3804, 21, 34, 27, 4, -34 },
  { 3894, 29, 43, 34, 3, -35 },
  { 4050, 24, 34, 28, 4, -34 },
  { 4152, 20, 35, 24, 2, -35 },
  { 4240, 23, 34, 25, 1, -34 },
  { 4338, 25, 34, 32, 4, -34 },
  { 4445, 28, 34, 28, 0, -34 },
  { 4564, 42, 34, 42, 0, -34 },
  { 4743, 27, 34, 27, 0, -34 },
  { 4858, 26, 34, 26, 0, -34 },
  { 4969, 22, 34, 24, 1, -34 },
  { 5063, 11, 42, 16, 3, -34 },
  { 5121, 19, 34, 19, 0, -34 },
  { 5202, 11, 42, 16, 1, -34 },
  { 5260, 24, 21, 26, 1, -34 },
  { 5323, 20, 3, 20, 0, 4 },
  { 5331, 11, 8, 15, 2, -37 },
  { 5342, 20, 27, 26, 2, -27 },
  { 5410, 22, 36, 28, 3, -36 },
  { 5509, 19, 27, 22, 2, -27 },
  { 5574, 22, 36, 28, 2, -36 },
  { 5673, 21, 27, 26, 2, -27 },
  { 5744, 17, 37, 16, 1, -37 },
  { 5823, 22, 39, 28, 2, -27 },
  { 5931, 22, 36, 28, 3, -36 },
  { 6030, 7, 36, 13, 3, -36 },
  { 6062, 12, 48, 13, -2, -36 },
  { 6134, 22, 36, 26, 4, -36 },
  { 6233, 6, 36, 13, 3, -36 },
  { 6260, 36, 27, 42, 3, -27 },
  { 6382, 22, 27, 28, 3, -27 },
  { 6457, 23, 27, 27, 2, -27 },
  { 6535, 22, 39, 28, 3, -27 },
  { 6643, 22, 39, 28, 2, -27 },
  { 6751, 15, 27, 19, 3, -27 },
  { 6802, 18, 27, 21, 2, -27 },
  { 6863, 16, 32, 18, 1, -32 },
  { 6927, 21, 26, 28, 3, -26 },
  { 6996, 24, 26, 24, 0, -26 },
  { 7074, 36, 26, 37, 0, -26 },
  { 7191, 24, 26, 24, 0, -26 },
  { 7269, 24, 38, 24, 0, -26 },
  { 7383, 18, 26, 21, 1, -26 },
  { 7442, 15, 42, 18, 1, -34 },
  { 7521, 4, 47, 24, 10, -36 },
  { 7545, 15, 42, 18, 2, -34 },
  { 7624, 21, 8, 25, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD48PT7B_H_
