#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xBB, 0xAA, 0x14, 0x48, 0x93, 0xF2, 0x85, 0x3F, 0x24,
  0x58, 0x27, 0xE9, 0x4E, 0x1C, 0xFE, 0x21, 0x00, 0x63, 0x29, 0x35, 0x9A,
  0x85, 0xFB, 0x54, 0x6A, 0x25, 0x33, 0x80, 0x30, 0x68, 0x68, 0x78, 0x31,
  0x5A, 0xCE, 0x4E, 0x7B, 0xF0, 0x5A, 0xAA, 0xB4, 0xC9, 0x92, 0x49, 0x2B,
  0x00, 0x32, 0x5F, 0xCC, 0x48, 0x10, 0x4F, 0xC4, 0x10, 0x40, 0x5C, 0xE0,
  0xC0, 0x18, 0x84, 0x62, 0x31, 0x08, 0xC0, 0x31, 0xE4, 0xD3, 0xCF, 0x34,
  0xD2, 0x38, 0x2F, 0x92, 0x49, 0x20, 0x33, 0xE0, 0xC2, 0x18, 0x42, 0x10,
  0xFC, 0x33, 0xE0, 0xC2, 0x30, 0x30, 0xE3, 0xF8, 0x08, 0x63, 0x8A, 0x49,
  0x2F, 0xC2, 0x08, 0xF7, 0xA1, 0x0F, 0x0C, 0x73, 0xF0, 0x19, 0xE4, 0x14,
  0x7B, 0x34, 0xD3, 0x38, 0xFF, 0xF0, 0x82, 0x18, 0x43, 0x08, 0x60, 0x31,
  0xA4, 0xDA, 0x31, 0xAC, 0xD3, 0x78, 0x31, 0xE4, 0xF3, 0x4D, 0xF0, 0xC6,
  0x70, 0xC6, 0x50, 0x05, 0x80, 0x0C, 0xEE, 0x1C, 0x1C, 0x10, 0xFC, 0x0F,
  0xFF, 0xC0, 0xC0, 0xC6, 0xE2, 0x00, 0x77, 0xC6, 0x33, 0x10, 0x04, 0x60,
  0x18, 0x66, 0xC1, 0xBD, 0xA5, 0xA5, 0xAD, 0x92, 0xC0, 0x3C, 0x18, 0x70,
  0xA1, 0x66, 0xCF, 0x9F, 0x63, 0xC2, 0xE3, 0xE8, 0xA2, 0xF2, 0x28, 0xE3,
  0xF8, 0x3D, 0xEC, 0x20, 0x82, 0x08, 0x31, 0x78, 0xE3, 0xE8, 0xE1, 0x86,
  0x18, 0xE7, 0xF0, 0xFF, 0xCC, 0xFC, 0xCC, 0xF0, 0xFF, 0x88, 0xFF, 0x88,
  0x80, 0x39, 0xFC, 0x20, 0x9E, 0x78, 0x71, 0x7C, 0xC7, 0x1C, 0x71, 0xFF,
  0x1C, 0x71, 0xC4, 0xF6, 0x66, 0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0x27,
  0x80, 0xCF, 0x2D, 0xBC, 0xE3, 0xCD, 0xB2, 0xCC, 0x84, 0x21, 0x08, 0x42,
  0x10, 0xF8, 0xC3, 0xC3, 0xE3, 0xA7, 0xA5, 0xB5, 0x9D, 0x99, 0x99, 0xC7,
  0x8F, 0x9D, 0x3B, 0x73, 0xE3, 0xC7, 0x86, 0x38, 0xFB, 0x1C, 0x38, 0x70,
  0xE1, 0xE6, 0x78, 0xE7, 0xE3, 0x19, 0xFA, 0x10, 0x80, 0x38, 0xFB, 0x1C,
  0x38, 0x70, 0xE1, 0xE6, 0x78, 0x10, 0x38, 0xE3, 0xE8, 0xA2, 0xFB, 0xC9,
  0xA2, 0x8C, 0x77, 0xA1, 0x0E, 0x18, 0x72, 0xF0, 0xFF, 0xF3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x86, 0x18, 0x73, 0x78, 0xC7, 0x8D,
  0x12, 0x26, 0xC5, 0x0A, 0x1C, 0x30, 0x84, 0x73, 0x14, 0xC5, 0x3B, 0x4A,
  0xDE, 0xA7, 0x28, 0xCE, 0x31, 0x80, 0xC6, 0x99, 0xA1, 0xC3, 0x07, 0x1A,
  0x26, 0xC6, 0xC6, 0x99, 0xB3, 0x43, 0x86, 0x04, 0x08, 0x10, 0xFF, 0xF0,
  0x86, 0x30, 0x86, 0x10, 0xFC, 0xFE, 0x49, 0x24, 0x93, 0x80, 0x82, 0x10,
  0xC2, 0x10, 0xC2, 0x18, 0xFC, 0x92, 0x49, 0x27, 0x80, 0x10, 0xC3, 0x9A,
  0x4F, 0x10, 0xF8, 0xE4, 0x31, 0xE0, 0xDF, 0x4F, 0x37, 0xC0, 0x84, 0x2D,
  0xF8, 0xC6, 0x3B, 0xB8, 0x7F, 0x88, 0x8D, 0xF0, 0x08, 0x5B, 0xF9, 0xC6,
  0x33, 0xE8, 0x67, 0xA7, 0xF8, 0x45, 0xE0, 0x7B, 0x1D, 0xE6, 0x31, 0x8C,
  0x60, 0x6F, 0xE7, 0x18, 0xCF, 0xA1, 0x9F, 0x80, 0x84, 0x2D, 0xF8, 0xC6,
  0x31, 0x88, 0xFF, 0x80, 0x24, 0x92, 0x49, 0x24, 0xF0, 0x84, 0x23, 0x2B,
  0x73, 0xD2, 0x98, 0xFF, 0x80, 0xB3, 0x7F, 0xA6, 0x71, 0x38, 0x9C, 0x4E,
  0x26, 0xB7, 0xE3, 0x18, 0xC6, 0x20, 0x67, 0xE3, 0x18, 0xCD, 0xC0, 0xB7,
  0xE3, 0x18, 0xEE, 0xF0, 0x84, 0x00, 0x6F, 0xE7, 0x18, 0xCF, 0xA1, 0x08,
  0x40, 0xBF, 0xC8, 0x88, 0x80, 0x33, 0xF0, 0xE1, 0xCF, 0xC0, 0x47, 0xF4,
  0x44, 0x67, 0x8C, 0x63, 0x18, 0xEF, 0xA0, 0xCF, 0x34, 0x92, 0x78, 0xC3,
  0x00, 0xC8, 0xE6, 0xD5, 0x6A, 0xA5, 0x53, 0xA8, 0xC8, 0xCD, 0x27, 0x8C,
  0x31, 0xEC, 0xC0, 0xCF, 0x34, 0x92, 0x78, 0xC3, 0x0C, 0x23, 0x00, 0xFF,
  0xC4, 0x46, 0x23, 0xE0, 0x13, 0x22, 0x2C, 0x62, 0x22, 0x30, 0xFF, 0xFF,
  0xFF, 0x8E, 0x22, 0x23, 0x22, 0x26, 0xC0, 0xF6, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 4, 4, 5, 1, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 10, 6, 1, -9 },
  { 20, 9, 9, 10, 0, -9 },
  { 31, 8, 9, 8, 0, -9 },
  { 40, 1, 4, 3, 1, -9 },
  { 41, 2, 11, 4, 1, -9 },
  { 44, 3, 11, 4, 0, -9 },
  { 49, 6, 5, 6, 0, -9 },
  { 53, 6, 6, 6, 0, -7 },
  { 58, 2, 3, 3, 0, -1 },
  { 59, 3, 1, 4, 0, -4 },
  { 60, 1, 2, 3, 1, -2 },
  { 61, 5, 9, 5, 0, -9 },
  { 67, 6, 9, 6, 0, -9 },
  { 74, 3, 9, 6, 1, -9 },
  { 78, 6, 9, 6, 0, -9 },
  { 85, 6, 9, 6, 0, -9 },
  { 92, 6, 9, 6, 0, -9 },
  { 99, 5, 9, 6, 1, -9 },
  { 105, 6, 9, 6, 0, -9 },
  { 112, 6, 9, 6, 0, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 6, 9, 6, 0, -9 },
  { 133, 1, 7, 3, 1, -7 },
  { 134, 2, 9, 3, 0, -7 },
  { 137, 6, 6, 6, 0, -7 },
  { 142, 6, 4, 6, 0, -6 },
  { 145, 6, 6, 6, 0, -7 },
  { 150, 5, 9, 5, 0, -9 },
  { 156, 8, 10, 10, 1, -9 },
  { 166, 7, 9, 7, 0, -9 },
  { 174, 6, 9, 7, 1, -9 },
  { 181, 6, 9, 7, 1, -9 },
  { 188, 6, 9, 8, 1, -9 },
  { 195, 4, 9, 6, 1, -9 },
  { 200, 4, 9, 6, 1, -9 },
  { 205, 6, 9, 8, 1, -9 },
  { 212, 6, 9, 8, 1, -9 },
  { 219, 4, 9, 4, 0, -9 },
  { 224, 3, 11, 3, -1, -9 },
  { 229, 6, 9, 7, 1, -9 },
  { 236, 5, 9, 6, 1, -9 },
  { 242, 8, 9, 10, 1, -9 },
  { 251, 7, 9, 9, 1, -9 },
  { 259, 7, 9, 9, 1, -9 },
  { 267, 5, 9, 7, 1, -9 },
  { 273, 7, 11, 9, 1, -9 },
  { 283, 6, 9, 7, 1, -9 },
  { 290, 5, 9, 6, 1, -9 },
  { 296, 6, 9, 6, 0, -9 },
  { 303, 6, 9, 8, 1, -9 },
  { 310, 7, 9, 7, 0, -9 },
  { 318, 10, 9, 10, 0, -9 },
  { 330, 7, 9, 7, 0, -9 },
  { 338, 7, 9, 7, 0, -9 },
  { 346, 6, 9, 6, 0, -9 },
  { 353, 3, 11, 4, 1, -9 },
  { 358, 5, 9, 5, 0, -9 },
  { 364, 3, 11, 4, 0, -9 },
  { 369, 6, 6, 7, 0, -9 },
  { 374, 5, 1, 5, 0, 1 },
  { 375, 3, 2, 4, 0, -9 },
  { 376, 6, 7, 6, 0, -7 },
  { 382, 5, 9, 7, 1, -9 },
  { 388, 4, 7, 5, 1, -7 },
  { 392, 5, 9, 7, 1, -9 },
  { 398, 5, 7, 6, 1, -7 },
  { 403, 5, 9, 4, 0, -9 },
  { 409, 5, 10, 7, 1, -7 },
  { 416, 5, 9, 7, 1, -9 },
  { 422, 1, 9, 3, 1, -9 },
  { 424, 3, 12, 3, -1, -9 },
  { 429, 5, 9, 6, 1, -9 },
  { 435, 1, 9, 3, 1, -9 },
  { 437, 9, 7, 10, 1, -7 },
  { 445, 5, 7, 7, 1, -7 },
  { 450, 5, 7, 7, 1, -7 },
  { 455, 5, 10, 7, 1, -7 },
  { 462, 5, 10, 7, 1, -7 },
  { 469, 4, 7, 5, 1, -7 },
  { 473, 5, 7, 5, 0, -7 },
  { 478, 4, 8, 4, 0, -8 },
  { 482, 5, 7, 7, 1, -7 },
  { 487, 6, 7, 6, 0, -7 },
  { 493, 9, 7, 9, 0, -7 },
  { 501, 6, 7, 6, 0, -7 },
  { 507, 6, 10, 6, 0, -7 },
  { 515, 5, 7, 5, 0, -7 },
  { 520, 4, 11, 5, 0, -9 },
  { 526, 2, 12, 6, 2, -9 },
  { 529, 4, 11, 5, 0, -9 },
  { 535, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD12PT7B_H_
