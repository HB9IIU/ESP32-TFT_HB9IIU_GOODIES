#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xDB, 0x6C, 0x07, 0xF8, 0xEF, 0xCF, 0x9F, 0x36, 0x60,
  0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x19, 0x81, 0x98,
  0x19, 0x8F, 0xFE, 0xFF, 0xE1, 0x10, 0x33, 0x03, 0x30, 0x33, 0x00, 0x08,
  0x04, 0x0F, 0xFF, 0xFE, 0x8E, 0x43, 0xA0, 0xF0, 0x3F, 0x07, 0xC2, 0xE1,
  0x38, 0xBF, 0xF9, 0xF8, 0x10, 0x08, 0x00, 0x78, 0x30, 0xFC, 0x30, 0xCC,
  0x60, 0xCC, 0x60, 0xCC, 0xC0, 0xCC, 0xC0, 0xCD, 0xBC, 0xFD, 0xBE, 0x7B,
  0x66, 0x03, 0x66, 0x06, 0x67, 0x06, 0x66, 0x0C, 0x66, 0x0C, 0x3E, 0x18,
  0x3C, 0x3E, 0x03, 0xF8, 0x1C, 0xC0, 0xC6, 0x07, 0x30, 0x1B, 0x80, 0xF8,
  0x0F, 0x86, 0xFE, 0x77, 0x3B, 0xB0, 0xF9, 0xC3, 0xCE, 0x1E, 0x3F, 0xF8,
  0xF9, 0xE0, 0xFF, 0xF6, 0x19, 0x9C, 0xC6, 0x73, 0x18, 0xC6, 0x31, 0x8E,
  0x71, 0x8E, 0x31, 0xC0, 0xC3, 0x18, 0xE3, 0x18, 0xE7, 0x39, 0xCE, 0x73,
  0x18, 0xCC, 0x66, 0x00, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xE0, 0xF8,
  0xEE, 0x26, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18,
  0x0C, 0x06, 0x00, 0x7F, 0x6C, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x07, 0x06,
  0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xE0,
  0x3E, 0x3F, 0x98, 0xDC, 0x7E, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8,
  0xFC, 0x76, 0x33, 0xF8, 0xF8, 0x0E, 0x3C, 0xFF, 0xF6, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x7E, 0x7F, 0xB0, 0xE0, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0xFF, 0xFE,
  0x7E, 0x7F, 0x90, 0xE0, 0x70, 0x38, 0x18, 0xF8, 0x7C, 0x07, 0x01, 0xC0,
  0xE0, 0x78, 0x3F, 0xFB, 0xF8, 0x03, 0x80, 0x70, 0x1E, 0x06, 0xC0, 0xF8,
  0x37, 0x0E, 0xE1, 0x9C, 0x63, 0x8C, 0x73, 0xFF, 0xFF, 0xF0, 0x38, 0x07,
  0x00, 0xE0, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x07, 0x03, 0xFC, 0xFE, 0x03,
  0x81, 0xC0, 0xE0, 0x78, 0x3F, 0xFB, 0xF8, 0x1F, 0x1F, 0x9C, 0x0C, 0x0E,
  0x06, 0x73, 0x7D, 0xEF, 0xE3, 0xE0, 0xF0, 0x7C, 0x36, 0x3B, 0xF8, 0xF8,
  0xFF, 0xFF, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07,
  0x03, 0x03, 0x81, 0xC1, 0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x3B, 0xB8,
  0xF8, 0x7C, 0x77, 0x71, 0xF0, 0x78, 0x3E, 0x3F, 0xFC, 0xF8, 0x3E, 0x3F,
  0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x8F, 0xEF, 0x7D, 0x9C, 0xC0, 0xE0, 0x60,
  0x73, 0xF1, 0xF0, 0x5F, 0xA0, 0x00, 0x0F, 0xF0, 0x5F, 0xA0, 0x00, 0x01,
  0xFD, 0xB0, 0x00, 0x80, 0xC1, 0xE3, 0xC7, 0x87, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x60,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x3E, 0x7C, 0xF0, 0x60, 0x20, 0x00, 0x7E,
  0xFF, 0x43, 0x03, 0x03, 0x07, 0x0E, 0x1C, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x38, 0x38, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x73, 0x80, 0x66, 0x3E, 0x68,
  0xEC, 0xF3, 0x19, 0xE6, 0x33, 0xCC, 0x67, 0x98, 0xCF, 0x33, 0x9E, 0x3D,
  0xE6, 0x31, 0x8C, 0x00, 0x0E, 0x04, 0x0F, 0xF8, 0x07, 0xC0, 0x07, 0x00,
  0x78, 0x03, 0xE0, 0x1B, 0x01, 0xD8, 0x0E, 0xE0, 0x63, 0x07, 0x18, 0x38,
  0xE1, 0xFF, 0x1F, 0xF8, 0xE0, 0xE7, 0x07, 0x70, 0x1B, 0x80, 0xE0, 0xFE,
  0x3F, 0xEC, 0x3B, 0x06, 0xC1, 0xB0, 0xEF, 0xF3, 0xFC, 0xC3, 0xB0, 0x7C,
  0x1F, 0x07, 0xC3, 0xBF, 0xEF, 0xE0, 0x0F, 0xE7, 0xF9, 0xE1, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x84,
  0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xF3, 0x0F, 0x60, 0xEC, 0x0D, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x60, 0xEC, 0x79, 0xFE, 0x3F, 0x80,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0xE7, 0xFC, 0xE0, 0xB8, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x1F, 0xE3, 0xFC, 0x0D, 0x81, 0xB8, 0x37, 0x86,
  0x7F, 0xC7, 0xF8, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x38,
  0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xEF, 0xC0,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x3F, 0xFC,
  0xC1, 0xF0, 0xEC, 0x33, 0x1C, 0xCE, 0x37, 0x0D, 0xC3, 0xF0, 0xFE, 0x33,
  0x8C, 0x73, 0x1C, 0xC3, 0xB0, 0x7C, 0x1C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xD8, 0x6F, 0x61, 0xBD, 0x86, 0xF7, 0x33,
  0xCC, 0xCF, 0x33, 0x3C, 0xFC, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x30,
  0xC0, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3D, 0x87, 0xB8, 0xF3, 0x1E, 0x73,
  0xC7, 0x78, 0xEF, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x38, 0x1F, 0xC1,
  0xFF, 0x1E, 0x3C, 0xE0, 0xEE, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0C, 0xE0, 0xE7, 0x8F, 0x1F, 0xF0, 0x7F, 0x00, 0xFE,
  0x7F, 0xB1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFE, 0xFE, 0x78, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xEE, 0x03,
  0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0C, 0xE0, 0xE7,
  0x8F, 0x1F, 0xF0, 0x7F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0xFE,
  0x3F, 0xCC, 0x7B, 0x0E, 0xC3, 0xB0, 0xEC, 0x7B, 0xFC, 0xFE, 0x33, 0x8C,
  0x73, 0x1C, 0xC3, 0xB0, 0xEC, 0x1C, 0x3F, 0xBF, 0xB8, 0x5C, 0x0E, 0x07,
  0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x77, 0xFB, 0xF8, 0xFF,
  0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x70, 0x6E, 0x1C,
  0xFF, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x60, 0x67, 0x0E, 0x70, 0xE3, 0x0C,
  0x38, 0xC3, 0x9C, 0x19, 0x81, 0x98, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0xC0, 0xF8, 0x38, 0x76, 0x1E, 0x1D, 0x87, 0x86, 0x71,
  0xE1, 0x9C, 0x6C, 0xE3, 0x3B, 0x38, 0xCC, 0xCE, 0x33, 0x33, 0x0E, 0xCE,
  0xC3, 0xF1, 0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xE0,
  0xE0, 0xF7, 0x0E, 0x39, 0xC3, 0x9C, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF8, 0x19, 0x83, 0x9C, 0x70, 0xC7, 0x0E, 0xE0, 0x70, 0xE0,
  0xEC, 0x1D, 0xC3, 0x18, 0xE3, 0x98, 0x37, 0x07, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xFF, 0xC0, 0xE0,
  0xE0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x07, 0xFF,
  0xFE, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF,
  0xC0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0C,
  0x0E, 0x06, 0x07, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xFF, 0x08, 0x07, 0x01, 0xC0, 0xD8, 0x36, 0x18, 0xC6, 0x3B, 0x06, 0xC1,
  0xC0, 0xFF, 0x80, 0xE3, 0x8E, 0x1C, 0x3F, 0x99, 0xC0, 0x70, 0x39, 0xFD,
  0xFF, 0xC7, 0xC3, 0xF1, 0xFF, 0xEF, 0x30, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE6, 0x3F, 0xEF, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC,
  0x7F, 0xFB, 0xBC, 0x0C, 0x3F, 0x7F, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF1, 0x7F, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x19, 0xDF, 0xF7, 0xFF,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xF7, 0xFC, 0xF7, 0x0C,
  0x1F, 0x9C, 0xFC, 0x3E, 0x1F, 0xFF, 0xFF, 0xC0, 0xE0, 0x30, 0x5F, 0xE7,
  0xF0, 0x1F, 0x3F, 0x38, 0x30, 0x30, 0xFE, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x1F, 0xF7, 0xFF, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xF7, 0xFC, 0xF7, 0x01, 0xC0, 0x64, 0x39,
  0xFE, 0x7E, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE6, 0x3F, 0xEF, 0xFB,
  0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x7D,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x19, 0xC6, 0x00, 0x1C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x3B, 0x19, 0x9C, 0xDC, 0x7C, 0x3F, 0x1D, 0x8C, 0xE6, 0x3B, 0x1D,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x18, 0xFF, 0xBE, 0xFF,
  0xFF, 0xF1, 0xC7, 0xE1, 0xC7, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0x06, 0x3F, 0xEF, 0xFB, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x0C, 0x0F,
  0xC7, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xD8, 0xE7, 0xF8,
  0xFC, 0x06, 0x3F, 0xEF, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFC, 0x7F, 0xFB, 0xBC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x18,
  0x1F, 0xF7, 0x7F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xF7,
  0xFC, 0xF7, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x07, 0xDF, 0xFF,
  0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x18, 0x7E, 0xE6, 0xC0,
  0xE0, 0x78, 0x3E, 0x0E, 0x07, 0x86, 0xFE, 0xFC, 0x10, 0x60, 0xC7, 0xFF,
  0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xE3, 0xC0, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x63, 0xDF, 0xF3, 0xCC, 0xE0,
  0xD8, 0x77, 0x19, 0xC6, 0x33, 0x8C, 0xC3, 0xB0, 0x7C, 0x1E, 0x07, 0x80,
  0xE0, 0xE3, 0xC7, 0x63, 0xC6, 0x63, 0xC6, 0x73, 0xCE, 0x76, 0x6E, 0x36,
  0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x3E, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0xF1,
  0xDC, 0xE3, 0xB0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xEC, 0x33, 0x9C, 0x6E,
  0x1C, 0xE0, 0xD8, 0x77, 0x19, 0xC6, 0x33, 0x8E, 0xC3, 0xB0, 0x7C, 0x1E,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x07, 0x81, 0xC0, 0xFF, 0xFC, 0x38,
  0xE1, 0x87, 0x1C, 0x30, 0xE1, 0xFF, 0xF8, 0x0E, 0x3C, 0x70, 0xC1, 0x83,
  0x06, 0x1C, 0xF1, 0xE0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1E, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x3C,
  0x73, 0x8C, 0x30, 0xC3, 0x0C, 0xF3, 0x80, 0x78, 0xFF, 0xE3, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 15, 6, 1, -15 },
  { 7, 7, 5, 9, 1, -15 },
  { 12, 12, 15, 12, 0, -15 },
  { 35, 9, 17, 11, 1, -16 },
  { 55, 16, 15, 17, 1, -15 },
  { 85, 13, 15, 14, 1, -15 },
  { 110, 3, 5, 5, 1, -15 },
  { 112, 5, 18, 7, 1, -15 },
  { 124, 5, 18, 7, 1, -15 },
  { 136, 9, 9, 11, 1, -16 },
  { 147, 9, 10, 11, 1, -12 },
  { 159, 3, 5, 6, 1, -2 },
  { 161, 5, 2, 7, 1, -7 },
  { 163, 3, 3, 6, 1, -3 },
  { 165, 8, 15, 8, 0, -15 },
  { 180, 9, 15, 11, 1, -15 },
  { 197, 7, 15, 11, 1, -15 },
  { 211, 9, 15, 11, 1, -15 },
  { 228, 9, 15, 11, 1, -15 },
  { 245, 11, 15, 11, 0, -15 },
  { 266, 9, 15, 11, 1, -15 },
  { 283, 9, 15, 11, 1, -15 },
  { 300, 9, 15, 11, 1, -15 },
  { 317, 9, 15, 11, 1, -15 },
  { 334, 9, 15, 11, 1, -15 },
  { 351, 3, 12, 6, 1, -12 },
  { 356, 3, 15, 6, 1, -12 },
  { 362, 9, 11, 11, 1, -13 },
  { 375, 9, 6, 11, 1, -10 },
  { 382, 9, 11, 11, 1, -13 },
  { 395, 8, 15, 9, 0, -15 },
  { 410, 15, 17, 17, 1, -15 },
  { 442, 13, 15, 13, 0, -15 },
  { 467, 10, 15, 13, 2, -15 },
  { 486, 11, 15, 12, 1, -15 },
  { 507, 11, 15, 14, 2, -15 },
  { 528, 8, 15, 11, 2, -15 },
  { 543, 8, 15, 10, 2, -15 },
  { 558, 11, 15, 14, 1, -15 },
  { 579, 11, 15, 14, 2, -15 },
  { 600, 6, 15, 7, 1, -15 },
  { 612, 5, 19, 6, -1, -15 },
  { 624, 10, 15, 12, 2, -15 },
  { 643, 8, 15, 10, 2, -15 },
  { 658, 14, 15, 18, 2, -15 },
  { 685, 11, 15, 15, 2, -15 },
  { 706, 13, 15, 15, 1, -15 },
  { 731, 9, 15, 12, 2, -15 },
  { 748, 13, 19, 15, 1, -15 },
  { 779, 10, 15, 12, 2, -15 },
  { 798, 9, 15, 11, 1, -15 },
  { 815, 10, 15, 11, 0, -15 },
  { 834, 11, 15, 14, 2, -15 },
  { 855, 12, 15, 12, 0, -15 },
  { 878, 18, 15, 18, 0, -15 },
  { 912, 12, 15, 12, 0, -15 },
  { 935, 11, 15, 11, 0, -15 },
  { 956, 9, 15, 11, 1, -15 },
  { 973, 5, 18, 7, 1, -15 },
  { 985, 8, 15, 8, 0, -15 },
  { 1000, 4, 18, 7, 1, -15 },
  { 1009, 10, 9, 11, 1, -15 },
  { 1021, 9, 1, 9, 0, 2 },
  { 1023, 5, 3, 7, 1, -16 },
  { 1025, 9, 12, 11, 1, -12 },
  { 1039, 10, 16, 12, 1, -16 },
  { 1059, 8, 12, 10, 1, -12 },
  { 1071, 10, 16, 12, 1, -16 },
  { 1091, 9, 12, 11, 1, -12 },
  { 1105, 8, 16, 7, 0, -16 },
  { 1121, 10, 17, 12, 1, -12 },
  { 1143, 10, 16, 12, 1, -16 },
  { 1163, 3, 16, 6, 1, -16 },
  { 1169, 5, 21, 6, -1, -16 },
  { 1183, 9, 16, 11, 2, -16 },
  { 1201, 3, 16, 6, 1, -16 },
  { 1207, 16, 12, 18, 1, -12 },
  { 1231, 10, 12, 12, 1, -12 },
  { 1246, 10, 12, 12, 1, -12 },
  { 1261, 10, 17, 12, 1, -12 },
  { 1283, 10, 17, 12, 1, -12 },
  { 1305, 7, 12, 8, 1, -12 },
  { 1316, 8, 12, 9, 1, -12 },
  { 1328, 7, 14, 8, 0, -14 },
  { 1341, 10, 11, 12, 1, -11 },
  { 1355, 10, 11, 10, 0, -11 },
  { 1369, 16, 11, 16, 0, -11 },
  { 1391, 10, 11, 11, 0, -11 },
  { 1405, 10, 16, 11, 0, -11 },
  { 1425, 7, 11, 9, 1, -11 },
  { 1435, 7, 18, 8, 0, -15 },
  { 1451, 2, 21, 11, 4, -16 },
  { 1457, 6, 18, 8, 1, -15 },
  { 1471, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD21PT7B_H_
