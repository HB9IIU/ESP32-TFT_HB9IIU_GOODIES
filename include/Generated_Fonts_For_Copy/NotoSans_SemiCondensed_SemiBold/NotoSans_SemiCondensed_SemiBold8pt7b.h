#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xB4, 0x32, 0xBE, 0xAE, 0x30, 0x2D, 0x43, 0xB6, 0x4A,
  0xAB, 0x57, 0x2D, 0xB0, 0x62, 0x98, 0xD9, 0xBC, 0xC0, 0x5A, 0x94, 0x95,
  0x5C, 0x4F, 0x60, 0x22, 0xF2, 0x60, 0xC0, 0xC0, 0x25, 0x25, 0x00, 0x69,
  0x99, 0x96, 0x75, 0x50, 0x69, 0x12, 0x4F, 0xE1, 0x27, 0x1E, 0x22, 0x6A,
  0xF2, 0x64, 0x61, 0x1E, 0x34, 0xAD, 0x96, 0xF1, 0x22, 0x64, 0x69, 0x66,
  0x97, 0x69, 0x97, 0x16, 0xC3, 0xC1, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C,
  0xE4, 0xA0, 0x80, 0x39, 0x1B, 0xEB, 0xBD, 0x03, 0x80, 0x23, 0x14, 0xAF,
  0x44, 0xF6, 0xFB, 0xC0, 0x34, 0xC8, 0x47, 0xCB, 0x99, 0x9E, 0xF2, 0x79,
  0xC0, 0xF2, 0x79, 0x00, 0x3A, 0x31, 0x34, 0xBC, 0x99, 0x9F, 0x99, 0xE9,
  0x25, 0xC0, 0x24, 0x92, 0x4E, 0xBA, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0x8C,
  0xF7, 0xBA, 0xD4, 0x9D, 0xDB, 0xB9, 0x32, 0x73, 0x14, 0xB8, 0xD6, 0xF9,
  0x00, 0x32, 0x73, 0x14, 0xB8, 0x60, 0xCA, 0xAC, 0xAB, 0x78, 0x42, 0x1E,
  0xF2, 0x22, 0x22, 0x99, 0x99, 0x9E, 0x8C, 0x94, 0xA6, 0x10, 0x93, 0x25,
  0xB3, 0x66, 0xCD, 0x80, 0x92, 0x98, 0xC5, 0x4C, 0x95, 0x62, 0x22, 0xF2,
  0x24, 0x4F, 0xFE, 0x91, 0x22, 0x40, 0xD5, 0x5C, 0x26, 0x59, 0xE0, 0xC0,
  0x77, 0x9F, 0x9A, 0xDB, 0xC0, 0x72, 0x30, 0x11, 0x79, 0x97, 0x7F, 0x87,
  0x6B, 0xA4, 0x80, 0x79, 0x97, 0x16, 0x9A, 0xDB, 0x40, 0xBC, 0x45, 0x56,
  0x93, 0xED, 0x40, 0xFC, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0x79, 0x97, 0xF6,
  0xF9, 0x00, 0x79, 0x97, 0x11, 0xEA, 0xE8, 0xF0, 0x5D, 0x26, 0xB6, 0xF0,
  0x96, 0x66, 0xB5, 0xD6, 0x92, 0xF6, 0x69, 0x96, 0x66, 0x4C, 0xE9, 0x70,
  0x29, 0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 6, 6, 7, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 2, 0, -6 },
  { 21, 2, 7, 3, 0, -6 },
  { 23, 2, 7, 3, 0, -6 },
  { 25, 4, 3, 4, 0, -6 },
  { 27, 4, 4, 4, 0, -5 },
  { 29, 2, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -3 },
  { 31, 2, 1, 2, 0, -1 },
  { 32, 3, 6, 3, 0, -6 },
  { 35, 4, 6, 4, 0, -6 },
  { 38, 2, 6, 4, 1, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 4, 4, 0, -5 },
  { 69, 4, 2, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -5 },
  { 72, 3, 6, 3, 0, -6 },
  { 75, 6, 7, 7, 0, -6 },
  { 81, 5, 6, 5, 0, -6 },
  { 85, 3, 6, 5, 1, -6 },
  { 88, 4, 6, 5, 0, -6 },
  { 91, 4, 6, 5, 1, -6 },
  { 94, 3, 6, 4, 1, -6 },
  { 97, 3, 6, 4, 1, -6 },
  { 100, 5, 6, 5, 0, -6 },
  { 104, 4, 6, 6, 1, -6 },
  { 107, 3, 6, 3, 0, -6 },
  { 110, 3, 8, 2, -1, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 3, 6, 4, 1, -6 },
  { 119, 5, 6, 7, 1, -6 },
  { 123, 4, 6, 6, 1, -6 },
  { 126, 5, 6, 6, 0, -6 },
  { 130, 3, 6, 5, 1, -6 },
  { 133, 5, 7, 6, 0, -6 },
  { 138, 4, 6, 5, 1, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 7, 6, 7, 0, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 4, 6, 4, 0, -6 },
  { 167, 4, 6, 4, 0, -6 },
  { 170, 1, 7, 3, 1, -6 },
  { 171, 3, 6, 3, 0, -6 },
  { 174, 2, 7, 3, 0, -6 },
  { 176, 4, 4, 4, 0, -6 },
  { 178, 3, 1, 3, 0, 0 },
  { 179, 2, 1, 3, 0, -6 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 3, 6, 5, 1, -6 },
  { 185, 3, 4, 4, 0, -4 },
  { 187, 4, 6, 5, 0, -6 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 3, 6, 3, 0, -6 },
  { 195, 4, 6, 5, 0, -4 },
  { 198, 3, 6, 5, 1, -6 },
  { 201, 1, 6, 2, 1, -6 },
  { 202, 2, 8, 2, 0, -6 },
  { 204, 3, 6, 4, 1, -6 },
  { 207, 1, 6, 2, 1, -6 },
  { 208, 5, 4, 7, 1, -4 },
  { 211, 3, 4, 5, 1, -4 },
  { 213, 4, 4, 5, 0, -4 },
  { 215, 3, 6, 5, 1, -4 },
  { 218, 4, 6, 5, 0, -4 },
  { 221, 2, 4, 3, 1, -4 },
  { 222, 3, 4, 4, 0, -4 },
  { 224, 3, 5, 3, 0, -5 },
  { 226, 3, 4, 5, 1, -4 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 6, 4, 6, 0, -4 },
  { 233, 4, 4, 4, 0, -4 },
  { 235, 4, 6, 4, 0, -4 },
  { 238, 3, 4, 3, 0, -4 },
  { 240, 3, 7, 3, 0, -6 },
  { 243, 1, 8, 4, 2, -6 },
  { 244, 3, 7, 3, 0, -6 },
  { 247, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD8PT7B_H_
