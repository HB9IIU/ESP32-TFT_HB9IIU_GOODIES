#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9,
  0xFC, 0x1E, 0x00, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xBF,
  0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0,
  0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0xFE,
  0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F, 0x80, 0xFC, 0x7E,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xC7, 0xFE, 0x78, 0xFE, 0x3F, 0xC3, 0xC0, 0x73, 0xFE,
  0x1E, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0xFF, 0x07, 0x80, 0x07, 0xF8, 0x3C,
  0x00, 0x3F, 0xC1, 0xE0, 0x01, 0xFF, 0x0F, 0x00, 0x07, 0xFC, 0x78, 0x00,
  0x3F, 0xFB, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0x9F, 0xF8, 0x00, 0x3C, 0x7F, 0xC0,
  0x01, 0xE1, 0xFE, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x78, 0x3F, 0x80, 0x03,
  0xC1, 0xFE, 0x00, 0x1E, 0x1F, 0xFE, 0x00, 0xF1, 0xFF, 0xFE, 0x07, 0x9F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x0F, 0xE0, 0xFF, 0x80, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0xF8,
  0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xFF, 0x81, 0xF8, 0x3F, 0x0F, 0xE3, 0xFF,
  0xF8, 0x3F, 0x8F, 0xE1, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF0, 0x7F, 0xFF, 0x0F, 0xC7, 0xF0, 0x7E, 0x07, 0xFF, 0xC3, 0xF8,
  0xFE, 0x0F, 0xE0, 0x7F, 0xF0, 0x7E, 0x1F, 0x80, 0xFC, 0x07, 0xFC, 0x1F,
  0xC3, 0xF0, 0x1F, 0x80, 0x18, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x00, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0x7F, 0xE0, 0x3F, 0xC3, 0xFF, 0x1F, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xFE,
  0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF0, 0xFF, 0x80, 0x7F, 0xCF, 0xF8,
  0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x3F, 0xC0, 0x07, 0xFF, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x0F, 0xC0, 0x13, 0xE0, 0x7E,
  0x0F, 0xDF, 0xF3, 0xE3, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x00,
  0xF8, 0x0F, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xE1, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80,
  0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0xBF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xFD, 0xFF, 0xFF, 0xCF, 0xF7, 0xFC, 0x7F, 0x9F, 0x83, 0xFC, 0xF8, 0x1F,
  0xE3, 0x80, 0xFF, 0x08, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x3F,
  0xE0, 0xF8, 0x00, 0x7F, 0xC1, 0xC0, 0x01, 0xFF, 0x02, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFE, 0x7F, 0xFC,
  0x3E, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0xFF, 0x84, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF7,
  0x00, 0x01, 0xFF, 0xBF, 0x80, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xE8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00,
  0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7E, 0x3F, 0xC0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x3F, 0x87, 0xFC, 0x00, 0x1F, 0x83, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0,
  0x07, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xFC,
  0x03, 0xF8, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFF,
  0x81, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x60, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xD8, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x1F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFC, 0x0E, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0xF0, 0xFF, 0xE0,
  0x3F, 0xCF, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xC3, 0xF9, 0xFF, 0xFF, 0x8F,
  0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF,
  0x80, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x81,
  0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x3F,
  0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFE, 0x7F, 0xC0,
  0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF1,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0,
  0x03, 0xFF, 0x9F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFB, 0xF8, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF,
  0x1F, 0xC0, 0x3F, 0xFC, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x30, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x07, 0x80, 0x07, 0x81, 0xFE, 0x3F, 0xE3,
  0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xE0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFF, 0x9F, 0xFE, 0x3E, 0x00, 0x7F, 0xC3, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x02, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x00, 0xFF,
  0xFF, 0xE0, 0x7E, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0x80, 0x7F,
  0xFF, 0xF8, 0x1F, 0x8F, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xEF, 0xE0, 0x7F,
  0x80, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFB, 0xF0, 0x1F,
  0x80, 0x3F, 0x80, 0xFD, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xFE, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xFF, 0x80,
  0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xFF, 0xE0,
  0x3F, 0x00, 0x3F, 0x01, 0xFB, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFD, 0xF8,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x7F,
  0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0x1F, 0x80, 0xFE, 0x0F, 0xFC, 0x3F, 0x8F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0xFF, 0xCF, 0xFF, 0xC3,
  0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x02, 0x00, 0x06, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80,
  0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x3E, 0x0F, 0xFE, 0x00, 0x06, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x02, 0x0F, 0xFF, 0x80, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0xFF, 0xE0,
  0x00, 0x18, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x0F,
  0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xF0,
  0x00, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F,
  0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x03, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x03, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xFB,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0xFF, 0xBF, 0x80, 0x00, 0x7F,
  0x7F, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFF, 0xFB, 0xF8, 0x00, 0x0F, 0xE7,
  0xFF, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xFF, 0x9F, 0xC0, 0x00, 0xFE, 0xFF,
  0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xFF, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xFF,
  0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0xFF, 0x8F, 0xE0, 0x03, 0xF8, 0xFF, 0xFE,
  0x3F, 0xC0, 0x0F, 0xE3, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xFF, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0xFF, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xFF, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0xFE, 0x07, 0xF0,
  0x3F, 0x03, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x87,
  0xF0, 0x3F, 0xFF, 0x80, 0xFE, 0x1F, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xF3, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xCF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xF9, 0xFF, 0x00,
  0x1F, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0xF1,
  0xFF, 0x00, 0x3F, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F,
  0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFC, 0x01, 0xFF,
  0x0F, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0xF8,
  0x01, 0xFF, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xFE, 0x00, 0x3F, 0xE3,
  0xFF, 0xF0, 0x00, 0xFF, 0x9F, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xFC, 0x00,
  0x1F, 0xF7, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xBC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0,
  0x7F, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0xFF,
  0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x07, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xE0, 0x0F, 0xC7, 0xFC, 0x00, 0x18, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xC0, 0x07, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x1F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F,
  0xE1, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF0, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3,
  0xF8, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x0F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xDF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xE0, 0x78,
  0x03, 0xFE, 0x04, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x0F, 0xF7,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF7, 0xFF, 0xFE, 0x7F, 0x3F, 0xFF, 0xE3,
  0xF1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC3, 0xFF, 0x80, 0xFF,
  0x3F, 0xFF, 0x83, 0xFD, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x00,
  0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF8, 0x07, 0xFE, 0xFF, 0xF0, 0x3F, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xF0, 0xFE,
  0x7F, 0xFF, 0x83, 0xF8, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xE0, 0x1C, 0x3F, 0xF0, 0x01, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x4F, 0xFC, 0x00, 0x63, 0xFF, 0xC0, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xF1, 0xFE,
  0x0F, 0xFF, 0xF3, 0xFC, 0x3F, 0xFF, 0xF7, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xBF,
  0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07,
  0xFD, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x83, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0xFF,
  0x07, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0x03, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0xFE, 0x7F, 0x80, 0x03, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xC1, 0xFF, 0x80, 0x1F,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xBC,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0xC3, 0xF8,
  0x3F, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xDF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF, 0x3F, 0xE0, 0x0F, 0xFE, 0xFF,
  0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0xFB, 0xFC,
  0x1F, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFC, 0x1F, 0xE0,
  0x03, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE3, 0x00, 0x00, 0xFF, 0xC7, 0xC0, 0x03, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0xE0,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF,
  0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFE, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC,
  0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0,
  0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0xFF, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7E, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0x8F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0x3F, 0x8F, 0xFF, 0xF1, 0xFC,
  0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xFE, 0x7F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xF8, 0x0F, 0xE3, 0xFF, 0xF8, 0x3F, 0x9F,
  0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB,
  0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFD, 0xFF, 0xFF, 0x0F, 0xF7, 0xFF, 0xF8, 0x3F, 0xC7,
  0xFF, 0xC0, 0xFF, 0x0F, 0xFE, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF,
  0xC1, 0xFC, 0x0F, 0xFF, 0xC3, 0xF8, 0x3F, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF,
  0xDF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xE7, 0xFC,
  0x01, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFD, 0xFE, 0x1F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF,
  0x8F, 0xF0, 0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0x80, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xEF, 0xE7, 0xFF, 0x7F, 0x7F, 0xFB,
  0xFB, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xC1, 0xFC, 0xFF, 0x00, 0x1C, 0xFF, 0x00,
  0x04, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x30, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF, 0xFB, 0xF8, 0xFF, 0xFF, 0x9F, 0xC3,
  0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFD, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x7E, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xDF, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF7, 0xF0, 0x1F,
  0xE0, 0x7F, 0x81, 0xF8, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x3F, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0x8F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE0, 0x0F, 0xF0, 0xFC, 0x1F,
  0x87, 0xF8, 0x03, 0xFC, 0x3F, 0x07, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xC1,
  0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC0, 0x07, 0xF9, 0xF8,
  0x0F, 0xC7, 0xF0, 0x01, 0xFE, 0x7E, 0x03, 0xF3, 0xFC, 0x00, 0x7F, 0x9F,
  0x80, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0x80, 0x03, 0xFB,
  0xF8, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF8, 0x00, 0x1F,
  0xBF, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x04, 0x7F, 0xF0, 0x00, 0x37, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0xC0, 0x03, 0xFF, 0xF2, 0x00, 0x03, 0xFF, 0x08,
  0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 49, 18, 4, -48 },
  { 63, 22, 17, 29, 4, -48 },
  { 110, 37, 48, 39, 1, -48 },
  { 332, 29, 55, 35, 3, -51 },
  { 532, 51, 50, 55, 2, -49 },
  { 851, 41, 50, 44, 3, -49 },
  { 1108, 8, 17, 16, 4, -48 },
  { 1125, 17, 59, 21, 3, -48 },
  { 1251, 16, 59, 21, 2, -48 },
  { 1369, 29, 29, 34, 2, -51 },
  { 1475, 30, 32, 35, 3, -40 },
  { 1595, 12, 17, 18, 2, -8 },
  { 1621, 17, 8, 21, 2, -22 },
  { 1638, 10, 10, 18, 4, -9 },
  { 1651, 25, 48, 27, 1, -48 },
  { 1801, 30, 50, 35, 3, -49 },
  { 1989, 21, 48, 35, 4, -48 },
  { 2115, 30, 49, 35, 3, -49 },
  { 2299, 29, 50, 35, 3, -49 },
  { 2481, 33, 48, 35, 1, -48 },
  { 2679, 29, 49, 35, 3, -48 },
  { 2857, 30, 49, 35, 3, -48 },
  { 3041, 31, 48, 35, 2, -48 },
  { 3227, 31, 49, 35, 2, -48 },
  { 3417, 31, 49, 35, 2, -48 },
  { 3607, 10, 38, 18, 4, -37 },
  { 3655, 12, 46, 18, 2, -37 },
  { 3724, 30, 33, 35, 3, -41 },
  { 3848, 30, 19, 35, 3, -33 },
  { 3920, 30, 33, 35, 3, -41 },
  { 4044, 27, 50, 28, 0, -49 },
  { 4213, 49, 54, 55, 3, -48 },
  { 4544, 41, 48, 41, 0, -48 },
  { 4790, 32, 48, 40, 5, -48 },
  { 4982, 33, 50, 39, 4, -49 },
  { 5189, 36, 48, 44, 5, -48 },
  { 5405, 24, 48, 34, 6, -48 },
  { 5549, 24, 48, 33, 6, -48 },
  { 5693, 36, 50, 44, 4, -49 },
  { 5918, 34, 48, 46, 6, -48 },
  { 6122, 19, 48, 23, 2, -48 },
  { 6236, 18, 62, 19, -4, -48 },
  { 6376, 34, 48, 39, 6, -48 },
  { 6580, 26, 48, 33, 5, -48 },
  { 6736, 46, 48, 58, 6, -48 },
  { 7012, 37, 48, 49, 6, -48 },
  { 7234, 40, 50, 48, 4, -49 },
  { 7484, 30, 48, 38, 5, -48 },
  { 7664, 40, 60, 48, 4, -49 },
  { 7964, 34, 48, 39, 5, -48 },
  { 8168, 28, 50, 34, 3, -49 },
  { 8343, 32, 48, 34, 1, -48 },
  { 8535, 35, 49, 45, 5, -48 },
  { 8750, 39, 48, 39, 0, -48 },
  { 8984, 58, 48, 58, 0, -48 },
  { 9332, 38, 48, 38, 0, -48 },
  { 9560, 36, 48, 36, 0, -48 },
  { 9776, 30, 48, 34, 2, -48 },
  { 9956, 15, 59, 22, 5, -48 },
  { 10067, 25, 48, 27, 1, -48 },
  { 10217, 15, 59, 22, 2, -48 },
  { 10328, 33, 30, 37, 2, -48 },
  { 10452, 28, 4, 28, 0, 6 },
  { 10466, 16, 10, 21, 3, -51 },
  { 10486, 28, 38, 36, 3, -37 },
  { 10619, 30, 52, 38, 5, -51 },
  { 10814, 26, 38, 31, 3, -37 },
  { 10938, 31, 52, 38, 3, -51 },
  { 11140, 30, 38, 36, 3, -37 },
  { 11283, 24, 51, 23, 1, -51 },
  { 11436, 31, 53, 38, 3, -37 },
  { 11642, 29, 51, 39, 5, -51 },
  { 11827, 9, 50, 18, 4, -50 },
  { 11884, 16, 66, 18, -3, -50 },
  { 12016, 31, 51, 36, 5, -51 },
  { 12214, 8, 51, 18, 5, -51 },
  { 12265, 49, 37, 58, 5, -37 },
  { 12492, 29, 37, 39, 5, -37 },
  { 12627, 32, 38, 38, 3, -37 },
  { 12779, 30, 53, 38, 5, -37 },
  { 12978, 31, 53, 38, 3, -37 },
  { 13184, 21, 37, 27, 5, -37 },
  { 13282, 24, 38, 30, 3, -37 },
  { 13396, 22, 45, 25, 1, -44 },
  { 13520, 29, 37, 39, 5, -36 },
  { 13655, 33, 36, 33, 0, -36 },
  { 13804, 50, 36, 51, 1, -36 },
  { 14029, 32, 36, 34, 1, -36 },
  { 14173, 33, 52, 34, 0, -36 },
  { 14388, 25, 36, 29, 2, -36 },
  { 14501, 22, 59, 25, 1, -48 },
  { 14664, 6, 67, 34, 14, -51 },
  { 14715, 22, 59, 25, 2, -48 },
  { 14878, 30, 11, 35, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD67PT7B_H_
