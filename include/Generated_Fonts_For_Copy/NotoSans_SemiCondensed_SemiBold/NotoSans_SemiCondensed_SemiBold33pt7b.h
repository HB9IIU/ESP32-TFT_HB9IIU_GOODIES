#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0xCF, 0xFF, 0xFE, 0xF3, 0xFE, 0x3F, 0xC7, 0x78, 0xEF, 0x1D, 0xE3,
  0xBC, 0x77, 0x8E, 0x61, 0xC0, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x71, 0xC1, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF0, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF, 0xEF, 0x31, 0xBC,
  0xC0, 0xE3, 0x03, 0xCC, 0x0F, 0xB0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0xFF, 0x03, 0x3C, 0x0C, 0xF0, 0x33, 0xF0, 0xDF, 0xFF, 0xFB,
  0xFF, 0xCF, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x70, 0x1F, 0x80, 0x70, 0x1F, 0xE0, 0x38, 0x0E, 0x78, 0x38, 0x0F,
  0x1C, 0x1C, 0x07, 0x0E, 0x1C, 0x03, 0x87, 0x0E, 0x01, 0xC3, 0x8E, 0x00,
  0xE1, 0xC7, 0x00, 0x70, 0xE7, 0x00, 0x3C, 0x73, 0x9F, 0x8E, 0x7B, 0x9F,
  0xE7, 0xF9, 0xCE, 0x71, 0xF9, 0xEF, 0x3C, 0x78, 0xE7, 0x0E, 0x00, 0xF3,
  0x87, 0x00, 0x71, 0xC3, 0x80, 0x78, 0xE1, 0xC0, 0x38, 0x70, 0xE0, 0x3C,
  0x38, 0x70, 0x1C, 0x1E, 0x70, 0x1E, 0x07, 0xF8, 0x0E, 0x03, 0xFC, 0x0F,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7C, 0xF8,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x1E,
  0x78, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x0F,
  0x1F, 0xF0, 0xF1, 0xF3, 0xC7, 0x8F, 0x1F, 0x3C, 0xF8, 0x7F, 0xC7, 0x81,
  0xFE, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xE7, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x07, 0x87,
  0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0xC0, 0xE0,
  0x78, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0xE0, 0x70, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0xF0,
  0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x06, 0x38, 0xDF, 0xFF, 0xBF,
  0xFF, 0x3F, 0xFD, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0x81, 0xE7, 0x83, 0xC7,
  0x81, 0x0C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3D, 0xF7, 0x9E,
  0x79, 0xC7, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x67, 0xFF, 0xFF, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC7, 0xC3, 0xCF,
  0x07, 0x9E, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x78, 0x1E, 0xF0, 0x3D,
  0xE0, 0xF3, 0xC1, 0xE3, 0xC7, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x01,
  0xC0, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xBD, 0xCF, 0x23, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF,
  0xE7, 0x03, 0xC4, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE2, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xC0, 0x7E,
  0x00, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xFE, 0x07, 0xDF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x38,
  0x78, 0x70, 0x78, 0xF0, 0x78, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xE0, 0x1E, 0xC1, 0xFB,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x00, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFE,
  0x63, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE7, 0xE3,
  0xDF, 0xE7, 0xFF, 0xEF, 0xC3, 0xDF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xF3, 0xC3, 0xC7, 0xFF, 0x87, 0xFE,
  0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x03, 0x9E, 0x07,
  0x3C, 0x1E, 0x7C, 0x3C, 0x7D, 0xF0, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0x07,
  0xDF, 0x1F, 0x1F, 0x3C, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xF7, 0x83, 0xEF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xC7, 0x83, 0xDF, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0xFB, 0xC1, 0xF7, 0xFF, 0xE7, 0xFF, 0xC7, 0xF7,
  0x83, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x87,
  0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x33, 0xFF, 0xFF, 0x80, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xDE, 0x79, 0xE7, 0x9C, 0xF3, 0x80, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0x60, 0x00, 0x0F, 0x83, 0xFF, 0x3F, 0xFC, 0xFF, 0xF6, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0x80, 0xF8, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x78, 0x00, 0x1E, 0x70, 0x7F, 0x8E, 0x70, 0xFF, 0x8E, 0xE1, 0xE3, 0x8E,
  0xE3, 0xC3, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87,
  0xE3, 0x83, 0x8E, 0xE3, 0x87, 0x8E, 0xE3, 0x87, 0x8E, 0xE3, 0xCF, 0xDC,
  0xE1, 0xFD, 0xFC, 0xF0, 0xF8, 0xF8, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xE0, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xE0, 0x78, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3C, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE7,
  0xFF, 0x0F, 0xFF, 0x9E, 0x1F, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0,
  0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3E, 0x02, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x06, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE,
  0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x07, 0xE7, 0x80,
  0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x07, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0x01, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F,
  0x3F, 0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE3,
  0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xDF, 0xEF, 0xE7,
  0xE1, 0xC0, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x0F, 0x9E, 0x07, 0x8F, 0x07,
  0x87, 0x87, 0xC3, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xE3, 0xE0,
  0xF1, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x8F, 0x03, 0xC7, 0x81,
  0xF3, 0xC0, 0x7D, 0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFD, 0xC0, 0x3F, 0xFB, 0x80,
  0x7F, 0xF7, 0x80, 0xEF, 0xEF, 0x03, 0xDF, 0xCE, 0x07, 0xBF, 0xDE, 0x0E,
  0x7F, 0xBC, 0x3C, 0xFF, 0x38, 0x79, 0xFE, 0x78, 0xE3, 0xFC, 0xF3, 0xC7,
  0xF8, 0xE7, 0x8F, 0xF1, 0xCE, 0x1F, 0xE3, 0xDC, 0x3F, 0xC3, 0xF8, 0x7F,
  0x87, 0xE0, 0xFF, 0x0F, 0xC1, 0xFE, 0x0F, 0x83, 0xFC, 0x1E, 0x07, 0xF8,
  0x3C, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFE, 0xF0, 0x3F, 0xBE, 0x0F, 0xE7, 0x83, 0xF9, 0xF0,
  0xFE, 0x3C, 0x3F, 0xCF, 0x8F, 0xF1, 0xE3, 0xFC, 0x7C, 0xFF, 0x0F, 0x3F,
  0xC1, 0xEF, 0xF0, 0x79, 0xFC, 0x0F, 0x7F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7E, 0x07, 0xC7, 0xC0, 0x3C, 0x78,
  0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E,
  0xF8, 0x01, 0xEF, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x7C, 0x3F, 0x0F,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFE, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x07, 0xFC, 0x3E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x7E, 0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0x78,
  0x03, 0xE7, 0xC0, 0x7C, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF,
  0xF8, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF1,
  0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0x07, 0xE0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFE,
  0x7C, 0x09, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xDF, 0x01, 0xE7, 0xC3, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0xE0, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x83,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x38, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0x7F, 0x80, 0x7C, 0x07, 0xDE, 0x03, 0xE0, 0x3C, 0xF0, 0x1F,
  0x01, 0xE7, 0x81, 0xF8, 0x0F, 0x3C, 0x0F, 0xE0, 0x79, 0xE0, 0x77, 0x07,
  0x87, 0x83, 0xB8, 0x3C, 0x3C, 0x1D, 0xC1, 0xE1, 0xE1, 0xEF, 0x0F, 0x0F,
  0x0E, 0x78, 0xF0, 0x3C, 0x71, 0xC7, 0x81, 0xE3, 0x8E, 0x3C, 0x0F, 0x3C,
  0x79, 0xE0, 0x79, 0xE3, 0xCE, 0x01, 0xCE, 0x0E, 0xF0, 0x0F, 0x70, 0x77,
  0x80, 0x7F, 0x83, 0xBC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xF8,
  0x07, 0xC0, 0x78, 0x03, 0xCF, 0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0x81,
  0xE0, 0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F,
  0x07, 0x83, 0xC0, 0xF8, 0xF8, 0x0F, 0x1E, 0x01, 0xF7, 0xC0, 0x1F, 0xF0,
  0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x87,
  0xC1, 0xE1, 0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x38, 0x3C, 0x38, 0x38, 0x1C, 0x78, 0x1C,
  0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0E, 0x07, 0x0F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC6, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC1, 0xFF, 0x3F, 0xFD, 0xFF, 0xF7, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFF, 0x7F, 0xDC, 0xFE, 0x70, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x79, 0xF8, 0xF7, 0xF9, 0xFF, 0xFB, 0xF0, 0xF7, 0xC1, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0x7B, 0xFC, 0xF3, 0xF0, 0x0F, 0xE3,
  0xFF, 0x7F, 0xF7, 0xC2, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x37, 0xFF, 0x3F, 0xF1,
  0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x8F, 0xCF, 0x3F, 0xDE, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFF, 0x0F, 0xDF, 0xFF, 0x9F, 0xEF, 0x1F, 0x9E,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0xC0, 0x9F, 0xFE, 0x3F, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x0F,
  0xF1, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x9E,
  0x7F, 0xBD, 0xFF, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x1F, 0xBF, 0xFF, 0x3F, 0xDE, 0x3F, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xD0, 0x07, 0x9E, 0x7F, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x79, 0xF8, 0xF7, 0xFD, 0xFF, 0xFB, 0xF0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x77, 0xBF,
  0xE2, 0x00, 0x1E, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF0, 0x0E, 0x1E, 0x1F, 0x1E, 0x04, 0x00, 0x00, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0xBE, 0xFE, 0xFC, 0xF8, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xF0, 0xF3,
  0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFD, 0xE0, 0xF9,
  0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF3, 0xF0, 0xFC, 0x7B, 0xFC, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF,
  0x8F, 0xE3, 0xEF, 0x83, 0xE0, 0xF7, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x1F,
  0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x01,
  0xFE, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x3F, 0xC0, 0xF0,
  0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xC0, 0xF3,
  0xF1, 0xEF, 0xFB, 0xFF, 0xF7, 0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x0F, 0xE0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xC3, 0xEF, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0x9E,
  0x1F, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0xC0, 0xF3, 0xF1, 0xEF, 0xF3, 0xFF,
  0xF7, 0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0xFE, 0xF7, 0xF9, 0xE7, 0xE3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x9E, 0x7F, 0xBD,
  0xFF, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x1F,
  0xBF, 0xFF, 0x3F, 0xDE, 0x3F, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF3, 0xFE, 0xFF,
  0xDF, 0x7F, 0xEF, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x1F, 0xE3,
  0xFF, 0x7F, 0xFF, 0x82, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFC, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xFF, 0x1F, 0xC3, 0xF0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x07, 0xDE, 0x1F, 0xBF, 0xFF, 0x3F,
  0xDE, 0x3F, 0x1C, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0E,
  0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0xBC, 0x1F, 0x03, 0xDE, 0x0F, 0x83,
  0xCF, 0x07, 0xE1, 0xE7, 0x87, 0x70, 0xF1, 0xE3, 0xB8, 0x78, 0xF1, 0xDC,
  0x78, 0x78, 0xEF, 0x3C, 0x3C, 0xF3, 0x9E, 0x0F, 0x71, 0xCE, 0x07, 0xB8,
  0xEF, 0x03, 0xDC, 0x77, 0x80, 0xEE, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x1F, 0x7C, 0x1E, 0x3C, 0x3E, 0x1E, 0x3C, 0x1E, 0x78, 0x0F, 0x78,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E, 0xF8, 0x0F,
  0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x78,
  0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x5F, 0x80, 0x7F, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x41, 0xF0, 0xFC, 0x3F,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x3F,
  0x0F, 0x83, 0xE0, 0xFE, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0xFC, 0x3F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x1F, 0x03,
  0xF0, 0x7F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x1F, 0xC0, 0xF8, 0x3F, 0x0F, 0xC3, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC3, 0xF8, 0x7E, 0x0F,
  0x80, 0x3E, 0x03, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xF8, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 11, 9, 15, 2, -24 },
  { 29, 18, 24, 19, 1, -24 },
  { 83, 14, 27, 17, 2, -25 },
  { 131, 25, 24, 27, 1, -24 },
  { 206, 21, 24, 22, 1, -24 },
  { 269, 4, 9, 8, 2, -24 },
  { 274, 9, 29, 11, 1, -24 },
  { 307, 8, 29, 11, 1, -24 },
  { 336, 15, 14, 17, 1, -25 },
  { 363, 15, 16, 17, 1, -20 },
  { 393, 6, 8, 9, 1, -4 },
  { 399, 8, 4, 10, 1, -11 },
  { 403, 5, 5, 9, 2, -5 },
  { 407, 13, 24, 13, 0, -24 },
  { 446, 15, 24, 17, 1, -24 },
  { 491, 10, 24, 17, 2, -24 },
  { 521, 15, 24, 17, 1, -24 },
  { 566, 15, 24, 17, 1, -24 },
  { 611, 16, 24, 17, 1, -24 },
  { 659, 14, 24, 17, 2, -24 },
  { 701, 15, 24, 17, 1, -24 },
  { 746, 15, 24, 17, 1, -24 },
  { 791, 15, 24, 17, 1, -24 },
  { 836, 15, 24, 17, 1, -24 },
  { 881, 5, 18, 9, 2, -18 },
  { 893, 6, 22, 9, 1, -18 },
  { 910, 15, 16, 17, 1, -20 },
  { 940, 15, 9, 17, 1, -16 },
  { 957, 15, 16, 17, 1, -20 },
  { 987, 13, 24, 14, 0, -24 },
  { 1026, 24, 27, 27, 2, -24 },
  { 1107, 20, 24, 20, 0, -24 },
  { 1167, 15, 24, 20, 3, -24 },
  { 1212, 16, 24, 19, 2, -24 },
  { 1260, 17, 24, 22, 3, -24 },
  { 1311, 12, 24, 17, 3, -24 },
  { 1347, 12, 24, 16, 3, -24 },
  { 1383, 18, 24, 22, 2, -24 },
  { 1437, 17, 24, 23, 3, -24 },
  { 1488, 9, 24, 11, 1, -24 },
  { 1515, 9, 31, 10, -2, -24 },
  { 1550, 17, 24, 19, 3, -24 },
  { 1601, 12, 24, 16, 3, -24 },
  { 1637, 23, 24, 29, 3, -24 },
  { 1706, 18, 24, 24, 3, -24 },
  { 1760, 20, 24, 23, 2, -24 },
  { 1820, 14, 24, 19, 3, -24 },
  { 1862, 20, 30, 23, 2, -24 },
  { 1937, 16, 24, 19, 3, -24 },
  { 1985, 14, 24, 17, 1, -24 },
  { 2027, 16, 24, 17, 0, -24 },
  { 2075, 17, 24, 22, 3, -24 },
  { 2126, 19, 24, 19, 0, -24 },
  { 2183, 29, 24, 29, 0, -24 },
  { 2270, 19, 24, 19, 0, -24 },
  { 2327, 18, 24, 18, 0, -24 },
  { 2381, 15, 24, 17, 1, -24 },
  { 2426, 8, 29, 11, 2, -24 },
  { 2455, 13, 24, 13, 0, -24 },
  { 2494, 7, 29, 11, 1, -24 },
  { 2520, 16, 15, 18, 1, -24 },
  { 2550, 14, 2, 14, 0, 3 },
  { 2554, 8, 5, 11, 1, -25 },
  { 2559, 14, 18, 18, 1, -18 },
  { 2591, 15, 25, 19, 2, -25 },
  { 2638, 12, 18, 15, 2, -18 },
  { 2665, 15, 25, 19, 2, -25 },
  { 2712, 14, 18, 18, 2, -18 },
  { 2744, 12, 25, 11, 0, -25 },
  { 2782, 15, 26, 19, 2, -18 },
  { 2831, 15, 25, 19, 2, -25 },
  { 2878, 5, 25, 9, 2, -25 },
  { 2894, 8, 33, 9, -1, -25 },
  { 2927, 16, 25, 18, 2, -25 },
  { 2977, 4, 25, 9, 2, -25 },
  { 2990, 25, 18, 29, 2, -18 },
  { 3047, 15, 18, 19, 2, -18 },
  { 3081, 15, 18, 19, 2, -18 },
  { 3115, 15, 26, 19, 2, -18 },
  { 3164, 15, 26, 19, 2, -18 },
  { 3213, 11, 18, 13, 2, -18 },
  { 3238, 12, 18, 15, 1, -18 },
  { 3265, 10, 22, 12, 1, -22 },
  { 3293, 15, 18, 19, 2, -18 },
  { 3327, 16, 18, 16, 0, -18 },
  { 3363, 25, 18, 25, 0, -18 },
  { 3420, 16, 18, 17, 0, -18 },
  { 3456, 16, 26, 17, 0, -18 },
  { 3508, 12, 18, 14, 1, -18 },
  { 3535, 10, 29, 12, 1, -24 },
  { 3572, 3, 33, 17, 7, -25 },
  { 3585, 11, 29, 12, 1, -24 },
  { 3625, 15, 5, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD33PT7B_H_
