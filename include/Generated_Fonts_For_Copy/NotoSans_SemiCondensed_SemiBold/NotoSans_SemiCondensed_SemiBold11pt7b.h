#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0x80, 0x28, 0xA7, 0xCA, 0x2B, 0xF5, 0x14, 0x4F, 0xCC,
  0x35, 0xF4, 0x40, 0x62, 0x6A, 0x25, 0x1B, 0x66, 0xF8, 0xA4, 0x52, 0x46,
  0x30, 0x91, 0x21, 0x87, 0x7B, 0xB3, 0x3F, 0xE0, 0x29, 0x2D, 0x92, 0x44,
  0xC9, 0x92, 0x4B, 0x58, 0x27, 0xCC, 0xB0, 0x21, 0x09, 0xF2, 0x10, 0x70,
  0xFC, 0xC0, 0x11, 0x22, 0x64, 0x4C, 0x72, 0x53, 0x9C, 0xA5, 0x2E, 0x3E,
  0x92, 0x49, 0x76, 0x42, 0x31, 0x11, 0x1F, 0xF2, 0x42, 0xE7, 0x86, 0x3F,
  0x18, 0x63, 0x96, 0x5B, 0xF1, 0x86, 0xF8, 0x8E, 0x11, 0x9E, 0x3B, 0x10,
  0xFC, 0xE5, 0x2F, 0xF8, 0x46, 0x21, 0x18, 0x8C, 0x72, 0x52, 0xE7, 0xE7,
  0x2F, 0x72, 0x73, 0x97, 0x84, 0x6E, 0xCC, 0x50, 0x1C, 0x08, 0xD9, 0xC1,
  0x84, 0xF8, 0x3E, 0x83, 0x06, 0x36, 0x40, 0xF9, 0x13, 0x64, 0x46, 0x3C,
  0x42, 0x9A, 0xA9, 0xA9, 0xAA, 0xB6, 0xC0, 0x7C, 0x30, 0x70, 0xA3, 0x44,
  0xCF, 0xB1, 0x63, 0xF4, 0xE7, 0xE9, 0xC6, 0x7E, 0x7E, 0x61, 0x08, 0x43,
  0x0F, 0xF2, 0x68, 0xE3, 0x8E, 0x39, 0xBC, 0xF8, 0x8F, 0x88, 0x8F, 0xF8,
  0x88, 0xF8, 0x88, 0x7B, 0x28, 0x20, 0x9E, 0x3C, 0xDF, 0x8E, 0x38, 0xFF,
  0x8E, 0x38, 0xE3, 0xED, 0xB6, 0xDF, 0x24, 0x92, 0x49, 0x3C, 0x8A, 0x4B,
  0x28, 0xE2, 0x49, 0xA3, 0x88, 0x88, 0x88, 0x8F, 0xC3, 0xC7, 0xE7, 0xA7,
  0xAB, 0xAB, 0x9B, 0x93, 0xC7, 0x1E, 0x69, 0xB6, 0x58, 0xE3, 0x7B, 0x38,
  0x61, 0x86, 0x1C, 0xDE, 0xF4, 0xE7, 0x3F, 0x42, 0x10, 0x7B, 0x38, 0x61,
  0x86, 0x1C, 0xDE, 0x18, 0x30, 0xF4, 0xE7, 0x3E, 0x4A, 0x71, 0x7A, 0x50,
  0xC3, 0x86, 0x3E, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x8E, 0x38, 0xE3, 0x8E,
  0x3C, 0x9E, 0x87, 0x14, 0xD2, 0x68, 0xE3, 0x0C, 0x8C, 0xF3, 0x24, 0xC9,
  0x56, 0x55, 0x9C, 0xC3, 0x30, 0xCC, 0xCD, 0x23, 0x8C, 0x31, 0xE4, 0xB3,
  0xCD, 0x27, 0x8C, 0x30, 0xC3, 0x0C, 0xF8, 0x44, 0x62, 0x31, 0x1F, 0xEA,
  0xAA, 0xB0, 0x84, 0x46, 0x22, 0x31, 0xE4, 0x92, 0x49, 0x3C, 0x20, 0xC7,
  0x12, 0xCC, 0xF8, 0xE0, 0x78, 0x4E, 0x9C, 0xBC, 0x84, 0x3D, 0x39, 0xCE,
  0x7E, 0x7A, 0x11, 0x84, 0x3C, 0x0C, 0x37, 0xD3, 0x4F, 0x34, 0xDF, 0x7A,
  0x5F, 0x84, 0x3C, 0x74, 0xF4, 0x44, 0x44, 0x7D, 0x34, 0xF3, 0x4D, 0xF0,
  0xD6, 0x70, 0x84, 0x3D, 0x39, 0xCE, 0x73, 0xBF, 0x45, 0x55, 0x78, 0x84,
  0x27, 0x6E, 0x72, 0xD3, 0xFF, 0xF6, 0x9B, 0x91, 0x91, 0x91, 0x91, 0xF4,
  0xE7, 0x39, 0xCC, 0x79, 0x24, 0xF3, 0x49, 0xE0, 0xF4, 0xE7, 0x39, 0xFA,
  0x10, 0x80, 0x7D, 0x34, 0xF3, 0x4D, 0xF0, 0xC3, 0x0C, 0xFA, 0x49, 0x00,
  0x7C, 0x63, 0x1F, 0x4F, 0x44, 0x44, 0x70, 0x9C, 0xE7, 0x39, 0xFC, 0xCA,
  0x56, 0xA3, 0x18, 0xD9, 0xD9, 0x5F, 0x56, 0x66, 0x26, 0xCA, 0x8C, 0x65,
  0xE4, 0xCA, 0x56, 0xE3, 0x18, 0x9C, 0xC0, 0xF1, 0x26, 0x4F, 0x32, 0x66,
  0xC6, 0x66, 0x23, 0xFF, 0xE0, 0xC6, 0x66, 0x32, 0x66, 0x6C, 0x6D, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 5, 1, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 9, 8, 9, 0, -8 },
  { 24, 7, 8, 7, 0, -8 },
  { 31, 1, 3, 3, 1, -8 },
  { 32, 3, 10, 4, 0, -8 },
  { 36, 3, 10, 4, 0, -8 },
  { 40, 5, 4, 6, 0, -8 },
  { 43, 5, 6, 6, 0, -7 },
  { 47, 2, 2, 3, 0, -1 },
  { 48, 3, 2, 3, 0, -4 },
  { 49, 1, 2, 3, 1, -2 },
  { 50, 4, 8, 4, 0, -8 },
  { 54, 5, 8, 6, 0, -8 },
  { 59, 3, 8, 6, 1, -8 },
  { 62, 5, 8, 6, 0, -8 },
  { 67, 5, 8, 6, 0, -8 },
  { 72, 6, 8, 6, 0, -8 },
  { 78, 4, 8, 6, 1, -8 },
  { 82, 5, 8, 6, 0, -8 },
  { 87, 5, 8, 6, 0, -8 },
  { 92, 5, 8, 6, 0, -8 },
  { 97, 5, 8, 6, 0, -8 },
  { 102, 1, 6, 3, 1, -6 },
  { 103, 2, 7, 3, 0, -6 },
  { 105, 5, 6, 6, 0, -7 },
  { 109, 5, 3, 6, 0, -5 },
  { 111, 5, 6, 6, 0, -7 },
  { 115, 4, 8, 5, 0, -8 },
  { 119, 8, 9, 9, 1, -8 },
  { 128, 7, 8, 7, 0, -8 },
  { 135, 5, 8, 7, 1, -8 },
  { 140, 5, 8, 6, 1, -8 },
  { 145, 6, 8, 7, 1, -8 },
  { 151, 4, 8, 6, 1, -8 },
  { 155, 4, 8, 5, 1, -8 },
  { 159, 6, 8, 7, 1, -8 },
  { 165, 6, 8, 8, 1, -8 },
  { 171, 3, 8, 4, 0, -8 },
  { 174, 3, 10, 3, -1, -8 },
  { 178, 6, 8, 6, 1, -8 },
  { 184, 4, 8, 5, 1, -8 },
  { 188, 8, 8, 10, 1, -8 },
  { 196, 6, 8, 8, 1, -8 },
  { 202, 6, 8, 8, 1, -8 },
  { 208, 5, 8, 6, 1, -8 },
  { 213, 6, 10, 8, 1, -8 },
  { 221, 5, 8, 6, 1, -8 },
  { 226, 5, 8, 6, 0, -8 },
  { 231, 5, 8, 6, 0, -8 },
  { 236, 6, 8, 7, 1, -8 },
  { 242, 6, 8, 6, 0, -8 },
  { 248, 10, 8, 10, 0, -8 },
  { 258, 6, 8, 6, 0, -8 },
  { 264, 6, 8, 6, 0, -8 },
  { 270, 5, 8, 6, 0, -8 },
  { 275, 2, 10, 4, 1, -8 },
  { 278, 4, 8, 4, 0, -8 },
  { 282, 3, 10, 4, 0, -8 },
  { 286, 6, 5, 6, 0, -8 },
  { 290, 5, 1, 5, 0, 1 },
  { 291, 3, 1, 4, 0, -8 },
  { 292, 5, 6, 6, 0, -6 },
  { 296, 5, 8, 6, 1, -8 },
  { 301, 5, 6, 5, 0, -6 },
  { 305, 6, 8, 6, 0, -8 },
  { 311, 5, 6, 6, 0, -6 },
  { 315, 4, 8, 4, 0, -8 },
  { 319, 6, 9, 6, 0, -6 },
  { 326, 5, 8, 6, 1, -8 },
  { 331, 1, 8, 3, 1, -8 },
  { 332, 2, 11, 3, 0, -8 },
  { 335, 5, 8, 6, 1, -8 },
  { 340, 1, 8, 3, 1, -8 },
  { 341, 8, 6, 10, 1, -6 },
  { 347, 5, 6, 6, 1, -6 },
  { 351, 6, 6, 6, 0, -6 },
  { 356, 5, 9, 6, 1, -6 },
  { 362, 6, 9, 6, 0, -6 },
  { 369, 3, 6, 4, 1, -6 },
  { 372, 4, 6, 5, 0, -6 },
  { 375, 4, 7, 4, 0, -7 },
  { 379, 5, 6, 6, 1, -6 },
  { 383, 5, 6, 5, 0, -6 },
  { 387, 8, 6, 8, 0, -6 },
  { 393, 5, 6, 6, 0, -6 },
  { 397, 5, 9, 6, 0, -6 },
  { 403, 4, 6, 5, 0, -6 },
  { 406, 4, 10, 4, 0, -8 },
  { 411, 1, 11, 6, 2, -8 },
  { 413, 4, 10, 4, 0, -8 },
  { 418, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD11PT7B_H_
