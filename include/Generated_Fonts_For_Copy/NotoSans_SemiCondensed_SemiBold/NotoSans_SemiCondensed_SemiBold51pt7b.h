#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFE,
  0x7E, 0x10, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xF7, 0xF1, 0xF8, 0xE0, 0xC3, 0xF1, 0xC0, 0x0F, 0xC3, 0x80, 0x1F,
  0x87, 0x00, 0x1F, 0x8E, 0x00, 0x3F, 0x9C, 0x00, 0x7F, 0xB8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3B, 0xFC, 0x00, 0x71,
  0xF8, 0x00, 0xE3, 0xF8, 0x01, 0xC3, 0xF0, 0x03, 0x87, 0xF0, 0x07, 0x1F,
  0xFC, 0x0E, 0x3F, 0x7F, 0x1F, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0x80, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x7E, 0xFC, 0x01, 0xF0, 0x01, 0xF1,
  0xF0, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x0F, 0x00,
  0x03, 0xE0, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE1, 0xE0, 0x00, 0x3E, 0x0F,
  0x8F, 0x87, 0xF0, 0xF8, 0x3E, 0x3E, 0x7F, 0xE1, 0xF1, 0xF1, 0xF1, 0xFF,
  0xC7, 0xEF, 0xC7, 0xCF, 0xFF, 0x8F, 0xFF, 0x3E, 0x3E, 0x3E, 0x3F, 0xF8,
  0xF9, 0xF0, 0xF8, 0x7F, 0xC7, 0xC7, 0xC1, 0xF0, 0x7C, 0x1F, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0xF8,
  0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0x00,
  0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x1F,
  0xFF, 0x00, 0xFC, 0x3F, 0xFF, 0x81, 0xFC, 0x7F, 0x9F, 0xC1, 0xF8, 0x7F,
  0x1F, 0xE1, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0xFE, 0x07, 0xFB, 0xF0, 0xFC,
  0x03, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xE0, 0xFE,
  0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0x81, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xE1, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDE,
  0x78, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x08, 0x07, 0x80, 0xBE, 0x1E, 0x1E, 0xFF,
  0x7B, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xCF, 0x80,
  0x3E, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x03, 0x80, 0x0C,
  0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0xFE, 0xFE, 0xFF,
  0xFE, 0xFE, 0x7E, 0x10, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFD,
  0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F, 0xC0,
  0x7E, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x7F, 0xBF, 0xFF, 0x3F, 0x7E, 0x3F, 0x3C, 0x3F, 0x10, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x0F, 0xFB, 0xFF, 0x1F, 0x80, 0xFE, 0x1C, 0x00, 0xFE, 0x10, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xE1, 0xFF, 0x0E, 0x00, 0xFE, 0x08, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xA0,
  0x00, 0x7F, 0x78, 0x03, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3F,
  0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xFE, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0x83, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x1F, 0xF0, 0x7E, 0x7F, 0xF0, 0xFD, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xEF, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F, 0x8F,
  0xC0, 0x7F, 0x1F, 0xC1, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xF0, 0x7F, 0x07,
  0xF3, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0x1F, 0xC0,
  0xFE, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xF9, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFD, 0xFE, 0x1F, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0xF7, 0xE3, 0xFF, 0xCF,
  0x83, 0xFF, 0x1F, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x7C,
  0xFE, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7E, 0x10, 0x3E, 0x1F, 0x9F, 0xCF, 0xF7, 0xFB, 0xF8, 0xFC,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x3F, 0x3F, 0x9F, 0x8F, 0xC7,
  0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xF1, 0xFF, 0x38, 0x07, 0xF2, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x07, 0xF8, 0x1F, 0x07, 0xC0, 0x7F, 0xFC, 0x3C, 0x3E, 0x07, 0xFF,
  0xF0, 0xF8, 0xF8, 0x3F, 0xFF, 0xC3, 0xE7, 0xC0, 0xFC, 0x1E, 0x07, 0x9F,
  0x07, 0xE0, 0x78, 0x1E, 0x7C, 0x1F, 0x01, 0xE0, 0x7D, 0xF0, 0xF8, 0x0F,
  0x81, 0xF7, 0x83, 0xE0, 0x3E, 0x07, 0xDE, 0x0F, 0x80, 0xF8, 0x1F, 0xF8,
  0x3E, 0x03, 0xE0, 0x7B, 0xE0, 0xF8, 0x0F, 0x81, 0xEF, 0x83, 0xE0, 0x3E,
  0x07, 0xBE, 0x0F, 0x80, 0xF8, 0x3E, 0x78, 0x3E, 0x03, 0xE0, 0xF9, 0xE0,
  0xF8, 0x1F, 0x83, 0xC7, 0x81, 0xF0, 0x7F, 0x1F, 0x1F, 0x07, 0xFF, 0xFF,
  0xF8, 0x7C, 0x0F, 0xFE, 0xFF, 0xE1, 0xF0, 0x1F, 0xF1, 0xFF, 0x03, 0xE0,
  0x3F, 0x83, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x02, 0x00, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x0F, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xF8, 0x7F, 0xC0,
  0x18, 0x7F, 0x80, 0x04, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x04, 0x3F, 0xF0, 0x1E, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x10, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xFE, 0x3F, 0x80,
  0x3F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x03, 0xFE, 0x3F, 0x87, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFC, 0x00, 0x60, 0xFF, 0x00, 0x04, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD,
  0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xCF, 0xF8, 0x01, 0xF8, 0xFF, 0x80, 0x3F, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x87, 0xFB, 0xFF, 0xCF,
  0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xBF, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFB, 0xFF, 0xDF, 0x00, 0x0F, 0xBF, 0xFD, 0xF0, 0x01, 0xFB, 0xFF,
  0xDF, 0x80, 0x1F, 0x3F, 0xFC, 0xF8, 0x01, 0xF3, 0xFF, 0xCF, 0x80, 0x3F,
  0x3F, 0xFC, 0xFC, 0x03, 0xE3, 0xFF, 0xC7, 0xC0, 0x3E, 0x3F, 0xFC, 0x7C,
  0x03, 0xE3, 0xFF, 0xC7, 0xE0, 0x7C, 0x3F, 0xFC, 0x3E, 0x07, 0xC3, 0xFF,
  0xC3, 0xE0, 0x7C, 0x3F, 0xFC, 0x3F, 0x0F, 0x83, 0xFF, 0xC3, 0xF0, 0xF8,
  0x3F, 0xFC, 0x1F, 0x0F, 0x83, 0xFF, 0xC1, 0xF9, 0xF0, 0x3F, 0xFC, 0x1F,
  0x9F, 0x03, 0xFF, 0xC0, 0xF9, 0xF0, 0x3F, 0xFC, 0x0F, 0xBE, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFC, 0x03,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xEF, 0xC0, 0x0F, 0xFF, 0x7F, 0x00, 0x7F, 0xF9, 0xF8, 0x03, 0xFF,
  0xCF, 0xE0, 0x1F, 0xFE, 0x3F, 0x80, 0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0x87,
  0xF0, 0x3F, 0xFC, 0x3F, 0x81, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x03, 0xF0,
  0x7F, 0xF8, 0x1F, 0xC3, 0xFF, 0xC0, 0x7E, 0x1F, 0xFE, 0x03, 0xF8, 0xFF,
  0xF0, 0x0F, 0xC7, 0xFF, 0x80, 0x7F, 0x3F, 0xFC, 0x01, 0xFD, 0xFF, 0xE0,
  0x0F, 0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xC0, 0xFF,
  0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF,
  0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x5F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0x1F, 0x80, 0x04, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xEE, 0x00, 0x3F,
  0xBF, 0x01, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xFC, 0x07,
  0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x87,
  0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC1, 0xFC,
  0x03, 0xEF, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0x3F, 0x01,
  0xFB, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE7, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x1F,
  0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0x87, 0xE1,
  0xF8, 0x01, 0xF8, 0x7C, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E,
  0x00, 0x7E, 0x3F, 0x07, 0xC7, 0xF0, 0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x00,
  0x1F, 0x8F, 0x81, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0x03,
  0xF7, 0xE0, 0x3E, 0x7E, 0x00, 0x1F, 0xBE, 0x01, 0xF3, 0xE0, 0x00, 0xFD,
  0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0x7C,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x81,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3F,
  0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x38, 0x0F, 0xE0, 0x80, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF,
  0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xE0, 0x3F, 0x7F,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xF9, 0xF3, 0xFF, 0xC7, 0xC3, 0xFE, 0x1F, 0x01, 0x80, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x0F, 0xCF, 0xFC,
  0x1F, 0xBF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0x83, 0xF9,
  0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x01, 0xFD, 0xFE, 0x07,
  0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xBF, 0xFF, 0x1F, 0x3F, 0xFC,
  0x3E, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFC, 0x0C, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x01, 0x3F, 0xC0, 0x63, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x3F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF,
  0x3F, 0x1F, 0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x81,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x0F, 0xFF,
  0x3F, 0x03, 0xFC, 0x1F, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x3F,
  0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x03, 0x0F, 0xF9, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x20, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x7F, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F, 0x03, 0xFC, 0x7F, 0x00,
  0x20, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x20, 0x00, 0xFE, 0x3C, 0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0xFC, 0xFF, 0xE3, 0xF7,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x7C,
  0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xC0, 0x03, 0xE0, 0x3F,
  0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xDF, 0x80, 0x7F, 0x3F, 0x01, 0xFC, 0x7E, 0x07, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0xCF, 0xE0,
  0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFB, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F,
  0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xE1, 0xF8,
  0x0F, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80,
  0x3F, 0xBF, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x7F, 0x80, 0x7F, 0x07, 0xC7, 0xFF, 0x0F, 0xFE, 0x3E, 0x7F, 0xFC, 0xFF,
  0xF9, 0xF7, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC3,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x00,
  0x3F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00,
  0x7E, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0x00, 0x3F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF,
  0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0xF8, 0x3F, 0x83,
  0xE3, 0xFF, 0x8F, 0x9F, 0xFF, 0x3E, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFE,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x00, 0xFE, 0x7F,
  0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0xF8, 0x3F, 0x81, 0xF1, 0xFF, 0x83, 0xE7,
  0xFF, 0xC7, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0xC0, 0xFF, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0x87, 0xE3,
  0xFC, 0x0F, 0xC0, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F, 0x03, 0xFC, 0x7F,
  0x00, 0x20, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xF9, 0xFE, 0xFB, 0xFE, 0xFB, 0xFE, 0xFF, 0xFE,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFC, 0x07, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF8, 0x03, 0xF7, 0xFB, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x1F, 0xFE, 0x00, 0x08, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x0C, 0x00, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF,
  0xC0, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFE, 0x7C, 0x7F,
  0xF8, 0xF8, 0x3F, 0xE1, 0xF0, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF1,
  0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0xFE,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7B, 0xC0, 0x7E, 0x1F, 0x81,
  0xF7, 0xC0, 0xFC, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x3F, 0x07, 0xDF, 0x07,
  0xE0, 0x7E, 0x0F, 0x1E, 0x0F, 0xC0, 0xFC, 0x3E, 0x3E, 0x1F, 0x80, 0xFC,
  0x7C, 0x7C, 0x7E, 0x01, 0xF8, 0xF8, 0xF8, 0xFC, 0x03, 0xF1, 0xF1, 0xF1,
  0xF8, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x07, 0xCF, 0x83, 0xE7, 0xC0, 0x0F,
  0xDF, 0x07, 0xDF, 0x80, 0x1F, 0xBE, 0x0F, 0xBF, 0x00, 0x3F, 0x78, 0x0F,
  0x7E, 0x00, 0x3E, 0xF0, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x3D, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x1F, 0x87, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x7F,
  0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFE, 0x1F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x0F, 0xDF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF,
  0x07, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x02, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFE,
  0x40, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 37, 14, 3, -36 },
  { 38, 16, 13, 22, 3, -36 },
  { 64, 28, 36, 30, 1, -36 },
  { 190, 23, 42, 27, 2, -39 },
  { 311, 38, 37, 42, 2, -37 },
  { 487, 32, 38, 34, 2, -37 },
  { 639, 6, 13, 12, 3, -36 },
  { 649, 13, 44, 16, 2, -36 },
  { 721, 13, 44, 16, 1, -36 },
  { 793, 22, 22, 26, 2, -39 },
  { 854, 23, 24, 27, 2, -30 },
  { 923, 8, 13, 13, 2, -6 },
  { 936, 12, 5, 16, 2, -16 },
  { 944, 8, 8, 13, 3, -7 },
  { 952, 19, 37, 20, 1, -37 },
  { 1040, 23, 38, 27, 2, -37 },
  { 1150, 16, 36, 27, 3, -36 },
  { 1222, 23, 37, 27, 2, -37 },
  { 1329, 23, 38, 27, 2, -37 },
  { 1439, 25, 37, 27, 1, -37 },
  { 1555, 21, 37, 27, 3, -36 },
  { 1653, 23, 38, 27, 2, -37 },
  { 1763, 23, 36, 27, 2, -36 },
  { 1867, 23, 38, 27, 2, -37 },
  { 1977, 23, 38, 27, 2, -37 },
  { 2087, 8, 29, 14, 3, -28 },
  { 2116, 9, 35, 14, 2, -28 },
  { 2156, 23, 25, 27, 2, -31 },
  { 2228, 23, 14, 27, 2, -25 },
  { 2269, 23, 25, 27, 2, -31 },
  { 2341, 20, 38, 21, 0, -37 },
  { 2436, 38, 41, 42, 2, -37 },
  { 2631, 31, 37, 31, 0, -37 },
  { 2775, 24, 36, 31, 4, -36 },
  { 2883, 25, 38, 29, 3, -37 },
  { 3002, 27, 36, 34, 4, -36 },
  { 3124, 19, 36, 26, 4, -36 },
  { 3210, 19, 36, 25, 4, -36 },
  { 3296, 27, 38, 34, 3, -37 },
  { 3425, 27, 36, 35, 4, -36 },
  { 3547, 14, 36, 18, 2, -36 },
  { 3610, 14, 46, 15, -3, -36 },
  { 3691, 26, 36, 30, 4, -36 },
  { 3808, 20, 36, 25, 4, -36 },
  { 3898, 36, 36, 44, 4, -36 },
  { 4060, 29, 36, 37, 4, -36 },
  { 4191, 31, 38, 36, 3, -37 },
  { 4339, 23, 36, 29, 4, -36 },
  { 4443, 31, 46, 36, 3, -37 },
  { 4622, 26, 36, 30, 4, -36 },
  { 4739, 22, 38, 26, 2, -37 },
  { 4844, 24, 36, 26, 1, -36 },
  { 4952, 26, 37, 34, 4, -36 },
  { 5073, 29, 36, 29, 0, -36 },
  { 5204, 45, 36, 45, 0, -36 },
  { 5407, 29, 36, 29, 0, -36 },
  { 5538, 28, 36, 28, 0, -36 },
  { 5664, 24, 36, 26, 1, -36 },
  { 5772, 11, 44, 16, 4, -36 },
  { 5833, 20, 37, 20, 0, -37 },
  { 5926, 12, 44, 16, 1, -36 },
  { 5992, 25, 23, 28, 1, -37 },
  { 6064, 22, 4, 22, 0, 4 },
  { 6075, 12, 8, 16, 2, -39 },
  { 6087, 22, 29, 27, 2, -28 },
  { 6167, 23, 40, 29, 4, -39 },
  { 6282, 20, 29, 23, 2, -28 },
  { 6355, 24, 40, 29, 2, -39 },
  { 6475, 23, 29, 27, 2, -28 },
  { 6559, 18, 39, 17, 1, -39 },
  { 6647, 24, 40, 29, 2, -28 },
  { 6767, 22, 39, 30, 4, -39 },
  { 6875, 7, 38, 13, 3, -38 },
  { 6909, 12, 50, 13, -2, -38 },
  { 6984, 23, 39, 27, 4, -39 },
  { 7097, 6, 39, 13, 4, -39 },
  { 7127, 37, 28, 45, 4, -28 },
  { 7257, 22, 28, 30, 4, -28 },
  { 7334, 24, 29, 29, 2, -28 },
  { 7421, 23, 40, 29, 4, -28 },
  { 7536, 24, 40, 29, 2, -28 },
  { 7656, 16, 28, 20, 4, -28 },
  { 7712, 19, 29, 23, 2, -28 },
  { 7781, 17, 35, 19, 1, -34 },
  { 7856, 23, 29, 30, 3, -28 },
  { 7940, 25, 28, 25, 0, -28 },
  { 8028, 39, 28, 39, 0, -28 },
  { 8165, 25, 28, 26, 0, -28 },
  { 8253, 25, 40, 26, 0, -28 },
  { 8378, 20, 28, 22, 1, -28 },
  { 8448, 16, 44, 19, 1, -36 },
  { 8536, 5, 51, 26, 10, -39 },
  { 8568, 16, 44, 19, 2, -36 },
  { 8656, 23, 8, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD51PT7B_H_
