#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDE, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0x7C, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x81, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE1,
  0xC0, 0x07, 0x0F, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x3C, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0E,
  0x1E, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xFF, 0xC3, 0xFF, 0xFB,
  0xFF, 0xF9, 0xFF, 0xFD, 0xFB, 0x8E, 0xF9, 0xC0, 0x7C, 0xE0, 0x3E, 0x70,
  0x1F, 0x38, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x39, 0xF0, 0x1C, 0xF8, 0x0E, 0x3E,
  0x07, 0x3F, 0xC3, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x07, 0xFE,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x7F, 0x00, 0x3C, 0x03, 0xFE, 0x01, 0xE0, 0x1F, 0x7C, 0x07, 0x80,
  0x78, 0xF0, 0x3C, 0x01, 0xE3, 0xC0, 0xF0, 0x07, 0x0F, 0x07, 0x80, 0x3C,
  0x1C, 0x1E, 0x00, 0xF0, 0x78, 0xF0, 0x03, 0xC1, 0xE3, 0xC0, 0x0F, 0x07,
  0x0E, 0x00, 0x1C, 0x3C, 0x78, 0x20, 0x78, 0xF1, 0xC7, 0xF1, 0xE3, 0xCF,
  0x3F, 0xE7, 0xDF, 0x39, 0xFF, 0x8F, 0xF9, 0xE7, 0x8F, 0x1F, 0xC7, 0x1E,
  0x3C, 0x3E, 0x3C, 0x70, 0xF0, 0x00, 0xF3, 0xC3, 0xC0, 0x07, 0x8F, 0x07,
  0x00, 0x1E, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x70, 0x03, 0xC3, 0xC3, 0xC0,
  0x1E, 0x07, 0x0F, 0x00, 0x78, 0x1E, 0x3C, 0x03, 0xC0, 0x78, 0xF0, 0x0F,
  0x00, 0xFF, 0x80, 0x78, 0x03, 0xFE, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xF8, 0x7F, 0xE0, 0x7C,
  0x7E, 0xF8, 0x3E, 0x7E, 0x7E, 0x3E, 0x3E, 0x1F, 0x9F, 0x1F, 0x07, 0xEF,
  0x8F, 0x81, 0xFF, 0x87, 0xC0, 0x7F, 0xC3, 0xE0, 0x1F, 0xC1, 0xF0, 0x0F,
  0xE0, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xCF, 0xC0, 0xFF, 0x83, 0xF8, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x3C,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x7C, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8,
  0x3C, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x41, 0xE0, 0x9E, 0x79, 0xE7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x3C, 0x07, 0xCF, 0x83,
  0xE1, 0xF0, 0x38, 0x70, 0x02, 0x08, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x79, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x31, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8, 0x3E, 0x7E, 0x3F, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF0,
  0xFF, 0x1F, 0xF3, 0xFF, 0x7D, 0xFF, 0x9F, 0xF1, 0xF6, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xC3, 0xF3, 0x80, 0xF8, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xE7, 0x83, 0xF3, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xBF, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1E, 0x7C, 0x07, 0x8F, 0x80,
  0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC1, 0xE0, 0xF8, 0x78, 0x1F, 0x0F,
  0x03, 0xE3, 0xC0, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC,
  0x60, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x7F, 0xFF, 0xBF,
  0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC7, 0xF0, 0xF7, 0xFE, 0x3D,
  0xFF, 0xCF, 0xFF, 0xFB, 0xF0, 0x7E, 0xF8, 0x0F, 0xBE, 0x01, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xF9, 0xF0, 0x3E,
  0x7E, 0x1F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F,
  0xDF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xBF, 0x07, 0xC3, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xEF, 0x80, 0x3D, 0xF0,
  0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0xF7, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x7D, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x07, 0xDF,
  0x03, 0xF7, 0xE1, 0xFC, 0xFF, 0xFF, 0x3F, 0xFB, 0xC7, 0xFC, 0xF0, 0x7C,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00,
  0x79, 0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x31, 0xFF, 0xFF, 0xFD, 0xF0, 0x3C, 0x7D, 0xFB, 0xF3, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF9, 0xF3, 0xCF,
  0x9F, 0x3C, 0x78, 0xF3, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0x20, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x7C, 0x00,
  0xFC, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E,
  0x3C, 0x0F, 0xF0, 0xF3, 0xC1, 0xFF, 0xC3, 0x9E, 0x1F, 0xFE, 0x1E, 0xE0,
  0xF0, 0xF0, 0xFF, 0x0F, 0x07, 0x87, 0xF8, 0x78, 0x3C, 0x3F, 0xC3, 0x81,
  0xE1, 0xFE, 0x3C, 0x0F, 0x0F, 0xF1, 0xE0, 0x78, 0x7F, 0x8F, 0x03, 0xC3,
  0xFC, 0x78, 0x1E, 0x1F, 0xE1, 0xC1, 0xF0, 0xEF, 0x0F, 0x0F, 0x8F, 0x78,
  0x7F, 0xFF, 0xF3, 0xC1, 0xFE, 0x7F, 0x8F, 0x07, 0xE1, 0xF8, 0x78, 0x04,
  0x02, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x04,
  0x00, 0xFC, 0x01, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0x80,
  0x01, 0xE7, 0x80, 0x01, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xC0,
  0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0x8F, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xF8, 0x1F, 0xDF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xE3, 0xE3, 0xF8, 0x04, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x61, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7C, 0x07, 0xF3, 0xE0, 0x0F, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0xFC, 0xF8, 0x3F, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xF1,
  0xF8, 0x7E, 0x00, 0x43, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x1F, 0xC0, 0x7C, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x8F, 0xFF, 0xFB, 0xFF, 0x7F, 0xCF, 0xE0, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC7,
  0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7E, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xEF, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x1E, 0xFF, 0xF8, 0x01, 0xEF, 0xFB, 0xC0, 0x1E, 0xFF, 0xBC, 0x03,
  0xCF, 0xFB, 0xC0, 0x3C, 0xFF, 0xBE, 0x03, 0xDF, 0xF9, 0xE0, 0x7D, 0xFF,
  0x9E, 0x07, 0x9F, 0xF9, 0xF0, 0x79, 0xFF, 0x8F, 0x0F, 0x9F, 0xF8, 0xF0,
  0xF1, 0xFF, 0x8F, 0x8F, 0x1F, 0xF8, 0x79, 0xF1, 0xFF, 0x87, 0x9E, 0x1F,
  0xF8, 0x79, 0xE1, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x83,
  0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81,
  0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFB, 0xE0, 0x3F, 0xF7, 0xC0,
  0x7F, 0xE7, 0xC0, 0xFF, 0xCF, 0x81, 0xFF, 0x8F, 0x83, 0xFF, 0x1F, 0x07,
  0xFE, 0x1F, 0x0F, 0xFC, 0x3F, 0x1F, 0xF8, 0x3E, 0x3F, 0xF0, 0x7E, 0x7F,
  0xE0, 0x7C, 0xFF, 0xC0, 0xFD, 0xFF, 0x80, 0xFB, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x81, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBE, 0x07,
  0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFE, 0x0F, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x81, 0xFC, 0xF8, 0x0F, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8,
  0x0F, 0x8F, 0x87, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xF3, 0xE7, 0xE0, 0x13, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7D, 0x00, 0x3E, 0xF0, 0x3F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7F, 0x07, 0xF1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1E, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7D, 0xE0, 0x07, 0xC0, 0x1F, 0x3E,
  0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x7C, 0xF8, 0x07, 0xF0, 0x0F,
  0x9F, 0x00, 0xFE, 0x01, 0xE1, 0xF0, 0x3D, 0xC0, 0x7C, 0x3E, 0x07, 0xBC,
  0x0F, 0x87, 0xC0, 0xF7, 0x81, 0xF0, 0xF8, 0x1E, 0xF0, 0x3E, 0x0F, 0x07,
  0xDE, 0x0F, 0x81, 0xF0, 0xF3, 0xE1, 0xF0, 0x3E, 0x1E, 0x3C, 0x3E, 0x07,
  0xC3, 0xC7, 0x87, 0xC0, 0x78, 0xF8, 0xF0, 0xF0, 0x0F, 0x9E, 0x1F, 0x3E,
  0x01, 0xF3, 0xC1, 0xE7, 0xC0, 0x3E, 0x78, 0x3C, 0xF8, 0x03, 0xDF, 0x07,
  0x9E, 0x00, 0x7B, 0xC0, 0xFB, 0xC0, 0x0F, 0x78, 0x0F, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0xF8,
  0x07, 0xE1, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE1,
  0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0x7C, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE0, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE3, 0xE0,
  0x07, 0xEF, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x78,
  0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0E, 0x07,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0x81, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFE, 0x79, 0xFE, 0x3C, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0xF8, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xFF, 0xFB, 0xDF,
  0xFC, 0xF3, 0xFE, 0x3C, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xE7, 0xE0, 0xCF, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x0D, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x07, 0xE7, 0xC7, 0xFD, 0xF3, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7E, 0x1F, 0xDF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x83, 0xF7, 0xFF,
  0xFC, 0xFF, 0xEF, 0x1F, 0xF3, 0xC3, 0xF8, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7B,
  0xE0, 0x1E, 0xF8, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x63, 0xFD, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xE0,
  0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0x98, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xE3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD,
  0xFF, 0xFF, 0x7E, 0x1F, 0xDF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x83, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xF7, 0xC3, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF4, 0x00, 0xF9, 0xF9, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x83, 0xFF, 0xC0, 0x06, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0xFC, 0x3E, 0xFF, 0x8F, 0x7F, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xF0, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFF, 0x7E, 0xFF, 0xBF, 0xCF, 0xE0, 0xC0, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xF3, 0xE0,
  0xF8, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x3E, 0x0F,
  0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0,
  0x7E, 0xF8, 0x0F, 0xBE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF1, 0xFC, 0x1F, 0xC7, 0x9F, 0xF1, 0xFF, 0x3D, 0xFF, 0xDF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0x1F, 0xFE, 0x0F, 0xE0, 0x7F, 0xE0,
  0x3F, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C,
  0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F,
  0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8,
  0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F,
  0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7C, 0xF0, 0xFC, 0x3C,
  0xFF, 0x8F, 0x7F, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xF8, 0xF8,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0,
  0x3E, 0x7C, 0x07, 0xCF, 0xC1, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xF1, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xFF,
  0xFE, 0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xFF, 0xFB, 0xDF,
  0xFC, 0xFB, 0xFE, 0x3E, 0x7F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x07, 0xE3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD, 0xFF,
  0xFF, 0x7E, 0x1F, 0xDF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x83, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xF7, 0xC3, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xF8, 0x1B, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF1, 0xFF, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0x78, 0xFE, 0x3C, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x07, 0x9E, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7D, 0xE0, 0x3F, 0x01,
  0xF7, 0xC0, 0xFE, 0x07, 0xDF, 0x03, 0xF8, 0x1E, 0x7C, 0x0F, 0xE0, 0xF8,
  0xF0, 0x7F, 0x83, 0xE3, 0xE1, 0xEE, 0x0F, 0x8F, 0x87, 0xBC, 0x3C, 0x3E,
  0x1C, 0xF1, 0xF0, 0x78, 0xF3, 0xC7, 0xC1, 0xF3, 0xC7, 0x1F, 0x07, 0xCF,
  0x1E, 0x78, 0x0F, 0x38, 0x7B, 0xE0, 0x3D, 0xE1, 0xEF, 0x80, 0xF7, 0x83,
  0xBC, 0x03, 0xFE, 0x0E, 0xF0, 0x07, 0xF8, 0x3B, 0xC0, 0x1F, 0xC0, 0xFF,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC1,
  0xF0, 0xFC, 0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xF0,
  0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C, 0x7E, 0x03, 0xEF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x0F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xF0, 0x07, 0xDE,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x18, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7C, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0xFF, 0x07, 0xE0, 0x3F, 0x01, 0xFE, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x07, 0xE0, 0x3F, 0x81, 0xFE,
  0x03, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0xC0,
  0x7E, 0x0F, 0xF0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xA0, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 29, 11, 2, -29 },
  { 23, 13, 11, 18, 2, -29 },
  { 41, 22, 29, 23, 1, -29 },
  { 121, 17, 32, 21, 2, -30 },
  { 189, 30, 29, 33, 1, -29 },
  { 298, 25, 29, 27, 2, -29 },
  { 389, 5, 11, 10, 2, -29 },
  { 396, 10, 35, 13, 2, -29 },
  { 440, 10, 35, 13, 1, -29 },
  { 484, 18, 17, 20, 1, -30 },
  { 523, 17, 19, 21, 2, -24 },
  { 564, 7, 10, 11, 1, -5 },
  { 573, 10, 4, 12, 1, -13 },
  { 578, 6, 6, 11, 2, -6 },
  { 583, 16, 29, 16, 0, -29 },
  { 641, 17, 29, 21, 2, -29 },
  { 703, 12, 29, 21, 3, -29 },
  { 747, 17, 29, 21, 2, -29 },
  { 809, 17, 29, 21, 2, -29 },
  { 871, 19, 29, 21, 1, -29 },
  { 940, 17, 29, 21, 2, -29 },
  { 1002, 18, 29, 21, 2, -29 },
  { 1068, 19, 29, 21, 1, -29 },
  { 1137, 19, 29, 21, 1, -29 },
  { 1206, 18, 29, 21, 1, -29 },
  { 1272, 6, 22, 11, 2, -22 },
  { 1289, 7, 27, 11, 1, -22 },
  { 1313, 18, 19, 21, 2, -24 },
  { 1356, 17, 12, 21, 2, -20 },
  { 1382, 18, 19, 21, 2, -24 },
  { 1425, 16, 29, 17, 0, -29 },
  { 1483, 29, 32, 33, 2, -29 },
  { 1599, 24, 29, 24, 0, -29 },
  { 1686, 19, 29, 24, 3, -29 },
  { 1755, 20, 29, 23, 2, -29 },
  { 1828, 21, 29, 26, 3, -29 },
  { 1905, 15, 29, 20, 3, -29 },
  { 1960, 15, 29, 20, 3, -29 },
  { 2015, 22, 29, 27, 2, -29 },
  { 2095, 21, 29, 27, 3, -29 },
  { 2172, 12, 29, 14, 1, -29 },
  { 2216, 11, 37, 12, -3, -29 },
  { 2267, 21, 29, 24, 3, -29 },
  { 2344, 16, 29, 20, 3, -29 },
  { 2402, 28, 29, 35, 3, -29 },
  { 2504, 23, 29, 29, 3, -29 },
  { 2588, 24, 29, 28, 2, -29 },
  { 2675, 18, 29, 23, 3, -29 },
  { 2741, 24, 36, 28, 2, -29 },
  { 2849, 20, 29, 24, 3, -29 },
  { 2922, 17, 29, 20, 2, -29 },
  { 2984, 19, 29, 20, 1, -29 },
  { 3053, 21, 29, 27, 3, -29 },
  { 3130, 23, 29, 23, 0, -29 },
  { 3214, 35, 29, 35, 0, -29 },
  { 3341, 23, 29, 23, 0, -29 },
  { 3425, 22, 29, 22, 0, -29 },
  { 3505, 18, 29, 20, 1, -29 },
  { 3571, 9, 35, 13, 3, -29 },
  { 3611, 16, 29, 16, 0, -29 },
  { 3669, 9, 35, 13, 1, -29 },
  { 3709, 20, 18, 22, 1, -29 },
  { 3754, 17, 2, 17, 0, 4 },
  { 3759, 9, 7, 13, 2, -31 },
  { 3767, 17, 22, 21, 2, -22 },
  { 3814, 18, 30, 23, 3, -30 },
  { 3882, 15, 22, 18, 2, -22 },
  { 3924, 18, 30, 23, 2, -30 },
  { 3992, 18, 22, 21, 2, -22 },
  { 4042, 14, 31, 14, 1, -31 },
  { 4097, 18, 32, 23, 2, -22 },
  { 4169, 18, 30, 23, 3, -30 },
  { 4237, 5, 30, 11, 3, -30 },
  { 4256, 10, 40, 11, -2, -30 },
  { 4306, 18, 30, 22, 3, -30 },
  { 4374, 5, 30, 11, 3, -30 },
  { 4393, 29, 22, 35, 3, -22 },
  { 4473, 18, 22, 23, 3, -22 },
  { 4523, 19, 22, 23, 2, -22 },
  { 4576, 18, 32, 23, 3, -22 },
  { 4648, 18, 32, 23, 2, -22 },
  { 4720, 12, 22, 16, 3, -22 },
  { 4753, 14, 22, 18, 2, -22 },
  { 4792, 13, 26, 15, 1, -26 },
  { 4835, 17, 22, 23, 3, -22 },
  { 4882, 20, 22, 20, 0, -22 },
  { 4937, 30, 22, 31, 0, -22 },
  { 5020, 20, 22, 20, 0, -22 },
  { 5075, 20, 32, 20, 0, -22 },
  { 5155, 15, 22, 17, 1, -22 },
  { 5197, 13, 35, 15, 1, -29 },
  { 5254, 4, 39, 20, 8, -30 },
  { 5274, 13, 35, 15, 1, -29 },
  { 5331, 18, 6, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD40PT7B_H_
