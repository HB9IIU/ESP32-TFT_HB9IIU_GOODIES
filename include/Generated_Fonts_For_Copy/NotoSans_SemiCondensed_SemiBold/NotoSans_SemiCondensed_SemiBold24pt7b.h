#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x00, 0x7F, 0x70, 0xE7, 0x67,
  0x67, 0x67, 0x63, 0x63, 0x0C, 0x60, 0x67, 0x03, 0x30, 0x19, 0x81, 0xCC,
  0x7F, 0xFF, 0xFF, 0xE3, 0x38, 0x19, 0x80, 0xCC, 0x3F, 0xFD, 0xFF, 0xE3,
  0x18, 0x19, 0xC0, 0xCC, 0x06, 0x60, 0x63, 0x00, 0x04, 0x00, 0x80, 0xFF,
  0x3F, 0xEF, 0x4D, 0xC8, 0x39, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x02,
  0xE0, 0x4F, 0x09, 0xFD, 0xF7, 0xFC, 0x3E, 0x00, 0x80, 0x10, 0x00, 0x7C,
  0x0C, 0x3F, 0x06, 0x0C, 0xE1, 0x83, 0x18, 0xC0, 0xC6, 0x30, 0x31, 0x98,
  0x0C, 0x66, 0x23, 0x3B, 0x3E, 0x7C, 0xDF, 0x9F, 0x66, 0x70, 0x19, 0x9C,
  0x0E, 0x63, 0x03, 0x19, 0xC1, 0xC6, 0x70, 0x61, 0x9C, 0x38, 0x7E, 0x0C,
  0x0F, 0x00, 0x1F, 0x80, 0x7F, 0x01, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x07,
  0x70, 0x0F, 0xE0, 0x0F, 0x00, 0x3E, 0x1C, 0xEE, 0x3B, 0x8E, 0xF7, 0x1F,
  0xCE, 0x1F, 0x9C, 0x1E, 0x3C, 0x7E, 0x3F, 0xFE, 0x3F, 0x1E, 0xED, 0xB6,
  0xC0, 0x1C, 0xE3, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x18, 0x71, 0xC3, 0x86, 0x1C, 0xE1, 0x87, 0x0C, 0x38, 0xE1, 0x86, 0x18,
  0x71, 0xC7, 0x18, 0x63, 0x8E, 0x39, 0xC7, 0x38, 0xC0, 0x0C, 0x03, 0x00,
  0xC3, 0xB7, 0xFF, 0xC7, 0x81, 0xE0, 0xFC, 0x73, 0x8C, 0xC0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x00, 0x77, 0x6E, 0xEC, 0xFF, 0xFF, 0xC0, 0x7F, 0x70, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03,
  0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x00, 0x3F, 0x0F, 0xF1, 0xCF, 0x70, 0xEE,
  0x1D, 0xC1, 0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x6E, 0x1C,
  0xE3, 0x9C, 0xF1, 0xFC, 0x1F, 0x00, 0x0E, 0x3D, 0xFF, 0xFE, 0xE9, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3F, 0x1F, 0xF3,
  0x8F, 0x20, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x1F, 0xF1,
  0x8F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE1, 0xF8, 0x3F, 0x00, 0xF8, 0x07,
  0x00, 0xF0, 0x1E, 0x03, 0xB0, 0xF7, 0xFC, 0xFF, 0x00, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x31, 0xC7, 0x1C,
  0x61, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F,
  0x8F, 0xF1, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x1F, 0x83, 0xFC, 0x7F, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x1C, 0x03, 0xB0, 0xF7, 0xFC, 0x7F, 0x00, 0x0F,
  0xC7, 0xF8, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x3B, 0xC7, 0xFE, 0xFB, 0xDC,
  0x3F, 0x83, 0xF0, 0x7E, 0x0E, 0xE3, 0xDC, 0x71, 0xFE, 0x1F, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x00, 0x3F,
  0x8F, 0xF9, 0xC7, 0x70, 0xEE, 0x1C, 0xE3, 0x9E, 0xE1, 0xF8, 0x3F, 0x0F,
  0xF3, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xFC, 0x73, 0xFE, 0x3F, 0x80, 0x3F,
  0x0F, 0xF3, 0xCF, 0x70, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x0F, 0xFF, 0xEF,
  0xDC, 0xF3, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xE3, 0xF8, 0x7E, 0x00, 0x7F,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0x70, 0x7F, 0x70, 0x00, 0x00, 0x00, 0x77,
  0x6E, 0xEC, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x18, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x38, 0x3E, 0x1F, 0x0F, 0x83, 0xC0, 0x60, 0x00, 0x7F, 0x3F,
  0xE6, 0x38, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xC0, 0x70, 0xE0, 0x0C, 0x70, 0xF1, 0x98, 0xFE, 0x66, 0x71, 0x9B,
  0x98, 0x67, 0xC6, 0x39, 0xF1, 0x8E, 0x7C, 0x63, 0x9B, 0x18, 0xE6, 0xE7,
  0xFF, 0x98, 0xF3, 0xC6, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x0C, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x76, 0x00, 0xEE,
  0x01, 0xDC, 0x07, 0x38, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x07, 0x78, 0x0E, 0xE0, 0x1E, 0xFF,
  0x9F, 0xFB, 0x8F, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0xFC, 0xFF, 0x9C,
  0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0xFF, 0xFE, 0xFF, 0x00, 0x0F,
  0xF1, 0xFF, 0x3C, 0x27, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x3E, 0x71, 0xFF, 0x0F,
  0xE0, 0xFF, 0x07, 0xFE, 0x38, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x73,
  0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0xFF, 0x7F,
  0xB8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x0F, 0xF8, 0xFF,
  0xCF, 0x84, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE1, 0xFF,
  0x0F, 0xFC, 0x0E, 0xE0, 0x77, 0x03, 0xBC, 0x1C, 0xF0, 0xE3, 0xFF, 0x0F,
  0xF8, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x70, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x7F, 0xFE, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xEF,
  0xDE, 0x00, 0xE0, 0xFE, 0x0E, 0xE1, 0xCE, 0x38, 0xE7, 0x8E, 0x70, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xE7, 0x0E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1,
  0xEE, 0x0E, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0xDF, 0xB0, 0xEF, 0xDC, 0x77, 0xEE, 0x33, 0xF3, 0x39, 0xF9, 0x9C, 0xFC,
  0xEC, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x0F, 0xC7, 0x87, 0xE1, 0xC3,
  0x80, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xF7, 0x0F, 0xB8,
  0x7C, 0xE3, 0xE7, 0x1F, 0x1C, 0xF8, 0xE7, 0xC3, 0xBE, 0x1F, 0xF0, 0x7F,
  0x83, 0xFC, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1,
  0xE7, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x7B, 0x80, 0xE7, 0x01, 0xCF, 0x07, 0x8F, 0x9E, 0x0F, 0xF8, 0x0F,
  0xE0, 0xFF, 0x1F, 0xF3, 0x9F, 0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0x77, 0x0E,
  0xFF, 0xDF, 0xF3, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x00, 0x0F, 0xE0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03,
  0xBC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7B, 0x80, 0xE7,
  0x01, 0xCF, 0x07, 0x8F, 0x9E, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0x0F, 0xFC, 0xE7, 0xCE, 0x1C, 0xE0,
  0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xFF, 0x8F, 0xF0, 0xE7, 0x0E, 0x38, 0xE3,
  0x8E, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0xF0, 0x3F, 0xDF, 0xFF, 0x1B, 0x80,
  0xE0, 0x3C, 0x07, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x7F, 0x7F, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x79, 0xF7, 0xFE, 0x1F, 0xC0, 0xE0, 0x1F, 0x80,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x03, 0x70, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xDC, 0x3E, 0x1C, 0xE1,
  0xF0, 0xE7, 0x0D, 0x87, 0x38, 0x6C, 0x38, 0xC7, 0x63, 0x87, 0x3B, 0x9C,
  0x39, 0xDC, 0xE1, 0xCC, 0x67, 0x06, 0xE3, 0x30, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0xF0, 0x39, 0xE1, 0xC3, 0x87, 0x0F, 0x38, 0x1C, 0xE0, 0x3F, 0x00, 0xFC,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0x70, 0x1C, 0xE0, 0xE3,
  0xC7, 0x87, 0x1C, 0x1E, 0xF0, 0x3C, 0xF0, 0x3B, 0x83, 0x9C, 0x1C, 0x71,
  0xC3, 0x8E, 0x0E, 0xE0, 0x77, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xFF, 0xDF,
  0xF8, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF1,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0x80,
  0xE0, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xFF, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF, 0x80, 0x0C, 0x01,
  0xC0, 0x78, 0x0D, 0x83, 0xB0, 0x63, 0x1C, 0x63, 0x06, 0x60, 0xD8, 0x0C,
  0xFF, 0xFF, 0xF0, 0xF1, 0xC1, 0xC0, 0x3F, 0x9F, 0xF2, 0x1C, 0x07, 0x01,
  0xC7, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0xFB, 0x7C, 0xC0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDE, 0x3F, 0xE7, 0x9E, 0xE1, 0xDC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x77, 0x9E, 0xDF, 0x99, 0xE0,
  0x1F, 0x9F, 0xDE, 0x2E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1E,
  0x2F, 0xF1, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x7D, 0xDF,
  0xFB, 0x8F, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3B,
  0x8F, 0x7F, 0xE7, 0xCC, 0x1F, 0x07, 0xF9, 0xC7, 0x30, 0x6E, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x0E, 0x01, 0xE1, 0x1F, 0xE1, 0xFC, 0x1F, 0x8F,
  0xCF, 0x07, 0x03, 0x83, 0xFB, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x3E, 0x6F, 0xFD, 0xC7, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1D, 0xC7, 0xBF, 0xF3,
  0xEE, 0x01, 0xC0, 0x3C, 0x0F, 0x7F, 0xCF, 0xF0, 0x78, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xED, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xDF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0x71, 0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xEF, 0xBC, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC3, 0xF8, 0xE7, 0x38, 0xEF, 0x1D, 0xC3,
  0xF0, 0x7F, 0x0F, 0xE1, 0xCE, 0x39, 0xE7, 0x1C, 0xE1, 0xDC, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xCF, 0x9F, 0x6F, 0xDF, 0xFC, 0xF8,
  0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1,
  0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x38, 0xCF, 0xB7,
  0xFF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xC0, 0x1F, 0x87, 0xF9, 0xC7, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xEE, 0x1D, 0xC7, 0x9F, 0xE1, 0xF8, 0xCF, 0x9B, 0xF3,
  0xCF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3B, 0xCF,
  0x6F, 0xCE, 0xF1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00,
  0x3E, 0x6F, 0xFD, 0xC7, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFE, 0x1D, 0xC7, 0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xCF, 0xBF, 0xFF, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x00, 0x3F, 0xFF, 0xB8, 0x5C, 0x0F, 0x03, 0xE0, 0xFC, 0x1E,
  0x07, 0x81, 0xF1, 0xFF, 0xEF, 0xE0, 0x18, 0x18, 0x38, 0x7F, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0x3F, 0x1F, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3F,
  0xFB, 0x7C, 0xC0, 0xE0, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x9C,
  0x39, 0xC1, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE1,
  0xE1, 0xD8, 0x78, 0x77, 0x1E, 0x19, 0xC7, 0xCE, 0x73, 0xB3, 0x8C, 0xEC,
  0xE3, 0xB3, 0x30, 0xEC, 0xFC, 0x3B, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x1E, 0x00, 0xF0, 0xF7, 0x0E, 0x39, 0xC3, 0xDC, 0x1F,
  0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0x9C, 0x39, 0xC7, 0x0E, 0xF0,
  0xF0, 0xE0, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x38, 0xC3, 0x9C, 0x39, 0xC1,
  0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x7C, 0x07, 0x80, 0x60, 0x00, 0xFF, 0x7F, 0x81, 0xC1, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1F, 0xFF, 0xF8, 0x07, 0x0F, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xF8, 0xF0, 0xF8, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x0F, 0x1E,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xC0, 0xFC, 0x3F, 0xFE,
  0x1F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 8, 6, 11, 1, -17 },
  { 16, 13, 17, 14, 1, -17 },
  { 44, 11, 19, 13, 1, -18 },
  { 71, 18, 17, 20, 1, -17 },
  { 110, 15, 17, 16, 1, -17 },
  { 142, 3, 6, 6, 1, -17 },
  { 145, 6, 21, 8, 1, -17 },
  { 161, 6, 21, 8, 1, -17 },
  { 177, 10, 10, 12, 1, -18 },
  { 190, 11, 11, 13, 1, -14 },
  { 206, 4, 6, 6, 1, -3 },
  { 209, 6, 3, 7, 1, -8 },
  { 212, 4, 3, 6, 1, -3 },
  { 214, 9, 17, 10, 0, -17 },
  { 234, 11, 17, 13, 1, -17 },
  { 258, 7, 17, 13, 2, -17 },
  { 273, 11, 17, 13, 1, -17 },
  { 297, 11, 17, 13, 1, -17 },
  { 321, 12, 17, 13, 0, -17 },
  { 347, 11, 17, 13, 1, -17 },
  { 371, 11, 17, 13, 1, -17 },
  { 395, 11, 17, 13, 1, -17 },
  { 419, 11, 17, 13, 1, -17 },
  { 443, 11, 17, 13, 1, -17 },
  { 467, 4, 13, 6, 1, -13 },
  { 474, 4, 16, 6, 1, -13 },
  { 482, 11, 12, 13, 1, -15 },
  { 499, 11, 7, 13, 1, -12 },
  { 509, 11, 12, 13, 1, -15 },
  { 526, 10, 17, 10, 0, -17 },
  { 548, 18, 19, 20, 1, -17 },
  { 591, 15, 17, 15, 0, -17 },
  { 623, 11, 17, 15, 2, -17 },
  { 647, 12, 17, 14, 1, -17 },
  { 673, 13, 17, 16, 2, -17 },
  { 701, 9, 17, 12, 2, -17 },
  { 721, 9, 17, 12, 2, -17 },
  { 741, 13, 17, 16, 1, -17 },
  { 769, 12, 17, 16, 2, -17 },
  { 795, 7, 17, 8, 1, -17 },
  { 810, 7, 22, 7, -2, -17 },
  { 830, 12, 17, 14, 2, -17 },
  { 856, 9, 17, 12, 2, -17 },
  { 876, 17, 17, 21, 2, -17 },
  { 913, 13, 17, 17, 2, -17 },
  { 941, 15, 17, 17, 1, -17 },
  { 973, 11, 17, 14, 2, -17 },
  { 997, 15, 21, 17, 1, -17 },
  { 1037, 12, 17, 14, 2, -17 },
  { 1063, 10, 17, 12, 1, -17 },
  { 1085, 12, 17, 12, 0, -17 },
  { 1111, 12, 17, 16, 2, -17 },
  { 1137, 14, 17, 14, 0, -17 },
  { 1167, 21, 17, 21, 0, -17 },
  { 1212, 14, 17, 14, 0, -17 },
  { 1242, 13, 17, 13, 0, -17 },
  { 1270, 11, 17, 12, 1, -17 },
  { 1294, 5, 21, 8, 2, -17 },
  { 1308, 9, 17, 10, 0, -17 },
  { 1328, 5, 21, 8, 1, -17 },
  { 1342, 11, 10, 13, 1, -17 },
  { 1356, 10, 2, 10, 0, 2 },
  { 1359, 6, 3, 8, 1, -18 },
  { 1362, 10, 13, 13, 1, -13 },
  { 1379, 11, 18, 14, 2, -18 },
  { 1404, 9, 13, 11, 1, -13 },
  { 1419, 11, 18, 14, 1, -18 },
  { 1444, 11, 13, 13, 1, -13 },
  { 1462, 9, 18, 8, 0, -18 },
  { 1483, 11, 19, 14, 1, -13 },
  { 1510, 10, 18, 14, 2, -18 },
  { 1533, 3, 18, 6, 2, -18 },
  { 1540, 6, 24, 6, -1, -18 },
  { 1558, 11, 18, 13, 2, -18 },
  { 1583, 3, 18, 6, 2, -18 },
  { 1590, 17, 13, 21, 2, -13 },
  { 1618, 10, 13, 14, 2, -13 },
  { 1635, 11, 13, 14, 1, -13 },
  { 1653, 11, 19, 14, 2, -13 },
  { 1680, 11, 19, 14, 1, -13 },
  { 1707, 7, 13, 10, 2, -13 },
  { 1719, 9, 13, 11, 1, -13 },
  { 1734, 8, 16, 9, 0, -16 },
  { 1750, 10, 13, 14, 2, -13 },
  { 1767, 12, 13, 12, 0, -13 },
  { 1787, 18, 13, 18, 0, -13 },
  { 1817, 12, 13, 12, 0, -13 },
  { 1837, 12, 19, 12, 0, -13 },
  { 1866, 9, 13, 10, 1, -13 },
  { 1881, 8, 21, 9, 0, -17 },
  { 1902, 2, 24, 12, 5, -18 },
  { 1908, 8, 21, 9, 1, -17 },
  { 1929, 11, 3, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD24PT7B_H_
