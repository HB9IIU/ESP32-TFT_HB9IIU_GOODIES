#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x70,
  0x00, 0x07, 0x7F, 0xFF, 0x78, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xDC, 0x7B, 0x87, 0x70, 0xE0, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x01, 0xE3, 0x83, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0xF1,
  0xC0, 0x1C, 0x38, 0x03, 0x87, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF8, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x3C, 0x70, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x3F, 0x03, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x79, 0x84, 0xF3, 0x01, 0xE6,
  0x03, 0xCC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x06, 0x7C, 0x0C, 0x78, 0x18, 0xF8, 0x31, 0xFC, 0x67, 0xBF,
  0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x38, 0x07, 0xF0, 0x0E, 0x01, 0xFF, 0x01, 0xC0, 0x38,
  0xE0, 0x70, 0x0F, 0x1E, 0x0E, 0x01, 0xE3, 0xC3, 0x80, 0x3C, 0x78, 0x70,
  0x07, 0x8F, 0x1E, 0x00, 0xF1, 0xE3, 0x80, 0x1E, 0x3C, 0xF0, 0x01, 0xC7,
  0x9C, 0xFC, 0x38, 0xE7, 0xBF, 0xC7, 0xFC, 0xE7, 0xFC, 0x7F, 0x3D, 0xE3,
  0x87, 0xC7, 0x3C, 0x70, 0x01, 0xE7, 0x0E, 0x00, 0x38, 0xE1, 0xC0, 0x0F,
  0x1C, 0x3C, 0x01, 0xC3, 0x87, 0x00, 0x78, 0x70, 0xE0, 0x0E, 0x0F, 0x1C,
  0x03, 0xC1, 0xE3, 0x80, 0x70, 0x1F, 0xF0, 0x1E, 0x03, 0xFC, 0x03, 0x80,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0x8F,
  0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xE1, 0xE0, 0x07, 0x8F, 0x00,
  0x1E, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x78, 0xFF, 0xC3, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3C, 0xF8, 0x7F,
  0xF3, 0xE0, 0xFF, 0x8F, 0x81, 0xFE, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xC1,
  0xF9, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0x3E, 0x0F, 0xF0, 0x7C, 0xFF,
  0xFF, 0xFF, 0x77, 0x70, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0,
  0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0x70, 0x38,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x3C, 0x0E, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1C,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83,
  0x83, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x0E,
  0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xF7,
  0x81, 0xE7, 0x87, 0x8F, 0x83, 0x0C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C,
  0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x7C,
  0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x7C, 0x3F, 0x8F, 0xF3,
  0xFE, 0xFB, 0xFE, 0x7B, 0x8F, 0x21, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7C,
  0x7E, 0x30, 0x3E, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0xFC, 0xFF,
  0xFC, 0x78, 0x7E, 0x20, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x3E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0xF0,
  0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x83, 0xC3,
  0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xEF, 0x03, 0xFF, 0xC7,
  0xFF, 0xC7, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE8, 0x07, 0xDE, 0x3F, 0xBF, 0xFE, 0x7F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x82, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x79, 0xF0, 0x7B, 0xFC,
  0xF7, 0xFE, 0xFE, 0x7E, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3E, 0x3E, 0x1F, 0xFE,
  0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3E,
  0x3E, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x7E,
  0x7C, 0x3E, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0x7C, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7E, 0x7C, 0x78, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7E, 0x7F, 0x3F, 0xFF,
  0x3F, 0xEF, 0x0F, 0xCF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x41, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xDE, 0x3D, 0xF7,
  0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3D, 0xF7,
  0x9E, 0x79, 0xCF, 0x38, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xE3, 0xFF, 0xC7,
  0xFF, 0x9E, 0x3F, 0x40, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xE0,
  0x38, 0x1C, 0xF0, 0xFF, 0x8E, 0x70, 0xFF, 0xC7, 0xF8, 0xF8, 0xE1, 0xF8,
  0x78, 0x70, 0xFC, 0x38, 0x38, 0x7E, 0x3C, 0x1C, 0x3F, 0x1E, 0x0E, 0x1F,
  0x8E, 0x07, 0x0F, 0xC7, 0x87, 0x87, 0xE3, 0xC3, 0xC7, 0xF0, 0xE1, 0xE3,
  0xB8, 0x7F, 0xFF, 0xDE, 0x1F, 0xDF, 0xC7, 0x07, 0xC7, 0xC3, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x7C, 0x0F, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0x80, 0x78, 0x78, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF8,
  0x00, 0xF8, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xF9,
  0xE3, 0xE0, 0x13, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x09, 0xFE, 0x78, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x3F, 0x3C, 0x03, 0xEF,
  0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x3F, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF,
  0xDE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xF3, 0xE3, 0xF0, 0x08, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0, 0x3E, 0x7F, 0x8F, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0x80, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xFF, 0xF7, 0xFB, 0xF9, 0xF8, 0xF0, 0x0F,
  0xFC, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F,
  0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x7C, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF0, 0xF8,
  0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0xCF,
  0x01, 0xF3, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0x00, 0xEF,
  0xF7, 0x80, 0xEF, 0xF7, 0x81, 0xEF, 0xF3, 0x81, 0xCF, 0xF3, 0xC1, 0xCF,
  0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0x8F, 0xF1, 0xC3, 0x8F, 0xF1, 0xE7, 0x8F,
  0xF1, 0xE7, 0x8F, 0xF0, 0xE7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xBC, 0x0F, 0xF7, 0xC1,
  0xFE, 0x78, 0x3F, 0xCF, 0x87, 0xF8, 0xF0, 0xFF, 0x1F, 0x1F, 0xE1, 0xF3,
  0xFC, 0x3E, 0x7F, 0x83, 0xE7, 0xF0, 0x3C, 0xFE, 0x07, 0xDF, 0xC0, 0x7B,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0x9F, 0xC7, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x1E,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0xEF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F,
  0xFC, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0x9F, 0xC7, 0xE0, 0x3E, 0x3E, 0x00, 0xF9,
  0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03,
  0xE3, 0xE0, 0x3E, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x3F, 0x8F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0x81, 0xE3, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1F, 0x1E, 0x07,
  0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1F, 0xF0, 0x0F, 0x80,
  0x0F, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xFB, 0xE7, 0xC0, 0x4F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFC, 0x03, 0xFF, 0xBF, 0xBF, 0xFF, 0x7F, 0xFC, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1E, 0xF8, 0x0F,
  0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0xDC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0xF0, 0x07, 0x80, 0x3F, 0xF0, 0x0F, 0x80, 0x79, 0xE0, 0x1F, 0x00,
  0xF3, 0xC0, 0x7E, 0x03, 0xE7, 0x80, 0xFC, 0x07, 0xCF, 0x81, 0xFC, 0x0F,
  0x0F, 0x03, 0xF8, 0x1E, 0x1E, 0x0F, 0x70, 0x3C, 0x3C, 0x1E, 0xE0, 0xF8,
  0x78, 0x3D, 0xE1, 0xE0, 0x78, 0x73, 0xC3, 0xC0, 0xF1, 0xE7, 0x87, 0x81,
  0xE3, 0xC7, 0x1F, 0x03, 0xC7, 0x8F, 0x3C, 0x07, 0xCE, 0x1E, 0x78, 0x07,
  0xBC, 0x3C, 0xF0, 0x0F, 0x78, 0x39, 0xE0, 0x1E, 0xF0, 0x77, 0x80, 0x3D,
  0xC0, 0xFF, 0x00, 0x3B, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x78,
  0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBE, 0x00, 0xF9, 0xE0, 0x0F,
  0x1F, 0x01, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0x7C, 0x3C, 0x03, 0xC7,
  0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F,
  0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0xF0,
  0x0F, 0x1E, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x39, 0xE0, 0x1C, 0x70, 0x1E, 0x3C,
  0x0E, 0x0E, 0x0F, 0x07, 0x87, 0x01, 0xC7, 0x80, 0xF3, 0x80, 0x3B, 0xC0,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x1C,
  0x0F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xC1, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x7F, 0x1F, 0xFE, 0x7F, 0xFD, 0xF8, 0x7B, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x0F, 0xBC, 0x3F, 0x7F, 0xFE, 0xFF, 0x9C, 0x7E, 0x38,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF9, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xC7, 0xCF, 0xC1, 0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F,
  0x7C, 0x07, 0xFE, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xF0,
  0x7D, 0xFC, 0x7C, 0xFF, 0xFE, 0x7B, 0xFE, 0x3C, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0xCF, 0xFC, 0xFC, 0x6F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC7,
  0x7F, 0xF9, 0xFF, 0xC3, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0xDF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7C, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x7C, 0x7F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x0F,
  0xE0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x06, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x03,
  0xE0, 0xFF, 0x1F, 0xF1, 0xFE, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7F,
  0xEF, 0xFE, 0xFF, 0xE3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0x7C, 0x7F,
  0x7F, 0xEF, 0x3F, 0xFF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x80, 0x3E, 0x60, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF9, 0xF8, 0xFF, 0xFC, 0xF7, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x7F, 0xFE, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x1F, 0x1F,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFE, 0xFE, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7,
  0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFB, 0xE0, 0xF1,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF3, 0xF8, 0x7F, 0x3D, 0xFF, 0x3F,
  0xEF, 0xFF, 0xFF, 0xFB, 0xF9, 0xFF, 0x3F, 0xFC, 0x1F, 0x07, 0xFE, 0x07,
  0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1E, 0x03, 0xFE,
  0x07, 0x80, 0xFF, 0x81, 0xE0, 0x3F, 0xE0, 0x78, 0x0F, 0xF8, 0x1E, 0x03,
  0xFE, 0x07, 0x80, 0xFF, 0x81, 0xE0, 0x3F, 0xE0, 0x78, 0x0F, 0xF8, 0x1E,
  0x03, 0xFE, 0x07, 0x80, 0xFF, 0x81, 0xE0, 0x3C, 0xF1, 0xF8, 0xF7, 0xFE,
  0xF7, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x0F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0xF1, 0xF8, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xCF, 0xC1, 0xF7, 0xC0,
  0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xDF,
  0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xF0, 0x7D, 0xFC, 0x7C, 0xFF, 0xFE,
  0x7F, 0xFE, 0x3E, 0x7E, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xCF,
  0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0x7C, 0x7F, 0x7F, 0xEF, 0x3F, 0xFF, 0x1F, 0x9F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0xE1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0xDF, 0xFC,
  0xF0, 0x6F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xF9,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x13, 0xFE, 0x3F, 0xC3, 0xF8, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x7F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF,
  0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0xF8, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF7, 0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x03, 0xDE, 0x07, 0xC0, 0xF7,
  0x83, 0xF0, 0x3D, 0xE0, 0xFE, 0x1F, 0x7C, 0x3B, 0x87, 0x8F, 0x0E, 0xE1,
  0xE3, 0xC7, 0xB8, 0x78, 0xF1, 0xEF, 0x3C, 0x1E, 0x73, 0xCF, 0x07, 0x9C,
  0x73, 0xC1, 0xEF, 0x1C, 0xF0, 0x7B, 0xC7, 0x38, 0x0E, 0xE1, 0xFE, 0x03,
  0xB8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xBE, 0x0F, 0x8F,
  0x87, 0xC3, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x79,
  0xE0, 0x7C, 0xF8, 0x7C, 0x3C, 0x3C, 0x1F, 0x3E, 0x07, 0xBE, 0x03, 0xE0,
  0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0x77, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0xFC, 0x3F, 0x87, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0xFC,
  0x3F, 0x07, 0x80, 0xFE, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0x07, 0xE1, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x7F, 0x0F, 0xE1, 0xF8, 0x20,
  0x00, 0x3E, 0x01, 0x7F, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 11, 9, 15, 2, -25 },
  { 30, 19, 25, 21, 1, -25 },
  { 90, 15, 29, 18, 2, -27 },
  { 145, 27, 25, 29, 1, -25 },
  { 230, 22, 25, 23, 1, -25 },
  { 299, 4, 9, 8, 2, -25 },
  { 304, 9, 31, 11, 1, -25 },
  { 339, 9, 31, 11, 1, -25 },
  { 374, 15, 15, 18, 1, -27 },
  { 403, 16, 17, 18, 1, -21 },
  { 437, 6, 9, 9, 1, -4 },
  { 444, 9, 3, 11, 1, -11 },
  { 448, 5, 5, 9, 2, -5 },
  { 452, 14, 25, 14, 0, -25 },
  { 496, 16, 25, 18, 1, -25 },
  { 546, 11, 25, 18, 2, -25 },
  { 581, 16, 25, 18, 1, -25 },
  { 631, 16, 25, 18, 1, -25 },
  { 681, 17, 25, 18, 1, -25 },
  { 735, 15, 25, 18, 2, -25 },
  { 782, 16, 25, 18, 1, -25 },
  { 832, 16, 25, 18, 1, -25 },
  { 882, 16, 25, 18, 1, -25 },
  { 932, 16, 25, 18, 1, -25 },
  { 982, 5, 19, 9, 2, -19 },
  { 994, 6, 24, 9, 1, -19 },
  { 1012, 16, 17, 18, 1, -21 },
  { 1046, 16, 10, 18, 1, -17 },
  { 1066, 16, 17, 18, 1, -21 },
  { 1100, 14, 25, 15, 0, -25 },
  { 1144, 25, 28, 29, 2, -25 },
  { 1232, 21, 25, 21, 0, -25 },
  { 1298, 16, 25, 21, 3, -25 },
  { 1348, 17, 25, 20, 2, -25 },
  { 1402, 18, 25, 23, 3, -25 },
  { 1459, 13, 25, 18, 3, -25 },
  { 1500, 13, 25, 17, 3, -25 },
  { 1541, 19, 25, 23, 2, -25 },
  { 1601, 18, 25, 24, 3, -25 },
  { 1658, 10, 25, 12, 1, -25 },
  { 1690, 9, 32, 10, -2, -25 },
  { 1726, 18, 25, 21, 3, -25 },
  { 1783, 13, 25, 17, 3, -25 },
  { 1824, 24, 25, 30, 3, -25 },
  { 1899, 19, 25, 25, 3, -25 },
  { 1959, 21, 25, 25, 2, -25 },
  { 2025, 15, 25, 20, 3, -25 },
  { 2072, 21, 31, 25, 2, -25 },
  { 2154, 17, 25, 21, 3, -25 },
  { 2208, 15, 25, 18, 1, -25 },
  { 2255, 16, 25, 18, 1, -25 },
  { 2305, 18, 25, 24, 3, -25 },
  { 2362, 20, 25, 20, 0, -25 },
  { 2425, 31, 25, 31, 0, -25 },
  { 2522, 20, 25, 20, 0, -25 },
  { 2585, 19, 25, 19, 0, -25 },
  { 2645, 16, 25, 18, 1, -25 },
  { 2695, 8, 31, 11, 2, -25 },
  { 2726, 14, 25, 14, 0, -25 },
  { 2770, 8, 31, 11, 1, -25 },
  { 2801, 17, 15, 19, 1, -25 },
  { 2833, 15, 2, 15, 0, 3 },
  { 2837, 9, 6, 11, 1, -27 },
  { 2844, 15, 19, 19, 1, -19 },
  { 2880, 17, 27, 20, 2, -27 },
  { 2938, 13, 19, 16, 2, -19 },
  { 2969, 16, 27, 20, 2, -27 },
  { 3023, 15, 19, 19, 2, -19 },
  { 3059, 12, 27, 12, 1, -27 },
  { 3100, 16, 27, 20, 2, -19 },
  { 3154, 16, 27, 20, 2, -27 },
  { 3208, 5, 26, 9, 2, -26 },
  { 3225, 8, 34, 9, -1, -26 },
  { 3259, 16, 27, 19, 3, -27 },
  { 3313, 5, 27, 9, 2, -27 },
  { 3330, 26, 19, 31, 2, -19 },
  { 3392, 16, 19, 20, 2, -19 },
  { 3430, 16, 19, 20, 2, -19 },
  { 3468, 17, 27, 20, 2, -19 },
  { 3526, 16, 27, 20, 2, -19 },
  { 3580, 11, 19, 14, 2, -19 },
  { 3607, 13, 19, 16, 1, -19 },
  { 3638, 11, 23, 13, 1, -23 },
  { 3670, 16, 19, 20, 2, -19 },
  { 3708, 17, 19, 17, 0, -19 },
  { 3749, 26, 19, 27, 0, -19 },
  { 3811, 17, 19, 18, 0, -19 },
  { 3852, 17, 27, 18, 0, -19 },
  { 3910, 13, 19, 15, 1, -19 },
  { 3941, 11, 31, 13, 1, -25 },
  { 3984, 4, 35, 18, 7, -27 },
  { 4002, 11, 31, 13, 1, -25 },
  { 4045, 16, 5, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD35PT7B_H_
