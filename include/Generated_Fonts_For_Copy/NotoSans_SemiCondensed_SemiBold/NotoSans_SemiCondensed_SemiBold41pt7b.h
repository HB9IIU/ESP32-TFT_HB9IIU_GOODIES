#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xCE, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xDF, 0x7C, 0xFC,
  0x7D, 0xE1, 0xF7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E,
  0x1E, 0x78, 0x79, 0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x3C,
  0x00, 0xF0, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFB, 0x3C, 0xF8, 0xC1, 0x3E, 0x30, 0x0F,
  0x8C, 0x03, 0xE3, 0x00, 0xFC, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0x7E, 0x00, 0xCF,
  0xC0, 0x31, 0xF0, 0x0C, 0x7E, 0x03, 0x1F, 0xF0, 0xCF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x00,
  0xFF, 0x80, 0x3C, 0x01, 0xFF, 0x80, 0x78, 0x07, 0x8F, 0x01, 0xE0, 0x0F,
  0x1E, 0x03, 0xC0, 0x1E, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x1E, 0x00, 0xF0,
  0x78, 0x78, 0x01, 0xE0, 0xF0, 0xF0, 0x03, 0xC1, 0xE3, 0xC0, 0x03, 0xC3,
  0xC7, 0x80, 0x07, 0x87, 0x9E, 0x1E, 0x0F, 0x1E, 0x3C, 0xFF, 0x1E, 0x3C,
  0xF3, 0xFF, 0x1F, 0xF9, 0xE7, 0xFE, 0x3F, 0xE7, 0x9E, 0x1E, 0x3F, 0x8F,
  0x3C, 0x3C, 0x1C, 0x3C, 0x78, 0x78, 0x00, 0x78, 0xF0, 0xF0, 0x01, 0xE1,
  0xE1, 0xE0, 0x03, 0xC3, 0xC3, 0xC0, 0x0F, 0x07, 0x87, 0x80, 0x1E, 0x0F,
  0x0F, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0xF0, 0x3C, 0x3C, 0x03, 0xC0, 0x3C,
  0xF0, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x7E,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C,
  0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xCF, 0x80, 0x03,
  0xEF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xE0, 0x3E, 0x3F, 0xF8, 0x3F, 0x3F, 0x7E, 0x1F, 0x3F, 0x1F, 0x8F,
  0x9F, 0x07, 0xEF, 0xCF, 0x81, 0xFF, 0xC7, 0xC0, 0x7F, 0xE3, 0xE0, 0x3F,
  0xE1, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0x7F, 0xC0, 0xFC, 0xFD,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x07, 0xC3, 0xE0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x38,
  0x77, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xBC, 0x03, 0xCF, 0x81, 0xF1, 0xF0, 0xF8, 0x7C, 0x06,
  0x0C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x7C, 0xF9,
  0xF3, 0xCF, 0x9F, 0x3C, 0x79, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39,
  0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x1F, 0x87, 0xC7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01,
  0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87,
  0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xF0,
  0x3F, 0x07, 0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0xFD, 0xFF, 0x9F, 0x71, 0xF2,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xFE, 0x03, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1E, 0x07, 0xE2, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1C, 0x07, 0xE4, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xB0, 0x0F,
  0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07,
  0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFA, 0x00, 0x7E, 0xE0, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xF3, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0xFB, 0xFE, 0x3D, 0xFF,
  0xCF, 0x7F, 0xFB, 0xFC, 0x7E, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C,
  0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xFC, 0x7C, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F,
  0x0F, 0x8F, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x07, 0xE7, 0xF0, 0xF8, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0xFD,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFC, 0x1F,
  0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x83, 0xFB, 0xFD, 0xFF,
  0x3F, 0xFF, 0xE3, 0xFF, 0x7C, 0x3F, 0xCF, 0x80, 0xC1, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x11, 0xFF,
  0xFF, 0x7D, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0xFF, 0xFD, 0xF7, 0xC0, 0x1C, 0x7C, 0xFB, 0xF3, 0xE7, 0xC3, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF,
  0x3E, 0x7C, 0xF1, 0xE7, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xE0, 0x3F, 0xF8, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0x30, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x0F, 0x0F, 0x00, 0xF0, 0x1E, 0x3C, 0x1F, 0xFC, 0x79, 0xE0, 0xFF,
  0xF1, 0xE7, 0x87, 0xE7, 0xC3, 0x9C, 0x1E, 0x0F, 0x0F, 0xF0, 0xF0, 0x3C,
  0x3F, 0xC3, 0xC0, 0xF0, 0xFF, 0x0F, 0x03, 0xC3, 0xFC, 0x3C, 0x0F, 0x0F,
  0xF0, 0xE0, 0x78, 0x3F, 0xC3, 0x81, 0xE0, 0xFF, 0x0F, 0x07, 0x83, 0xBC,
  0x3C, 0x1E, 0x1E, 0xF0, 0xF8, 0xFC, 0x7B, 0xC1, 0xFF, 0x7F, 0xC7, 0x87,
  0xFD, 0xFE, 0x1E, 0x0F, 0xE3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x80, 0x0F, 0xC0, 0x1E,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x81,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8,
  0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFC, 0x06, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x06, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x0F,
  0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF,
  0x80, 0x3F, 0x3E, 0x01, 0xFC, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x00, 0x63, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x80, 0x7C,
  0x7F, 0x01, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x83,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xFF, 0xFB, 0xFF, 0x7F, 0xCF, 0xE0, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F,
  0x3E, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x81, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF8,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x78, 0x03, 0xFF, 0xFB, 0xC0, 0x1E, 0xFF, 0xDF, 0x00, 0xF7,
  0xFE, 0x78, 0x0F, 0xBF, 0xF3, 0xC0, 0x79, 0xFF, 0x9E, 0x03, 0xCF, 0xFC,
  0xF8, 0x3E, 0x7F, 0xE3, 0xC1, 0xE3, 0xFF, 0x1E, 0x0F, 0x1F, 0xF8, 0xF8,
  0xF8, 0xFF, 0xC3, 0xC7, 0x87, 0xFE, 0x1E, 0x3C, 0x3F, 0xF0, 0xFB, 0xE1,
  0xFF, 0x83, 0xDE, 0x0F, 0xFC, 0x1E, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF,
  0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x07, 0xFE, 0x07,
  0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFD, 0xF0, 0x0F, 0xFB, 0xE0, 0x1F,
  0xF3, 0xE0, 0x3F, 0xE7, 0xE0, 0x7F, 0xC7, 0xC0, 0xFF, 0x8F, 0xC1, 0xFF,
  0x0F, 0x83, 0xFE, 0x1F, 0x87, 0xFC, 0x1F, 0x0F, 0xF8, 0x3F, 0x1F, 0xF0,
  0x3E, 0x3F, 0xE0, 0x7E, 0x7F, 0xC0, 0x7C, 0xFF, 0x80, 0xFD, 0xFF, 0x00,
  0xFB, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00,
  0x7C, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0x81, 0xFC, 0x7C,
  0x07, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x81, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xEF,
  0x80, 0x1F, 0x80, 0x01, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xE7,
  0xFF, 0xF7, 0xE0, 0x33, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0xBF, 0xFF,
  0xDF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0xC0, 0x3F, 0x7F, 0x03, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x83, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xC0,
  0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80,
  0x01, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x03, 0xF8, 0x03, 0xE7, 0xC0,
  0x3F, 0xC0, 0x7C, 0x3E, 0x03, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0xC0, 0x7C,
  0x3E, 0x07, 0xBC, 0x07, 0xC3, 0xE0, 0x7B, 0xE0, 0x78, 0x1E, 0x07, 0x9E,
  0x0F, 0x81, 0xF0, 0x79, 0xE0, 0xF8, 0x1F, 0x0F, 0x9E, 0x0F, 0x81, 0xF0,
  0xF1, 0xF0, 0xF8, 0x0F, 0x0F, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0,
  0x0F, 0x9F, 0x0F, 0x1F, 0x00, 0xF9, 0xE0, 0xF9, 0xF0, 0x0F, 0x9E, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x7B, 0xE0, 0x07, 0xDE, 0x07, 0xBE, 0x00, 0x7F,
  0xE0, 0x7B, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF8,
  0x3F, 0x01, 0xF0, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF8, 0x7E,
  0x01, 0xF0, 0xF8, 0x03, 0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x01,
  0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x1F, 0x00, 0xF0,
  0xF0, 0x1E, 0x0F, 0x81, 0xE0, 0x78, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x01, 0xC0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xE3, 0xF8, 0x80, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7F, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xFE,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0x7B, 0xFF, 0x3C, 0xFF, 0x1E, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x30, 0x1F, 0x3F, 0xC3, 0xEF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x81, 0xFB,
  0xF8, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xE7, 0xFE, 0x3C, 0x7F, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x02,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x02, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0x83, 0xE1, 0xFE, 0x7C, 0x7F, 0xEF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F, 0xDF, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xEF, 0x80, 0xFD,
  0xF8, 0x3F, 0xBF, 0xFF, 0xF3, 0xFF, 0xBE, 0x3F, 0xF7, 0xC3, 0xF8, 0x78,
  0x00, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x1F, 0x9F,
  0x03, 0xE7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x08, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFF, 0xCF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x01, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC,
  0x1F, 0xDF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0xBF, 0xFF, 0xF3, 0xFF,
  0xBE, 0x3F, 0xF7, 0xC3, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x20, 0x07, 0xE7, 0xC3, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x78, 0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7C, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x8F, 0xFF, 0xEF,
  0xFB, 0xFC, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0,
  0xFC, 0x3E, 0x3F, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x3E, 0x07, 0xC3,
  0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x0F, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x38, 0x07, 0x03, 0xC7, 0xF8, 0x7F, 0x8F, 0x7F, 0xF3,
  0xFF, 0x3D, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x7F, 0x83,
  0xFF, 0xC0, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F,
  0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF8,
  0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03,
  0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8,
  0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01,
  0xFF, 0x80, 0xF8, 0x07, 0xC0, 0x00, 0x30, 0x3C, 0x7F, 0x8F, 0x3F, 0xF3,
  0xDF, 0xFE, 0xFF, 0xFF, 0xBF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF9, 0xF8, 0xFC, 0x1F, 0x9F,
  0x01, 0xF7, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C,
  0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x3F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x1E, 0x3F, 0xC3, 0xCF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFB, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x81, 0xFB, 0xF8,
  0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xF7, 0xFE, 0x3E, 0x7F, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F, 0xFF, 0xF7, 0xFB, 0xFE, 0xFC,
  0x1F, 0xDF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0xBF, 0xFF, 0xF3, 0xFF,
  0xBE, 0x3F, 0xF7, 0xC3, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x77, 0x8F, 0xFC, 0xFF, 0xEF,
  0xEF, 0x7F, 0x7F, 0x83, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xF1,
  0xFF, 0xF7, 0xFF, 0xEF, 0xC3, 0x9F, 0x01, 0x3C, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7F, 0x01, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xF3, 0xC7,
  0xF8, 0xF0, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0x79,
  0xF0, 0x07, 0xDE, 0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0xF8, 0x0F, 0xC0, 0x7D, 0xF0, 0x3F, 0x81, 0xF3, 0xE0, 0x7F, 0x03,
  0xE3, 0xC0, 0xFF, 0x07, 0xC7, 0xC1, 0xDE, 0x0F, 0x0F, 0x87, 0xBC, 0x3E,
  0x1F, 0x0F, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0xF8, 0x3E, 0x38, 0xF1, 0xE0,
  0x7C, 0xF1, 0xE7, 0xC0, 0xF9, 0xE3, 0xCF, 0x80, 0xF3, 0xC3, 0x9F, 0x01,
  0xE7, 0x87, 0xBC, 0x03, 0xEE, 0x0F, 0x78, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xF3, 0xE0, 0x7E, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x0F, 0x8F, 0x80,
  0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xDF,
  0x00, 0xFD, 0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x07, 0xC3, 0xE0,
  0x7E, 0x7E, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x03, 0xF7, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x07, 0x9F, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x04, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x0F, 0xE0, 0xFE, 0x07,
  0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xC1, 0xFE, 0x1F,
  0xF0, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3E,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x5F, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xE0, 0x3F, 0xE8, 0x00, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 29, 11, 2, -29 },
  { 23, 14, 10, 18, 2, -29 },
  { 41, 22, 29, 24, 1, -29 },
  { 121, 18, 33, 22, 2, -31 },
  { 196, 31, 30, 34, 1, -30 },
  { 313, 25, 30, 27, 2, -30 },
  { 407, 6, 10, 10, 2, -29 },
  { 415, 10, 35, 13, 2, -29 },
  { 459, 10, 35, 13, 1, -29 },
  { 503, 18, 17, 21, 1, -31 },
  { 542, 18, 19, 22, 2, -24 },
  { 585, 7, 10, 11, 1, -5 },
  { 594, 10, 4, 13, 1, -13 },
  { 599, 6, 6, 11, 2, -6 },
  { 604, 16, 29, 16, 0, -29 },
  { 662, 18, 30, 22, 2, -30 },
  { 730, 12, 29, 22, 3, -29 },
  { 774, 18, 30, 22, 2, -30 },
  { 842, 18, 30, 22, 2, -30 },
  { 910, 20, 29, 22, 1, -29 },
  { 983, 18, 29, 22, 2, -29 },
  { 1049, 18, 30, 22, 2, -30 },
  { 1117, 19, 29, 22, 1, -29 },
  { 1186, 19, 30, 22, 1, -30 },
  { 1258, 19, 30, 22, 1, -30 },
  { 1330, 6, 23, 11, 2, -23 },
  { 1348, 7, 28, 11, 1, -23 },
  { 1373, 18, 20, 22, 2, -25 },
  { 1418, 18, 11, 22, 2, -20 },
  { 1443, 18, 20, 22, 2, -25 },
  { 1488, 16, 30, 17, 0, -30 },
  { 1548, 30, 32, 34, 2, -29 },
  { 1668, 25, 29, 25, 0, -29 },
  { 1759, 20, 29, 25, 3, -29 },
  { 1832, 20, 30, 24, 2, -30 },
  { 1907, 22, 29, 27, 3, -29 },
  { 1987, 16, 29, 21, 3, -29 },
  { 2045, 16, 29, 20, 3, -29 },
  { 2103, 22, 30, 27, 2, -30 },
  { 2186, 22, 29, 28, 3, -29 },
  { 2266, 12, 29, 14, 1, -29 },
  { 2310, 11, 37, 12, -3, -29 },
  { 2361, 21, 29, 24, 3, -29 },
  { 2438, 16, 29, 20, 3, -29 },
  { 2496, 29, 29, 35, 3, -29 },
  { 2602, 23, 29, 30, 3, -29 },
  { 2686, 25, 30, 29, 2, -30 },
  { 2780, 18, 29, 23, 3, -29 },
  { 2846, 25, 37, 29, 2, -30 },
  { 2962, 21, 29, 24, 3, -29 },
  { 3039, 17, 30, 21, 2, -30 },
  { 3103, 19, 29, 21, 1, -29 },
  { 3172, 21, 29, 28, 3, -29 },
  { 3249, 24, 29, 24, 0, -29 },
  { 3336, 36, 29, 36, 0, -29 },
  { 3467, 23, 29, 23, 0, -29 },
  { 3551, 22, 29, 22, 0, -29 },
  { 3631, 19, 29, 21, 1, -29 },
  { 3700, 9, 36, 13, 3, -29 },
  { 3741, 16, 29, 16, 0, -29 },
  { 3799, 9, 36, 13, 1, -29 },
  { 3840, 20, 18, 22, 1, -29 },
  { 3885, 17, 2, 17, 0, 4 },
  { 3890, 9, 6, 13, 2, -31 },
  { 3897, 17, 23, 22, 2, -23 },
  { 3946, 19, 31, 24, 3, -31 },
  { 4020, 16, 23, 19, 2, -23 },
  { 4066, 19, 31, 24, 2, -31 },
  { 4140, 18, 23, 22, 2, -23 },
  { 4192, 14, 31, 14, 1, -31 },
  { 4247, 19, 33, 24, 2, -23 },
  { 4326, 18, 31, 24, 3, -31 },
  { 4396, 5, 31, 11, 3, -31 },
  { 4416, 10, 41, 11, -2, -31 },
  { 4468, 19, 31, 22, 3, -31 },
  { 4542, 5, 31, 11, 3, -31 },
  { 4562, 30, 23, 36, 3, -23 },
  { 4649, 18, 23, 24, 3, -23 },
  { 4701, 19, 23, 23, 2, -23 },
  { 4756, 19, 33, 24, 3, -23 },
  { 4835, 19, 33, 24, 2, -23 },
  { 4914, 13, 23, 16, 3, -23 },
  { 4952, 15, 23, 18, 2, -23 },
  { 4996, 13, 27, 15, 1, -27 },
  { 5040, 18, 22, 24, 3, -22 },
  { 5090, 20, 22, 20, 0, -22 },
  { 5145, 31, 22, 31, 0, -22 },
  { 5231, 20, 22, 21, 0, -22 },
  { 5286, 20, 32, 21, 0, -22 },
  { 5366, 15, 22, 18, 1, -22 },
  { 5408, 13, 36, 15, 1, -29 },
  { 5467, 4, 41, 21, 8, -31 },
  { 5488, 13, 36, 15, 2, -29 },
  { 5547, 18, 7, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD41PT7B_H_
