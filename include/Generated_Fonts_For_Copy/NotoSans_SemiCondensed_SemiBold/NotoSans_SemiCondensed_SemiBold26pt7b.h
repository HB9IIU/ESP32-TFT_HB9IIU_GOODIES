#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x02, 0xFF, 0x80, 0xE7, 0xE7, 0xE7,
  0xE7, 0xC7, 0xC7, 0xC7, 0x06, 0x30, 0x39, 0xC0, 0xE7, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x8F, 0xFF, 0xFF, 0xFF, 0x1C, 0xC0, 0x63, 0x01, 0x8C, 0x3F,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0x98, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x07,
  0x38, 0x00, 0x06, 0x00, 0x60, 0x0F, 0x03, 0xFE, 0x7F, 0xEF, 0x64, 0xE6,
  0x0E, 0x60, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x6F, 0x06,
  0x78, 0x6E, 0xFF, 0xEF, 0xFC, 0x3F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x38,
  0x06, 0x0F, 0xC1, 0xC3, 0xB8, 0x30, 0x73, 0x8E, 0x0E, 0x71, 0x81, 0x8E,
  0x70, 0x31, 0xCE, 0x07, 0x3B, 0x80, 0xE7, 0x77, 0xCD, 0xCD, 0xFD, 0xFB,
  0xBB, 0x9C, 0x66, 0x30, 0x1C, 0xC6, 0x03, 0x18, 0xC0, 0xE3, 0x18, 0x18,
  0x63, 0x07, 0x0E, 0xE0, 0xC1, 0xFC, 0x38, 0x1F, 0x00, 0x0F, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x38, 0xE0, 0x30, 0xE0, 0x38, 0xE0, 0x39, 0xC0, 0x3F,
  0x80, 0x1F, 0x00, 0x3F, 0x0E, 0x7F, 0x8E, 0x73, 0x8E, 0xF1, 0xDE, 0xE1,
  0xFC, 0xE0, 0xF8, 0xF0, 0x78, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x8F, 0xFF,
  0xFD, 0xB0, 0x0E, 0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x80, 0xC3,
  0x87, 0x1C, 0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0xE3, 0x8E, 0x71, 0xCE, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x47, 0x1F, 0xFF,
  0xFF, 0xC3, 0x80, 0xF8, 0x3B, 0x8F, 0x78, 0xC6, 0x00, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x77, 0x7E, 0xEE, 0xFF, 0xF0, 0x5F, 0xF0, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x00, 0x0F, 0x03,
  0xF8, 0x7F, 0xC7, 0x1E, 0x70, 0xEF, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xF0, 0xE7, 0x0E, 0x7F, 0xC3,
  0xFC, 0x1F, 0x80, 0x07, 0x0F, 0x1F, 0x7F, 0xFF, 0xEF, 0x4F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x07,
  0xFC, 0xFF, 0xC6, 0x1E, 0x40, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xFC, 0xFF, 0xE6, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x1F, 0x81, 0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xE8, 0x0E, 0xF3, 0xEF, 0xFC, 0xFF, 0x80, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x7E, 0x03, 0x70, 0x3B, 0x81, 0x9C, 0x1C, 0xE1, 0xC7,
  0x0C, 0x38, 0xE1, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xF8, 0x7F, 0xCF, 0xFC, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C,
  0x0F, 0xF7, 0xFF, 0xF9, 0xFC, 0x00, 0x03, 0xE0, 0xFE, 0x3F, 0xE3, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x78, 0xEF, 0xCF, 0xFE, 0xF0, 0xEE, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0x0E, 0x7D, 0xE3, 0xFC, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xE7,
  0x0E, 0x70, 0xE7, 0xBC, 0x3F, 0x81, 0xF8, 0x3F, 0xC7, 0x1E, 0xE0, 0xEE,
  0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xE7, 0xFE, 0x3F, 0x80, 0x0F, 0x03, 0xF8,
  0x7F, 0xCF, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F,
  0x7F, 0x73, 0xF6, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x4F, 0xC7, 0xF8,
  0x7E, 0x00, 0xFF, 0xA0, 0x00, 0x01, 0x7F, 0xC0, 0x77, 0x72, 0x00, 0x00,
  0x00, 0x07, 0x77, 0xEE, 0xE0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF0,
  0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x0E, 0x00, 0x80, 0x00, 0x1F, 0x3F, 0xE7,
  0xFD, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x20, 0x1C, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x00,
  0xFF, 0xC0, 0x3E, 0x3C, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x60, 0xF1, 0x9C,
  0x7F, 0x3B, 0x1C, 0x63, 0x67, 0x1C, 0x7C, 0xE3, 0x8F, 0x9C, 0x71, 0xF3,
  0x8E, 0x3E, 0x71, 0xCF, 0xCE, 0x39, 0x98, 0xFF, 0xF3, 0x0F, 0x3C, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x18, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E,
  0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x3F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFC, 0x78, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0xFF, 0xCF, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x78,
  0x27, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0xF8, 0xFF, 0xC3,
  0xFC, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x38, 0x7C, 0xE0, 0x7B, 0x80, 0xEE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xEE, 0x07, 0xB8, 0x3C, 0xFF, 0xF3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF, 0xEF,
  0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xEF,
  0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x01,
  0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0x82, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC3, 0xFF, 0x0F, 0xDC, 0x3F, 0x70, 0x1D, 0xC0, 0x77,
  0x81, 0xCF, 0x07, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xF9, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x39, 0xFF, 0xF8,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0x7C, 0xE0, 0x3F, 0x03,
  0xB8, 0x3D, 0xC3, 0xCE, 0x1C, 0x71, 0xE3, 0x9E, 0x1C, 0xE0, 0xEE, 0x07,
  0xF8, 0x3F, 0xC1, 0xEF, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0,
  0xF7, 0x03, 0xB8, 0x1E, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0xE0, 0xFF, 0xB8, 0x37, 0xEE, 0x1D,
  0xF9, 0xC7, 0x7E, 0x71, 0x9F, 0x9C, 0xE7, 0xE3, 0x39, 0xF8, 0xEC, 0x7E,
  0x3F, 0x1F, 0x87, 0xC7, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x0E, 0x1C, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFB, 0x83,
  0xF3, 0x87, 0xE7, 0x8F, 0xC7, 0x1F, 0x8F, 0x3F, 0x0E, 0x7E, 0x1E, 0xFC,
  0x1D, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xF8, 0x03,
  0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x70, 0x0F, 0x70,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70,
  0x0F, 0x70, 0x0F, 0x78, 0x0E, 0x3C, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xF0, 0xFC, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE,
  0x0E, 0xE0, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC,
  0x3C, 0x3E, 0x78, 0x1E, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x0E,
  0x3C, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xCE, 0x0F,
  0x70, 0x7B, 0x83, 0xDC, 0x1C, 0xE1, 0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0E,
  0x38, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xF7, 0x03, 0xB8, 0x1E, 0x0F,
  0x87, 0xFD, 0xFF, 0x38, 0x2F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x0F, 0xFF, 0xDF, 0xF9,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEF, 0x03, 0xBC,
  0x1E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0xE0, 0x0F, 0xE0, 0x3D, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x3C, 0x70,
  0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x03,
  0x60, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0xE0, 0x38, 0x1F, 0xC0, 0x70,
  0x39, 0xC1, 0xE0, 0x73, 0x83, 0xE0, 0xE7, 0x07, 0xC1, 0xCE, 0x0F, 0x87,
  0x9E, 0x3B, 0x0E, 0x1C, 0x77, 0x1C, 0x38, 0xEE, 0x38, 0x71, 0x9C, 0xF0,
  0xE7, 0x19, 0xC0, 0xEE, 0x3B, 0x81, 0xDC, 0x77, 0x03, 0xB0, 0xEE, 0x07,
  0x60, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x3C,
  0x07, 0x00, 0xF0, 0x1C, 0xF0, 0x78, 0xE0, 0xE1, 0xE3, 0xC1, 0xC7, 0x03,
  0xDC, 0x03, 0xB8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0xEE, 0x03, 0xDE, 0x07, 0x1C, 0x1C, 0x3C, 0x78, 0x38, 0xE0, 0x7B,
  0xC0, 0x78, 0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x38, 0x70, 0xF3,
  0xC1, 0xCE, 0x07, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xE0,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0xFF,
  0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x01,
  0xF8, 0x0C, 0xC0, 0xE7, 0x06, 0x18, 0x70, 0xE3, 0x03, 0x38, 0x1D, 0x80,
  0x70, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0x87, 0x3F, 0x8F, 0xF8, 0xC7, 0x80,
  0x70, 0x0E, 0x0F, 0xCF, 0xFB, 0xE7, 0xF0, 0xFC, 0x1F, 0x87, 0xF9, 0xF7,
  0xFE, 0xFC, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xEF, 0x8F, 0xFC, 0xF9, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xEF, 0xBE, 0xFF, 0xCC, 0xF8, 0x1F, 0xCF, 0xF7,
  0x89, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xF7,
  0x3F, 0xC7, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x1F, 0x73, 0xFF, 0x79, 0xF7, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0x70, 0xF7, 0xDF, 0x3F, 0xF1, 0xF7, 0x1F, 0x83, 0xFC,
  0x78, 0xE7, 0x0E, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x86, 0x3F, 0xE1, 0xFE, 0x07, 0x87, 0xF1, 0xF8, 0xF0, 0x3C,
  0x0F, 0x07, 0xFB, 0xFE, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1F, 0x73, 0xFF, 0x79, 0xF7,
  0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0xF7,
  0x9F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00, 0xF7, 0x1E, 0x7F, 0xE7,
  0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xF7, 0xFF,
  0xF9, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x70, 0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x08, 0x71, 0xC7, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xEF, 0xFB, 0xE0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x1C, 0xE3, 0x8E, 0x78,
  0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x0E, 0x38, 0xE3, 0xCE, 0x1C,
  0xE1, 0xEE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xCF,
  0xCF, 0x9F, 0xFB, 0xFB, 0xEF, 0xE7, 0xF8, 0x78, 0xFE, 0x0E, 0x0F, 0xC1,
  0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83,
  0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xC0, 0xCF, 0xDF, 0xFF,
  0xE7, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x1F, 0xC3, 0xFE, 0x78, 0xE7, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x9E, 0x3F,
  0xE1, 0xF8, 0xEF, 0x8F, 0xFC, 0xF9, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xEF, 0x9E, 0xFF, 0xCE, 0xF8, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0x73, 0xFF, 0x79,
  0xF7, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x70,
  0xF7, 0xDF, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0xCF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x9F, 0xEF, 0x1B, 0x80, 0xF0, 0x1F, 0x07,
  0xF0, 0x7E, 0x07, 0x80, 0xF0, 0x3F, 0x9E, 0xFF, 0xBF, 0xC0, 0x18, 0x0C,
  0x0E, 0x0F, 0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xFA, 0x3F, 0x1F, 0x80, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xFD, 0xF7, 0xFE,
  0x7C, 0xC0, 0xF0, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70,
  0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0xF8, 0x03,
  0x80, 0xF0, 0xF0, 0xF7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x1F, 0x8E, 0x71,
  0xF9, 0xC3, 0x99, 0x9C, 0x39, 0x99, 0xC3, 0xB9, 0xDC, 0x3B, 0x9F, 0x81,
  0xB1, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x00, 0xE0, 0xF0,
  0xF0, 0x7B, 0xC7, 0x8E, 0x38, 0x3B, 0x81, 0xDC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0xC0, 0xEE, 0x0F, 0x78, 0x71, 0xC7, 0x87, 0x78, 0x3C, 0xF0,
  0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x83, 0xB8,
  0x1D, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x05, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0xE0,
  0xE0, 0xF0, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x1C, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0x0F, 0x1F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF8, 0xE0,
  0xF0, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1E, 0x1F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0xF0, 0xF8,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x0F, 0x1F, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF8, 0xF0, 0x7C, 0x1F, 0xFF, 0xCF,
  0xF8, 0x1C,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 8, 7, 11, 2, -19 },
  { 16, 14, 19, 15, 1, -19 },
  { 50, 12, 22, 14, 1, -20 },
  { 83, 19, 19, 21, 1, -19 },
  { 129, 16, 19, 17, 1, -19 },
  { 167, 3, 7, 6, 2, -19 },
  { 170, 7, 23, 8, 1, -19 },
  { 191, 6, 23, 8, 1, -19 },
  { 209, 11, 11, 13, 1, -20 },
  { 225, 12, 12, 14, 1, -15 },
  { 243, 4, 6, 7, 1, -3 },
  { 246, 6, 2, 8, 1, -8 },
  { 248, 3, 4, 7, 2, -4 },
  { 250, 10, 19, 10, 0, -19 },
  { 274, 12, 19, 14, 1, -19 },
  { 303, 8, 19, 14, 2, -19 },
  { 322, 12, 19, 14, 1, -19 },
  { 351, 12, 19, 14, 1, -19 },
  { 380, 13, 19, 14, 0, -19 },
  { 411, 11, 19, 14, 1, -19 },
  { 438, 12, 19, 14, 1, -19 },
  { 467, 12, 19, 14, 1, -19 },
  { 496, 12, 19, 14, 1, -19 },
  { 525, 12, 19, 14, 1, -19 },
  { 554, 3, 14, 7, 2, -14 },
  { 560, 4, 17, 7, 1, -14 },
  { 569, 12, 13, 14, 1, -16 },
  { 589, 12, 8, 14, 1, -13 },
  { 601, 12, 13, 14, 1, -16 },
  { 621, 10, 19, 11, 0, -19 },
  { 645, 19, 21, 21, 1, -19 },
  { 695, 16, 19, 16, 0, -19 },
  { 733, 12, 19, 16, 2, -19 },
  { 762, 13, 19, 15, 1, -19 },
  { 793, 14, 19, 17, 2, -19 },
  { 827, 10, 19, 13, 2, -19 },
  { 851, 10, 19, 13, 2, -19 },
  { 875, 14, 19, 17, 1, -19 },
  { 909, 14, 19, 18, 2, -19 },
  { 943, 7, 19, 9, 1, -19 },
  { 960, 7, 24, 8, -2, -19 },
  { 981, 13, 19, 15, 2, -19 },
  { 1012, 10, 19, 13, 2, -19 },
  { 1036, 18, 19, 22, 2, -19 },
  { 1079, 15, 19, 19, 2, -19 },
  { 1115, 16, 19, 18, 1, -19 },
  { 1153, 12, 19, 15, 2, -19 },
  { 1182, 16, 23, 18, 1, -19 },
  { 1228, 13, 19, 15, 2, -19 },
  { 1259, 11, 19, 13, 1, -19 },
  { 1286, 13, 19, 13, 0, -19 },
  { 1317, 14, 19, 18, 2, -19 },
  { 1351, 15, 19, 15, 0, -19 },
  { 1387, 23, 19, 23, 0, -19 },
  { 1442, 15, 19, 15, 0, -19 },
  { 1478, 14, 19, 14, 0, -19 },
  { 1512, 12, 19, 13, 1, -19 },
  { 1541, 6, 23, 8, 2, -19 },
  { 1559, 10, 19, 10, 0, -19 },
  { 1583, 6, 23, 8, 1, -19 },
  { 1601, 13, 12, 14, 1, -19 },
  { 1621, 11, 2, 11, 0, 2 },
  { 1624, 6, 4, 8, 1, -20 },
  { 1627, 11, 14, 14, 1, -14 },
  { 1647, 12, 20, 15, 2, -20 },
  { 1677, 10, 14, 12, 1, -14 },
  { 1695, 12, 20, 15, 1, -20 },
  { 1725, 12, 14, 14, 1, -14 },
  { 1746, 10, 20, 9, 0, -20 },
  { 1771, 12, 20, 15, 1, -14 },
  { 1801, 11, 20, 15, 2, -20 },
  { 1829, 3, 20, 7, 2, -20 },
  { 1837, 6, 26, 7, -1, -20 },
  { 1857, 12, 20, 14, 2, -20 },
  { 1887, 3, 20, 7, 2, -20 },
  { 1895, 19, 14, 23, 2, -14 },
  { 1929, 11, 14, 15, 2, -14 },
  { 1949, 12, 14, 15, 1, -14 },
  { 1970, 12, 20, 15, 2, -14 },
  { 2000, 12, 20, 15, 1, -14 },
  { 2030, 8, 14, 10, 2, -14 },
  { 2044, 10, 14, 12, 1, -14 },
  { 2062, 9, 17, 10, 0, -17 },
  { 2082, 11, 14, 15, 2, -14 },
  { 2102, 13, 14, 13, 0, -14 },
  { 2125, 20, 14, 20, 0, -14 },
  { 2160, 13, 14, 13, 0, -14 },
  { 2183, 13, 20, 13, 0, -14 },
  { 2216, 9, 14, 11, 1, -14 },
  { 2232, 8, 23, 10, 1, -19 },
  { 2255, 3, 26, 13, 5, -20 },
  { 2265, 8, 23, 10, 1, -19 },
  { 2288, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD26PT7B_H_
