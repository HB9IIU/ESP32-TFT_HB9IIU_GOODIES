#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x07, 0xE7, 0xFB, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xCF, 0xC1, 0xC0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xCF, 0x07, 0x8F, 0xF1, 0xE0, 0x11, 0xFC, 0x3C, 0x00,
  0x3F, 0x87, 0x80, 0x07, 0xF0, 0xF0, 0x00, 0xFE, 0x1E, 0x00, 0x1F, 0xE3,
  0xC0, 0x01, 0xFE, 0x78, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xEF, 0xFC, 0x00, 0x3C, 0x7F, 0x80, 0x07, 0x87, 0xF0, 0x00, 0xF0,
  0xFE, 0x00, 0x1E, 0x1F, 0xE0, 0x03, 0xC3, 0xFA, 0x00, 0x78, 0x7F, 0x70,
  0x0F, 0x1F, 0xEF, 0xC1, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x00,
  0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC,
  0x3F, 0x0F, 0xF8, 0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0xF0, 0x7E, 0x0F, 0xC7,
  0xE3, 0xFF, 0xE0, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC,
  0x7F, 0x3F, 0x07, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0x1F, 0x8F,
  0xC1, 0xF8, 0x3F, 0xF0, 0xFC, 0x3F, 0x03, 0xE0, 0x3F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x0F,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x00, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x01,
  0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F,
  0xCF, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0x83, 0xFC, 0x0F, 0xF8,
  0xFF, 0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0x0F, 0xF7, 0xF8, 0x3F,
  0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0x00, 0x1F,
  0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0x00, 0xF8, 0x0E, 0x7E, 0x1F, 0x0F, 0xCF, 0xFB, 0xEF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFF,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3E, 0x03, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0x10, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x18, 0x3F, 0x3F, 0xDF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x0E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F,
  0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF,
  0xCF, 0xF7, 0xE1, 0xFE, 0x78, 0x3F, 0xC6, 0x07, 0xF8, 0x80, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xF0, 0x07, 0xFC, 0x1E, 0x00,
  0x3F, 0xC0, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE0, 0x3F, 0xF0, 0xF0, 0x03, 0xFE, 0x18, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xA0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x60, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0xC0, 0x00, 0xFF, 0xBE, 0x00, 0x7F,
  0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xF1, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF, 0x07, 0xF7, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x7F, 0xEF, 0xFC, 0x01, 0xFE,
  0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F,
  0x80, 0x0F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xF8,
  0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01,
  0xFE, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFF,
  0x7F, 0x80, 0x3F, 0xF7, 0xFC, 0x07, 0xFF, 0x3F, 0xFB, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF7, 0xE0, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xCF,
  0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0x10, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x3F, 0x3F, 0xDF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1F, 0x9F, 0xEF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0x07, 0x00, 0x06, 0x03, 0xF0, 0xFF,
  0x1F, 0xE3, 0xFE, 0x7F, 0xCF, 0xF1, 0xFE, 0x1F, 0x80, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0x83, 0xFF, 0x3C, 0x00, 0xFF,
  0x10, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0xFC, 0x07, 0xE3, 0xF0, 0x07, 0xFF, 0xF0, 0x7E, 0x3F, 0x01, 0xFF, 0xFF,
  0x03, 0xE3, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x7E, 0x03, 0xFC, 0x3F, 0x03,
  0xF7, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF7,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xFF, 0xC0,
  0xFC, 0x03, 0xF0, 0x1F, 0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0xC1, 0xF8,
  0x03, 0xF0, 0x1F, 0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0x81, 0xF8, 0x03,
  0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xFF, 0xC0, 0xFC, 0x07, 0xF0, 0x3E,
  0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xEF, 0xC0, 0xFE, 0x0F, 0xF0, 0x7C, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x7F, 0xFE, 0xFF, 0xF8, 0x7E, 0x03,
  0xFF, 0xC7, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0,
  0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8,
  0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0x01, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xBF, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0x7F,
  0x80, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0x83, 0xFF, 0x00, 0x1C, 0x1F, 0xF8, 0x00, 0x10, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x08, 0x3F, 0xFC, 0x03, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xF8, 0x1F, 0xFC, 0x00, 0x1C, 0x0F, 0xFC, 0x00,
  0x02, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xDF,
  0xC0, 0x0F, 0xFF, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F,
  0xE3, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x03, 0xF8, 0x7F, 0xF8, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x41, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xDF, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0xFF, 0x7E, 0x00, 0x07,
  0xF7, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0xFF, 0xFD, 0xFC, 0x00, 0x1F, 0x9F,
  0xFF, 0x9F, 0x80, 0x03, 0xF3, 0xFF, 0xF3, 0xF0, 0x00, 0xFC, 0xFF, 0xFE,
  0x7F, 0x00, 0x1F, 0x9F, 0xFF, 0xCF, 0xE0, 0x03, 0xF3, 0xFF, 0xF8, 0xFC,
  0x00, 0xFE, 0x7F, 0xFF, 0x1F, 0xC0, 0x1F, 0x8F, 0xFF, 0xE3, 0xF8, 0x03,
  0xF1, 0xFF, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0xFF, 0x87, 0xF0, 0x1F, 0x87,
  0xFF, 0xF0, 0xFE, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xFF,
  0xC1, 0xF8, 0x1F, 0x83, 0xFF, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0xFF, 0x03,
  0xF0, 0xFE, 0x0F, 0xFF, 0xE0, 0x7E, 0x1F, 0x81, 0xFF, 0xFC, 0x0F, 0xE3,
  0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x9F, 0x80,
  0xFF, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0x00,
  0x1F, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xF9, 0xFF,
  0x00, 0x7F, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xE1,
  0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF,
  0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F,
  0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0x87, 0xFF, 0xE0, 0x1F, 0xE1,
  0xFF, 0xF8, 0x03, 0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0x9F, 0xFF, 0x80, 0x1F,
  0xE7, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFB, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F, 0xFE, 0xFF, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xEF, 0xF0, 0x0F, 0xFD, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xEF, 0xF8, 0xFF, 0x80,
  0x3C, 0xFF, 0x80, 0x02, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F,
  0xC7, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFE, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xBF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x7F, 0x00, 0x7F,
  0x01, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xE3,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03,
  0xF8, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xF0, 0x1F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x00, 0x3F,
  0x9F, 0x80, 0x3F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7C,
  0x0F, 0xFC, 0x1C, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xE1, 0xFD, 0xFF, 0x80, 0x7F, 0x7F, 0x80, 0x1F, 0xDF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0x7F, 0xC1,
  0xFF, 0xDF, 0xFF, 0xFB, 0xF3, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0x3F, 0x1F,
  0xFF, 0x87, 0xC1, 0xFF, 0x81, 0xF0, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x01, 0xE0, 0x0F, 0xF1, 0xFF, 0xC0, 0xFF, 0x3F,
  0xFE, 0x0F, 0xF7, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFD, 0xFF, 0xCF, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xEF, 0xF8,
  0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0xC0,
  0x1F, 0xEF, 0xFE, 0x03, 0xFE, 0xFF, 0xFD, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFE, 0xFF, 0xFF, 0x8F, 0xE7, 0xFF, 0xF0, 0xFE, 0x3F, 0xFE, 0x0F, 0xC1,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0xF0, 0x04, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x09,
  0xFF, 0x00, 0x73, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0xF8, 0xFF,
  0x07, 0xFF, 0xCF, 0xF0, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0xF7, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0x7F, 0xC0, 0x1F,
  0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFF,
  0x7F, 0xC0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xC7,
  0xF0, 0x1F, 0xF0, 0x3F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x01, 0xFC, 0x7F,
  0x80, 0x3F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0x1F, 0xF0, 0x00, 0xC3, 0xFF, 0x81, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x00, 0x2E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xEF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF8, 0x7F,
  0x07, 0xFF, 0xC7, 0xF0, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0xF7, 0xF1, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFB, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0x7F, 0x80, 0x1F,
  0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x3F, 0xF9, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xCF,
  0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0x30, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x20, 0x00, 0x3F, 0xE3, 0x80, 0x07, 0xFC, 0x3F, 0xF7, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x1C, 0x01, 0xFE, 0x3F, 0xF8, 0x3F, 0xCF, 0xFF, 0xC7,
  0xF3, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x01, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x01,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0xC0,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC,
  0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0x0F, 0xFF, 0x83, 0xFF, 0xF1, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x83, 0xFF, 0x83,
  0xF0, 0xFF, 0xFC, 0x7F, 0x3F, 0xFF, 0xCF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC3,
  0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F,
  0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE1,
  0xFF, 0xC0, 0xFE, 0x3F, 0xFE, 0x0F, 0xE7, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF9, 0xFF, 0xCF, 0xFE, 0x03, 0xFE, 0xFF,
  0xC0, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xEF, 0xF8,
  0x01, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xF0, 0xFF,
  0x3F, 0xFE, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x01, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0x07, 0xFF, 0xC7, 0xF0, 0xFF, 0xFE,
  0x7F, 0x1F, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0xF7,
  0xFC, 0x03, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x03,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xCF, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0x30,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F,
  0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xE0, 0x3E, 0x3F, 0x80, 0x08, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFD, 0x00, 0x07, 0xFB, 0x80, 0x0F, 0xE7, 0xF0, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x05, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0C, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xC7, 0xFF, 0xF9, 0xF8, 0x7F, 0xFE, 0x3F,
  0x07, 0xFF, 0x07, 0xE0, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xBE, 0x01, 0xFC, 0x3F, 0x80, 0xFD, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xEF, 0xC0, 0xFF, 0x0F, 0xF0, 0x3E, 0x7E, 0x07,
  0xF0, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFC, 0x7E, 0x1F, 0xE0, 0x7F, 0x07, 0xC3, 0xF0, 0xFE, 0x01,
  0xFC, 0x7E, 0x1F, 0x87, 0xF0, 0x0F, 0xE3, 0xF0, 0x7C, 0x3F, 0x80, 0x7F,
  0x1F, 0x83, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x1F, 0x9F, 0xC0, 0x0F, 0xC7,
  0xC0, 0xFC, 0xFE, 0x00, 0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0x03, 0xFB, 0xF0,
  0x1F, 0x3F, 0x00, 0x1F, 0xDF, 0x80, 0xFD, 0xF8, 0x00, 0x7E, 0xF8, 0x07,
  0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xBE, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00,
  0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13, 0xFF,
  0xC0, 0x03, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xEC, 0x00, 0x3F, 0xFC, 0x80,
  0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 45, 16, 4, -44 },
  { 52, 19, 16, 27, 4, -44 },
  { 90, 34, 44, 36, 1, -44 },
  { 277, 27, 50, 32, 3, -46 },
  { 446, 46, 45, 50, 2, -44 },
  { 705, 39, 45, 41, 2, -44 },
  { 925, 7, 16, 15, 4, -44 },
  { 939, 15, 54, 19, 3, -44 },
  { 1041, 15, 54, 19, 2, -44 },
  { 1143, 27, 26, 31, 2, -46 },
  { 1231, 28, 29, 32, 2, -36 },
  { 1333, 11, 15, 16, 2, -7 },
  { 1354, 15, 7, 19, 2, -20 },
  { 1368, 9, 10, 16, 4, -9 },
  { 1380, 23, 44, 24, 1, -44 },
  { 1507, 28, 45, 32, 2, -44 },
  { 1665, 19, 44, 32, 4, -44 },
  { 1770, 28, 44, 32, 2, -44 },
  { 1924, 27, 45, 32, 2, -44 },
  { 2076, 30, 44, 32, 1, -44 },
  { 2241, 26, 45, 32, 3, -44 },
  { 2388, 28, 45, 32, 2, -44 },
  { 2546, 28, 44, 32, 2, -44 },
  { 2700, 28, 45, 32, 2, -44 },
  { 2858, 28, 45, 32, 2, -44 },
  { 3016, 9, 35, 16, 4, -34 },
  { 3056, 11, 42, 16, 2, -34 },
  { 3114, 28, 30, 32, 2, -37 },
  { 3219, 28, 17, 32, 2, -30 },
  { 3279, 28, 30, 32, 2, -37 },
  { 3384, 24, 45, 26, 0, -44 },
  { 3519, 44, 49, 50, 3, -44 },
  { 3789, 37, 44, 37, 0, -44 },
  { 3993, 29, 44, 37, 5, -44 },
  { 4153, 30, 45, 35, 3, -44 },
  { 4322, 32, 44, 40, 5, -44 },
  { 4498, 23, 44, 31, 5, -44 },
  { 4625, 23, 44, 30, 5, -44 },
  { 4752, 33, 45, 40, 3, -44 },
  { 4938, 32, 44, 42, 5, -44 },
  { 5114, 17, 44, 21, 2, -44 },
  { 5208, 17, 56, 18, -4, -44 },
  { 5327, 31, 44, 36, 5, -44 },
  { 5498, 23, 44, 30, 5, -44 },
  { 5625, 43, 44, 53, 5, -44 },
  { 5862, 34, 44, 44, 5, -44 },
  { 6049, 37, 45, 43, 3, -44 },
  { 6258, 27, 44, 34, 5, -44 },
  { 6407, 37, 54, 43, 3, -44 },
  { 6657, 31, 44, 36, 5, -44 },
  { 6828, 25, 45, 31, 3, -44 },
  { 6969, 29, 44, 31, 1, -44 },
  { 7129, 31, 45, 41, 5, -44 },
  { 7304, 35, 44, 35, 0, -44 },
  { 7497, 53, 44, 53, 0, -44 },
  { 7789, 34, 44, 35, 0, -44 },
  { 7976, 33, 44, 33, 0, -44 },
  { 8158, 28, 44, 31, 2, -44 },
  { 8312, 14, 54, 20, 4, -44 },
  { 8407, 23, 44, 24, 1, -44 },
  { 8534, 14, 54, 20, 2, -44 },
  { 8629, 30, 27, 33, 2, -44 },
  { 8731, 26, 4, 26, 0, 5 },
  { 8744, 15, 10, 19, 2, -47 },
  { 8763, 26, 35, 33, 2, -34 },
  { 8877, 28, 47, 35, 4, -46 },
  { 9042, 23, 35, 28, 3, -34 },
  { 9143, 28, 47, 35, 3, -46 },
  { 9308, 27, 35, 32, 3, -34 },
  { 9427, 22, 47, 21, 1, -47 },
  { 9557, 28, 49, 35, 3, -34 },
  { 9729, 27, 46, 35, 4, -46 },
  { 9885, 8, 46, 16, 4, -46 },
  { 9931, 15, 61, 16, -3, -46 },
  { 10046, 28, 46, 33, 5, -46 },
  { 10207, 8, 46, 16, 4, -46 },
  { 10253, 45, 34, 53, 4, -34 },
  { 10445, 27, 34, 35, 4, -34 },
  { 10560, 29, 35, 34, 3, -34 },
  { 10687, 28, 49, 35, 4, -34 },
  { 10859, 28, 49, 35, 3, -34 },
  { 11031, 19, 34, 24, 4, -34 },
  { 11112, 23, 35, 27, 2, -34 },
  { 11213, 20, 41, 23, 1, -40 },
  { 11316, 27, 34, 35, 4, -33 },
  { 11431, 30, 33, 30, 0, -33 },
  { 11555, 45, 33, 47, 1, -33 },
  { 11741, 29, 33, 31, 1, -33 },
  { 11861, 30, 48, 31, 0, -33 },
  { 12041, 23, 33, 26, 2, -33 },
  { 12136, 20, 54, 23, 1, -44 },
  { 12271, 6, 60, 31, 12, -46 },
  { 12316, 20, 54, 23, 2, -44 },
  { 12451, 28, 9, 32, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD61PT7B_H_
