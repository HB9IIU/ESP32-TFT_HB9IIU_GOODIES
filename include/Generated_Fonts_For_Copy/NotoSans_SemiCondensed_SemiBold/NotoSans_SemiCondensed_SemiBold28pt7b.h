#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0xEF, 0xFE, 0xE7,
  0xF3, 0xF9, 0xFC, 0xEE, 0x37, 0x1B, 0x8C, 0x07, 0x38, 0x0C, 0x70, 0x18,
  0xC0, 0x71, 0x80, 0xE3, 0x01, 0xCE, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x60,
  0x38, 0xC0, 0x71, 0x80, 0xE7, 0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x1C,
  0x60, 0x38, 0xC0, 0x73, 0x80, 0xC7, 0x01, 0x8E, 0x00, 0x02, 0x00, 0x10,
  0x07, 0xF8, 0x7F, 0xE7, 0xFF, 0x79, 0x13, 0xC8, 0x1E, 0x40, 0x7A, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0x38, 0x09, 0xE0, 0x4E, 0xE2,
  0xF7, 0xFF, 0xBF, 0xF8, 0x1E, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x3E,
  0x03, 0x83, 0xF0, 0x38, 0x39, 0xC1, 0xC1, 0xCE, 0x1C, 0x0E, 0x30, 0xE0,
  0x71, 0x8E, 0x03, 0x8C, 0x70, 0x1C, 0x67, 0x00, 0xE7, 0x3B, 0xE3, 0x3B,
  0xBF, 0x9F, 0x9D, 0xCC, 0x7D, 0xCC, 0x70, 0x0E, 0x63, 0x80, 0xE3, 0x1C,
  0x07, 0x18, 0xE0, 0x70, 0xC7, 0x03, 0x86, 0x38, 0x38, 0x39, 0x81, 0xC0,
  0xFC, 0x1C, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xE3,
  0xC0, 0x38, 0xF0, 0x0E, 0x38, 0x03, 0xDE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF8, 0x79, 0xEF, 0x1C, 0xF1, 0xEF, 0x3C, 0x3F, 0x8F,
  0x07, 0xE3, 0xC1, 0xF0, 0xF0, 0x7C, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x38, 0xF1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0x70, 0xE1, 0xC3, 0xC3, 0x87, 0x07,
  0x07, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x70,
  0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x8F, 0x1C, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x0C, 0x63, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xF8, 0x1F, 0x83,
  0x9C, 0x79, 0xE1, 0x08, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x7B, 0x9C, 0xEE, 0x73, 0x80, 0xFF, 0xFF, 0xF8, 0xEF,
  0xFE, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x78, 0x00, 0x1F, 0x81, 0xFE, 0x1F, 0xF8, 0xF1, 0xE7,
  0x07, 0x78, 0x3B, 0xC1, 0xDE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3B, 0xC1, 0xCE, 0x0E, 0x78, 0xF1, 0xFF, 0x0F, 0xF8,
  0x3F, 0x00, 0x07, 0x0F, 0x1F, 0x7F, 0xF7, 0xE7, 0x47, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F, 0x83,
  0xFF, 0x3F, 0xF8, 0xC1, 0xE4, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0x1F, 0xFC,
  0xC1, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x1F, 0xC0, 0xF8, 0x07,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0E, 0x80, 0xF7, 0xFF,
  0xBF, 0xF8, 0xFF, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0x70, 0x1D, 0xC0, 0x67, 0x03, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0C,
  0x1C, 0x70, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x60, 0x7F, 0xC7, 0xFE, 0x21, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x80, 0xFF, 0xFE, 0xFF, 0xE7, 0xF8, 0x07, 0xE0, 0xFF,
  0x0F, 0xF8, 0x78, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x70, 0xEF, 0xE7,
  0xFF, 0xBE, 0x3D, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xEE, 0x0F, 0x78,
  0x71, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0x7C, 0xE0, 0xE7, 0x07, 0x38,
  0x39, 0xC3, 0xCF, 0xBC, 0x3F, 0xC0, 0x7C, 0x0F, 0xF0, 0xF3, 0xC7, 0x0F,
  0x78, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x73, 0xEF, 0x9F, 0xF8, 0x3F, 0x80,
  0x1F, 0x81, 0xFE, 0x1F, 0xF9, 0xE1, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xDC,
  0x0F, 0xF0, 0x7F, 0x87, 0xDF, 0xFE, 0x7F, 0xE1, 0xE7, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0xE3, 0xFE, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0xF6, 0x00,
  0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x7B, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xB9, 0xCE, 0xE7, 0x38, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xF0,
  0x0E, 0x00, 0x40, 0x00, 0x3F, 0x9F, 0xF9, 0xFF, 0xA0, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xC0, 0xF0, 0x3C, 0x01, 0xC3, 0x80, 0x06, 0x1C, 0x3E, 0x39,
  0xC7, 0xF8, 0xCE, 0x38, 0xC7, 0x63, 0x8E, 0x3B, 0x18, 0x71, 0xF8, 0xC3,
  0x8F, 0xC6, 0x1C, 0x7E, 0x30, 0xE3, 0x71, 0x87, 0x19, 0x8E, 0x7D, 0xCC,
  0x3F, 0x7C, 0x70, 0xE1, 0xC1, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x06,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x0F, 0x1E, 0x07, 0x07, 0x03, 0x83, 0x83, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x03, 0xBC, 0x01, 0xFE, 0x00,
  0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF,
  0x07, 0xBC, 0x1C, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0x3C, 0x1E, 0xF0, 0x3B,
  0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0,
  0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x82, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x04, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0xFF,
  0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x03, 0xBC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0x78, 0x1E, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0xDF, 0xFB, 0xFF, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xFA, 0x3F,
  0xF8, 0xFF, 0xF3, 0xE0, 0x27, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xBC, 0x0F, 0x7C, 0x1E, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xF0, 0xFF, 0xFF, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x9E, 0xFE, 0xFC, 0x70, 0xF0,
  0x3D, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x38, 0x3C, 0xF0,
  0x7B, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xDE, 0x0F, 0x3C, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0x71, 0xE0, 0xF3, 0xC0, 0xF7, 0x81,
  0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xEE, 0x03, 0x7E, 0xE0, 0x77, 0xEE, 0x07, 0x7E, 0x70,
  0x67, 0xF7, 0x0E, 0x7F, 0x70, 0xE7, 0xF7, 0x0E, 0x7F, 0x39, 0xC7, 0xF3,
  0x9C, 0x7F, 0x39, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F,
  0x0F, 0x07, 0xF0, 0xF0, 0x7F, 0x0F, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x07, 0xEF, 0x07, 0xEF, 0x07, 0xE7, 0x87, 0xE3,
  0x87, 0xF3, 0xC7, 0xF1, 0xC7, 0xF1, 0xE7, 0xF0, 0xE7, 0xF0, 0xF7, 0xF0,
  0x77, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0x07,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE7, 0x80, 0x73, 0xC0, 0x3D,
  0xE0, 0x1E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00,
  0x77, 0x00, 0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE1,
  0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0x9F, 0xBF, 0xF9,
  0xFF, 0x8F, 0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE7,
  0x80, 0x73, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x1E, 0x3C, 0x0F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xF3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x3C, 0xF0, 0x73, 0xC1, 0xEF, 0x03, 0xBC, 0x0F, 0x1F, 0xE3, 0xFF, 0x7F,
  0xE7, 0x02, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x0F, 0xC0, 0xFF, 0xFE, 0xFF,
  0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0x78, 0x3C, 0xFF, 0xF8, 0xFF,
  0xE0, 0x7F, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78,
  0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x1E,
  0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0xF0, 0x3C,
  0x07, 0x70, 0x3C, 0x0F, 0x70, 0x3E, 0x0F, 0x70, 0x7E, 0x0E, 0x78, 0x7E,
  0x0E, 0x38, 0x76, 0x0E, 0x38, 0x77, 0x1E, 0x38, 0xE7, 0x1C, 0x3C, 0xE7,
  0x1C, 0x1C, 0xE7, 0x1C, 0x1C, 0xE3, 0xBC, 0x1C, 0xC3, 0xB8, 0x1D, 0xC3,
  0xB8, 0x1F, 0xC3, 0xB8, 0x0F, 0xC1, 0xB8, 0x0F, 0xC1, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF0, 0xF8, 0x1E, 0x78, 0x1E, 0x3C,
  0x3C, 0x3C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E,
  0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x78, 0x1C, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x1E, 0xE0, 0x3D, 0xE0, 0xF1, 0xC1, 0xE3, 0xC3, 0x83, 0x8F, 0x07, 0x9C,
  0x07, 0x78, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8F, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x7F, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x1D, 0xC0, 0x77,
  0x03, 0x8E, 0x0E, 0x38, 0x70, 0x71, 0xC1, 0xC6, 0x03, 0xB8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x70, 0x70, 0x70, 0x3F, 0xC3, 0xFE, 0x30, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x1F, 0xF7, 0xFF, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x0F,
  0xFB, 0xF7, 0xF7, 0x3E, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xBF, 0x1D, 0xFC, 0xF9, 0xF7, 0x83, 0xBC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x77, 0x87, 0xBF, 0xFD,
  0xDF, 0xCE, 0x7C, 0x00, 0x1F, 0xE7, 0xFD, 0xF3, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x17, 0xFE, 0x7F, 0xC7,
  0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7E,
  0xE7, 0xFF, 0x7D, 0xFB, 0xC3, 0xDC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0x70, 0x7B, 0xC3, 0xDF, 0xFE, 0x7F, 0x71, 0xF3, 0x80,
  0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x07, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x23, 0xEF, 0x1F, 0xF8, 0x3F,
  0x80, 0x0F, 0xE3, 0xF8, 0x79, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0xE7, 0xFC,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1F, 0xB9, 0xFF, 0xDF, 0x3E, 0xF0,
  0xF7, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x1E,
  0xF0, 0xF7, 0xFF, 0x9F, 0xDC, 0x7C, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xD8,
  0x3C, 0xFF, 0xE7, 0xFE, 0x0F, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xEF, 0xEE, 0xFF, 0xFD, 0xFF, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x70, 0xEF, 0xF4, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xE0, 0x1C, 0x3C, 0x78, 0x40, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3D, 0xFB,
  0xE7, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x83, 0xDC, 0x1C, 0xE1, 0xC7, 0x1E, 0x39, 0xE1, 0xDE, 0x0E, 0xF0, 0x7F,
  0x83, 0xFE, 0x1E, 0x70, 0xE3, 0xC7, 0x0F, 0x38, 0x39, 0xC1, 0xEE, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEF, 0xC7, 0xE7,
  0xFF, 0x7F, 0xBE, 0x7F, 0x7D, 0xE1, 0xF0, 0xEF, 0x0F, 0x07, 0x78, 0x38,
  0x3F, 0x81, 0xC1, 0xFC, 0x0E, 0x0F, 0xE0, 0x70, 0x7F, 0x03, 0x83, 0xF8,
  0x1C, 0x1F, 0xC0, 0xE0, 0xFE, 0x07, 0x07, 0xF0, 0x38, 0x3F, 0x81, 0xC1,
  0xE0, 0xEF, 0xEF, 0xFF, 0xFD, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70,
  0x1F, 0xC0, 0xFF, 0xC7, 0xCF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xEF, 0x03,
  0xBC, 0x0F, 0xF0, 0x3B, 0xC0, 0xE7, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0xFF,
  0x80, 0xFC, 0x00, 0xEF, 0xC7, 0x7F, 0x3E, 0x7D, 0xE0, 0xEF, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0xFF,
  0x77, 0xF3, 0x9F, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x1F, 0xB9, 0xFF, 0xDF, 0x7E, 0xF0, 0xF7, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x1E, 0xF0, 0xF7, 0xFF,
  0x9F, 0xDC, 0x7C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0xE7, 0xF7, 0xFF, 0xFF, 0x0F, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x3F, 0xDF, 0xFF, 0x0B,
  0x80, 0xF0, 0x3E, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xF0, 0x1E, 0x07, 0xF7,
  0xFF, 0xEF, 0xF0, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x7F, 0xBF, 0xE3, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1F,
  0xC7, 0xF0, 0xFC, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF,
  0x3F, 0x30, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9E, 0x1E, 0x38, 0x70, 0xE1,
  0xC3, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x78, 0x3B, 0x87, 0xC3, 0xDC, 0x3E,
  0x1C, 0xF1, 0xF0, 0xE7, 0x8D, 0xC7, 0x1C, 0xEE, 0x78, 0xE7, 0x33, 0x87,
  0x39, 0x9C, 0x3D, 0x8E, 0xE0, 0xEC, 0x77, 0x07, 0xE3, 0xF0, 0x3F, 0x0F,
  0x80, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x00, 0xF8, 0x7D, 0xE1,
  0xE3, 0xCF, 0x07, 0x38, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x0F,
  0xC0, 0x3F, 0x81, 0xEE, 0x0F, 0x3C, 0x38, 0x71, 0xE1, 0xEF, 0x03, 0xC0,
  0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9E, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0xCF,
  0x07, 0x38, 0x1C, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x1F, 0x80, 0x7C,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x83, 0xC0, 0xE0,
  0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x0F,
  0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF0, 0xF8,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x3E, 0x07, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xF0, 0x78, 0xFC, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE3, 0xE1, 0xE0, 0x7C, 0x0F, 0xFD, 0xFF,
  0xFF, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 20, 7, 2, -20 },
  { 11, 9, 7, 12, 2, -20 },
  { 19, 15, 20, 16, 1, -20 },
  { 57, 13, 23, 15, 1, -21 },
  { 95, 21, 20, 23, 1, -20 },
  { 148, 18, 20, 19, 1, -20 },
  { 193, 3, 7, 7, 2, -20 },
  { 196, 7, 24, 9, 1, -20 },
  { 217, 7, 24, 9, 1, -20 },
  { 238, 12, 12, 14, 1, -21 },
  { 256, 13, 14, 15, 1, -17 },
  { 279, 5, 7, 7, 1, -3 },
  { 284, 7, 3, 9, 1, -9 },
  { 287, 4, 4, 7, 2, -4 },
  { 289, 11, 20, 11, 0, -20 },
  { 317, 13, 20, 15, 1, -20 },
  { 350, 8, 20, 15, 2, -20 },
  { 370, 13, 20, 15, 1, -20 },
  { 403, 13, 20, 15, 1, -20 },
  { 436, 14, 20, 15, 0, -20 },
  { 471, 12, 20, 15, 1, -20 },
  { 501, 13, 20, 15, 1, -20 },
  { 534, 13, 20, 15, 1, -20 },
  { 567, 13, 20, 15, 1, -20 },
  { 600, 13, 20, 15, 1, -20 },
  { 633, 4, 15, 7, 2, -15 },
  { 641, 5, 19, 7, 1, -15 },
  { 653, 13, 14, 15, 1, -17 },
  { 676, 13, 8, 15, 1, -14 },
  { 689, 13, 14, 15, 1, -17 },
  { 712, 11, 20, 12, 0, -20 },
  { 740, 21, 22, 23, 1, -20 },
  { 798, 17, 20, 17, 0, -20 },
  { 841, 14, 20, 17, 2, -20 },
  { 876, 14, 20, 16, 1, -20 },
  { 911, 15, 20, 19, 2, -20 },
  { 949, 11, 20, 14, 2, -20 },
  { 977, 11, 20, 14, 2, -20 },
  { 1005, 15, 20, 19, 2, -20 },
  { 1043, 15, 20, 19, 2, -20 },
  { 1081, 8, 20, 10, 1, -20 },
  { 1101, 8, 26, 8, -2, -20 },
  { 1127, 15, 20, 16, 2, -20 },
  { 1165, 11, 20, 14, 2, -20 },
  { 1193, 20, 20, 24, 2, -20 },
  { 1243, 16, 20, 20, 2, -20 },
  { 1283, 17, 20, 20, 1, -20 },
  { 1326, 13, 20, 16, 2, -20 },
  { 1359, 17, 25, 20, 1, -20 },
  { 1413, 14, 20, 16, 2, -20 },
  { 1448, 12, 20, 14, 1, -20 },
  { 1478, 14, 20, 14, 0, -20 },
  { 1513, 15, 20, 19, 2, -20 },
  { 1551, 16, 20, 16, 0, -20 },
  { 1591, 24, 20, 24, 0, -20 },
  { 1651, 16, 20, 16, 0, -20 },
  { 1691, 15, 20, 15, 0, -20 },
  { 1729, 13, 20, 14, 1, -20 },
  { 1762, 6, 24, 9, 2, -20 },
  { 1780, 11, 20, 11, 0, -20 },
  { 1808, 6, 24, 9, 1, -20 },
  { 1826, 14, 12, 15, 1, -20 },
  { 1847, 12, 2, 12, 0, 2 },
  { 1850, 7, 4, 9, 1, -21 },
  { 1854, 12, 15, 15, 1, -15 },
  { 1877, 13, 21, 16, 2, -21 },
  { 1912, 11, 15, 13, 1, -15 },
  { 1933, 13, 21, 16, 1, -21 },
  { 1968, 13, 15, 15, 1, -15 },
  { 1993, 11, 21, 9, 0, -21 },
  { 2022, 13, 22, 16, 1, -15 },
  { 2058, 12, 21, 16, 2, -21 },
  { 2090, 4, 21, 7, 2, -21 },
  { 2101, 7, 28, 7, -1, -21 },
  { 2126, 13, 21, 15, 2, -21 },
  { 2161, 3, 21, 7, 2, -21 },
  { 2169, 21, 15, 24, 2, -15 },
  { 2209, 12, 15, 16, 2, -15 },
  { 2232, 14, 15, 16, 1, -15 },
  { 2259, 13, 22, 16, 2, -15 },
  { 2295, 13, 22, 16, 1, -15 },
  { 2331, 9, 15, 11, 2, -15 },
  { 2348, 10, 15, 12, 1, -15 },
  { 2367, 10, 19, 10, 0, -19 },
  { 2391, 12, 15, 16, 2, -15 },
  { 2414, 14, 15, 14, 0, -15 },
  { 2441, 21, 15, 21, 0, -15 },
  { 2481, 14, 15, 14, 0, -15 },
  { 2508, 14, 22, 14, 0, -15 },
  { 2547, 10, 15, 12, 1, -15 },
  { 2566, 8, 24, 11, 1, -20 },
  { 2590, 2, 28, 14, 6, -21 },
  { 2597, 9, 24, 11, 1, -20 },
  { 2624, 13, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD28PT7B_H_
