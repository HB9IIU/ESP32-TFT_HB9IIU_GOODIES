#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x70, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F,
  0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0x7E, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xCF, 0x0F, 0x8F, 0xF8, 0xF0, 0x18,
  0xFF, 0x0F, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0xFF, 0x0F, 0x00, 0x0F, 0xF0,
  0xF0, 0x00, 0xFF, 0x0F, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x7F, 0xEF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x7F, 0xE0,
  0x00, 0xF3, 0xFE, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0x00, 0x0F,
  0x0F, 0xF0, 0x00, 0xF0, 0x7F, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0xF0, 0xFF,
  0xF8, 0x0F, 0x1F, 0xEF, 0xF0, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x3F,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE1, 0xFC, 0x1F, 0xC0, 0x7E,
  0x07, 0xE1, 0xF8, 0x7F, 0xF0, 0x7E, 0x07, 0xE3, 0xF8, 0xFF, 0xF8, 0x7F,
  0x0F, 0xE3, 0xF1, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xE3, 0xFC, 0xFE, 0x1F, 0xFF, 0x8F, 0xE3, 0xF0, 0x7E, 0x0F,
  0xFF, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x03,
  0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFE,
  0x0F, 0xFC, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0x83, 0xFC, 0x07, 0xFE, 0x7F, 0x81, 0xFE, 0x01, 0xFF,
  0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x1F, 0x80, 0x67, 0xE1, 0xF8, 0x3E,
  0x7F, 0xDF, 0xBF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7E, 0x07, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xF9,
  0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x7F,
  0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFC, 0xFF, 0x7F, 0x0F, 0xF3, 0xE0, 0xFF, 0x1C,
  0x0F, 0xF1, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0x87, 0xF0, 0x07, 0xFC,
  0x1F, 0x00, 0x1F, 0xE0, 0x60, 0x00, 0xFF, 0x82, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0x83, 0xE0, 0x07, 0xFC, 0x1C,
  0x00, 0x1F, 0xE0, 0x40, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x40, 0x00, 0x0F, 0xFB,
  0x80, 0x00, 0xFF, 0xDF, 0x80, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x1F,
  0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF9, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x0C, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE8, 0x00,
  0x03, 0xFE, 0xE0, 0x00, 0x7F, 0xCF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x80, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF,
  0x80, 0xFE, 0x3F, 0xFE, 0x0F, 0xE7, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x07, 0xFE, 0xFF, 0xC0,
  0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xE3, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC3,
  0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD,
  0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0x3F, 0xFD, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xFC, 0xFE, 0x0F,
  0xFF, 0xCF, 0xF0, 0x1F, 0xFC, 0x7F, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xC3, 0x80, 0x0F, 0xC3, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF8, 0xFF, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC7, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0xF8, 0xF0,
  0x03, 0xFE, 0x10, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0x83, 0xF0, 0x03, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3E, 0x1F, 0x80, 0x7F, 0xFF, 0xE0, 0x7E, 0x3F, 0x01, 0xFF, 0xFF, 0xC0,
  0xFC, 0xFC, 0x07, 0xF8, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xF3, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x00, 0xFC, 0x07,
  0xEF, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F,
  0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0x01, 0xF7,
  0xE0, 0x7E, 0x00, 0xFE, 0x03, 0xEF, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xDF,
  0x81, 0xF8, 0x03, 0xF0, 0x1F, 0xBF, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x7E,
  0x07, 0xF0, 0x1F, 0xE0, 0xFC, 0xFC, 0x07, 0xE0, 0x3F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xF1, 0xFF, 0xC7, 0xE1, 0xF8, 0x0F, 0xFF, 0xEF, 0xFF, 0xC3, 0xF0,
  0x1F, 0xFF, 0x9F, 0xFF, 0x07, 0xE0, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xE0,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x1F,
  0xFC, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0x03, 0xFF, 0xE3, 0xFC,
  0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x07,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0x00,
  0x3C, 0x0F, 0xFC, 0x00, 0x0C, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x0C, 0x07, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0xF0, 0xFF,
  0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xF3,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x07, 0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xBF, 0xF0, 0x3F,
  0xFC, 0x00, 0x3C, 0x1F, 0xFC, 0x00, 0x02, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x0F, 0xF1, 0xFF,
  0xC0, 0x03, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xD0, 0x3F, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC,
  0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFE,
  0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x7E, 0xFF, 0xFD, 0xFC, 0x00, 0x07, 0xF7,
  0xFF, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0xFF, 0x3F, 0x80, 0x01, 0xF9, 0xFF,
  0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xFF, 0xCF, 0xE0, 0x00, 0xFE, 0xFF, 0xFF,
  0x3F, 0x00, 0x07, 0xE7, 0xFF, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0xFF, 0xCF,
  0xE0, 0x03, 0xF9, 0xFF, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xFF, 0xF1, 0xFC,
  0x01, 0xFC, 0x7F, 0xFF, 0x8F, 0xE0, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0xFF, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F,
  0x87, 0xFF, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xE0, 0x7F,
  0xFF, 0x81, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0x1F, 0x80, 0xFF, 0xFF, 0x01, 0xF9, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xEF, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xE7,
  0xF8, 0x00, 0x7F, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0xE3, 0xFC, 0x00, 0x7F,
  0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0xE1, 0xFE, 0x00, 0x7F, 0xFF, 0x0F, 0xF0,
  0x07, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xC0, 0x7F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F,
  0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0x00, 0xFF,
  0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0xF0,
  0x07, 0xFC, 0x7F, 0xFF, 0x00, 0x3F, 0xC7, 0xFF, 0xF0, 0x01, 0xFE, 0x7F,
  0xFF, 0x00, 0x1F, 0xF7, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFB, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x0F, 0xFE, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFE, 0xFF, 0x1F,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x2F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0x00, 0x78, 0x7F, 0x80, 0x03, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE8, 0x00, 0x03, 0xFD, 0x80, 0x00, 0x7F,
  0xBE, 0x00, 0x1F, 0xF7, 0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x3F,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0x20,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x03, 0xFF,
  0x7F, 0xC0, 0x7F, 0xF7, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0xF7, 0xF3, 0xFF,
  0xFF, 0x7F, 0x1F, 0xFF, 0xE7, 0xF0, 0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0x03,
  0xF0, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x1F, 0xC7,
  0xFF, 0xC0, 0xFE, 0x7F, 0xFF, 0x07, 0xF7, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3,
  0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x01, 0xFF,
  0x3F, 0xF8, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0x7F, 0xFF, 0xC3, 0xF1, 0xFF, 0xFC, 0x1F, 0x87, 0xFF, 0xC0, 0xFC, 0x1F,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xE0, 0xF8, 0x7F, 0xC0, 0x08, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x63, 0xFF, 0x00,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0xFC, 0x7F, 0x07, 0xFF, 0xF3,
  0xF8, 0x7F, 0xFF, 0xDF, 0xC7, 0xFF, 0xFE, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0x07, 0xFF, 0x9F, 0xF0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF0,
  0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF,
  0xCF, 0xE0, 0x7F, 0xFC, 0x3F, 0x01, 0xFF, 0x81, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x02, 0x3F, 0xF0, 0x01, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xDE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0x1F, 0xC1,
  0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xBF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFB, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x03,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xE1, 0xFF, 0xFF, 0x7F,
  0x0F, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0x3F, 0xC0, 0x7F, 0xE1, 0xFE, 0x00,
  0x30, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF9, 0x00, 0x00, 0x7F,
  0x8E, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xFC, 0x0F, 0xE3,
  0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0x8F, 0xEF, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xEF, 0xFC, 0x03, 0xFE, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x83, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0xE7,
  0xF0, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x01, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC1, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x01,
  0xFC, 0xFF, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x7F, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFB, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x01, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xE1, 0xFC, 0x00,
  0xFF, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x7F,
  0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x8F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3, 0xFF, 0xF0, 0xFC, 0x7F, 0xFF, 0x8F,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0,
  0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x03,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x0F, 0xF8, 0x07, 0xE1,
  0xFF, 0xF0, 0x3F, 0x1F, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x7F,
  0xCF, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xDF, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0x07, 0xF1, 0xFF, 0xF0, 0x3F, 0x87,
  0xFE, 0x01, 0xFC, 0x03, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81,
  0xF8, 0x1F, 0xFF, 0x1F, 0xC1, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0xF7, 0xF1,
  0xFF, 0xFF, 0xBF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xE7, 0xFC,
  0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xEF, 0xE1, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0x3F,
  0xC0, 0x7F, 0xE1, 0xFE, 0x00, 0x30, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFE, 0xFC, 0x3F, 0xEF, 0xC7, 0xFE, 0xFC, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0x82, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xC0, 0x1E, 0x7F,
  0x00, 0x08, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x10, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x03, 0x80, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x07,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F,
  0x1F, 0xFF, 0xF3, 0xF8, 0x7F, 0xFF, 0x1F, 0xC0, 0xFF, 0xE0, 0xFE, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xE7, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xCF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x7E, 0x01, 0xFC, 0x3F, 0x80,
  0x7E, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFD, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFB, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0x8F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0x1F, 0x83, 0xFC, 0x07, 0xF0, 0xFE, 0x3F, 0x07, 0xF0, 0x0F, 0xE1, 0xF8,
  0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x7E, 0x3F, 0xC0, 0x3F, 0xC7, 0xE0,
  0xFC, 0x7F, 0x80, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0xFC, 0x07,
  0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xE0, 0x1F,
  0xBF, 0x80, 0x07, 0xF7, 0xC0, 0x1F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x3E,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFC,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x41, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x09, 0xFF, 0xF8, 0x00, 0xDF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x80, 0x00, 0x7F,
  0xC0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 9, 47, 17, 4, -46 },
  { 54, 20, 17, 28, 4, -46 },
  { 97, 35, 46, 38, 1, -46 },
  { 299, 28, 53, 34, 3, -49 },
  { 485, 48, 47, 53, 2, -46 },
  { 767, 41, 47, 43, 2, -46 },
  { 1008, 8, 17, 15, 4, -46 },
  { 1025, 16, 56, 20, 3, -46 },
  { 1137, 16, 56, 20, 2, -46 },
  { 1249, 28, 28, 32, 2, -49 },
  { 1347, 28, 31, 34, 3, -38 },
  { 1456, 11, 15, 17, 2, -7 },
  { 1477, 16, 7, 20, 2, -21 },
  { 1491, 9, 10, 17, 4, -9 },
  { 1503, 24, 46, 25, 1, -46 },
  { 1641, 29, 47, 34, 2, -46 },
  { 1812, 20, 46, 34, 4, -46 },
  { 1927, 29, 46, 34, 2, -46 },
  { 2094, 29, 47, 34, 2, -46 },
  { 2265, 32, 46, 34, 1, -46 },
  { 2449, 28, 47, 34, 3, -46 },
  { 2614, 28, 47, 34, 3, -46 },
  { 2779, 29, 46, 34, 2, -46 },
  { 2946, 29, 47, 34, 2, -46 },
  { 3117, 29, 47, 34, 2, -46 },
  { 3288, 9, 36, 17, 4, -35 },
  { 3329, 11, 43, 17, 2, -35 },
  { 3389, 29, 32, 34, 2, -39 },
  { 3505, 28, 19, 34, 3, -32 },
  { 3572, 28, 32, 34, 3, -39 },
  { 3684, 26, 47, 27, 0, -46 },
  { 3837, 47, 51, 53, 3, -46 },
  { 4137, 39, 46, 39, 0, -46 },
  { 4362, 31, 46, 39, 5, -46 },
  { 4541, 32, 47, 37, 3, -46 },
  { 4729, 34, 46, 42, 5, -46 },
  { 4925, 24, 46, 33, 5, -46 },
  { 5063, 24, 46, 31, 5, -46 },
  { 5201, 34, 47, 42, 4, -46 },
  { 5401, 34, 46, 44, 5, -46 },
  { 5597, 18, 46, 22, 2, -46 },
  { 5701, 17, 59, 19, -4, -46 },
  { 5827, 33, 46, 38, 5, -46 },
  { 6017, 25, 46, 31, 5, -46 },
  { 6161, 45, 46, 55, 5, -46 },
  { 6420, 36, 46, 46, 5, -46 },
  { 6627, 39, 47, 45, 3, -46 },
  { 6857, 28, 46, 36, 5, -46 },
  { 7018, 39, 57, 45, 3, -46 },
  { 7296, 32, 46, 38, 5, -46 },
  { 7480, 27, 47, 32, 3, -46 },
  { 7639, 31, 46, 33, 1, -46 },
  { 7818, 33, 47, 43, 5, -46 },
  { 8012, 37, 46, 37, 0, -46 },
  { 8225, 56, 46, 56, 0, -46 },
  { 8547, 36, 46, 36, 0, -46 },
  { 8754, 35, 46, 35, 0, -46 },
  { 8956, 29, 46, 33, 2, -46 },
  { 9123, 15, 56, 21, 4, -46 },
  { 9228, 24, 46, 25, 1, -46 },
  { 9366, 14, 56, 21, 2, -46 },
  { 9464, 31, 29, 35, 2, -46 },
  { 9577, 27, 4, 27, 0, 6 },
  { 9591, 15, 10, 20, 3, -49 },
  { 9610, 28, 36, 34, 2, -35 },
  { 9736, 29, 50, 37, 5, -49 },
  { 9918, 25, 36, 29, 3, -35 },
  { 10031, 29, 50, 37, 3, -49 },
  { 10213, 28, 36, 34, 3, -35 },
  { 10339, 23, 49, 22, 1, -49 },
  { 10480, 29, 50, 37, 3, -35 },
  { 10662, 28, 49, 37, 5, -49 },
  { 10834, 9, 48, 17, 4, -48 },
  { 10888, 16, 63, 17, -3, -48 },
  { 11014, 29, 49, 34, 5, -49 },
  { 11192, 7, 49, 17, 5, -49 },
  { 11235, 46, 35, 56, 5, -35 },
  { 11437, 28, 35, 37, 5, -35 },
  { 11560, 30, 36, 36, 3, -35 },
  { 11695, 29, 50, 37, 5, -35 },
  { 11877, 29, 50, 37, 3, -35 },
  { 12059, 20, 35, 25, 5, -35 },
  { 12147, 23, 36, 28, 3, -35 },
  { 12251, 21, 43, 24, 1, -42 },
  { 12364, 29, 36, 37, 4, -35 },
  { 12495, 32, 35, 32, 0, -35 },
  { 12635, 47, 35, 49, 1, -35 },
  { 12841, 31, 35, 32, 1, -35 },
  { 12977, 32, 50, 32, 0, -35 },
  { 13177, 24, 35, 28, 2, -35 },
  { 13282, 21, 56, 24, 1, -46 },
  { 13429, 6, 64, 32, 13, -49 },
  { 13477, 21, 56, 24, 2, -46 },
  { 13624, 29, 9, 34, 2, -27 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD64PT7B_H_
