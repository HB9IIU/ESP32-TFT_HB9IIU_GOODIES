#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xCF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x9F,
  0x83, 0x00, 0xFF, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7E, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFE, 0x70, 0x78, 0xFE, 0x1C, 0x02, 0x3F, 0x87,
  0x00, 0x0F, 0xE1, 0xC0, 0x03, 0xF8, 0x70, 0x00, 0xFE, 0x1C, 0x00, 0x3F,
  0xC7, 0x00, 0x0F, 0xF9, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x1C, 0xFF, 0x80, 0x07, 0x1F, 0xE0, 0x01, 0xC3, 0xF8, 0x00, 0x70, 0x7F,
  0x00, 0x1C, 0x1F, 0xC0, 0x07, 0x0F, 0xEC, 0x01, 0xC3, 0xFB, 0xE0, 0x71,
  0xFE, 0xFF, 0x9F, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC3, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x87, 0xE1, 0xFF,
  0x07, 0xE0, 0xF8, 0x7C, 0x3F, 0xF8, 0x7E, 0x1F, 0x8F, 0xC7, 0xFF, 0xC3,
  0xF3, 0xF8, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x1F, 0x8F, 0xC7, 0xE1, 0xFF,
  0xE1, 0xF1, 0xF8, 0x3E, 0x1F, 0xFE, 0x3F, 0x1F, 0x83, 0xF0, 0x7F, 0x83,
  0xE1, 0xF8, 0x3F, 0x01, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC1,
  0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xEF, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xF0,
  0x3F, 0xFF, 0x80, 0x3F, 0x83, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0xEF, 0xF0,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x7F, 0x87, 0xF0, 0x0F, 0xF3, 0xF8, 0x7F, 0x80, 0x7F, 0xFF,
  0xC3, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0x00,
  0x1F, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0x00, 0xF8, 0x06, 0x7C,
  0x3E, 0x0F, 0x9F, 0xEF, 0x9F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0x03, 0xE0, 0x01, 0x80, 0x60, 0x00, 0x20, 0x10, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC7, 0xF3,
  0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE,
  0x7E, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F,
  0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xDF,
  0xDF, 0xE7, 0xFF, 0xF1, 0xFD, 0xF8, 0x7F, 0x3C, 0x1F, 0xC6, 0x07, 0xF1,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC1, 0xF8, 0x07, 0xFC, 0x1E, 0x00, 0x7F, 0x83, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFE, 0x3F, 0xF8, 0xF8, 0x03, 0xFE, 0x18, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xE3, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xDE, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x0F,
  0xF0, 0x0F, 0xC7, 0xFF, 0x81, 0xF9, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0x87,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x1F, 0xF7, 0xFE, 0x01,
  0xFE, 0xFF, 0x80, 0x1F, 0xDF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xF3, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80,
  0x3F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3,
  0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE7, 0xF8, 0x03, 0xFC,
  0xFF, 0x81, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC3,
  0xFE, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xF7, 0xF8, 0x07, 0xFE, 0xFF,
  0x81, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xEF,
  0xC1, 0xFF, 0xF9, 0xF8, 0x1F, 0xFE, 0x3F, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x30, 0x7F, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xD0, 0x00, 0x00, 0x08, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFE, 0xFF, 0x3F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x3F, 0x06, 0x00, 0x04, 0x07, 0xE3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xCF, 0xFE, 0x3C,
  0x01, 0xFE, 0x10, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0xFF, 0xE0, 0xFC,
  0x7E, 0x03, 0xFF, 0xFC, 0x1F, 0x9F, 0x80, 0xFF, 0xFF, 0x81, 0xF3, 0xF0,
  0x3F, 0xC3, 0xF0, 0x3E, 0x7C, 0x0F, 0xE0, 0x7E, 0x07, 0xCF, 0x81, 0xF8,
  0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xFE, 0x0F, 0xC0, 0x3F,
  0x03, 0xFF, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xFE, 0x07, 0xC0, 0x1F, 0x81, 0xFF, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0xF8,
  0x1F, 0x00, 0x7E, 0x07, 0xDF, 0x03, 0xE0, 0x0F, 0xC0, 0xFB, 0xE0, 0x7C,
  0x01, 0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0x7F, 0x03, 0xEF, 0x81, 0xF8, 0x0F,
  0xE0, 0xFD, 0xF8, 0x1F, 0x83, 0xFC, 0x1F, 0x3F, 0x03, 0xF8, 0xFF, 0xCF,
  0xE7, 0xE0, 0x7F, 0xFE, 0xFF, 0xF8, 0x7C, 0x07, 0xFF, 0xCF, 0xFE, 0x0F,
  0xC0, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0xFF,
  0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE,
  0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0xFC,
  0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0xFE,
  0x00, 0x3F, 0xEF, 0xE0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x1C, 0x1F, 0xF8, 0x00, 0x20,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x20, 0xFF, 0xE0, 0x0F, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0xF8, 0x7F, 0x00,
  0x1F, 0xF8, 0xFE, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x1F, 0xF3, 0xF8, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xE3, 0xF8, 0x01, 0xFF, 0x87, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0x3C, 0x0F, 0xF8, 0x00, 0x04, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x7F, 0x1F, 0xF0,
  0x00, 0x7F, 0x1F, 0xF8, 0x00, 0x7F, 0x0F, 0xFC, 0x00, 0x7F, 0x07, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0xC7, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF8,
  0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F,
  0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0xFE, 0x00, 0xFF,
  0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0,
  0xFE, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x3F,
  0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x7E,
  0x00, 0x07, 0xEF, 0xFF, 0xBF, 0x80, 0x03, 0xF7, 0xFF, 0xCF, 0xC0, 0x01,
  0xFB, 0xFF, 0xE7, 0xE0, 0x01, 0xFD, 0xFF, 0xFB, 0xF8, 0x00, 0xFC, 0xFF,
  0xFC, 0xFC, 0x00, 0x7E, 0x7F, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0xFF, 0x3F,
  0x80, 0x3F, 0x1F, 0xFF, 0x8F, 0xC0, 0x1F, 0x8F, 0xFF, 0xC7, 0xE0, 0x1F,
  0xC7, 0xFF, 0xE3, 0xF8, 0x0F, 0xC3, 0xFF, 0xF0, 0xFC, 0x07, 0xE1, 0xFF,
  0xF8, 0x7E, 0x03, 0xF0, 0xFF, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFC, 0x7E, 0x07, 0xFF, 0xE0, 0x7E, 0x3F, 0x03, 0xFF,
  0xF0, 0x3F, 0x3F, 0x01, 0xFF, 0xF8, 0x1F, 0xDF, 0x80, 0xFF, 0xFC, 0x07,
  0xEF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xCF, 0xF0, 0x03,
  0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0x00,
  0x7F, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0x0F, 0xE0, 0x1F, 0xFF, 0x87, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xC1, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xFE, 0x03,
  0xFC, 0x3F, 0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0x80, 0x3F, 0x8F, 0xFF, 0xC0,
  0x1F, 0xE7, 0xFF, 0xE0, 0x07, 0xF3, 0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0xFB, 0xF8, 0x03, 0xFE, 0xFE, 0x00, 0x7F,
  0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x0F, 0xFB, 0xF8, 0x07, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x17, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xFE,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F,
  0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03,
  0xFC, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0x80, 0x3C, 0xFF, 0x00, 0x0C, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x68, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xF8,
  0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F,
  0xBF, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xBF, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x1F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xF1, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xE0,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x03, 0xF3, 0xF8,
  0x00, 0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0x03, 0xFE, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xF8, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x3F, 0xF7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFC, 0xFF, 0xFE, 0x3E, 0x3F, 0xFE, 0x1F, 0x07, 0xFE,
  0x0F, 0x80, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x10,
  0x01, 0xFC, 0x3F, 0xF0, 0x3F, 0x8F, 0xFF, 0x07, 0xF3, 0xFF, 0xF0, 0xFE,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xE7, 0xFE, 0x7F, 0xE0, 0x3F,
  0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFD, 0xFF, 0x00,
  0x7F, 0xBF, 0xF0, 0x1F, 0xF7, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xDF, 0xFF, 0xE3, 0xFB, 0xFF, 0xF8, 0x7E, 0x3F, 0xFE, 0x0F, 0xC1, 0xFF,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0x9F,
  0x8F, 0xF0, 0x06, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x17, 0xFC, 0x01, 0xCF, 0xFE, 0x7F, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0x80, 0xFE, 0x07,
  0xFE, 0x1F, 0xC1, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x7F, 0x1F, 0xFF, 0xEF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xCF, 0xFF, 0xBF, 0xE0, 0x3F, 0xF7, 0xF8,
  0x03, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF,
  0xF0, 0x1F, 0xF9, 0xFF, 0x8F, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFD,
  0xFC, 0x3F, 0xFF, 0x3F, 0x83, 0xFF, 0xC3, 0xF0, 0x3F, 0xF0, 0x7E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF,
  0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x30, 0xFF, 0xC0, 0x7C, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xE0,
  0x40, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0xFC,
  0x1F, 0xFE, 0x3F, 0x87, 0xFF, 0xE7, 0xF1, 0xFF, 0xFE, 0xFE, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFC, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xEF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x07, 0xFD, 0xFF, 0x01, 0xFF,
  0x9F, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xDF, 0xC3, 0xFF,
  0xF3, 0xF8, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0x0F, 0xE0, 0x06, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF1, 0x00, 0x03, 0xFE, 0x3C, 0x00, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x01, 0xC0, 0x3F, 0x87, 0xFE, 0x0F, 0xE3, 0xFF, 0xE3, 0xFB, 0xFF, 0xFC,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFB, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x7E,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x1F, 0x83, 0xFF, 0x00, 0xFF, 0xC3, 0xF1, 0xFF, 0xF0, 0x7F, 0xFC, 0x7E,
  0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0x07, 0xFE, 0x0F,
  0xC7, 0xFF, 0xE3, 0xF3, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xC7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFF, 0x00,
  0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x83, 0xFF, 0x03, 0xF0,
  0xFF, 0xF0, 0x7F, 0x3F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFC, 0x7F, 0xE7, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0,
  0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xDF, 0xF0, 0x07, 0xFB, 0xFF, 0x01, 0xFF, 0x7F,
  0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFD, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF,
  0x87, 0xF3, 0xFF, 0xE0, 0xFE, 0x1F, 0xF0, 0x1F, 0xC0, 0x20, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xE0, 0xFC, 0x1F, 0xFE, 0x3F, 0x87, 0xFF, 0xE7, 0xF1, 0xFF, 0xFE, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0x80,
  0x3F, 0xEF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x07, 0xFD, 0xFF,
  0x01, 0xFF, 0x9F, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xDF,
  0xC3, 0xFF, 0xF3, 0xF8, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0x0F, 0xE0, 0x07,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0x9F, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xEF, 0xCF, 0xFD, 0xFD, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xC2, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F,
  0x1F, 0xC0, 0x0C, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x81, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x8C,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x60, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xDF,
  0xE0, 0x3F, 0xF7, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF,
  0xCF, 0xFF, 0xF3, 0xF1, 0xFF, 0xF8, 0xFC, 0x1F, 0xF8, 0x3F, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xEF, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFB, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xBE, 0x01, 0xFC, 0x3F, 0x81, 0xFB, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xBF, 0x03, 0xF8, 0x3F, 0x81, 0xF9, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0x1F, 0x03, 0xF8, 0x1F, 0xC3, 0xF1, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF1, 0xF8, 0x7F, 0x00, 0xFC, 0x3E, 0x0F,
  0x87, 0xE0, 0x0F, 0xE3, 0xE0, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x0F, 0xCF,
  0xE0, 0x0F, 0xE7, 0xE0, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x07, 0xCF, 0xC0,
  0x07, 0xE7, 0xC0, 0x7C, 0xFC, 0x00, 0x7E, 0x7C, 0x07, 0xCF, 0xC0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF9,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x07,
  0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC7,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x27, 0xFF, 0x80, 0x0D, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xF6, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x1C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 43, 16, 3, -42 },
  { 50, 20, 15, 26, 3, -42 },
  { 88, 32, 42, 35, 1, -42 },
  { 256, 26, 48, 31, 3, -45 },
  { 412, 44, 44, 49, 2, -43 },
  { 654, 37, 44, 39, 2, -43 },
  { 858, 8, 15, 14, 3, -42 },
  { 873, 14, 51, 19, 3, -42 },
  { 963, 14, 51, 19, 2, -42 },
  { 1053, 26, 26, 30, 2, -45 },
  { 1138, 27, 28, 31, 2, -35 },
  { 1233, 10, 15, 16, 2, -7 },
  { 1252, 15, 6, 18, 2, -19 },
  { 1264, 9, 9, 16, 3, -8 },
  { 1275, 22, 42, 23, 1, -42 },
  { 1391, 27, 44, 31, 2, -43 },
  { 1540, 18, 42, 31, 4, -42 },
  { 1635, 27, 43, 31, 2, -43 },
  { 1781, 26, 44, 31, 2, -43 },
  { 1924, 29, 42, 31, 1, -42 },
  { 2077, 25, 43, 31, 3, -42 },
  { 2212, 27, 44, 31, 2, -43 },
  { 2361, 27, 42, 31, 2, -42 },
  { 2503, 27, 44, 31, 2, -43 },
  { 2652, 27, 44, 31, 2, -43 },
  { 2801, 9, 34, 16, 3, -33 },
  { 2840, 10, 41, 16, 2, -33 },
  { 2892, 27, 29, 31, 2, -36 },
  { 2990, 27, 17, 31, 2, -29 },
  { 3048, 27, 29, 31, 2, -36 },
  { 3146, 24, 44, 25, 0, -43 },
  { 3278, 43, 47, 49, 3, -42 },
  { 3531, 36, 42, 36, 0, -42 },
  { 3720, 28, 42, 36, 5, -42 },
  { 3867, 29, 44, 34, 3, -43 },
  { 4027, 31, 42, 39, 5, -42 },
  { 4190, 22, 42, 30, 5, -42 },
  { 4306, 22, 42, 29, 5, -42 },
  { 4422, 32, 44, 39, 3, -43 },
  { 4598, 31, 42, 41, 5, -42 },
  { 4761, 16, 42, 20, 2, -42 },
  { 4845, 16, 54, 17, -4, -42 },
  { 4953, 30, 42, 35, 5, -42 },
  { 5111, 22, 42, 29, 5, -42 },
  { 5227, 41, 42, 51, 5, -42 },
  { 5443, 33, 42, 43, 5, -42 },
  { 5617, 36, 44, 42, 3, -43 },
  { 5815, 26, 42, 33, 5, -42 },
  { 5952, 36, 53, 42, 3, -43 },
  { 6191, 29, 42, 35, 5, -42 },
  { 6344, 24, 44, 30, 3, -43 },
  { 6476, 28, 42, 30, 1, -42 },
  { 6623, 30, 43, 40, 5, -42 },
  { 6785, 34, 42, 34, 0, -42 },
  { 6964, 52, 42, 52, 0, -42 },
  { 7237, 33, 42, 33, 0, -42 },
  { 7411, 32, 42, 32, 0, -42 },
  { 7579, 28, 42, 30, 1, -42 },
  { 7726, 14, 51, 19, 4, -42 },
  { 7816, 22, 42, 23, 1, -42 },
  { 7932, 13, 51, 19, 2, -42 },
  { 8015, 30, 26, 32, 1, -42 },
  { 8113, 25, 4, 25, 0, 5 },
  { 8126, 14, 9, 19, 2, -45 },
  { 8142, 25, 34, 32, 2, -33 },
  { 8249, 27, 46, 34, 4, -45 },
  { 8405, 22, 34, 27, 3, -33 },
  { 8499, 27, 46, 34, 3, -45 },
  { 8655, 26, 34, 31, 3, -33 },
  { 8766, 21, 45, 20, 1, -45 },
  { 8885, 27, 47, 34, 3, -33 },
  { 9044, 26, 45, 34, 4, -45 },
  { 9191, 8, 44, 16, 4, -44 },
  { 9235, 14, 58, 16, -2, -44 },
  { 9337, 28, 45, 32, 4, -45 },
  { 9495, 7, 45, 16, 4, -45 },
  { 9535, 43, 33, 52, 4, -33 },
  { 9713, 26, 33, 34, 4, -33 },
  { 9821, 28, 34, 33, 3, -33 },
  { 9940, 27, 47, 34, 4, -33 },
  { 10099, 27, 47, 34, 3, -33 },
  { 10258, 19, 33, 23, 4, -33 },
  { 10337, 22, 34, 26, 2, -33 },
  { 10431, 19, 40, 22, 1, -39 },
  { 10526, 26, 33, 34, 4, -32 },
  { 10634, 29, 32, 29, 0, -32 },
  { 10750, 44, 32, 45, 1, -32 },
  { 10926, 28, 32, 30, 1, -32 },
  { 11038, 29, 46, 30, 0, -32 },
  { 11205, 22, 32, 25, 2, -32 },
  { 11293, 19, 51, 22, 1, -42 },
  { 11415, 6, 59, 30, 12, -45 },
  { 11460, 19, 51, 22, 2, -42 },
  { 11582, 27, 9, 31, 2, -25 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD59PT7B_H_
