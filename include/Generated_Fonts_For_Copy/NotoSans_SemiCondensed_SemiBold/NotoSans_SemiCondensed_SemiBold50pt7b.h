#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7C, 0x3F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x01, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF8, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFC, 0xE3, 0xC7, 0xE3, 0x81, 0x3F, 0x0E, 0x00, 0xFC,
  0x38, 0x03, 0xF0, 0xE0, 0x07, 0xE3, 0x80, 0x1F, 0xCE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x39, 0xFC, 0x00,
  0xE3, 0xF0, 0x03, 0x8F, 0xC0, 0x0E, 0x3F, 0x80, 0x38, 0xFF, 0x80, 0xE7,
  0xFF, 0xC3, 0xBF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0xFF, 0x80, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x03, 0xE0,
  0xF0, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x3E, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0xF8, 0x7C, 0x1F, 0x07, 0x8F, 0x8F, 0xF8, 0xF8, 0x7C, 0x7C,
  0xFF, 0xE3, 0xE3, 0xE7, 0xC7, 0xFF, 0x9F, 0xFE, 0x3E, 0x7E, 0x7C, 0x7F,
  0xF3, 0xE3, 0xE1, 0xF1, 0xFF, 0x1F, 0x1F, 0x0F, 0x87, 0xF1, 0xF1, 0xF0,
  0x7C, 0x00, 0x0F, 0x8F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x3E,
  0x00, 0x1E, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x0F, 0x00,
  0xF0, 0x7C, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x80, 0x3E, 0x3E, 0x00,
  0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x08, 0x7F, 0xF8, 0x07, 0xE1, 0xFF, 0xF8, 0x0F, 0xC3,
  0xFB, 0xF8, 0x1F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x7F,
  0x03, 0xF9, 0xF8, 0xFC, 0x03, 0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0xC3, 0xF0,
  0x07, 0xFF, 0x07, 0xE0, 0x07, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0x8F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xF0, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7D, 0xE7, 0x9E, 0x78, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0E, 0x0F, 0x81, 0xBF,
  0x3E, 0x7E, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF9, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0,
  0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x07,
  0x03, 0x00, 0x04, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F,
  0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0x08, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F,
  0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7E, 0x01,
  0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF,
  0x9F, 0xDF, 0x7F, 0x7F, 0xFC, 0xFD, 0xF1, 0xF9, 0xC3, 0xF1, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFC, 0x1F, 0xE3,
  0xC0, 0x3F, 0x84, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xF0, 0x1F, 0xE3, 0x00, 0x3F, 0x88, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x1F, 0x80,
  0x0F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8,
  0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x40, 0x03, 0xFB, 0x80, 0x3F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x87, 0xE0, 0x3F, 0x3F, 0xF0, 0x7E, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xE7, 0xF8, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF,
  0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0,
  0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xF8,
  0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x07,
  0xF8, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x0F, 0xE0,
  0xFF, 0x1F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x80, 0x7F, 0x3F, 0xC3, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE,
  0x1F, 0xC7, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xDF, 0x3F, 0xFE, 0xFC, 0x7F, 0xF3, 0xF0, 0x7F, 0x8F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0x08, 0x3F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC,
  0xF8, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xC0,
  0xFF, 0x30, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x80, 0x1F, 0x07, 0xC0, 0x7F, 0xF0, 0x7C, 0x7C, 0x07,
  0xFF, 0xC3, 0xE3, 0xE0, 0xFF, 0xFE, 0x0F, 0x1E, 0x07, 0xE1, 0xF0, 0x79,
  0xF0, 0x7E, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0x7C, 0x1F, 0x78, 0x3E, 0x03,
  0xE0, 0xFB, 0xC1, 0xF0, 0x1F, 0x07, 0xDE, 0x0F, 0x80, 0xF8, 0x3F, 0xF0,
  0x78, 0x07, 0xC1, 0xFF, 0x83, 0xC0, 0x3E, 0x0F, 0xFC, 0x1E, 0x01, 0xF0,
  0x7F, 0xE0, 0xF0, 0x1F, 0x83, 0xDF, 0x07, 0xC0, 0xFC, 0x1E, 0x78, 0x3E,
  0x07, 0xE1, 0xF3, 0xC1, 0xF8, 0x7F, 0x0F, 0x1F, 0x07, 0xFF, 0xFD, 0xF8,
  0xF8, 0x3F, 0xFD, 0xFF, 0x87, 0xC0, 0xFF, 0xCF, 0xF8, 0x1F, 0x03, 0xFC,
  0x3F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x04,
  0x00, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC, 0x01, 0xFE,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x03, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x3E, 0x1F, 0xE0, 0x06,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0x1F, 0xF0, 0x0E,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0xFF, 0xF4, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0x00, 0x7F, 0xC7, 0xE0, 0x07, 0xF8, 0xFC, 0x00, 0x7F,
  0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0xCF, 0xC0, 0x0F, 0xF1, 0xF8, 0x03, 0xFC, 0x3F,
  0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0xF8, 0x00, 0x61,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF3, 0xF8,
  0x00, 0x7E, 0x7F, 0x80, 0x0F, 0xC7, 0xFC, 0x01, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x87, 0xF7,
  0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0xBF,
  0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00,
  0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03,
  0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xCF, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF7, 0xC0, 0x07, 0xDF, 0xFE, 0xF8, 0x00, 0xFB, 0xFF,
  0xDF, 0x80, 0x3F, 0x7F, 0xF9, 0xF0, 0x07, 0xCF, 0xFF, 0x3E, 0x00, 0xF9,
  0xFF, 0xE7, 0xE0, 0x3F, 0x3F, 0xFC, 0x7C, 0x07, 0xC7, 0xFF, 0x8F, 0x80,
  0xF8, 0xFF, 0xF1, 0xF0, 0x3F, 0x1F, 0xFE, 0x3F, 0x07, 0xC3, 0xFF, 0xC3,
  0xE0, 0xF8, 0x7F, 0xF8, 0x7C, 0x1F, 0x0F, 0xFF, 0x0F, 0xC7, 0xC1, 0xFF,
  0xE0, 0xF8, 0xF8, 0x3F, 0xFC, 0x1F, 0x1F, 0x07, 0xFF, 0x83, 0xF7, 0xC0,
  0xFF, 0xF0, 0x3E, 0xF8, 0x1F, 0xFE, 0x07, 0xDF, 0x03, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0xFF,
  0xF0, 0x0F, 0xC0, 0x1F, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xF8, 0x03, 0xFF,
  0xDF, 0xC0, 0x3F, 0xFC, 0xFC, 0x03, 0xFF, 0xCF, 0xE0, 0x3F, 0xFC, 0x7E,
  0x03, 0xFF, 0xC7, 0xF0, 0x3F, 0xFC, 0x3F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0xC3, 0xFF, 0xC0, 0xFC, 0x3F, 0xFC, 0x0F, 0xE3, 0xFF, 0xC0,
  0x7E, 0x3F, 0xFC, 0x07, 0xF3, 0xFF, 0xC0, 0x3F, 0x1F, 0xFC, 0x03, 0xF9,
  0xFF, 0xC0, 0x1F, 0x9F, 0xFC, 0x01, 0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFB, 0xF0, 0x7F, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xE1, 0xFF, 0xC3, 0xF0, 0x0F, 0xF1,
  0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFF,
  0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xE1, 0xF9, 0xFC,
  0x01, 0x8F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x80,
  0x07, 0xE7, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xC0, 0x0F,
  0xE7, 0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x07, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFB, 0xE0, 0x1F, 0x81, 0xF8, 0x0F,
  0xBE, 0x01, 0xF8, 0x1F, 0x80, 0xF9, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x9F,
  0x03, 0xF8, 0x1F, 0x81, 0xF9, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x1F, 0x03,
  0xF0, 0x0F, 0xC1, 0xF1, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x0F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x0F, 0x87, 0xE0, 0x07,
  0xE3, 0xE0, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x07, 0xC7, 0xE0, 0x07, 0xE7,
  0xE0, 0x7C, 0xFC, 0x00, 0x3E, 0x7C, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0,
  0x7E, 0xFC, 0x00, 0x3F, 0x7C, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x3E,
  0xF8, 0x00, 0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF8,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7,
  0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xE7,
  0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0x83, 0xFC, 0x20, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0x7F,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0x7F, 0xFE, 0xFB, 0xFF,
  0xF7, 0xCF, 0xFF, 0x3E, 0x3F, 0xE0, 0xF0, 0x10, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC1, 0xC0, 0x3F, 0x3F, 0xE0, 0xFD, 0xFF, 0xE3, 0xEF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x3F, 0xF3, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7E, 0xFF, 0x03, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3E, 0xFF,
  0xF8, 0xF9, 0xFF, 0xC3, 0xC3, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0x7C, 0x3F, 0x80, 0x47, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x63, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x01, 0xC1, 0xF8, 0x1F, 0xE3, 0xF0, 0xFF, 0xF7,
  0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF, 0x3F, 0x81, 0xFE,
  0xFE, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xF9, 0xF0, 0xFF, 0xE3, 0xE0, 0x7F, 0x87,
  0xC0, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x0F, 0xE3, 0xF0, 0x1F, 0x9F,
  0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0x8F, 0xF8, 0x7E, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF8, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF,
  0xFD, 0xF1, 0xFF, 0xFF, 0xE7, 0xFD, 0xFF, 0xCF, 0xE0, 0x7F, 0xBF, 0x80,
  0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xF7, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFE, 0xFC, 0x3F, 0xF9, 0xF8, 0x1F, 0xE3, 0xF0, 0x04,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x40, 0x03, 0xF8, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xC0, 0x3F, 0x3F, 0xF0, 0xF9, 0xFF, 0xE3, 0xEF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xBF, 0xFB, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x18, 0xFB, 0xFF, 0xFF, 0xEF, 0xDF,
  0x00, 0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xC0, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x8F, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x3F,
  0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xF1,
  0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x3E, 0xFE,
  0x00, 0x7D, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xF8,
  0x07, 0xF3, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7,
  0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x3C, 0x0F, 0x0F, 0xF8, 0x1F, 0xF8, 0xF9,
  0xFF, 0xE3, 0xFF, 0xCF, 0xBF, 0xFE, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xC0, 0x7F, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x0E, 0x03, 0xC3,
  0xFF, 0x0F, 0x9F, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xBF,
  0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xE7,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x1E, 0x03, 0xE3, 0xFE, 0x0F, 0x9F, 0xFE,
  0x3E, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0x3F, 0xEF, 0xF0, 0x3F, 0xBF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xF0, 0x3F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xEF, 0xFF, 0x8F, 0xDF, 0xFC, 0x3F, 0x1F, 0xE0, 0xFC, 0x08, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF8, 0x7C,
  0x3F, 0xFC, 0xF8, 0xFF, 0xFD, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0xCF,
  0xE0, 0x7F, 0xBF, 0x80, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x7F,
  0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFE, 0xFC, 0x3F, 0xF9, 0xF8,
  0x1F, 0xE3, 0xF0, 0x04, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x1D, 0xE0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xC3, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x81, 0xEF, 0xC0, 0x13, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0xF0, 0x01, 0x80, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x20, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xEF, 0xE0, 0x7F, 0xDF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7E, 0x3F, 0xFC, 0xFC, 0x3F,
  0xF0, 0xF8, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFD, 0xF8,
  0x07, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x80,
  0x7E, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFB, 0xC0, 0xFC, 0x1F, 0x83, 0xCF, 0x83,
  0xF0, 0x7E, 0x1F, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0xF8, 0x7E, 0x07, 0xE1,
  0xF1, 0xE1, 0xF8, 0x0F, 0xC7, 0x87, 0xC7, 0xC0, 0x3F, 0x3E, 0x1F, 0x3F,
  0x00, 0xFC, 0xF8, 0x7C, 0xFC, 0x03, 0xF3, 0xE1, 0xF3, 0xF0, 0x07, 0xCF,
  0x83, 0xCF, 0x80, 0x1F, 0x3C, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x3E, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0xFD, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x0F, 0xC0,
  0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F,
  0xBF, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFE,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xF3, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x05, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0xE8, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 37, 13, 3, -36 },
  { 34, 16, 13, 22, 3, -36 },
  { 60, 27, 36, 29, 1, -36 },
  { 182, 22, 41, 26, 2, -38 },
  { 295, 37, 36, 41, 2, -36 },
  { 462, 31, 37, 33, 2, -36 },
  { 606, 6, 13, 12, 3, -36 },
  { 616, 13, 44, 16, 2, -36 },
  { 688, 13, 44, 16, 1, -36 },
  { 760, 22, 22, 25, 2, -38 },
  { 821, 22, 24, 26, 2, -30 },
  { 887, 8, 13, 13, 2, -6 },
  { 900, 12, 5, 16, 2, -16 },
  { 908, 7, 8, 13, 3, -7 },
  { 915, 19, 36, 20, 0, -36 },
  { 1001, 22, 37, 26, 2, -36 },
  { 1103, 15, 36, 26, 3, -36 },
  { 1171, 22, 36, 26, 2, -36 },
  { 1270, 22, 37, 26, 2, -36 },
  { 1372, 25, 36, 26, 1, -36 },
  { 1485, 21, 37, 26, 3, -36 },
  { 1583, 23, 37, 26, 2, -36 },
  { 1690, 24, 36, 26, 1, -36 },
  { 1798, 23, 37, 26, 2, -36 },
  { 1905, 22, 37, 26, 2, -36 },
  { 2007, 7, 29, 13, 3, -28 },
  { 2033, 8, 35, 13, 2, -28 },
  { 2068, 22, 24, 26, 2, -30 },
  { 2134, 22, 15, 26, 2, -25 },
  { 2176, 22, 24, 26, 2, -30 },
  { 2242, 20, 37, 21, 0, -36 },
  { 2335, 37, 40, 41, 2, -36 },
  { 2520, 30, 36, 30, 0, -36 },
  { 2655, 24, 36, 30, 4, -36 },
  { 2763, 24, 37, 29, 3, -36 },
  { 2874, 27, 36, 33, 4, -36 },
  { 2996, 19, 36, 25, 4, -36 },
  { 3082, 19, 36, 25, 4, -36 },
  { 3168, 27, 37, 33, 3, -36 },
  { 3293, 26, 36, 34, 4, -36 },
  { 3410, 14, 36, 17, 2, -36 },
  { 3473, 13, 46, 14, -3, -36 },
  { 3548, 26, 36, 29, 4, -36 },
  { 3665, 19, 36, 25, 4, -36 },
  { 3751, 35, 36, 43, 4, -36 },
  { 3909, 28, 36, 36, 4, -36 },
  { 4035, 30, 37, 36, 3, -36 },
  { 4174, 22, 36, 28, 4, -36 },
  { 4273, 30, 45, 36, 3, -36 },
  { 4442, 25, 36, 29, 4, -36 },
  { 4555, 21, 37, 25, 2, -36 },
  { 4653, 24, 36, 26, 1, -36 },
  { 4761, 26, 37, 34, 4, -36 },
  { 4882, 29, 36, 29, 0, -36 },
  { 5013, 44, 36, 44, 0, -36 },
  { 5211, 28, 36, 28, 0, -36 },
  { 5337, 27, 36, 27, 0, -36 },
  { 5459, 23, 36, 25, 1, -36 },
  { 5563, 12, 44, 16, 3, -36 },
  { 5629, 19, 36, 20, 0, -36 },
  { 5715, 12, 44, 16, 1, -36 },
  { 5781, 25, 22, 27, 1, -36 },
  { 5850, 21, 4, 21, 0, 4 },
  { 5861, 12, 8, 16, 2, -38 },
  { 5873, 21, 29, 27, 2, -28 },
  { 5950, 22, 39, 29, 4, -38 },
  { 6058, 20, 29, 23, 2, -28 },
  { 6131, 23, 39, 29, 2, -38 },
  { 6244, 22, 29, 27, 2, -28 },
  { 6324, 18, 38, 17, 1, -38 },
  { 6410, 23, 40, 29, 2, -28 },
  { 6525, 22, 38, 29, 4, -38 },
  { 6630, 7, 38, 13, 3, -38 },
  { 6664, 12, 50, 13, -2, -38 },
  { 6739, 23, 38, 27, 4, -38 },
  { 6849, 6, 38, 13, 4, -38 },
  { 6878, 36, 28, 44, 4, -28 },
  { 7004, 22, 28, 29, 4, -28 },
  { 7081, 24, 29, 28, 2, -28 },
  { 7168, 22, 40, 29, 4, -28 },
  { 7278, 23, 40, 29, 2, -28 },
  { 7393, 15, 28, 20, 4, -28 },
  { 7446, 18, 29, 22, 2, -28 },
  { 7512, 16, 34, 18, 1, -33 },
  { 7580, 23, 28, 29, 3, -27 },
  { 7661, 25, 27, 25, 0, -27 },
  { 7746, 38, 27, 38, 0, -27 },
  { 7875, 25, 27, 25, 0, -27 },
  { 7960, 25, 39, 25, 0, -27 },
  { 8082, 19, 27, 22, 1, -27 },
  { 8147, 16, 44, 19, 1, -36 },
  { 8235, 5, 50, 25, 10, -38 },
  { 8267, 16, 44, 19, 2, -36 },
  { 8355, 22, 7, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD50PT7B_H_
