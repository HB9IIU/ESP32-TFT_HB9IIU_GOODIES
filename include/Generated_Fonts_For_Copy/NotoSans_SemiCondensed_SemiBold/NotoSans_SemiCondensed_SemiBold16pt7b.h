#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x1B, 0x0D, 0x84, 0x8F, 0xF1,
  0x21, 0xB3, 0xFF, 0xFF, 0x24, 0x12, 0x09, 0x00, 0x10, 0xFF, 0xF6, 0x8D,
  0x1E, 0x0F, 0x0F, 0x17, 0x3F, 0xF0, 0x81, 0x00, 0x60, 0x0F, 0x18, 0x91,
  0x09, 0x30, 0x92, 0x09, 0x6E, 0xF5, 0xA6, 0xD3, 0x09, 0x31, 0x93, 0x11,
  0xA3, 0x0E, 0x10, 0x1F, 0x04, 0xC1, 0x30, 0x6C, 0x1E, 0x07, 0x9B, 0x76,
  0xCF, 0x31, 0xCF, 0xF1, 0xF7, 0xFF, 0x76, 0xCC, 0xCC, 0x8C, 0xCC, 0xC6,
  0x63, 0xE2, 0x33, 0x31, 0x11, 0x33, 0x32, 0x6C, 0x18, 0x18, 0x7E, 0xFF,
  0x3C, 0x66, 0x24, 0x30, 0x60, 0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0xFE, 0xFF,
  0xF0, 0x0C, 0x21, 0x86, 0x10, 0xC3, 0x18, 0x61, 0x8C, 0x00, 0x30, 0xFB,
  0x36, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9B, 0xF3, 0xC0, 0x3B, 0xF6, 0xB1,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFB, 0x30, 0x60, 0xC1, 0x86, 0x18, 0x70,
  0xC3, 0xFF, 0xF0, 0x31, 0xFA, 0x30, 0x60, 0xCF, 0x1F, 0x06, 0x06, 0x1F,
  0x77, 0xC0, 0x0E, 0x0E, 0x1E, 0x36, 0x26, 0x66, 0x46, 0xFF, 0xFF, 0x06,
  0x06, 0xFD, 0x83, 0x06, 0x0F, 0xCB, 0x81, 0x83, 0x0F, 0xBB, 0xE0, 0x0C,
  0xF9, 0x86, 0x0C, 0x1F, 0xB3, 0xE3, 0xC7, 0x8F, 0xB3, 0xC0, 0xFF, 0x03,
  0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x31, 0xFB, 0x36,
  0x3C, 0xCF, 0x1E, 0x66, 0xC7, 0x8F, 0x33, 0xE0, 0x31, 0xFB, 0x36, 0x3C,
  0x78, 0xFF, 0xBB, 0x04, 0x1A, 0xF7, 0x80, 0xF4, 0x03, 0xC0, 0xF4, 0x03,
  0xF8, 0x02, 0x1C, 0xF7, 0x0C, 0x0E, 0x07, 0x83, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x81, 0x81, 0xC0, 0xE0, 0xE7, 0x38, 0x40, 0x33, 0xF8, 0xC1, 0x0C,
  0x63, 0x0C, 0x00, 0x03, 0x0C, 0x04, 0x07, 0xF1, 0x83, 0x20, 0x3C, 0xF3,
  0x32, 0x64, 0x4C, 0x89, 0x9B, 0x3B, 0xFB, 0x00, 0x30, 0x43, 0xF8, 0x1C,
  0x07, 0x81, 0xE0, 0xD8, 0x33, 0x0C, 0xC7, 0xF1, 0xFE, 0x61, 0xB8, 0x6C,
  0x1C, 0xFE, 0xC7, 0xC3, 0xC6, 0xFE, 0xFE, 0xC3, 0xC3, 0xC3, 0xFE, 0xFC,
  0x0C, 0x3F, 0x62, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7E, 0x3E,
  0xFE, 0x63, 0xB0, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x86, 0xC3, 0x7F, 0x3F,
  0x00, 0xFF, 0x0C, 0x30, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xC0, 0xFF, 0x0C,
  0x30, 0xC3, 0xFC, 0x30, 0xC3, 0x0C, 0x00, 0x0C, 0x3F, 0x71, 0xE0, 0xC0,
  0xC0, 0xC7, 0xC1, 0xC1, 0xE1, 0x7F, 0x3F, 0xC1, 0xE0, 0xF0, 0x78, 0x3F,
  0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0xF6, 0x66, 0x66, 0x66,
  0x6E, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3, 0xC6, 0xCC,
  0xDC, 0xD8, 0xF8, 0xEC, 0xCC, 0xC6, 0xC7, 0xC3, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE0, 0xFE, 0x1F, 0xC2, 0xE8, 0xDD, 0x9B,
  0xB2, 0x72, 0xCE, 0x79, 0xCE, 0x39, 0xC7, 0x18, 0x80, 0xE1, 0xF8, 0xFC,
  0x7B, 0x3D, 0x9E, 0x6F, 0x3F, 0x8D, 0xC7, 0xE1, 0xF0, 0x60, 0x0C, 0x1F,
  0xC6, 0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x1F, 0x06, 0xC1, 0xB8, 0x67, 0xF0,
  0xF8, 0xFD, 0x8F, 0x1E, 0x3C, 0x7F, 0xFE, 0x60, 0xC1, 0x83, 0x00, 0x0C,
  0x1F, 0xC6, 0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x1F, 0x06, 0xC1, 0xB8, 0x67,
  0xF0, 0xF8, 0x06, 0x00, 0xC0, 0x18, 0xFE, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC,
  0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0x31, 0xFC, 0x70, 0xC3, 0xC3, 0x87, 0x0C,
  0x3F, 0xFE, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3, 0x3F,
  0x8F, 0x80, 0xC1, 0xB0, 0xD8, 0xCC, 0x62, 0x31, 0x90, 0xD8, 0x6C, 0x14,
  0x0E, 0x07, 0x00, 0xC3, 0x0F, 0x0C, 0x36, 0x79, 0x99, 0xE6, 0x67, 0x99,
  0x92, 0x63, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE1, 0xC1, 0x86, 0x00, 0xE3,
  0xB1, 0x8D, 0x86, 0xC1, 0xC0, 0xE0, 0x70, 0x6C, 0x77, 0x31, 0xB0, 0x60,
  0xE3, 0xB1, 0x99, 0x86, 0xC3, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x7F, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0xFF, 0xFF,
  0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC1, 0x86, 0x08, 0x30, 0xC1,
  0x86, 0x18, 0x30, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18,
  0x1C, 0x34, 0x26, 0x62, 0x63, 0xC1, 0xFE, 0xCC, 0xF9, 0xF0, 0xC1, 0xFF,
  0x1C, 0xF3, 0xF4, 0xC1, 0x83, 0x06, 0xEF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F,
  0xBE, 0xE0, 0x39, 0xFC, 0x30, 0xC3, 0x0C, 0x3B, 0x7C, 0x06, 0x0C, 0x1B,
  0xBF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0xBB, 0xF0, 0x38, 0xFB, 0x1E, 0x3F,
  0xF8, 0x30, 0x72, 0x7C, 0x3C, 0xD6, 0x1E, 0xF9, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x77, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0x7E, 0x0C, 0x1F, 0xE7,
  0x80, 0xC1, 0x83, 0x06, 0xEF, 0xFC, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30,
  0xF3, 0xFF, 0xFF, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC0,
  0xC0, 0xC0, 0xC6, 0xCC, 0xDC, 0xD8, 0xF8, 0xF8, 0xCC, 0xCE, 0xC7, 0xFF,
  0xFF, 0xFF, 0xDC, 0xEF, 0xFF, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x30, 0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6,
  0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0x7C, 0xDD, 0xFF, 0x1E, 0x3C,
  0x78, 0xF1, 0xF7, 0xDD, 0x83, 0x06, 0x0C, 0x00, 0x77, 0xFF, 0x1E, 0x3C,
  0x78, 0xF1, 0xF7, 0x7E, 0x0C, 0x18, 0x30, 0x60, 0xDF, 0xF9, 0x8C, 0x63,
  0x18, 0xC0, 0x7B, 0xEC, 0x38, 0x70, 0x60, 0xE6, 0xF8, 0x20, 0x87, 0xBE,
  0x61, 0x86, 0x18, 0x61, 0xD3, 0xC0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xF7, 0x7A, 0xC3, 0xC3, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x18, 0xC6,
  0x3C, 0x63, 0x67, 0x36, 0xF6, 0x6D, 0x66, 0x96, 0x29, 0xC3, 0x9C, 0x38,
  0xC0, 0xE3, 0x66, 0x3C, 0x3C, 0x18, 0x3C, 0x3C, 0x66, 0xE7, 0xC3, 0xC3,
  0x66, 0x66, 0x26, 0x3C, 0x3C, 0x1C, 0x18, 0x18, 0x38, 0xF0, 0xE0, 0x7D,
  0xF0, 0xC6, 0x38, 0xC6, 0x1F, 0xFC, 0x19, 0x8C, 0x63, 0x1B, 0x0E, 0x31,
  0x8C, 0x63, 0x84, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x18, 0xC6, 0x30, 0x6E,
  0x63, 0x18, 0xCE, 0x40, 0xE3, 0xFE, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 9, 11, 9, 0, -11 },
  { 20, 7, 13, 8, 1, -12 },
  { 32, 12, 12, 13, 1, -12 },
  { 50, 10, 12, 11, 1, -12 },
  { 65, 2, 4, 4, 1, -11 },
  { 66, 4, 14, 5, 1, -11 },
  { 73, 4, 14, 5, 0, -11 },
  { 80, 8, 7, 8, 0, -12 },
  { 87, 7, 8, 8, 1, -10 },
  { 94, 2, 4, 4, 1, -2 },
  { 95, 4, 2, 5, 0, -5 },
  { 96, 2, 2, 4, 1, -2 },
  { 97, 6, 11, 6, 0, -11 },
  { 106, 7, 12, 8, 1, -12 },
  { 117, 5, 11, 8, 1, -11 },
  { 124, 7, 12, 8, 1, -12 },
  { 135, 7, 12, 8, 1, -12 },
  { 146, 8, 11, 8, 0, -11 },
  { 157, 7, 11, 8, 1, -11 },
  { 167, 7, 12, 8, 1, -12 },
  { 178, 8, 11, 8, 0, -11 },
  { 189, 7, 12, 8, 1, -12 },
  { 200, 7, 12, 8, 1, -12 },
  { 211, 2, 9, 4, 1, -9 },
  { 214, 2, 11, 4, 1, -9 },
  { 217, 7, 8, 8, 1, -10 },
  { 224, 7, 5, 8, 1, -8 },
  { 229, 7, 8, 8, 1, -10 },
  { 236, 6, 12, 7, 0, -12 },
  { 245, 11, 13, 13, 1, -12 },
  { 263, 10, 11, 10, 0, -11 },
  { 277, 8, 11, 10, 1, -11 },
  { 288, 8, 12, 9, 1, -12 },
  { 300, 9, 11, 11, 1, -11 },
  { 313, 6, 11, 8, 1, -11 },
  { 322, 6, 11, 8, 1, -11 },
  { 331, 8, 12, 11, 1, -12 },
  { 343, 9, 11, 11, 1, -11 },
  { 356, 4, 11, 6, 1, -11 },
  { 362, 4, 14, 5, -1, -11 },
  { 369, 8, 11, 9, 1, -11 },
  { 380, 6, 11, 8, 1, -11 },
  { 389, 11, 11, 14, 1, -11 },
  { 405, 9, 11, 12, 1, -11 },
  { 418, 10, 12, 11, 1, -12 },
  { 433, 7, 11, 9, 1, -11 },
  { 443, 10, 15, 11, 1, -12 },
  { 462, 8, 11, 9, 1, -11 },
  { 473, 6, 12, 8, 1, -12 },
  { 482, 8, 11, 8, 0, -11 },
  { 493, 9, 11, 11, 1, -11 },
  { 506, 9, 11, 9, 0, -11 },
  { 519, 14, 11, 14, 0, -11 },
  { 539, 9, 11, 9, 0, -11 },
  { 552, 9, 11, 9, 0, -11 },
  { 565, 8, 11, 8, 0, -11 },
  { 576, 4, 14, 5, 1, -11 },
  { 583, 6, 11, 6, 0, -11 },
  { 592, 4, 14, 5, 0, -11 },
  { 599, 8, 7, 9, 0, -11 },
  { 606, 7, 1, 7, 0, 1 },
  { 607, 3, 2, 5, 1, -12 },
  { 608, 6, 9, 9, 1, -9 },
  { 615, 7, 12, 9, 1, -12 },
  { 626, 6, 9, 7, 1, -9 },
  { 633, 7, 12, 9, 1, -12 },
  { 644, 7, 9, 9, 1, -9 },
  { 652, 6, 12, 5, 0, -12 },
  { 661, 7, 13, 9, 1, -9 },
  { 673, 7, 12, 9, 1, -12 },
  { 684, 2, 12, 4, 1, -12 },
  { 687, 4, 16, 4, -1, -12 },
  { 695, 8, 12, 9, 1, -12 },
  { 707, 2, 12, 4, 1, -12 },
  { 710, 12, 9, 14, 1, -9 },
  { 724, 7, 9, 9, 1, -9 },
  { 732, 7, 9, 9, 1, -9 },
  { 740, 7, 13, 9, 1, -9 },
  { 752, 7, 13, 9, 1, -9 },
  { 764, 5, 9, 6, 1, -9 },
  { 770, 6, 9, 7, 1, -9 },
  { 777, 6, 11, 6, 0, -11 },
  { 786, 7, 9, 9, 1, -9 },
  { 794, 8, 9, 8, 0, -9 },
  { 803, 12, 9, 12, 0, -9 },
  { 817, 8, 9, 8, 0, -9 },
  { 826, 8, 13, 8, 0, -9 },
  { 839, 6, 9, 7, 0, -9 },
  { 846, 5, 14, 6, 0, -11 },
  { 855, 2, 16, 8, 3, -12 },
  { 859, 5, 14, 6, 1, -11 },
  { 868, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD16PT7B_H_
