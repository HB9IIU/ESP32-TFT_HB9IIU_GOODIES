#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0xFC,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x70, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0x80, 0xFC, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xF3, 0xFC, 0x7F, 0x8F, 0x03,
  0xCF, 0xF0, 0xF0, 0x04, 0xFF, 0x0F, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0xFF,
  0x0F, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0xFF, 0x8F, 0x00, 0x07, 0xFC, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0x7F, 0xF0, 0x00, 0xF1, 0xFF, 0x00, 0x0F, 0x0F, 0xF0, 0x00,
  0xF0, 0x7F, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0xF0, 0x7F, 0x80, 0x0F, 0x07,
  0xFC, 0x00, 0xF0, 0xFF, 0xF8, 0x0F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x81,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x81, 0xFC, 0x3F, 0x00, 0xC0, 0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xFE, 0x07,
  0xE0, 0x7E, 0x1F, 0x87, 0xFF, 0x83, 0xF8, 0x3F, 0x0F, 0xC7, 0xFF, 0xE0,
  0xFC, 0x3F, 0x8F, 0xC3, 0xFF, 0xF8, 0x7F, 0x3F, 0x87, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xE1, 0xFC, 0x7F, 0x0F, 0xFF, 0xC3, 0xF1, 0xFC, 0x1F,
  0x83, 0xFF, 0xC3, 0xF0, 0xFC, 0x0F, 0xC0, 0xFF, 0xC1, 0xF8, 0x7E, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xFE, 0x7F,
  0xC0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xC1, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x7F,
  0x80, 0x1F, 0xFF, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0x03,
  0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFD, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x08, 0x03,
  0xF0, 0x02, 0x78, 0x0F, 0x81, 0xF3, 0xFC, 0x7C, 0x7F, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x20, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x9F,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xD0, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF3, 0xFE, 0xFF, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0x7F, 0x0F, 0xF3, 0xE0,
  0xFF, 0x1C, 0x0F, 0xF0, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF8, 0x3E, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0xFF, 0x06, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x83, 0xF0, 0x07, 0xFE, 0x1E, 0x00, 0x1F, 0xF0, 0x40, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFE, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x1F,
  0x9F, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0,
  0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFC,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE8,
  0x00, 0x03, 0xFE, 0xF0, 0x00, 0x7F, 0xEF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x1F, 0x00, 0x3F, 0x87, 0xFF, 0x01, 0xFC, 0x7F, 0xFE, 0x0F,
  0xE7, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x03, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xDF, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F,
  0x9F, 0xF0, 0x01, 0xFE, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x01,
  0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0xCF, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xBF, 0x83, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xE3, 0xF8, 0x07,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x10, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xE1, 0xC0, 0x07, 0x83, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFC, 0x03,
  0xFE, 0x18, 0x00, 0x7F, 0xC4, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0x0F,
  0xFF, 0xF8, 0x3F, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x7E, 0x3F, 0x00, 0xFF,
  0xFF, 0xE0, 0x7E, 0x7E, 0x03, 0xFF, 0xFF, 0xC0, 0xFD, 0xF8, 0x0F, 0xF0,
  0x3F, 0x81, 0xFB, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF7, 0xE0, 0x7F, 0x00,
  0xFE, 0x03, 0xEF, 0xC0, 0xFC, 0x01, 0xF8, 0x07, 0xDF, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC0, 0x3F, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0xF0, 0x3F, 0x00, 0x3F,
  0x00, 0xFF, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0xFC,
  0x07, 0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xFF, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0xFC, 0x07, 0xE0, 0x1F, 0xC0,
  0xFD, 0xFC, 0x0F, 0xE0, 0x7F, 0xC3, 0xF1, 0xF8, 0x0F, 0xF3, 0xFF, 0xCF,
  0xE3, 0xF0, 0x1F, 0xFF, 0xDF, 0xFF, 0x87, 0xE0, 0x1F, 0xFF, 0x9F, 0xFF,
  0x0F, 0xE0, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xC0, 0x1F, 0xFE, 0x7F, 0x80, 0x07, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x03,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFE, 0x00, 0x7F, 0xF3, 0xFC, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x0F, 0xFE, 0x00, 0x0C,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x08, 0x1F, 0xFE, 0x00, 0x1C, 0x07, 0xFF, 0xE0, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xE1, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xF8, 0x0F, 0xFE, 0x00,
  0x03, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0x87, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xEF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xF8,
  0x00, 0x07, 0xEF, 0xFF, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0xFF, 0x7F, 0x00,
  0x03, 0xFB, 0xFF, 0xFB, 0xF8, 0x00, 0x1F, 0x9F, 0xFF, 0xCF, 0xE0, 0x01,
  0xFC, 0xFF, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xFF, 0xF3, 0xF8, 0x00, 0x7E,
  0x3F, 0xFF, 0x8F, 0xE0, 0x07, 0xF1, 0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0x8F,
  0xFF, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0xFF, 0x0F, 0xC0, 0x1F, 0xC3, 0xFF,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0xFF, 0xFE,
  0x0F, 0xC0, 0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xFF, 0x83,
  0xF8, 0x1F, 0x81, 0xFF, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0xFF, 0x03, 0xF8, 0x7E, 0x03, 0xFF, 0xF8, 0x1F, 0xC7,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0xFE, 0x03, 0xF9, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xDF, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0x00,
  0x0F, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xFE, 0x7F, 0x80, 0x0F, 0xFF, 0xE7,
  0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xE3, 0xFE, 0x00, 0xFF,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF,
  0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xFE, 0x00, 0xFF,
  0x8F, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0xE0,
  0x03, 0xFE, 0x7F, 0xFE, 0x00, 0x1F, 0xE7, 0xFF, 0xE0, 0x01, 0xFF, 0x7F,
  0xFE, 0x00, 0x0F, 0xF7, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0xDF, 0xE0, 0x07, 0xFE, 0xFF,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0x7F, 0x80,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xC1,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x07, 0xFC,
  0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xFE, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFE,
  0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0x00, 0xFC, 0x7F, 0xC0, 0x03, 0x8F,
  0xF0, 0x00, 0x13, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF7, 0xC0, 0x03, 0xFE, 0xFF, 0xC3, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xDF, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xCF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x7F, 0x01,
  0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFE,
  0x0F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x03, 0xF1, 0xFE,
  0x00, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F,
  0x3F, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x07, 0xF0, 0x7F, 0xE0, 0x38, 0x01, 0xFF, 0x02, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xF0, 0xFF, 0x3F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xF7, 0xFC, 0x07,
  0xFF, 0x7F, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF1,
  0xFF, 0xFE, 0x3F, 0x0F, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0x3F, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x81, 0xF8, 0x03, 0xF8, 0x7F, 0xF0, 0x1F, 0xC7, 0xFF, 0xE0,
  0xFE, 0x7F, 0xFF, 0x87, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFE, 0x00,
  0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xF8,
  0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF,
  0xE3, 0xF9, 0xFF, 0xFE, 0x1F, 0x87, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xE0, 0x1C, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x11, 0xFF,
  0xC0, 0x78, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xBC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xFC, 0xFF,
  0x0F, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFC,
  0x00, 0xFF, 0xDF, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x1F, 0xC0, 0xFF, 0xF8, 0x7F,
  0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFC,
  0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x02, 0x1F, 0xFC, 0x00, 0xF0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x04, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x07,
  0xF0, 0x3F, 0xFF, 0x1F, 0xC3, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xFB, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0x7F,
  0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xF0,
  0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xCF,
  0xF0, 0x3F, 0xFE, 0x3F, 0xC0, 0x7F, 0xF0, 0xFF, 0x00, 0x1C, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE2, 0x00, 0x00, 0xFF, 0x8E, 0x00,
  0x07, 0xFC, 0x3F, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x1F, 0xFE,
  0x0F, 0xE3, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xCF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0,
  0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF,
  0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x83, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x01,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x3F,
  0x9F, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFB, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0,
  0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC1,
  0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0x8F, 0xC7, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xBF, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0xC1,
  0xFC, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x00,
  0x7F, 0xBF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xF8,
  0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF,
  0xC7, 0xF3, 0xFF, 0xFC, 0x3F, 0x8F, 0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x1E, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0x1F, 0xC3, 0xFF, 0xFE,
  0x7F, 0x0F, 0xFF, 0xFB, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFC, 0x07, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7,
  0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF,
  0xC0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFB, 0xFC, 0x1F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFE, 0x3F, 0xC0, 0x7F, 0xF0,
  0xFF, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xF0, 0x7E, 0x7F, 0x80, 0x1C, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x81,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x0E, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF,
  0xF3, 0xF8, 0x7F, 0xFF, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x3F,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7E,
  0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x3F, 0xC0, 0x7E,
  0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x7E, 0x07, 0xF8, 0x1F, 0xE0, 0xFC,
  0x7E, 0x07, 0xF8, 0x1F, 0xE0, 0xFC, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFC,
  0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x3F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC,
  0x3F, 0x0F, 0xF0, 0x0F, 0xF1, 0xF8, 0x3F, 0x8F, 0xE0, 0x0F, 0xF1, 0xF8,
  0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8,
  0x1F, 0x9F, 0xE0, 0x07, 0xF3, 0xF0, 0x1F, 0x9F, 0xC0, 0x07, 0xFB, 0xF0,
  0x1F, 0x9F, 0xC0, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF0,
  0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xE0,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC,
  0x7F, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFD, 0xFF,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x04, 0x7F, 0xF8,
  0x00, 0x33, 0xFF, 0xF8, 0x01, 0xDF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0xC0, 0x01, 0xFF, 0xE2, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 9, 47, 17, 4, -46 },
  { 54, 21, 16, 29, 4, -46 },
  { 96, 36, 46, 38, 1, -46 },
  { 303, 28, 53, 34, 3, -49 },
  { 489, 49, 48, 53, 2, -47 },
  { 783, 41, 48, 43, 2, -47 },
  { 1029, 8, 16, 16, 4, -46 },
  { 1045, 16, 56, 21, 3, -46 },
  { 1157, 16, 56, 21, 2, -46 },
  { 1269, 29, 28, 33, 2, -49 },
  { 1371, 29, 32, 34, 3, -39 },
  { 1487, 11, 16, 17, 2, -8 },
  { 1509, 16, 7, 20, 2, -21 },
  { 1523, 9, 10, 17, 4, -9 },
  { 1535, 24, 47, 26, 1, -47 },
  { 1676, 29, 48, 34, 3, -47 },
  { 1850, 20, 46, 34, 4, -46 },
  { 1965, 29, 47, 34, 3, -47 },
  { 2136, 29, 48, 34, 2, -47 },
  { 2310, 32, 47, 34, 1, -47 },
  { 2498, 28, 47, 34, 3, -46 },
  { 2663, 29, 48, 34, 3, -47 },
  { 2837, 30, 46, 34, 2, -46 },
  { 3010, 30, 48, 34, 2, -47 },
  { 3190, 30, 48, 34, 2, -47 },
  { 3370, 9, 37, 17, 4, -36 },
  { 3412, 11, 44, 17, 2, -36 },
  { 3473, 29, 33, 34, 3, -40 },
  { 3593, 29, 18, 34, 3, -32 },
  { 3659, 29, 33, 34, 3, -40 },
  { 3779, 26, 48, 27, 0, -47 },
  { 3935, 47, 52, 54, 3, -47 },
  { 4241, 40, 47, 40, 0, -47 },
  { 4476, 31, 46, 39, 5, -46 },
  { 4655, 33, 48, 37, 3, -47 },
  { 4853, 35, 46, 43, 5, -46 },
  { 5055, 24, 46, 33, 6, -46 },
  { 5193, 23, 46, 32, 6, -46 },
  { 5326, 35, 48, 43, 4, -47 },
  { 5536, 33, 46, 45, 6, -46 },
  { 5726, 18, 46, 22, 2, -46 },
  { 5830, 17, 59, 19, -4, -46 },
  { 5956, 32, 46, 38, 6, -46 },
  { 6140, 25, 46, 32, 5, -46 },
  { 6284, 45, 46, 56, 6, -46 },
  { 6543, 36, 46, 47, 6, -46 },
  { 6750, 40, 48, 46, 3, -47 },
  { 6990, 29, 46, 37, 5, -46 },
  { 7157, 40, 58, 46, 3, -47 },
  { 7447, 33, 46, 38, 5, -46 },
  { 7637, 27, 48, 33, 3, -47 },
  { 7799, 31, 46, 33, 1, -46 },
  { 7978, 34, 47, 44, 5, -46 },
  { 8178, 37, 46, 37, 0, -46 },
  { 8391, 57, 46, 57, 0, -46 },
  { 8719, 37, 46, 37, 0, -46 },
  { 8932, 35, 46, 35, 0, -46 },
  { 9134, 29, 46, 33, 2, -46 },
  { 9301, 14, 56, 21, 5, -46 },
  { 9399, 24, 47, 26, 1, -47 },
  { 9540, 15, 56, 21, 2, -46 },
  { 9645, 32, 29, 35, 2, -47 },
  { 9761, 28, 4, 27, 0, 6 },
  { 9775, 15, 11, 21, 3, -50 },
  { 9796, 28, 37, 35, 2, -36 },
  { 9926, 29, 50, 37, 5, -49 },
  { 10108, 25, 37, 30, 3, -36 },
  { 10224, 30, 50, 37, 3, -49 },
  { 10412, 29, 37, 35, 3, -36 },
  { 10547, 24, 50, 22, 1, -50 },
  { 10697, 30, 52, 37, 3, -36 },
  { 10892, 28, 49, 38, 5, -49 },
  { 11064, 9, 49, 17, 4, -49 },
  { 11120, 16, 65, 17, -3, -49 },
  { 11250, 30, 49, 35, 5, -49 },
  { 11434, 8, 49, 17, 5, -49 },
  { 11483, 47, 36, 57, 5, -36 },
  { 11695, 28, 36, 38, 5, -36 },
  { 11821, 31, 37, 37, 3, -36 },
  { 11965, 29, 52, 37, 5, -36 },
  { 12154, 30, 52, 37, 3, -36 },
  { 12349, 20, 36, 26, 5, -36 },
  { 12439, 23, 37, 29, 3, -36 },
  { 12546, 21, 44, 24, 1, -43 },
  { 12662, 29, 36, 38, 4, -35 },
  { 12793, 32, 35, 32, 0, -35 },
  { 12933, 48, 35, 50, 1, -35 },
  { 13143, 31, 35, 33, 1, -35 },
  { 13279, 32, 51, 33, 0, -35 },
  { 13483, 24, 35, 28, 2, -35 },
  { 13588, 21, 56, 24, 1, -46 },
  { 13735, 7, 64, 33, 13, -49 },
  { 13791, 21, 56, 24, 2, -46 },
  { 13938, 30, 10, 34, 2, -28 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD65PT7B_H_
