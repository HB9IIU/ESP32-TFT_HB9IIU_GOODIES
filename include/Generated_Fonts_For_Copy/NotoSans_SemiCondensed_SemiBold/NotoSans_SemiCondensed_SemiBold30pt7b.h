#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x00, 0x0F, 0xFF, 0xF0,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x38, 0x7F, 0xFF, 0x7F, 0xFF,
  0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xC0,
  0x39, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xFC, 0x3F, 0xF9, 0xFF,
  0xC7, 0x31, 0x3C, 0xC0, 0xF3, 0x01, 0xEC, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xCE, 0x03, 0x3E, 0x0C, 0xEF, 0x3F, 0xBF,
  0xFC, 0xFF, 0xE0, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x7C, 0x03, 0x81, 0xFC, 0x0E, 0x03, 0x9C, 0x1C, 0x0E, 0x38, 0x70,
  0x1C, 0x70, 0xE0, 0x38, 0xE3, 0x80, 0x71, 0xC7, 0x00, 0xE3, 0x9C, 0x01,
  0xC7, 0x39, 0xE1, 0xCE, 0xE7, 0xE3, 0xF9, 0xDE, 0xE3, 0xF7, 0x39, 0xC1,
  0x8E, 0x71, 0x80, 0x38, 0xC3, 0x80, 0x71, 0x87, 0x01, 0xC3, 0x0E, 0x03,
  0x87, 0x18, 0x0E, 0x0E, 0x70, 0x1C, 0x1C, 0xE0, 0x70, 0x1F, 0x80, 0xE0,
  0x1E, 0x00, 0x03, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1E, 0x78, 0x03,
  0x87, 0x80, 0x70, 0xF0, 0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC1, 0xE7, 0xFC, 0x3C, 0xF3, 0xC7, 0x3C,
  0x3D, 0xE7, 0x83, 0xF8, 0xF0, 0x3F, 0x1E, 0x07, 0xC3, 0xE0, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0x7C, 0x3F, 0xC7, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0x1C,
  0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0F,
  0xF0, 0xE0, 0xE1, 0xC3, 0xC3, 0x87, 0x0F, 0x1E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x3C, 0x78, 0xE3, 0xC7, 0x0E, 0x3C, 0x71, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0,
  0x0F, 0x80, 0xEE, 0x0F, 0x78, 0xF1, 0xE1, 0x8C, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x7B, 0xDC, 0xE7, 0x73, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0x7C, 0x78, 0x79, 0xC1, 0xE7, 0x03, 0xBC, 0x0E, 0xF0, 0x3B,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E,
  0x70, 0x79, 0xE1, 0xE7, 0x8F, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x07,
  0x87, 0xC7, 0xEF, 0xFF, 0xFF, 0xBD, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x07,
  0x80, 0xFF, 0x87, 0xFF, 0x3F, 0x7C, 0x60, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x03, 0xFF, 0x3F, 0xFC, 0xF3, 0xF2, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xF0, 0x3F, 0xFF, 0xEF, 0xFF,
  0x3F, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xEF, 0x07, 0x3C, 0x1C, 0xF0, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0xE0,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF8, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x01,
  0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xC2, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x73, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF, 0x1E, 0xF8, 0x3B, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0x70, 0x3D, 0xE0, 0xE7, 0x87, 0x8F, 0xFE, 0x1F, 0xF0,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x3E, 0x70, 0x79,
  0xC0, 0xE7, 0x07, 0x9E, 0x1E, 0x3C, 0xF0, 0xFF, 0x80, 0xFC, 0x07, 0xF8,
  0x3D, 0xF1, 0xE3, 0xEF, 0x07, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0x00, 0x7F, 0x03, 0xFE, 0x1F,
  0x7C, 0x70, 0x7B, 0xC1, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xDF, 0xFF, 0x7F, 0xF8, 0x7E, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x4F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x33, 0xDE, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xEF, 0x73, 0xBD, 0xCE, 0x00, 0x00, 0x0C, 0x00, 0xF0,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x80,
  0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x07, 0x07, 0xFC, 0xFF, 0xE7, 0x9F,
  0x40, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03,
  0xC0, 0x7C, 0x1E, 0x00, 0x70, 0xF0, 0x00, 0xE3, 0x83, 0xE1, 0x9C, 0x3F,
  0xC7, 0x71, 0xE7, 0x1D, 0xC7, 0x1C, 0x76, 0x38, 0x70, 0xD8, 0xE1, 0xC3,
  0xE3, 0x87, 0x0F, 0x8E, 0x1C, 0x7E, 0x38, 0x71, 0xD8, 0xE3, 0xC6, 0x71,
  0xFF, 0xF9, 0xC7, 0xE7, 0xC7, 0x03, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x06, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00, 0x73,
  0xC0, 0x3C, 0xF0, 0x0F, 0x1C, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xF0, 0x1C, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xF1, 0xFF,
  0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0xE7, 0x87, 0xEF, 0x03, 0xDE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE,
  0x00, 0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x7C, 0x05, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0xCF, 0xFF,
  0x1F, 0xFC, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB,
  0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEE, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0xFF,
  0x1F, 0xFE, 0x3F, 0xBE, 0x7C, 0x02, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFE, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xE0, 0xFF, 0xFF, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7E, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFE, 0xFE, 0xF8, 0xE0, 0x3F, 0xC0, 0xF3,
  0x83, 0xC7, 0x07, 0x8E, 0x1E, 0x1C, 0x78, 0x39, 0xF0, 0x73, 0xC0, 0xEF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0x78,
  0x70, 0xF8, 0xE0, 0xF1, 0xC1, 0xF3, 0x81, 0xE7, 0x01, 0xEE, 0x03, 0xE0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x77, 0xEE,
  0x07, 0x7E, 0xE0, 0x77, 0xEE, 0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x0E, 0x7E,
  0x71, 0xC7, 0xE3, 0x9C, 0x7E, 0x39, 0xC7, 0xE3, 0xB8, 0x7E, 0x3F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0,
  0x70, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xEF, 0x07, 0xEF, 0x07, 0xE7, 0x87, 0xE7, 0x87, 0xE3, 0xC7, 0xE1,
  0xE7, 0xE1, 0xE7, 0xE0, 0xF7, 0xE0, 0xF7, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0x01, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0xE0, 0xFD, 0xFC, 0x7C, 0x0F, 0x1E, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x9E, 0x03, 0xE7,
  0xC1, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xE3, 0xFF,
  0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7B, 0xC3, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xFC, 0x7C, 0x0F, 0x1E, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07,
  0x9E, 0x03, 0xE7, 0xC1, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFF,
  0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x1E, 0xF0, 0x79, 0xE7, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x79, 0xE0, 0xFB, 0xC0, 0xF7, 0x81,
  0xFF, 0x01, 0xE0, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF, 0xE7, 0x81, 0x38,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xF8, 0x3D, 0xFF, 0xEF,
  0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF0, 0xF0, 0x07, 0xB8, 0x03, 0xDE, 0x01, 0xCF, 0x01, 0xE3, 0x80, 0xF1,
  0xC0, 0x70, 0xF0, 0x38, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x0E, 0x07, 0x8F,
  0x01, 0xC7, 0x80, 0xE3, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07,
  0x70, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xF7, 0x01, 0xF0, 0x3D, 0xE0, 0xFC, 0x0E, 0x78,
  0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE3, 0x83, 0xF8, 0x78, 0xE1, 0xCE, 0x1C,
  0x3C, 0x73, 0x8F, 0x0F, 0x1C, 0xE3, 0xC1, 0xC7, 0x38, 0xF0, 0x73, 0xC7,
  0x38, 0x1E, 0xE1, 0xCE, 0x07, 0xB8, 0x77, 0x80, 0xEE, 0x1D, 0xE0, 0x3B,
  0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x1E, 0x0F, 0x0F,
  0x07, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7B,
  0xC0, 0x3D, 0xE0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x0F, 0x1F, 0x07, 0xCF,
  0x01, 0xEF, 0x00, 0xF8, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1C,
  0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0x38, 0x0E, 0x70, 0x38, 0x70, 0x70,
  0xE1, 0xC0, 0xE3, 0x81, 0xCE, 0x01, 0xDC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0x01, 0x81, 0xFF, 0x0F, 0xFC, 0x71,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE1, 0xFF, 0x3F, 0xFB, 0xF3, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xEF, 0xF7, 0x3F, 0x38, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x08, 0x3D, 0xF8,
  0xFF, 0xF3, 0xFF, 0xEF, 0x87, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBE, 0x1E, 0xFF, 0xFB, 0xBF,
  0xCE, 0x7E, 0x00, 0x01, 0x00, 0xFF, 0x3F, 0xF3, 0xEE, 0x78, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0xC1,
  0x3F, 0xF3, 0xFF, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x63, 0xC7, 0xE7, 0x3F, 0xDD, 0xFF, 0xF7, 0x83,
  0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0,
  0xF7, 0x83, 0xDE, 0x1F, 0x3F, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0x01, 0x00,
  0x7F, 0x83, 0xFF, 0x0F, 0x3E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x23, 0xFF,
  0x87, 0xFE, 0x0F, 0xF0, 0x07, 0xE1, 0xFC, 0x7F, 0x8F, 0x01, 0xE0, 0x38,
  0x07, 0x03, 0xFE, 0xFF, 0xDF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x06, 0x00, 0x7E, 0x73, 0xFD, 0xDF, 0xBF, 0x78, 0x3D, 0xE0, 0xF7, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x0F, 0x78, 0x3D, 0xE1,
  0xF3, 0xFF, 0xCF, 0xF7, 0x1F, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x60,
  0x7D, 0xFF, 0xE7, 0xFF, 0x0F, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC6, 0x1E, 0xFE, 0xFF, 0xF7, 0xFF, 0xFE, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xE0, 0x4F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x3C, 0x78, 0xF0,
  0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xEF, 0xDF, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x1E, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFB, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC1, 0xEF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0xC3, 0x9F, 0x8F, 0xEE, 0xFF, 0x7F,
  0xBF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC,
  0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F,
  0xF0, 0x78, 0x3C, 0x00, 0x87, 0x3F, 0xBB, 0xFF, 0xFF, 0xFF, 0x87, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x38, 0x01, 0x00, 0x3F, 0xC0, 0xFF,
  0xE1, 0xF7, 0xC7, 0x83, 0xCF, 0x07, 0x9C, 0x07, 0x78, 0x0E, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x73, 0x80, 0xE7, 0x83, 0xCF, 0x07, 0x8F, 0xFE, 0x0F,
  0xF8, 0x0F, 0xE0, 0x00, 0x83, 0x9F, 0x8F, 0xFF, 0x3F, 0x7E, 0xF8, 0x7B,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7B, 0xE1, 0xEF, 0xFF, 0xBF, 0xFC, 0xF7, 0xE3, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x7E,
  0x73, 0xFD, 0xDF, 0xBF, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x0F, 0x78, 0x3D, 0xE1, 0xF3, 0xFF, 0xCF,
  0xF7, 0x1F, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x01, 0xF9, 0xEE, 0xFB, 0xFE, 0xFC, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x06, 0x07, 0xFD, 0xFF, 0xFC, 0x6F, 0x01, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x03, 0xFF, 0xFF, 0xFE, 0x7F,
  0x80, 0x18, 0x1C, 0x0E, 0x07, 0x0F, 0xFF, 0xFF, 0xFE, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1F, 0xCF, 0xE3, 0xF0,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xBF, 0xFD, 0xFE,
  0xE7, 0xE7, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0x87,
  0x8F, 0x0F, 0x1E, 0x0E, 0x38, 0x1C, 0xF0, 0x3D, 0xE0, 0x3B, 0x80, 0x77,
  0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xF0, 0x7C, 0x1E, 0xE0,
  0xF8, 0x39, 0xE1, 0xF0, 0xF3, 0xC3, 0x61, 0xE7, 0x8E, 0xE3, 0x87, 0x1D,
  0xC7, 0x0F, 0x3B, 0x9E, 0x1E, 0x67, 0x3C, 0x1D, 0xC7, 0x70, 0x3B, 0x8E,
  0xE0, 0x77, 0x1D, 0xC0, 0xEE, 0x3F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x78, 0x78, 0xF1, 0xE0,
  0xF7, 0x81, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0xC0, 0x3B, 0x80, 0xF7, 0x83, 0xC7, 0x87, 0x8F, 0x1E, 0x0F, 0x7C, 0x0F,
  0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0x87, 0x8F, 0x0F,
  0x1E, 0x0E, 0x38, 0x1E, 0x70, 0x1D, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x87, 0xC7, 0xC3, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x1F, 0x8F, 0x07, 0xC0, 0xF0, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3F, 0x0F, 0x80, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x3F, 0x07, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xE0, 0x3F, 0x07, 0xC3, 0xF1, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0xC3, 0xF0, 0xF8, 0x30, 0x00, 0x3C, 0x07, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFE, 0x80, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 9, 7, 13, 2, -21 },
  { 20, 16, 21, 18, 1, -21 },
  { 62, 14, 25, 16, 1, -23 },
  { 106, 23, 22, 25, 1, -22 },
  { 170, 19, 22, 20, 1, -22 },
  { 223, 3, 7, 7, 2, -21 },
  { 226, 8, 26, 10, 1, -21 },
  { 252, 7, 26, 10, 1, -21 },
  { 275, 13, 13, 15, 1, -23 },
  { 297, 14, 15, 16, 1, -18 },
  { 324, 5, 7, 8, 1, -3 },
  { 329, 7, 4, 9, 1, -10 },
  { 333, 4, 4, 8, 2, -4 },
  { 335, 12, 22, 12, 0, -22 },
  { 368, 14, 22, 16, 1, -22 },
  { 407, 9, 21, 16, 2, -21 },
  { 431, 14, 22, 16, 1, -22 },
  { 470, 13, 22, 16, 1, -22 },
  { 506, 14, 21, 16, 1, -21 },
  { 543, 12, 21, 16, 2, -21 },
  { 575, 14, 22, 16, 1, -22 },
  { 614, 14, 21, 16, 1, -21 },
  { 651, 14, 22, 16, 1, -22 },
  { 690, 14, 22, 16, 1, -22 },
  { 729, 4, 17, 8, 2, -17 },
  { 738, 5, 21, 8, 1, -17 },
  { 752, 14, 15, 16, 1, -18 },
  { 779, 14, 9, 16, 1, -15 },
  { 795, 14, 15, 16, 1, -18 },
  { 822, 12, 22, 13, 0, -22 },
  { 855, 22, 24, 25, 1, -22 },
  { 921, 18, 21, 18, 0, -21 },
  { 969, 15, 21, 18, 2, -21 },
  { 1009, 14, 22, 17, 2, -22 },
  { 1048, 16, 21, 20, 2, -21 },
  { 1090, 11, 21, 15, 3, -21 },
  { 1119, 11, 21, 15, 3, -21 },
  { 1148, 16, 22, 20, 2, -22 },
  { 1192, 15, 21, 21, 3, -21 },
  { 1232, 8, 21, 10, 1, -21 },
  { 1253, 8, 27, 9, -2, -21 },
  { 1280, 15, 21, 18, 3, -21 },
  { 1320, 12, 21, 15, 2, -21 },
  { 1352, 20, 21, 26, 3, -21 },
  { 1405, 16, 21, 22, 3, -21 },
  { 1447, 18, 22, 21, 2, -22 },
  { 1497, 14, 21, 17, 2, -21 },
  { 1534, 18, 27, 21, 2, -22 },
  { 1595, 15, 21, 18, 2, -21 },
  { 1635, 13, 22, 15, 1, -22 },
  { 1671, 15, 21, 15, 0, -21 },
  { 1711, 16, 21, 20, 2, -21 },
  { 1753, 17, 21, 17, 0, -21 },
  { 1798, 26, 21, 26, 0, -21 },
  { 1867, 17, 21, 17, 0, -21 },
  { 1912, 16, 21, 16, 0, -21 },
  { 1954, 14, 21, 15, 1, -21 },
  { 1991, 7, 26, 10, 2, -21 },
  { 2014, 12, 22, 12, 0, -22 },
  { 2047, 7, 26, 10, 1, -21 },
  { 2070, 15, 14, 16, 1, -22 },
  { 2097, 13, 2, 13, 0, 3 },
  { 2101, 7, 5, 10, 1, -23 },
  { 2106, 13, 17, 16, 1, -17 },
  { 2134, 14, 23, 17, 2, -23 },
  { 2175, 12, 17, 14, 1, -17 },
  { 2201, 14, 23, 17, 1, -23 },
  { 2242, 14, 17, 16, 1, -17 },
  { 2272, 11, 23, 10, 0, -23 },
  { 2304, 14, 24, 17, 1, -17 },
  { 2346, 13, 23, 17, 2, -23 },
  { 2384, 4, 23, 8, 2, -23 },
  { 2396, 7, 30, 8, -1, -23 },
  { 2423, 14, 23, 16, 2, -23 },
  { 2464, 4, 23, 8, 2, -23 },
  { 2476, 22, 17, 26, 2, -17 },
  { 2523, 13, 17, 17, 2, -17 },
  { 2551, 15, 17, 17, 1, -17 },
  { 2583, 14, 24, 17, 2, -17 },
  { 2625, 14, 24, 17, 1, -17 },
  { 2667, 10, 17, 12, 2, -17 },
  { 2689, 11, 17, 13, 1, -17 },
  { 2713, 9, 20, 11, 1, -20 },
  { 2736, 13, 16, 17, 2, -16 },
  { 2762, 15, 16, 15, 0, -16 },
  { 2792, 23, 16, 23, 0, -16 },
  { 2838, 15, 16, 15, 0, -16 },
  { 2868, 15, 23, 15, 0, -16 },
  { 2912, 11, 16, 13, 1, -16 },
  { 2934, 9, 26, 11, 1, -21 },
  { 2964, 3, 30, 15, 6, -23 },
  { 2976, 10, 26, 11, 1, -21 },
  { 3009, 14, 5, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD30PT7B_H_
