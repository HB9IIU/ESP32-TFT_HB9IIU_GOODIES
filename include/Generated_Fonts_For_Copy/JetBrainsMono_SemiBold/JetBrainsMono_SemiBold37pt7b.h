#ifndef _JETBRAINSMONO_SEMIBOLD37PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE3, 0x80, 0x00, 0x03, 0x3F, 0xFF, 0xF7, 0x80, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xF0, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x38,
  0x1C, 0x03, 0x83, 0xC0, 0x38, 0x38, 0x03, 0x83, 0x87, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x0E, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1C, 0x0E, 0x01, 0xC1, 0xE0, 0x1C, 0x1C,
  0x03, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0x33, 0xE7, 0x8C, 0x79,
  0xE3, 0x1F, 0x78, 0xC0, 0x1E, 0x30, 0x07, 0xCC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x33,
  0xE0, 0x0C, 0x7C, 0x03, 0x1F, 0x00, 0xC3, 0xFE, 0x30, 0xFF, 0x8C, 0x7D,
  0xF3, 0x1E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x80, 0x1C, 0xFF, 0x00, 0xE7, 0xFE, 0x07, 0x1C, 0x38, 0x3C, 0xF0, 0xE0,
  0xE3, 0xC3, 0x87, 0x0F, 0x0E, 0x3C, 0x3C, 0x38, 0xE0, 0x70, 0xE7, 0x01,
  0xFF, 0xBC, 0x03, 0xFC, 0xE0, 0x07, 0xE7, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x39, 0xF8, 0x01, 0xEF, 0xF8, 0x07, 0x3F,
  0xE0, 0x39, 0xC3, 0xC1, 0xE7, 0x07, 0x07, 0x1C, 0x1C, 0x38, 0x70, 0x71,
  0xC1, 0xC1, 0xCF, 0x07, 0x0F, 0x38, 0x0F, 0xF9, 0xC0, 0x3F, 0xEF, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0x1F, 0x03,
  0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3E,
  0xF0, 0xFF, 0x8F, 0x1E, 0xF1, 0xF7, 0x9E, 0x1E, 0xF3, 0xC1, 0xFC, 0x78,
  0x3F, 0x8F, 0x03, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0xC7, 0xE7, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFE, 0x78, 0x7F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0,
  0xFF, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xE0,
  0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x3F, 0x8F, 0xF0, 0xFC, 0x0F, 0x80, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x04,
  0x0F, 0x02, 0x78, 0x71, 0xE7, 0xE6, 0x3E, 0xFF, 0x6F, 0xF7, 0xFF, 0xFE,
  0x07, 0xFE, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x07, 0x9E,
  0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0x40,
  0x20, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xCF, 0xEF, 0x81, 0xF7, 0x80,
  0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x39, 0xFF, 0x3C, 0xFF, 0x9E, 0x7F, 0xCF, 0x3F, 0xE3, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xE0,
  0x7C, 0xFC, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF, 0x83, 0xC7,
  0xC1, 0x83, 0xE0, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xF0, 0x3E, 0xFE, 0x7E,
  0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7E,
  0x7F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE7, 0x00, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0xFF, 0xE7, 0xC0, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0xF9, 0xFC,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0x7B,
  0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xCF, 0xEF, 0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0xF8, 0x0F, 0x3C, 0x0F, 0x9F, 0x0F, 0x87, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xF0, 0xFC, 0x7C, 0xF8, 0x1F, 0x78, 0x07, 0xBC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7D, 0xFC, 0xFE,
  0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFC, 0xFE, 0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x0F,
  0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xBC, 0x03, 0x9F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x33, 0xFF, 0xFF, 0xFD,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0x7C,
  0x0E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xC3,
  0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7E, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xE0, 0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xE7, 0xF0, 0x7F, 0x7F, 0x0F, 0xFF, 0xF0,
  0xF0, 0xFF, 0x0E, 0x0F, 0xF0, 0xE0, 0xFF, 0x0E, 0x0F, 0xF0, 0xE0, 0xFF,
  0x0E, 0x0F, 0xF0, 0xE0, 0xFF, 0x0E, 0x0F, 0xF0, 0xE0, 0xFF, 0x0F, 0x0F,
  0xF0, 0xFF, 0xFF, 0x07, 0xF7, 0xF0, 0x3E, 0x77, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF8,
  0x01, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x01,
  0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x07, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xE0, 0x3E,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xEF, 0xEF, 0x81, 0xF7, 0x80,
  0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xE0,
  0x7C, 0xFE, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xF7, 0x80, 0xFB, 0xC0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0xFB, 0xC0, 0xFD, 0xFF,
  0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xEF, 0xEF, 0x81, 0xF7, 0x80,
  0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xE0,
  0x7C, 0xFE, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xE7,
  0xC0, 0xF9, 0xFC, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xF0,
  0x07, 0xFC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x0F,
  0x8F, 0x03, 0xE3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x0F, 0x83,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xC3, 0xE0, 0xF0,
  0xF8, 0x3C, 0x1F, 0x0F, 0x07, 0xC3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3C, 0x07,
  0x8F, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0x7C,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xB8, 0x3F, 0xEE, 0x1D, 0xFF, 0x87, 0x7F, 0xE1, 0xDF, 0xDC, 0xEF,
  0xF7, 0x3B, 0xFD, 0xCE, 0xFF, 0x3B, 0xBF, 0xCF, 0xCF, 0xF3, 0xF3, 0xFC,
  0x7C, 0xFF, 0x1E, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xEE, 0x0F, 0xEE, 0x0F, 0xFF, 0x0F, 0xF7,
  0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1,
  0xCF, 0xF1, 0xEF, 0xF1, 0xEF, 0xF0, 0xE7, 0xF0, 0xF7, 0xF0, 0xF7, 0xF0,
  0x77, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xF0, 0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x7F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xCF, 0xEF, 0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xE0, 0x7C, 0xFF, 0xFE, 0x7F,
  0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x7C,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xF0, 0xF8, 0x3C,
  0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x8F, 0x01,
  0xE3, 0xC0, 0x7C, 0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0xFC, 0x07, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFC, 0xFE, 0x7C, 0x0F, 0x9E, 0x01, 0xE7,
  0x80, 0x7D, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7,
  0xC0, 0x79, 0xFE, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7F, 0x7E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78,
  0x01, 0xE7, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3,
  0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x78,
  0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0x8F,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xBC, 0x3C, 0x1D, 0xE1, 0xE1,
  0xEF, 0x0F, 0x8F, 0x78, 0x7C, 0x7B, 0xC7, 0xE3, 0xDE, 0x3B, 0x1E, 0x71,
  0xD8, 0xF3, 0x8C, 0xC7, 0x1C, 0x66, 0x38, 0xF3, 0x31, 0xC7, 0x99, 0x8E,
  0x3C, 0xCE, 0x71, 0xE6, 0x77, 0x8F, 0x73, 0xBC, 0x7B, 0x8D, 0xE1, 0xDC,
  0x6F, 0x0E, 0xC3, 0x70, 0x76, 0x1B, 0x83, 0xB0, 0xDC, 0x1D, 0x86, 0xE0,
  0xEC, 0x3F, 0x07, 0x61, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1,
  0xF0, 0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1F,
  0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0xDE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0x9E,
  0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0xC3, 0xE0,
  0x7C, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF7,
  0x80, 0x1F, 0x7C, 0x01, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xC1, 0xE0, 0x7C,
  0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9E,
  0x00, 0x7D, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x73, 0xC0, 0x79,
  0xE0, 0x3C, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x1E, 0x07, 0x8F, 0x03, 0xCF,
  0x00, 0xF7, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0xE0, 0x07, 0xFE, 0x07,
  0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0xFB, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xDF, 0xFF, 0xE7,
  0xFE, 0xF1, 0xFE, 0x78, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE, 0xF7, 0xFE,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xF7, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0x03, 0xC0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xC3, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x3F, 0xE0, 0x1E, 0xF8, 0x1F, 0x3F, 0xBF,
  0x9F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x0F, 0x1F, 0xCF, 0x7F,
  0xEF, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFE, 0x7F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F,
  0xCF, 0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x7C,
  0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1F, 0xCF,
  0x3F, 0xEF, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xCF, 0x07, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE, 0xF7, 0xFE,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xFE,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFC, 0x3F, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x3E, 0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x7C,
  0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0,
  0x7C, 0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7C, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0x06, 0x3D, 0xF7, 0xEF, 0xFD, 0xFF, 0xEF,
  0xDF, 0xF1, 0xE3, 0xFC, 0x38, 0xFF, 0x0E, 0x3F, 0xC3, 0x8F, 0xF0, 0xE3,
  0xFC, 0x38, 0xFF, 0x0E, 0x3F, 0xC3, 0x8F, 0xF0, 0xE3, 0xFC, 0x38, 0xFF,
  0x0E, 0x3F, 0xC3, 0x8F, 0xF0, 0xE3, 0xFC, 0x38, 0xFF, 0x0E, 0x3F, 0xC3,
  0x8F, 0xF0, 0xE3, 0xC0, 0x00, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE, 0xF7, 0xFE,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xC0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xFE, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0xF3, 0xFC, 0xF7, 0xFE, 0xF7, 0xFE,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xF7, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7E, 0x7F,
  0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0xF7, 0xFC,
  0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF, 0x81,
  0xF7, 0xC0, 0x7B, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0xF0, 0x0F, 0xFE, 0x0F, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7F, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0xF0, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7,
  0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x1F, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x01,
  0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0xF0, 0xF0, 0x7F, 0x0F, 0x07, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0x70, 0xF8, 0xF7, 0x1F, 0x8E, 0x71, 0xD8, 0xE7, 0x99, 0x8E, 0x79, 0x98,
  0xE7, 0x99, 0x9E, 0x39, 0x9D, 0xE3, 0x99, 0xDC, 0x3B, 0x9D, 0xC3, 0xB8,
  0xDC, 0x3F, 0x0D, 0xC3, 0xF0, 0xDC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x07, 0x80,
  0xF0, 0xF8, 0x0F, 0x9F, 0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x7D, 0xE0, 0x0F, 0x9F, 0x01, 0xF0, 0xF8, 0x1F, 0x07, 0x83, 0xE0,
  0x7C, 0x7C, 0x03, 0xEF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xF9, 0xE0,
  0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x83, 0xC0, 0xF0,
  0xF8, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0xFF,
  0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x03, 0xDF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xCF, 0x8F, 0xF1, 0xF3, 0xFC, 0x3F, 0xFF, 0x07, 0xFB, 0xC0, 0xFC,
};

const GFXglyph JetBrainsMono_SemiBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 27, 22, 8, -27 },
  { 22, 12, 11, 22, 5, -27 },
  { 39, 20, 27, 22, 1, -27 },
  { 107, 18, 37, 22, 2, -32 },
  { 191, 22, 27, 22, 0, -27 },
  { 266, 19, 27, 22, 2, -27 },
  { 331, 4, 11, 22, 9, -27 },
  { 337, 12, 35, 22, 6, -31 },
  { 390, 12, 35, 22, 4, -31 },
  { 443, 20, 20, 22, 1, -23 },
  { 493, 18, 18, 22, 2, -21 },
  { 534, 8, 12, 22, 6, -6 },
  { 546, 12, 4, 22, 5, -14 },
  { 552, 6, 6, 22, 8, -6 },
  { 557, 18, 35, 22, 2, -31 },
  { 636, 17, 27, 22, 3, -27 },
  { 694, 17, 27, 22, 3, -27 },
  { 752, 18, 27, 22, 2, -27 },
  { 813, 17, 27, 22, 2, -27 },
  { 871, 16, 27, 22, 3, -27 },
  { 925, 16, 27, 22, 3, -27 },
  { 979, 18, 27, 22, 2, -27 },
  { 1040, 18, 27, 22, 2, -27 },
  { 1101, 17, 27, 22, 3, -27 },
  { 1159, 18, 27, 22, 2, -27 },
  { 1220, 6, 21, 22, 8, -21 },
  { 1236, 9, 27, 22, 6, -21 },
  { 1267, 16, 20, 22, 3, -22 },
  { 1307, 16, 13, 22, 3, -19 },
  { 1333, 16, 20, 22, 3, -22 },
  { 1373, 14, 27, 22, 5, -27 },
  { 1421, 20, 34, 22, 1, -27 },
  { 1506, 20, 27, 22, 1, -27 },
  { 1574, 17, 27, 22, 3, -27 },
  { 1632, 17, 27, 22, 3, -27 },
  { 1690, 17, 27, 22, 3, -27 },
  { 1748, 16, 27, 22, 3, -27 },
  { 1802, 17, 27, 22, 3, -27 },
  { 1860, 17, 27, 22, 3, -27 },
  { 1918, 16, 27, 22, 3, -27 },
  { 1972, 16, 27, 22, 3, -27 },
  { 2026, 18, 27, 22, 1, -27 },
  { 2087, 18, 27, 22, 3, -27 },
  { 2148, 16, 27, 22, 4, -27 },
  { 2202, 18, 27, 22, 2, -27 },
  { 2263, 16, 27, 22, 3, -27 },
  { 2317, 16, 27, 22, 3, -27 },
  { 2371, 18, 27, 22, 3, -27 },
  { 2432, 17, 34, 22, 3, -27 },
  { 2505, 18, 27, 22, 3, -27 },
  { 2566, 18, 27, 22, 2, -27 },
  { 2627, 18, 27, 22, 2, -27 },
  { 2688, 16, 27, 22, 3, -27 },
  { 2742, 20, 27, 22, 1, -27 },
  { 2810, 21, 27, 22, 1, -27 },
  { 2881, 20, 27, 22, 1, -27 },
  { 2949, 20, 27, 22, 1, -27 },
  { 3017, 16, 27, 22, 3, -27 },
  { 3071, 10, 35, 22, 7, -31 },
  { 3115, 18, 35, 22, 2, -31 },
  { 3194, 10, 35, 22, 5, -31 },
  { 3238, 17, 14, 22, 3, -27 },
  { 3268, 18, 4, 22, 2, 1 },
  { 3277, 9, 5, 22, 6, -29 },
  { 3283, 17, 21, 22, 2, -21 },
  { 3328, 16, 27, 22, 3, -27 },
  { 3382, 17, 21, 22, 3, -21 },
  { 3427, 16, 27, 22, 3, -27 },
  { 3481, 16, 21, 22, 3, -21 },
  { 3523, 18, 27, 22, 2, -27 },
  { 3584, 16, 28, 22, 3, -21 },
  { 3640, 16, 27, 22, 3, -27 },
  { 3694, 18, 29, 22, 3, -29 },
  { 3760, 14, 36, 22, 3, -29 },
  { 3823, 18, 27, 22, 3, -27 },
  { 3884, 20, 27, 22, 1, -27 },
  { 3952, 18, 21, 22, 2, -21 },
  { 4000, 16, 21, 22, 3, -21 },
  { 4042, 16, 21, 22, 3, -21 },
  { 4084, 16, 28, 22, 3, -21 },
  { 4140, 16, 28, 22, 3, -21 },
  { 4196, 16, 21, 22, 4, -21 },
  { 4238, 17, 21, 22, 3, -21 },
  { 4283, 18, 26, 22, 2, -26 },
  { 4342, 16, 20, 22, 3, -20 },
  { 4382, 19, 20, 22, 2, -20 },
  { 4430, 20, 20, 22, 1, -20 },
  { 4480, 20, 20, 22, 1, -20 },
  { 4530, 19, 27, 22, 2, -20 },
  { 4595, 16, 20, 22, 3, -20 },
  { 4635, 16, 35, 22, 3, -31 },
  { 4705, 4, 35, 22, 9, -31 },
  { 4723, 16, 35, 22, 3, -31 },
  { 4793, 18, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_SemiBold37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_SEMIBOLD37PT7B_H_
