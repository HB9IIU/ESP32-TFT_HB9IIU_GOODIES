#ifndef _JETBRAINSMONO_SEMIBOLD30PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x66, 0x60, 0x00, 0x6F, 0xFF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0,
  0x07, 0x0E, 0x07, 0x0C, 0x06, 0x0C, 0x06, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x18, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x30, 0x18, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x38, 0x70, 0x38, 0x70,
  0x38, 0x60, 0x30, 0x60, 0x30, 0xE0, 0x70, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0xDE, 0xF3, 0x3F,
  0xCC, 0xFF, 0x30, 0x3C, 0xC0, 0x7B, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x0D, 0xF0, 0x33, 0xC0, 0xC7, 0xE3, 0x1F, 0xCC, 0xFF, 0x33,
  0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x3E, 0x01, 0xDF, 0xC0, 0xE7, 0x38, 0x33, 0x8E, 0x1C, 0xE3, 0x8E,
  0x38, 0xE3, 0x0E, 0x39, 0xC1, 0xDE, 0xE0, 0x7F, 0x70, 0x0F, 0x98, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x9E, 0x00, 0xEF, 0xE0, 0x77, 0xB8, 0x19,
  0xC7, 0x0E, 0x71, 0xC7, 0x1C, 0x73, 0x87, 0x1C, 0xC1, 0xCE, 0x70, 0x3F,
  0xB8, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x78, 0x38,
  0x38, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7F,
  0x00, 0x7F, 0x8F, 0xF3, 0x8E, 0xF3, 0xDE, 0xF1, 0xFC, 0xF0, 0xFC, 0xF0,
  0x78, 0xF0, 0x78, 0x70, 0xFC, 0x7F, 0xFC, 0x3F, 0xEE, 0x1F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE0, 0x01, 0xC0, 0xF0, 0xFC, 0x7E, 0x3E, 0x0F, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x1F, 0x03,
  0xF0, 0x7C, 0x07, 0x00, 0x40, 0xE0, 0x3C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x3C, 0x3E,
  0x3F, 0x0F, 0x83, 0x80, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0x80, 0x61, 0x86, 0xF9, 0x9F, 0xFF, 0xFF, 0x3F, 0xFC, 0x01, 0x80,
  0x07, 0xE0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x18, 0x18,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3E, 0x79, 0xF3, 0xC7, 0x8E, 0x3C, 0x78, 0xE1, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x8C,
  0x7E, 0x79, 0xF9, 0xE7, 0xE3, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0x80,
  0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0x78, 0x63, 0xC2, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0xBE, 0x1E, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0x9F, 0xFE,
  0x3F, 0xF0, 0x7F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE1, 0xDE, 0x0E, 0xF0, 0x7F,
  0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x77, 0xE1, 0xFF, 0xE7, 0xFF, 0x9E,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0xF7,
  0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x81, 0xFF,
  0xC7, 0xFF, 0xBE, 0x1E, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0xFF, 0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF,
  0x03, 0x9C, 0x0E, 0x78, 0x78, 0xFF, 0xC0, 0xFC, 0x07, 0xF8, 0x3C, 0xF1,
  0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x07, 0xDF, 0xFE,
  0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBE, 0x1E, 0xF0,
  0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xF7, 0x87, 0xDF,
  0xFE, 0x3F, 0xF8, 0x11, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x31, 0xEF, 0xFF, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x31, 0xEF, 0xFF, 0x78, 0x18, 0x79, 0xFB, 0xF3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0x8F, 0x3C, 0x78, 0xF1,
  0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0xFE, 0x1F, 0xF3, 0xFF, 0x03, 0xE0,
  0x1E, 0x03, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0xF8, 0xFF, 0x1F, 0xC3, 0xE0,
  0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x07, 0xC0, 0x70,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0x3E, 0x78, 0x0E, 0x70, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x67, 0xE1, 0xFF, 0xE3, 0xFF, 0xE3, 0x87, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3,
  0x87, 0xE1, 0xFB, 0xE1, 0xF7, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x3C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70,
  0x0E, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xFF, 0xCF, 0xFC, 0x3F, 0xFC,
  0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x07,
  0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E,
  0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3F,
  0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xBF, 0xFE, 0xFF, 0xE3, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F,
  0xF0, 0x7F, 0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0x87,
  0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7,
  0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0x71, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x03, 0xC0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xF6, 0x1B, 0xF8, 0x7F, 0xF3, 0xFE, 0xCD,
  0xFB, 0x37, 0xEF, 0xDF, 0xBF, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x70, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F,
  0xB8, 0xFE, 0xE3, 0xFB, 0x8F, 0xE7, 0x3F, 0x9C, 0xFF, 0x73, 0xFC, 0xEF,
  0xF3, 0xBF, 0xCE, 0x7F, 0x1D, 0xFC, 0x77, 0xF1, 0xDF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xF0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E,
  0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF,
  0xE3, 0xFF, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7B, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xEF, 0x03,
  0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE7,
  0xFF, 0x8F, 0xFE, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF1, 0xE0,
  0xE3, 0xC1, 0xE7, 0x81, 0xCF, 0x03, 0xDE, 0x07, 0xC0, 0x0F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xF0,
  0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1E,
  0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x47, 0xE2,
  0x67, 0x66, 0x66, 0x76, 0x6E, 0x76, 0x6E, 0x76, 0x6E, 0x76, 0x6E, 0x76,
  0x6E, 0x76, 0x6E, 0x76, 0x6E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0xF0, 0x0F, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x1C,
  0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x1C,
  0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0xFC,
  0x03, 0xF0, 0x1C, 0xE0, 0x73, 0x83, 0xCF, 0x0E, 0x1C, 0x38, 0x71, 0xC0,
  0xE7, 0x03, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0,
  0xE0, 0xE1, 0xE0, 0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x3C,
  0x00, 0xF0, 0x03, 0xC3, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xDF, 0xFF, 0x3F, 0xBC, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x0F, 0x7F, 0x3F, 0xFE, 0xFC,
  0xFB, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xBF, 0xFE, 0xFF, 0xF3, 0xDF, 0x80,
  0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0xF0, 0x3D, 0xE1,
  0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x3C, 0xF3, 0xFB, 0xDF, 0xFF, 0x7C, 0xFF, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xF7, 0x87, 0xDF, 0xFF, 0x3F, 0xBC, 0x7C, 0xF0, 0x07, 0x80, 0x7F,
  0x83, 0xFF, 0x1E, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0xF7, 0xFF, 0x8F,
  0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF,
  0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFB, 0xC7, 0xCF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x0F, 0x7F, 0x3F, 0xFE, 0xFC,
  0xFB, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0,
  0x01, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x0F,
  0x01, 0xF0, 0x1F, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x03, 0xFC, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xE1, 0xE3,
  0xC3, 0xC7, 0x8F, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x78, 0xF0, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC1, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x03, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xEE, 0x33, 0xFD, 0xFF, 0xFF,
  0xF9, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C,
  0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3,
  0x1C, 0xF3, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF, 0x3E, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x07, 0x80, 0x7F, 0x83, 0xFF,
  0x1F, 0x3E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xE0, 0xF3, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF, 0x1E, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE1, 0xEF, 0xFF, 0xBF, 0xFC, 0xF7, 0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDE, 0x3F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3D, 0xE1, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xE3, 0xC3, 0xBF, 0xCE, 0xFF,
  0x3E, 0x3E, 0xF0, 0x7B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1F, 0x70, 0x3D, 0xC0, 0x07,
  0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F,
  0xC0, 0xF7, 0xFF, 0xDF, 0xFE, 0x1F, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x39, 0xE1, 0xE7,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78,
  0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E,
  0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0xE1, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0x63, 0xC6, 0x76, 0x4E, 0x76, 0x6E, 0x76, 0x6E, 0x76,
  0x6E, 0x76, 0x6E, 0x36, 0x6C, 0x34, 0x6C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C,
  0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC3,
  0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x3C, 0x1F, 0xF8, 0x7F, 0xF1, 0xF9, 0xE7,
  0xE3, 0xFF, 0x87, 0xE0, 0x07, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 22, 18, 7, -22 },
  { 12, 10, 9, 18, 4, -22 },
  { 24, 16, 22, 18, 1, -22 },
  { 68, 14, 30, 18, 2, -26 },
  { 121, 18, 22, 18, 0, -22 },
  { 171, 16, 22, 18, 1, -22 },
  { 215, 4, 9, 18, 7, -22 },
  { 220, 10, 29, 18, 5, -25 },
  { 257, 10, 29, 18, 3, -25 },
  { 294, 16, 15, 18, 1, -18 },
  { 324, 14, 14, 18, 2, -17 },
  { 349, 7, 10, 18, 5, -5 },
  { 358, 10, 3, 18, 4, -11 },
  { 362, 6, 5, 18, 6, -5 },
  { 366, 14, 28, 18, 2, -25 },
  { 415, 14, 22, 18, 2, -22 },
  { 454, 13, 22, 18, 3, -22 },
  { 490, 14, 22, 18, 2, -22 },
  { 529, 14, 22, 18, 2, -22 },
  { 568, 13, 22, 18, 2, -22 },
  { 604, 14, 22, 18, 2, -22 },
  { 643, 14, 22, 18, 2, -22 },
  { 682, 14, 22, 18, 2, -22 },
  { 721, 14, 22, 18, 2, -22 },
  { 760, 14, 22, 18, 2, -22 },
  { 799, 6, 17, 18, 6, -17 },
  { 812, 7, 22, 18, 5, -17 },
  { 832, 14, 16, 18, 2, -18 },
  { 860, 14, 10, 18, 2, -15 },
  { 878, 14, 16, 18, 2, -18 },
  { 906, 11, 22, 18, 4, -22 },
  { 937, 16, 27, 18, 1, -22 },
  { 991, 16, 22, 18, 1, -22 },
  { 1035, 14, 22, 18, 2, -22 },
  { 1074, 14, 22, 18, 2, -22 },
  { 1113, 14, 22, 18, 2, -22 },
  { 1152, 13, 22, 18, 3, -22 },
  { 1188, 13, 22, 18, 3, -22 },
  { 1224, 14, 22, 18, 2, -22 },
  { 1263, 14, 22, 18, 2, -22 },
  { 1302, 12, 22, 18, 3, -22 },
  { 1335, 14, 22, 18, 1, -22 },
  { 1374, 15, 22, 18, 2, -22 },
  { 1416, 13, 22, 18, 3, -22 },
  { 1452, 14, 22, 18, 2, -22 },
  { 1491, 14, 22, 18, 2, -22 },
  { 1530, 14, 22, 18, 2, -22 },
  { 1569, 15, 22, 18, 2, -22 },
  { 1611, 14, 27, 18, 2, -22 },
  { 1659, 15, 22, 18, 2, -22 },
  { 1701, 14, 22, 18, 2, -22 },
  { 1740, 16, 22, 18, 1, -22 },
  { 1784, 14, 22, 18, 2, -22 },
  { 1823, 16, 22, 18, 1, -22 },
  { 1867, 16, 22, 18, 1, -22 },
  { 1911, 16, 22, 18, 1, -22 },
  { 1955, 16, 22, 18, 1, -22 },
  { 1999, 14, 22, 18, 2, -22 },
  { 2038, 8, 28, 18, 6, -25 },
  { 2066, 14, 28, 18, 2, -25 },
  { 2115, 8, 28, 18, 4, -25 },
  { 2143, 14, 12, 18, 2, -22 },
  { 2164, 14, 3, 18, 2, 1 },
  { 2170, 7, 5, 18, 5, -24 },
  { 2175, 14, 17, 18, 2, -17 },
  { 2205, 14, 22, 18, 2, -22 },
  { 2244, 14, 17, 18, 2, -17 },
  { 2274, 14, 22, 18, 2, -22 },
  { 2313, 14, 17, 18, 2, -17 },
  { 2343, 14, 22, 18, 2, -22 },
  { 2382, 14, 22, 18, 2, -17 },
  { 2421, 14, 22, 18, 2, -22 },
  { 2460, 15, 24, 18, 2, -24 },
  { 2505, 12, 29, 18, 2, -24 },
  { 2549, 15, 22, 18, 2, -22 },
  { 2591, 16, 22, 18, 1, -22 },
  { 2635, 14, 17, 18, 2, -17 },
  { 2665, 14, 17, 18, 2, -17 },
  { 2695, 14, 17, 18, 2, -17 },
  { 2725, 14, 22, 18, 2, -17 },
  { 2764, 14, 22, 18, 2, -17 },
  { 2803, 14, 17, 18, 3, -17 },
  { 2833, 14, 17, 18, 2, -17 },
  { 2863, 15, 21, 18, 1, -21 },
  { 2903, 14, 17, 18, 2, -17 },
  { 2933, 16, 17, 18, 1, -17 },
  { 2967, 16, 17, 18, 1, -17 },
  { 3001, 16, 17, 18, 1, -17 },
  { 3035, 16, 22, 18, 1, -17 },
  { 3079, 14, 17, 18, 2, -17 },
  { 3109, 14, 28, 18, 2, -25 },
  { 3158, 4, 28, 18, 7, -25 },
  { 3172, 14, 28, 18, 2, -25 },
  { 3221, 14, 7, 18, 2, -14 },
};

const GFXfont JetBrainsMono_SemiBold30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_SEMIBOLD30PT7B_H_
