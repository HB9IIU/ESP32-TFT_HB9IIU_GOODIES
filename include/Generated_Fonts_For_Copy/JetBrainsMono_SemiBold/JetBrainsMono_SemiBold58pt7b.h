#ifndef _JETBRAINSMONO_SEMIBOLD58PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold58pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xC7,
  0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0x80, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F,
  0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0x9D, 0xFF,
  0x9F, 0xE3, 0x8F, 0xF3, 0xF8, 0x70, 0xFE, 0x7E, 0x0E, 0x0F, 0xCF, 0xC1,
  0xC1, 0xFF, 0xF8, 0x38, 0x3F, 0xFF, 0x07, 0x00, 0x07, 0xF0, 0xE0, 0x00,
  0xFE, 0x1C, 0x00, 0x1F, 0xE3, 0x80, 0x03, 0xFE, 0x70, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xCF, 0xF8, 0x00, 0x38, 0x7F, 0x80,
  0x07, 0x07, 0xF0, 0x00, 0xE0, 0xFE, 0x00, 0x1C, 0x1F, 0xC0, 0x03, 0x81,
  0xFF, 0xE0, 0x70, 0x7F, 0xFC, 0x0E, 0x0F, 0xFF, 0xC1, 0xC1, 0xFF, 0xFC,
  0x38, 0x7F, 0xFF, 0xC7, 0x1F, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x21, 0xFF, 0x80,
  0x00, 0xF8, 0x7F, 0xF8, 0x00, 0x3E, 0x1F, 0xFF, 0x80, 0x07, 0xC3, 0xFF,
  0xF8, 0x01, 0xF0, 0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x0F, 0x83,
  0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x3F,
  0x01, 0xF0, 0x1E, 0x07, 0xC0, 0x3E, 0x03, 0xC1, 0xF0, 0x07, 0xC0, 0xF8,
  0x7C, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x1F, 0x03, 0xE3, 0xE0, 0x03, 0xFF,
  0xFC, 0xF8, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x03, 0xFF, 0xC7, 0xC0, 0x00,
  0x3F, 0xF1, 0xF0, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x01, 0xF1, 0xFF, 0xC0, 0x00,
  0x3E, 0x7F, 0xFC, 0x00, 0x0F, 0x9F, 0xFF, 0xC0, 0x03, 0xE3, 0xF1, 0xF8,
  0x00, 0xFC, 0x7C, 0x0F, 0x80, 0x1F, 0x1F, 0x01, 0xF0, 0x07, 0xC3, 0xE0,
  0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F,
  0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xF1, 0xF8, 0x01, 0xFF, 0xFC,
  0x3E, 0x00, 0x1F, 0xFF, 0x0F, 0x80, 0x01, 0xFF, 0xC3, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xDF, 0xC0, 0x7E, 0xFE, 0x3F, 0x83, 0xFB,
  0xF0, 0x7F, 0x1F, 0xCF, 0xC1, 0xFC, 0x7F, 0x3F, 0x03, 0xFB, 0xF8, 0xFC,
  0x07, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x0F, 0xC0, 0x3F, 0xF8, 0x3F, 0x00,
  0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0xC3, 0xFE, 0x1F, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0,
  0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xF0, 0x1F, 0xC0, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x10, 0x03, 0xE0, 0x04, 0x78, 0x07, 0xC0,
  0x78, 0xFE, 0x0F, 0x83, 0xF9, 0xFF, 0x1E, 0x1F, 0xF7, 0xFF, 0x1C, 0x7F,
  0xEF, 0xFF, 0xBB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x07, 0xF1, 0xFF, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x18, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x7C, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xE3, 0xF8,
  0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0x8F, 0xE3, 0xFF, 0xF1, 0xFC, 0x7F, 0xFE,
  0x1F, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xF7, 0xF0, 0x07, 0xFC, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xE0, 0x7F, 0x00, 0x70, 0x0F, 0xE0, 0x0C,
  0x01, 0xFC, 0x01, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03,
  0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xDF,
  0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x03, 0xF9,
  0xFF, 0xC0, 0x7F, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE3, 0xFF, 0x3F,
  0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x0F,
  0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xF0, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC, 0x01, 0xFE,
  0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xE3, 0xFF, 0xDF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0xC0,
  0x3F, 0xFB, 0xF8, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xF3, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x7F, 0x8F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xF1, 0xFC, 0x06,
  0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0,
  0xFF, 0x83, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0x3F, 0xFC, 0x03,
  0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x3F, 0xFE, 0xFF, 0xE0, 0x7F,
  0x07, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xF0, 0x0F, 0xFF, 0x07, 0xE0,
  0x1F, 0xFE, 0x0F, 0xC0, 0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0xF8, 0x3F, 0x00,
  0xFF, 0xF0, 0x7E, 0x01, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0xC1, 0xF8, 0x07,
  0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0x07, 0xE0, 0x1F, 0xFE, 0x0F, 0xC0, 0x3F,
  0xFC, 0x1F, 0x80, 0x7F, 0xF8, 0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x03, 0xFF,
  0xE0, 0x7F, 0xDF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0x80, 0xFF, 0xE7, 0xFF,
  0x00, 0x7F, 0x8F, 0xFE, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F,
  0xFE, 0x3F, 0x00, 0x3F, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x9F,
  0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF8, 0xFC,
  0x00, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xE0,
  0x07, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB,
  0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xFC, 0x03, 0xFC, 0x7F, 0xF7, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xCF, 0xC0, 0x1F, 0xF3, 0xF0, 0x01, 0xFE, 0xFC, 0x00,
  0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xEF, 0xC0,
  0x0F, 0xFB, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xFC, 0x03, 0xFC, 0x7F,
  0xF3, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xE3, 0xFF, 0x9F, 0xFC, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F,
  0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0xFF, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xEF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xDF, 0xFB, 0xC0, 0xFB, 0xFF, 0x7C, 0x1F, 0x7F, 0xEF, 0x83, 0xEF, 0xFC,
  0xF0, 0x79, 0xFF, 0x9F, 0x1F, 0x3F, 0xF3, 0xE3, 0xE7, 0xFE, 0x3C, 0x78,
  0xFF, 0xC7, 0xDF, 0x3F, 0xF8, 0xFB, 0xE7, 0xFF, 0x1F, 0x78, 0xFF, 0xF1,
  0xEF, 0x1F, 0xFE, 0x3F, 0xE3, 0xFF, 0xC7, 0xFC, 0x7F, 0xF8, 0x7F, 0x0F,
  0xFF, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x7C, 0x03, 0xFF, 0xDF, 0x80, 0xFF, 0xF7, 0xE0, 0x3F, 0xFC,
  0xF8, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0xFF, 0xF9, 0xF0, 0x3F,
  0xFE, 0x7E, 0x0F, 0xFF, 0x9F, 0x83, 0xFF, 0xE3, 0xE0, 0xFF, 0xF8, 0xFC,
  0x3F, 0xFE, 0x1F, 0x0F, 0xFF, 0x87, 0xC3, 0xFF, 0xE1, 0xF8, 0xFF, 0xF8,
  0x3E, 0x3F, 0xFE, 0x0F, 0x8F, 0xFF, 0x83, 0xF3, 0xFF, 0xE0, 0x7C, 0xFF,
  0xF8, 0x1F, 0x3F, 0xFE, 0x07, 0xEF, 0xFF, 0x80, 0xFB, 0xFF, 0xE0, 0x3F,
  0x7F, 0xF8, 0x0F, 0xDF, 0xFE, 0x01, 0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFE, 0x0F, 0xF9,
  0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x7F, 0x8F, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x50, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0x00, 0x1F, 0xF7,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFC, 0x01,
  0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE7,
  0xF8, 0x07, 0xFC, 0x7F, 0xF7, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0B, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x1F, 0xE7, 0xE0, 0x01, 0xFE,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xFB, 0xF0, 0x03,
  0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0x81, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFE,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFC,
  0xFF, 0xF7, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7,
  0xF0, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0x3F, 0xF3, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x07,
  0xDF, 0x80, 0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x03, 0xF3, 0xF0, 0x3B, 0x81,
  0xF9, 0xF8, 0x1D, 0xC0, 0xFC, 0xFC, 0x0E, 0xE0, 0x7E, 0x7E, 0x0F, 0x70,
  0x3F, 0x3F, 0x07, 0xBC, 0x1F, 0x9F, 0x83, 0xDE, 0x0F, 0xCF, 0xC1, 0xEF,
  0x07, 0xC7, 0xE0, 0xF7, 0x83, 0xE1, 0xF0, 0x7B, 0xC1, 0xF0, 0xF8, 0x39,
  0xE0, 0xF8, 0x7C, 0x1C, 0x70, 0xFC, 0x3F, 0x0E, 0x38, 0x7E, 0x1F, 0x8F,
  0x1C, 0x3F, 0x0F, 0xC7, 0x8F, 0x1F, 0x87, 0xE3, 0xC7, 0x8F, 0xC3, 0xF1,
  0xE3, 0xC7, 0xC1, 0xF8, 0xF1, 0xE3, 0xE0, 0xFC, 0x78, 0xF1, 0xF0, 0x3E,
  0x38, 0x78, 0xF8, 0x1F, 0x1C, 0x1C, 0x7C, 0x0F, 0x9E, 0x0E, 0x3E, 0x07,
  0xCF, 0x07, 0x3F, 0x03, 0xF7, 0x83, 0xDF, 0x81, 0xFB, 0xC1, 0xEF, 0xC0,
  0xFD, 0xE0, 0xF7, 0xC0, 0x7E, 0xF0, 0x7B, 0xE0, 0x3F, 0x70, 0x3D, 0xF0,
  0x0F, 0xB8, 0x1E, 0xF8, 0x07, 0xFC, 0x0F, 0x7C, 0x03, 0xFE, 0x03, 0xBE,
  0x01, 0xFF, 0x01, 0xDF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x83, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x00, 0xFD, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0,
  0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0xFB,
  0xF3, 0xFF, 0xFF, 0x7E, 0x3F, 0xFF, 0xCF, 0xC3, 0xFF, 0xF1, 0xF8, 0x3F,
  0xFC, 0x3F, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC3, 0xFF, 0x03, 0xF1, 0xFF, 0xE0, 0xFC, 0xFF, 0xFC,
  0x3F, 0x7F, 0xFF, 0x8F, 0xDF, 0xFF, 0xF3, 0xF7, 0xDF, 0xFC, 0xFF, 0x80,
  0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x03, 0xFB,
  0xFE, 0x01, 0xFE, 0xFD, 0xE3, 0xFF, 0x3F, 0x7F, 0xFF, 0xCF, 0xDF, 0xFF,
  0xE3, 0xF3, 0xFF, 0xF0, 0xFC, 0x7F, 0xF8, 0x3F, 0x0F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0xE7, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFC, 0x1F, 0xFE, 0x7F, 0x1F, 0xFF, 0xDF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFD, 0xFF, 0xEF, 0xBF, 0x7F, 0x80,
  0x7F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFD,
  0xFE, 0x01, 0xFF, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0x7F, 0x0F, 0xFF, 0x9F, 0xC0, 0xFF, 0xC7, 0xF0, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x1F,
  0xC1, 0xFF, 0xE7, 0xF1, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0xF8, 0x07, 0xFD, 0xFC, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD,
  0xFF, 0x03, 0xBF, 0x3F, 0xFF, 0xEF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD,
  0xFC, 0x3F, 0xFF, 0x7F, 0x07, 0xFF, 0x9F, 0xC0, 0x7F, 0x87, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xFC,
  0x1F, 0x8F, 0xFF, 0x0F, 0xCF, 0xFF, 0xC7, 0xEF, 0xFF, 0xF3, 0xF7, 0xFF,
  0xFD, 0xFB, 0xC7, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0xFC,
  0xFC, 0x1F, 0xC7, 0xEF, 0xF1, 0xFF, 0x3F, 0x7F, 0xDF, 0xF9, 0xFF, 0xFE,
  0xFF, 0xEF, 0xF3, 0xFE, 0xFF, 0x7F, 0x0F, 0xE1, 0xFB, 0xF0, 0x3E, 0x0F,
  0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF,
  0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x1F, 0xFE, 0x07,
  0xC0, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81,
  0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF,
  0xC0, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x81,
  0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0,
  0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFF,
  0xF0, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x3F, 0xF0, 0x7E, 0x3F,
  0xFC, 0x3F, 0x3F, 0xFF, 0x1F, 0xBF, 0xFF, 0xCF, 0xDF, 0xFF, 0xF7, 0xEF,
  0xBF, 0xFB, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xF8,
  0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F,
  0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF,
  0xF0, 0x0F, 0xF0, 0xFF, 0xEF, 0xFE, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xFC, 0x3F, 0xF0, 0x3F, 0x1F, 0xFE, 0x0F, 0xCF, 0xFF,
  0xC3, 0xF7, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x3F, 0x7D, 0xFF, 0xCF, 0xF8,
  0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F,
  0xBF, 0xE0, 0x1F, 0xEF, 0xDE, 0x3F, 0xF3, 0xF7, 0xFF, 0xFC, 0xFD, 0xFF,
  0xFE, 0x3F, 0x3F, 0xFF, 0x0F, 0xC7, 0xFF, 0x83, 0xF0, 0xFF, 0xC0, 0xFC,
  0x03, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xC1,
  0xFF, 0xE7, 0xF1, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFE, 0xFF, 0xF7, 0xF8, 0x07, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFF, 0x1E, 0xFC,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0xF0, 0xFF, 0xF9,
  0xFC, 0x0F, 0xFC, 0x7F, 0x00, 0x30, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0xFC, 0x3F, 0xF0, 0x3F, 0x1F, 0xFF, 0x0F, 0xCF, 0xFF, 0xE3, 0xF7,
  0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xEF, 0xF8, 0x07, 0xFB,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x2F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFD, 0xFF, 0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x9F, 0xF9,
  0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x7C, 0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0x1F, 0x7E, 0x07, 0xF0,
  0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0x70,
  0x3E, 0x3E, 0x07, 0x70, 0x3E, 0x3E, 0x0F, 0x70, 0x3E, 0x3E, 0x0F, 0x78,
  0x3E, 0x3F, 0x0F, 0x78, 0x7E, 0x3F, 0x0F, 0x78, 0x7E, 0x3F, 0x0E, 0x78,
  0x7C, 0x3F, 0x0E, 0x38, 0x7C, 0x1F, 0x1E, 0x38, 0x7C, 0x1F, 0x1E, 0x3C,
  0x7C, 0x1F, 0x1E, 0x3C, 0x7C, 0x1F, 0x1E, 0x3C, 0xFC, 0x1F, 0x9C, 0x3C,
  0xFC, 0x1F, 0x9C, 0x3C, 0xF8, 0x0F, 0x9C, 0x1C, 0xF8, 0x0F, 0xBC, 0x1C,
  0xF8, 0x0F, 0xBC, 0x1E, 0xF8, 0x0F, 0xBC, 0x1E, 0xF8, 0x0F, 0xBC, 0x1F,
  0xF8, 0x0F, 0xB8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xCF, 0xFF, 0x80, 0x7E, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF,
  0x3F, 0xC0, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0x81, 0xFC, 0x7E, 0xFC, 0x0F,
  0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xBF, 0x00, 0xFF, 0xF9, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 42, 35, 13, -42 },
  { 49, 19, 17, 35, 8, -42 },
  { 90, 31, 42, 35, 2, -42 },
  { 253, 27, 58, 35, 4, -50 },
  { 449, 35, 43, 35, 0, -43 },
  { 638, 30, 44, 35, 3, -43 },
  { 803, 7, 17, 35, 14, -42 },
  { 818, 18, 56, 35, 10, -49 },
  { 944, 18, 56, 35, 7, -49 },
  { 1070, 31, 30, 35, 2, -35 },
  { 1187, 27, 28, 35, 4, -33 },
  { 1282, 13, 18, 35, 9, -9 },
  { 1312, 19, 6, 35, 8, -22 },
  { 1327, 11, 11, 35, 12, -10 },
  { 1343, 27, 54, 35, 4, -48 },
  { 1526, 27, 44, 35, 4, -43 },
  { 1675, 27, 42, 35, 5, -42 },
  { 1817, 27, 43, 35, 4, -43 },
  { 1963, 26, 43, 35, 4, -42 },
  { 2103, 26, 42, 35, 4, -42 },
  { 2240, 27, 43, 35, 4, -42 },
  { 2386, 28, 43, 35, 3, -42 },
  { 2537, 27, 42, 35, 4, -42 },
  { 2679, 27, 44, 35, 4, -43 },
  { 2828, 28, 43, 35, 3, -43 },
  { 2979, 11, 33, 35, 12, -32 },
  { 3025, 14, 41, 35, 9, -32 },
  { 3097, 25, 32, 35, 5, -35 },
  { 3197, 25, 20, 35, 5, -29 },
  { 3260, 25, 32, 35, 5, -35 },
  { 3360, 22, 42, 35, 7, -42 },
  { 3476, 31, 53, 35, 2, -43 },
  { 3682, 31, 42, 35, 2, -42 },
  { 3845, 27, 42, 35, 5, -42 },
  { 3987, 27, 44, 35, 4, -43 },
  { 4136, 26, 42, 35, 5, -42 },
  { 4273, 25, 42, 35, 5, -42 },
  { 4405, 26, 42, 35, 5, -42 },
  { 4542, 27, 44, 35, 4, -43 },
  { 4691, 25, 42, 35, 5, -42 },
  { 4823, 24, 42, 35, 5, -42 },
  { 4949, 27, 43, 35, 2, -42 },
  { 5095, 28, 42, 35, 5, -42 },
  { 5242, 25, 42, 35, 6, -42 },
  { 5374, 27, 42, 35, 4, -42 },
  { 5516, 26, 42, 35, 4, -42 },
  { 5653, 26, 44, 35, 4, -43 },
  { 5796, 27, 42, 35, 5, -42 },
  { 5938, 27, 53, 35, 4, -43 },
  { 6117, 27, 42, 35, 5, -42 },
  { 6259, 27, 44, 35, 4, -43 },
  { 6408, 29, 42, 35, 3, -42 },
  { 6561, 26, 43, 35, 4, -42 },
  { 6701, 31, 42, 35, 2, -42 },
  { 6864, 33, 42, 35, 1, -42 },
  { 7038, 31, 42, 35, 2, -42 },
  { 7201, 31, 42, 35, 2, -42 },
  { 7364, 25, 42, 35, 5, -42 },
  { 7496, 16, 54, 35, 11, -48 },
  { 7604, 27, 54, 35, 4, -48 },
  { 7787, 16, 54, 35, 8, -48 },
  { 7895, 27, 22, 35, 4, -42 },
  { 7970, 28, 6, 35, 3, 1 },
  { 7991, 13, 9, 35, 10, -46 },
  { 8006, 27, 33, 35, 3, -32 },
  { 8118, 26, 43, 35, 5, -42 },
  { 8258, 27, 33, 35, 4, -32 },
  { 8370, 26, 43, 35, 4, -42 },
  { 8510, 27, 33, 35, 4, -32 },
  { 8622, 28, 42, 35, 3, -42 },
  { 8769, 26, 42, 35, 4, -32 },
  { 8906, 25, 42, 35, 5, -42 },
  { 9038, 27, 45, 35, 5, -45 },
  { 9190, 22, 55, 35, 5, -45 },
  { 9342, 28, 42, 35, 5, -42 },
  { 9489, 30, 42, 35, 2, -42 },
  { 9647, 29, 32, 35, 3, -32 },
  { 9763, 25, 32, 35, 5, -32 },
  { 9863, 27, 33, 35, 4, -32 },
  { 9975, 26, 42, 35, 5, -32 },
  { 10112, 26, 42, 35, 4, -32 },
  { 10249, 26, 32, 35, 6, -32 },
  { 10353, 27, 33, 35, 4, -32 },
  { 10465, 28, 41, 35, 3, -41 },
  { 10609, 25, 33, 35, 5, -32 },
  { 10713, 30, 32, 35, 2, -32 },
  { 10833, 32, 32, 35, 1, -32 },
  { 10961, 31, 32, 35, 2, -32 },
  { 11085, 30, 42, 35, 2, -32 },
  { 11243, 25, 32, 35, 5, -32 },
  { 11343, 25, 54, 35, 5, -48 },
  { 11512, 7, 54, 35, 14, -48 },
  { 11560, 25, 54, 35, 5, -48 },
  { 11729, 29, 13, 35, 3, -27 },
};

const GFXfont JetBrainsMono_SemiBold58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_SEMIBOLD58PT7B_H_
