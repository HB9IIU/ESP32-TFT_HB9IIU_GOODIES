#ifndef _JETBRAINSMONO_SEMIBOLD19PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0xDB, 0x6C, 0x0F, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x30,
  0x19, 0x84, 0x61, 0x18, 0xC4, 0xFF, 0xCC, 0xC2, 0x30, 0x8C, 0x62, 0x3F,
  0xE6, 0x61, 0x98, 0x46, 0x31, 0x80, 0x08, 0x04, 0x02, 0x07, 0xC7, 0xF3,
  0x5F, 0xA6, 0xD0, 0x78, 0x3F, 0x07, 0xC1, 0x70, 0x9E, 0x4F, 0xA6, 0xFF,
  0x3E, 0x04, 0x02, 0x01, 0x00, 0x78, 0x7F, 0x8B, 0x33, 0x66, 0xCC, 0xD0,
  0xF6, 0x01, 0x80, 0x20, 0x0F, 0xC3, 0x6C, 0xC8, 0x91, 0x16, 0x37, 0x83,
  0x80, 0x3E, 0x1F, 0xC6, 0x31, 0x80, 0x60, 0x0C, 0x07, 0x83, 0xE7, 0xCD,
  0xB3, 0xEC, 0x73, 0x1C, 0xFF, 0x9F, 0x70, 0xFF, 0xB6, 0xC0, 0x04, 0x73,
  0x9C, 0x63, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xE1, 0x87, 0x0E, 0x1C, 0x30,
  0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0x8E,
  0xF3, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0x26, 0xFB, 0xCF, 0xC1, 0xC0, 0xD8,
  0x73, 0x18, 0xC0, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18,
  0x0C, 0x00, 0x77, 0x66, 0xEC, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x70, 0x00, 0x3E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E,
  0x0F, 0x37, 0xBB, 0xC1, 0xE0, 0xF0, 0x6C, 0x77, 0xF1, 0xF0, 0x38, 0x78,
  0xF8, 0x98, 0x98, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x3E, 0x3F, 0xB8, 0xF8, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x07, 0xFB, 0xFC, 0x7F, 0x3F, 0x80, 0xC0, 0xC0, 0xC0, 0xF0, 0x7C,
  0x07, 0x01, 0x80, 0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0x07, 0x03, 0x03, 0x83,
  0x81, 0x81, 0x81, 0xCE, 0xC7, 0xC3, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C,
  0x7F, 0xBF, 0xD8, 0x0C, 0x06, 0x03, 0xF9, 0xFC, 0xC7, 0x01, 0x80, 0xC0,
  0x7C, 0x77, 0xF1, 0xF0, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x03, 0xA1, 0xFD,
  0xC7, 0xE1, 0xE0, 0xF0, 0x7C, 0x37, 0xF1, 0xF0, 0xFF, 0xFF, 0xF0, 0x78,
  0x30, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0x81, 0xC0,
  0x3E, 0x3F, 0x98, 0xEC, 0x36, 0x3B, 0x98, 0xF8, 0x7E, 0x63, 0xF0, 0xF0,
  0x7C, 0x37, 0xF9, 0xF0, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x8E,
  0xFF, 0x1B, 0x03, 0x83, 0x81, 0x81, 0xC1, 0xC0, 0x5F, 0x80, 0x00, 0xFF,
  0x80, 0x37, 0x70, 0x00, 0x00, 0x77, 0x66, 0xEC, 0x01, 0x83, 0xC7, 0x8F,
  0x0E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x40, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x18, 0x3C, 0x7C, 0xF8,
  0xE0, 0x40, 0x00, 0xF8, 0xFE, 0x0E, 0x06, 0x07, 0x06, 0x3E, 0x3C, 0x30,
  0x30, 0x00, 0x00, 0x70, 0x70, 0x3F, 0x1F, 0xEE, 0x1B, 0x03, 0xC0, 0xF3,
  0xFC, 0xCF, 0x63, 0xD8, 0xF6, 0x3D, 0x8F, 0x37, 0xCE, 0xF0, 0x0C, 0x01,
  0xC0, 0x3E, 0x00, 0x1C, 0x07, 0x01, 0xE0, 0xD8, 0x36, 0x0D, 0xC3, 0x31,
  0x8C, 0x63, 0x1F, 0xE7, 0xFB, 0x86, 0xC1, 0xB0, 0x70, 0xFC, 0xFE, 0xC7,
  0xC3, 0xC3, 0xC6, 0xFC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFC, 0x3E,
  0x3F, 0x98, 0xFC, 0x3E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x6C,
  0x77, 0xF1, 0xF0, 0xFE, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x7F, 0xF7, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E,
  0x3F, 0x98, 0xFC, 0x3E, 0x07, 0x03, 0x81, 0xDF, 0xEF, 0xF0, 0xF8, 0x6C,
  0x77, 0xF1, 0xF0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x1F, 0x8F, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xF0, 0xF8, 0x6F, 0xF3, 0xF0, 0xC3,
  0xE1, 0xB1, 0x98, 0xCC, 0xE6, 0x63, 0xF1, 0xF8, 0xCC, 0x67, 0x31, 0x98,
  0xEC, 0x36, 0x1C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE3, 0xF1, 0xFC, 0xBE, 0x5D, 0x7E, 0xBF,
  0x77, 0x9B, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xE1, 0xF8, 0xFC,
  0x7A, 0x3D, 0x9E, 0xCF, 0x27, 0xDB, 0xED, 0xF2, 0xF9, 0xFC, 0xFE, 0x3F,
  0x1C, 0x3E, 0x3F, 0x98, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xFC, 0x7F, 0xB1, 0xD8, 0x7C, 0x3E, 0x1B,
  0x1D, 0xFC, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x3E, 0x3F, 0x98,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0xF1,
  0xF0, 0x18, 0x06, 0x03, 0x80, 0xFC, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x1B,
  0xFD, 0xFC, 0xCC, 0x66, 0x33, 0x98, 0xCC, 0x76, 0x1C, 0x3E, 0x3F, 0x98,
  0xFC, 0x36, 0x03, 0x81, 0xF8, 0x3E, 0x03, 0x80, 0xF0, 0x7C, 0x37, 0xF9,
  0xF0, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xC1, 0xF0, 0x6E,
  0x19, 0x86, 0x63, 0x98, 0xC7, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0x60, 0x78,
  0x1E, 0x07, 0x00, 0xC6, 0x78, 0xCD, 0xB9, 0xB7, 0x36, 0xA6, 0xD4, 0x9A,
  0x93, 0x5E, 0x6B, 0xCD, 0x39, 0xA7, 0x1C, 0xE3, 0x9C, 0x63, 0x80, 0xE1,
  0xD8, 0xE7, 0x30, 0xDC, 0x3E, 0x07, 0x81, 0xC0, 0x70, 0x1E, 0x0D, 0x83,
  0x31, 0x8C, 0xE1, 0xB0, 0x70, 0xE0, 0xEC, 0x18, 0xC3, 0x18, 0xC1, 0x98,
  0x36, 0x07, 0xC0, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xFF, 0xFF, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xFF, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0,
  0x1C, 0x0E, 0x05, 0x86, 0xC3, 0x33, 0x19, 0x87, 0x83, 0xFF, 0xFF, 0xC0,
  0xE3, 0x8E, 0x1C, 0x1F, 0x98, 0xEC, 0x30, 0x1B, 0xFF, 0x87, 0x83, 0xC3,
  0xFB, 0xDF, 0x60, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xFE, 0xFE, 0x1C, 0x1F, 0x9C, 0xFC, 0x3E, 0x07, 0x03,
  0x81, 0xC3, 0x61, 0xBF, 0x8F, 0x80, 0x01, 0x80, 0xC0, 0x63, 0x37, 0xDB,
  0x9F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0xF9, 0xEC, 0x1C, 0x1F,
  0x98, 0xFC, 0x3E, 0x1F, 0xFF, 0x81, 0xC0, 0x61, 0xBF, 0x8F, 0x80, 0x0F,
  0x8F, 0xC6, 0x03, 0x01, 0x87, 0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x18, 0x3E, 0xDC, 0xFC, 0x3E, 0x1F, 0x0F, 0x86, 0xC7,
  0x7F, 0x9E, 0xC0, 0x60, 0x30, 0x79, 0xF8, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE,
  0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x0C, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x3F, 0xFF, 0xFC, 0x0E, 0x1C, 0x30, 0x00, 0x1F, 0xFF, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0xFD, 0xF0, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x36, 0x33, 0x39, 0x98, 0xFC, 0x7E, 0x33, 0x98, 0xCC, 0x76, 0x1C,
  0xF8, 0x3E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1F, 0xC3, 0xF0, 0x11, 0x7D, 0xF3, 0x79, 0xBC, 0xDE,
  0x6F, 0x37, 0x9B, 0xCD, 0xE6, 0xF3, 0x60, 0x1C, 0xFE, 0xE7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x1C, 0x1F, 0x9C, 0xFC, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0x63, 0xBF, 0x8F, 0x80, 0x1C, 0xFE, 0xE7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xDE, 0xC0, 0xC0, 0xC0, 0x18, 0x3E, 0xDC,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0x63, 0xBF, 0xCF, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0xFF, 0xE7, 0xC3, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x1C, 0x3F, 0x98, 0xEC, 0x07, 0x03, 0xF8, 0x3E, 0x03, 0xE1, 0xBF, 0xCF,
  0xC0, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0xF0, 0xF8, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x86,
  0xC7, 0x7F, 0x1F, 0x00, 0xC1, 0xF8, 0x66, 0x39, 0x8C, 0x73, 0x0D, 0xC3,
  0x60, 0xF8, 0x1E, 0x07, 0x00, 0xC6, 0x6C, 0xCD, 0xB9, 0x35, 0x26, 0xAC,
  0xD7, 0x8A, 0xF1, 0x4E, 0x39, 0xC6, 0x30, 0xE3, 0x9C, 0xC3, 0x60, 0x78,
  0x1C, 0x07, 0x83, 0x61, 0xCC, 0x63, 0xB8, 0x70, 0xE1, 0xD8, 0x66, 0x39,
  0xCC, 0x33, 0x0D, 0x81, 0xE0, 0x78, 0x1C, 0x03, 0x01, 0xC0, 0x60, 0x38,
  0x00, 0xFF, 0xFF, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0x07,
  0x0F, 0x1C, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0xF8, 0xF8, 0x18, 0x1C, 0x1C,
  0x18, 0x18, 0x1C, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xF0,
  0x70, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0xF0, 0xE0, 0x71, 0xFC, 0xF3, 0x79, 0xF0,
};

const GFXglyph JetBrainsMono_SemiBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 6, 6, 11, 3, -14 },
  { 12, 10, 14, 11, 1, -14 },
  { 30, 9, 20, 11, 1, -17 },
  { 53, 11, 14, 11, 0, -14 },
  { 73, 10, 14, 11, 1, -14 },
  { 91, 3, 6, 11, 4, -14 },
  { 94, 6, 18, 11, 3, -16 },
  { 108, 6, 18, 11, 2, -16 },
  { 122, 10, 10, 11, 1, -12 },
  { 135, 9, 9, 11, 1, -11 },
  { 146, 4, 6, 11, 3, -3 },
  { 149, 6, 2, 11, 3, -7 },
  { 151, 3, 3, 11, 4, -3 },
  { 153, 9, 18, 11, 1, -16 },
  { 174, 9, 14, 11, 1, -14 },
  { 190, 8, 14, 11, 2, -14 },
  { 204, 9, 14, 11, 1, -14 },
  { 220, 9, 14, 11, 1, -14 },
  { 236, 9, 14, 11, 1, -14 },
  { 252, 9, 14, 11, 1, -14 },
  { 268, 9, 14, 11, 1, -14 },
  { 284, 9, 14, 11, 1, -14 },
  { 300, 9, 14, 11, 1, -14 },
  { 316, 9, 14, 11, 1, -14 },
  { 332, 3, 11, 11, 4, -11 },
  { 337, 4, 14, 11, 3, -11 },
  { 344, 9, 10, 11, 1, -11 },
  { 356, 8, 7, 11, 2, -10 },
  { 363, 9, 10, 11, 1, -11 },
  { 375, 8, 14, 11, 2, -14 },
  { 389, 10, 17, 11, 1, -14 },
  { 411, 10, 14, 11, 1, -14 },
  { 429, 8, 14, 11, 2, -14 },
  { 443, 9, 14, 11, 1, -14 },
  { 459, 9, 14, 11, 1, -14 },
  { 475, 8, 14, 11, 2, -14 },
  { 489, 8, 14, 11, 2, -14 },
  { 503, 9, 14, 11, 1, -14 },
  { 519, 8, 14, 11, 2, -14 },
  { 533, 8, 14, 11, 2, -14 },
  { 547, 9, 14, 11, 1, -14 },
  { 563, 9, 14, 11, 2, -14 },
  { 579, 8, 14, 11, 2, -14 },
  { 593, 9, 14, 11, 1, -14 },
  { 609, 9, 14, 11, 1, -14 },
  { 625, 9, 14, 11, 1, -14 },
  { 641, 9, 14, 11, 2, -14 },
  { 657, 9, 17, 11, 1, -14 },
  { 677, 9, 14, 11, 2, -14 },
  { 693, 9, 14, 11, 1, -14 },
  { 709, 9, 14, 11, 1, -14 },
  { 725, 9, 14, 11, 1, -14 },
  { 741, 10, 14, 11, 1, -14 },
  { 759, 11, 14, 11, 0, -14 },
  { 779, 10, 14, 11, 1, -14 },
  { 797, 11, 14, 11, 0, -14 },
  { 817, 8, 14, 11, 2, -14 },
  { 831, 5, 18, 11, 4, -16 },
  { 843, 9, 18, 11, 1, -16 },
  { 864, 5, 18, 11, 3, -16 },
  { 876, 9, 8, 11, 1, -14 },
  { 885, 9, 2, 11, 1, 0 },
  { 888, 5, 3, 11, 3, -15 },
  { 890, 9, 11, 11, 1, -11 },
  { 903, 8, 14, 11, 2, -14 },
  { 917, 9, 11, 11, 1, -11 },
  { 930, 9, 14, 11, 1, -14 },
  { 946, 9, 11, 11, 1, -11 },
  { 959, 9, 14, 11, 1, -14 },
  { 975, 9, 14, 11, 1, -11 },
  { 991, 8, 14, 11, 2, -14 },
  { 1005, 10, 15, 11, 1, -15 },
  { 1024, 7, 18, 11, 2, -15 },
  { 1040, 9, 14, 11, 2, -14 },
  { 1056, 10, 14, 11, 1, -14 },
  { 1074, 9, 11, 11, 1, -11 },
  { 1087, 8, 11, 11, 2, -11 },
  { 1098, 9, 11, 11, 1, -11 },
  { 1111, 8, 14, 11, 2, -11 },
  { 1125, 9, 14, 11, 1, -11 },
  { 1141, 8, 11, 11, 2, -11 },
  { 1152, 9, 11, 11, 1, -11 },
  { 1165, 9, 13, 11, 1, -13 },
  { 1180, 9, 10, 11, 1, -10 },
  { 1192, 10, 10, 11, 1, -10 },
  { 1205, 11, 10, 11, 0, -10 },
  { 1219, 10, 10, 11, 1, -10 },
  { 1232, 10, 13, 11, 1, -10 },
  { 1249, 8, 10, 11, 2, -10 },
  { 1259, 8, 18, 11, 2, -16 },
  { 1277, 2, 18, 11, 5, -16 },
  { 1282, 8, 18, 11, 2, -16 },
  { 1300, 9, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_SemiBold19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_SEMIBOLD19PT7B_H_
