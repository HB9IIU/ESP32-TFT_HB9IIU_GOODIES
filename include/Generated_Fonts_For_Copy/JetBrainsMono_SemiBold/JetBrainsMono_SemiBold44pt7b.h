#ifndef _JETBRAINSMONO_SEMIBOLD44PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xEF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x3D, 0xF0, 0x7B,
  0xE0, 0xF7, 0xC1, 0xEF, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0xF0,
  0x03, 0x80, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0x01, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x03, 0xC0, 0x0E, 0x03, 0x80,
  0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x1C, 0x07, 0x80, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xDD, 0xFC, 0xF8,
  0xE7, 0xE7, 0xC7, 0x1F, 0x7E, 0x38, 0xFB, 0xF1, 0xC0, 0x1F, 0x8E, 0x00,
  0x7C, 0x70, 0x03, 0xF3, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xBF, 0x80, 0x1C, 0xFC, 0x00, 0xE3, 0xF0, 0x07, 0x1F, 0xFC, 0x38,
  0x7F, 0xE1, 0xC7, 0xFF, 0x0E, 0x3E, 0xFC, 0x73, 0xF3, 0xFB, 0xBF, 0x9F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xCF, 0xFC, 0x01, 0xE7, 0xFF, 0x00, 0x79,
  0xE1, 0xE0, 0x3C, 0x70, 0x78, 0x1E, 0x1C, 0x1E, 0x07, 0x07, 0x07, 0x83,
  0xC1, 0xC1, 0xE1, 0xE0, 0x70, 0x78, 0xF0, 0x1C, 0x1E, 0x3C, 0x07, 0x87,
  0x9E, 0x01, 0xFF, 0xEF, 0x00, 0x3F, 0xF3, 0xC0, 0x07, 0xF9, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x04,
  0x00, 0x07, 0x8F, 0xE0, 0x01, 0xEF, 0xFC, 0x00, 0xF3, 0xFF, 0x80, 0x79,
  0xE1, 0xF0, 0x1E, 0x78, 0x3C, 0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x78, 0x1E, 0x0F, 0x3C, 0x07, 0xC7,
  0x8F, 0x00, 0xFF, 0xE7, 0x80, 0x1F, 0xF3, 0xC0, 0x03, 0xF8, 0x00, 0x60,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF3, 0xE1, 0xF7, 0xC7, 0xE3, 0xEF, 0x87, 0xCF, 0x9F, 0x07,
  0xDF, 0x3E, 0x0F, 0xFC, 0x7C, 0x0F, 0xF8, 0xF8, 0x0F, 0xE1, 0xF0, 0x0F,
  0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x7F, 0x0F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xBE, 0x1F, 0xFE, 0x3E, 0x0F, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x7D, 0xE7, 0x9E, 0x78, 0x00, 0x08, 0x03, 0xC0, 0x3E,
  0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x3F,
  0x00, 0x78, 0x00, 0xC0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0,
  0x3F, 0x80, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x20, 0x3C, 0x06, 0x7C, 0x3C, 0x3E, 0x7F, 0x1C, 0xFE, 0x7F, 0x99, 0xFF,
  0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF7, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE3, 0xE0,
  0x07, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0x00, 0xE0,
  0x03, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0xF1, 0xFF, 0x8F, 0x9F, 0xF9, 0xF9, 0xFF, 0x9F, 0x9F, 0xF8, 0xF9,
  0xFF, 0x86, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7F,
  0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xEF, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xE0, 0xF8, 0x08, 0x0F,
  0x80, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xE7, 0xE0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0xF9, 0xF8, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC7,
  0xE0, 0x7D, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0x7E,
  0x03, 0xF7, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0x7C, 0x03, 0xF7, 0xF0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF3,
  0xE0, 0x1F, 0x7F, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0x0F, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBF,
  0x00, 0xFC, 0xFE, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x7E,
  0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3,
  0xF0, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC3, 0xF0, 0xFE, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xDF, 0xC0, 0x7E, 0x7F, 0x9F, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFE, 0xF8, 0x1F, 0xEF, 0xC0, 0x1C, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x06, 0x07, 0xE3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF1, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x20,
  0xFF, 0x01, 0xF9, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xFF, 0xF8, 0x3C, 0x1F,
  0xF0, 0xF8, 0x3F, 0xE1, 0xF0, 0x3F, 0xC3, 0xC0, 0x7F, 0x87, 0x80, 0xFF,
  0x0F, 0x01, 0xFE, 0x1E, 0x03, 0xFC, 0x3C, 0x07, 0xF8, 0x78, 0x0F, 0xF0,
  0xF8, 0x1F, 0xE1, 0xF0, 0x7F, 0xC1, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFD, 0xFE, 0x07, 0xF3, 0xFC, 0x00, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03,
  0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3E, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xCF, 0x80, 0x7E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x8F, 0x83, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xEF, 0x83, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xF7, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0xE0, 0x3F, 0x7F, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03,
  0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x0F, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C,
  0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8,
  0x3E, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x1F, 0x81,
  0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x03,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFE, 0xE0, 0x7F, 0xFF, 0x83, 0xBF, 0xFC, 0x1D, 0xFE, 0xE1, 0xEF, 0xF7,
  0x8F, 0x7F, 0xBC, 0x77, 0xFC, 0xE7, 0xBF, 0xE7, 0x3D, 0xFF, 0x3D, 0xCF,
  0xF9, 0xEE, 0x7F, 0xC7, 0xF3, 0xFE, 0x3F, 0x1F, 0xF1, 0xF8, 0xFF, 0x87,
  0xC7, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFB, 0xC1,
  0xFF, 0xBC, 0x1F, 0xFB, 0xC1, 0xFF, 0x9E, 0x1F, 0xF9, 0xE1, 0xFF, 0x9E,
  0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF9, 0xFF, 0x87, 0x9F, 0xF8,
  0x79, 0xFF, 0x87, 0xDF, 0xF8, 0x3D, 0xFF, 0x83, 0xCF, 0xF8, 0x3E, 0xFF,
  0x81, 0xEF, 0xF8, 0x1E, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x30,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0,
  0x7E, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x0F, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7C, 0x03,
  0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x3F,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83,
  0xF1, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xF0,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x3F, 0xEF, 0x80, 0x7E,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x87, 0xC0, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x7E,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x03, 0xF9, 0xF0, 0x0F, 0xCF,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7D, 0xF8, 0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80,
  0x1F, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03,
  0xE0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x01,
  0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0xF0, 0x3E, 0x0F, 0xF8, 0x1F, 0x07, 0xBE, 0x0F,
  0x83, 0xDF, 0x07, 0xC1, 0xEF, 0x87, 0xE0, 0xF7, 0xC3, 0xF0, 0x79, 0xE1,
  0xD8, 0x3C, 0xF0, 0xEC, 0x3E, 0x78, 0x76, 0x1F, 0x3C, 0x3B, 0x8F, 0x9E,
  0x1D, 0xC7, 0x8F, 0x0C, 0xE3, 0xC7, 0x86, 0x71, 0xE3, 0xE7, 0x38, 0xF1,
  0xF3, 0x9C, 0x78, 0xF9, 0xCE, 0x3C, 0x3C, 0xE3, 0x1E, 0x1E, 0x71, 0x8F,
  0x0F, 0x38, 0xEF, 0x87, 0x9C, 0x77, 0x83, 0xCC, 0x3B, 0xC1, 0xEE, 0x1D,
  0xE0, 0xF7, 0x0E, 0xF0, 0x7B, 0x87, 0x78, 0x3F, 0xC3, 0xBC, 0x0F, 0xE0,
  0xDE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x3E,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x0F,
  0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03,
  0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F,
  0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x07,
  0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x03,
  0xF7, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x7D, 0xE0,
  0x07, 0x9F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x07,
  0x81, 0xE0, 0x7C, 0x3E, 0x03, 0xC3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xF7, 0xC0, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xFB, 0xFF, 0x7F,
  0xFD, 0xF3, 0xFF, 0x9F, 0x1F, 0xF1, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC1, 0xC0, 0xF9, 0xFE, 0x1F, 0x7F, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xE0, 0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3E, 0xFF, 0xC7, 0xCF, 0xF0, 0x00,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xF0, 0x7F, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0,
  0x3F, 0x7F, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x18, 0x1F, 0x0F, 0xF1,
  0xF1, 0xFF, 0x9F, 0x3F, 0xFD, 0xF7, 0xFF, 0xFF, 0x7E, 0x07, 0xF7, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xF0, 0xFF,
  0x7F, 0xFD, 0xF3, 0xFF, 0xDF, 0x1F, 0xF9, 0xF0, 0xFF, 0x1F, 0x00, 0x70,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xDF, 0xE7, 0xE0,
  0x3E, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F,
  0x7E, 0x03, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x1F, 0x1F, 0xFD,
  0xF3, 0xFF, 0xDF, 0x7F, 0xFF, 0xF7, 0xE0, 0x7F, 0x7C, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7,
  0xC0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0xDF,
  0x0F, 0xF1, 0xF0, 0x08, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0xF9,
  0xFE, 0x1F, 0x7F, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xE0, 0xFD, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x20, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8,
  0x7F, 0xF8, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x0F,
  0x8F, 0x80, 0xFC, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8,
  0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0,
  0xFC, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xC0, 0xC3, 0xEF, 0xCF, 0xCF, 0xFF,
  0x7F, 0xBF, 0xFF, 0xFE, 0xFC, 0xFC, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87,
  0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE,
  0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E,
  0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F,
  0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8,
  0x78, 0x7C, 0x00, 0x78, 0x1F, 0x3F, 0xC3, 0xEF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xE0, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x1F, 0x3F, 0xC3, 0xEF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xDF, 0xF8, 0xF9, 0xFE, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0x1F, 0x1F, 0xF9, 0xF3, 0xFF, 0xDF, 0x7F, 0xFF,
  0xF7, 0xE0, 0x7F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7,
  0xC0, 0x3F, 0x7F, 0x0F, 0xF7, 0xFF, 0xDF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F,
  0x0F, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3C, 0x0F, 0x8F, 0xF0, 0xF9, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0x7E, 0x03, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F,
  0x7E, 0x03, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3,
  0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7,
  0xC0, 0x07, 0xCF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0xF0, 0x3C, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0x78, 0x3E, 0x0F,
  0x78, 0x7E, 0x0F, 0x78, 0x7E, 0x1E, 0x78, 0x76, 0x1E, 0x78, 0x76, 0x1E,
  0x7C, 0x77, 0x1E, 0x3C, 0x67, 0x1E, 0x3C, 0xE7, 0x1E, 0x3C, 0xE7, 0x1E,
  0x3C, 0xE7, 0x3C, 0x3C, 0xE3, 0x3C, 0x3C, 0xE3, 0xBC, 0x3E, 0xC3, 0xBC,
  0x1E, 0xC3, 0xBC, 0x1F, 0xC3, 0xBC, 0x1F, 0xC3, 0xB8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8,
  0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x7E, 0x01, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xF7, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x07, 0xCF,
  0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x1F,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87,
  0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0x00, 0xF3, 0xFE, 0x03, 0xDF, 0xFC, 0x0F,
  0x7F, 0xF8, 0x3F, 0xE3, 0xF1, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8,
  0x1F, 0xFB, 0xE0, 0x3F, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 32, 26, 10, -32 },
  { 29, 15, 13, 26, 6, -32 },
  { 54, 24, 32, 26, 1, -32 },
  { 150, 21, 44, 26, 3, -38 },
  { 266, 26, 32, 26, 0, -32 },
  { 370, 23, 33, 26, 2, -33 },
  { 465, 6, 13, 26, 10, -32 },
  { 475, 13, 42, 26, 8, -37 },
  { 544, 14, 42, 26, 5, -37 },
  { 618, 24, 23, 26, 1, -27 },
  { 687, 21, 21, 26, 3, -25 },
  { 743, 10, 14, 26, 7, -7 },
  { 761, 14, 5, 26, 6, -17 },
  { 770, 8, 8, 26, 9, -8 },
  { 778, 21, 42, 26, 3, -37 },
  { 889, 20, 33, 26, 3, -33 },
  { 972, 20, 32, 26, 4, -32 },
  { 1052, 20, 33, 26, 3, -33 },
  { 1135, 20, 32, 26, 3, -32 },
  { 1215, 19, 32, 26, 3, -32 },
  { 1291, 20, 32, 26, 3, -32 },
  { 1371, 21, 32, 26, 3, -32 },
  { 1455, 21, 32, 26, 3, -32 },
  { 1539, 20, 33, 26, 3, -33 },
  { 1622, 21, 33, 26, 3, -33 },
  { 1709, 8, 25, 26, 9, -25 },
  { 1734, 10, 32, 26, 7, -25 },
  { 1774, 20, 23, 26, 3, -26 },
  { 1832, 19, 15, 26, 4, -22 },
  { 1868, 20, 23, 26, 3, -26 },
  { 1926, 17, 32, 26, 5, -32 },
  { 1994, 23, 41, 26, 2, -33 },
  { 2112, 23, 32, 26, 2, -32 },
  { 2204, 20, 32, 26, 4, -32 },
  { 2284, 20, 33, 26, 3, -33 },
  { 2367, 20, 32, 26, 3, -32 },
  { 2447, 19, 32, 26, 4, -32 },
  { 2523, 19, 32, 26, 4, -32 },
  { 2599, 20, 33, 26, 3, -33 },
  { 2682, 19, 32, 26, 4, -32 },
  { 2758, 18, 32, 26, 4, -32 },
  { 2830, 21, 32, 26, 1, -32 },
  { 2914, 21, 32, 26, 4, -32 },
  { 2998, 19, 32, 26, 5, -32 },
  { 3074, 21, 32, 26, 3, -32 },
  { 3158, 20, 32, 26, 3, -32 },
  { 3238, 20, 33, 26, 3, -33 },
  { 3321, 21, 32, 26, 4, -32 },
  { 3405, 21, 41, 26, 3, -33 },
  { 3513, 20, 32, 26, 4, -32 },
  { 3593, 21, 33, 26, 3, -33 },
  { 3680, 22, 32, 26, 2, -32 },
  { 3768, 20, 32, 26, 3, -32 },
  { 3848, 23, 32, 26, 2, -32 },
  { 3940, 25, 32, 26, 1, -32 },
  { 4040, 24, 32, 26, 1, -32 },
  { 4136, 24, 32, 26, 1, -32 },
  { 4232, 19, 32, 26, 4, -32 },
  { 4308, 12, 42, 26, 8, -37 },
  { 4371, 21, 42, 26, 3, -37 },
  { 4482, 12, 42, 26, 6, -37 },
  { 4545, 20, 17, 26, 3, -32 },
  { 4588, 21, 5, 26, 3, 1 },
  { 4602, 11, 7, 26, 7, -35 },
  { 4612, 20, 25, 26, 3, -25 },
  { 4675, 19, 32, 26, 4, -32 },
  { 4751, 20, 25, 26, 3, -25 },
  { 4814, 20, 32, 26, 3, -32 },
  { 4894, 20, 25, 26, 3, -25 },
  { 4957, 22, 32, 26, 2, -32 },
  { 5045, 20, 33, 26, 3, -25 },
  { 5128, 19, 32, 26, 4, -32 },
  { 5204, 22, 35, 26, 3, -35 },
  { 5301, 17, 43, 26, 4, -35 },
  { 5393, 21, 32, 26, 4, -32 },
  { 5477, 24, 32, 26, 1, -32 },
  { 5573, 22, 25, 26, 2, -25 },
  { 5642, 19, 25, 26, 4, -25 },
  { 5702, 20, 25, 26, 3, -25 },
  { 5765, 19, 33, 26, 4, -25 },
  { 5844, 20, 33, 26, 3, -25 },
  { 5927, 20, 25, 26, 4, -25 },
  { 5990, 20, 25, 26, 3, -25 },
  { 6053, 21, 31, 26, 2, -31 },
  { 6135, 20, 24, 26, 3, -24 },
  { 6195, 23, 24, 26, 2, -24 },
  { 6264, 24, 24, 26, 1, -24 },
  { 6336, 23, 24, 26, 2, -24 },
  { 6405, 23, 32, 26, 2, -24 },
  { 6497, 19, 24, 26, 4, -24 },
  { 6554, 19, 42, 26, 4, -37 },
  { 6654, 5, 42, 26, 11, -37 },
  { 6681, 19, 42, 26, 4, -37 },
  { 6781, 22, 10, 26, 2, -21 },
};

const GFXfont JetBrainsMono_SemiBold44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_SEMIBOLD44PT7B_H_
