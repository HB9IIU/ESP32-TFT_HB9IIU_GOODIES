#ifndef _JETBRAINSMONO_SEMIBOLD38PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x7D, 0xFF,
  0xF3, 0xE0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xBC, 0x1D, 0xE0, 0xE0, 0x01, 0xC0,
  0xE0, 0x0E, 0x0F, 0x00, 0xF0, 0x70, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x01,
  0xC0, 0xE0, 0x0E, 0x07, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC1, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x78, 0x03, 0x83, 0xC0, 0x3C,
  0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83,
  0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xBB, 0xF7, 0xCE,
  0x7D, 0xE3, 0x8F, 0x78, 0xE0, 0x1E, 0x38, 0x07, 0xCE, 0x01, 0xFB, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0E, 0x7C, 0x03, 0x9F, 0x00, 0xE3, 0xC0, 0x38, 0xFF, 0x8E,
  0x3D, 0xE3, 0x8F, 0x7C, 0xE7, 0xDF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x07, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x1E, 0x7F, 0x80, 0x39, 0xFF, 0x80, 0xE3, 0x87,
  0x03, 0xC7, 0x0E, 0x0F, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x70, 0x78, 0x71,
  0xE0, 0x70, 0xE3, 0x80, 0xE3, 0xCE, 0x01, 0xFF, 0xBC, 0x01, 0xFE, 0x70,
  0x00, 0xF1, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x40,
  0x00, 0xE7, 0xF0, 0x03, 0xDF, 0xF0, 0x07, 0x3C, 0xF0, 0x1C, 0xF0, 0xE0,
  0x79, 0xE1, 0xC0, 0xE3, 0xC3, 0x83, 0x87, 0x87, 0x0F, 0x0F, 0x0E, 0x3C,
  0x0E, 0x1C, 0x70, 0x1F, 0xF9, 0xC0, 0x1F, 0xE7, 0x80, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3C, 0x1F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0xBE, 0x1E, 0xF1, 0xF3, 0xCF, 0x0F, 0x7C, 0xF0, 0xFF, 0x8F, 0x07,
  0xF8, 0xF0, 0x3F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x83, 0xF8, 0xFC,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF3, 0xE1, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF7, 0xBD, 0xE0, 0x00, 0x20, 0x1C, 0x0F, 0x83, 0xF0, 0xFE,
  0x3F, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0xC0, 0x0F, 0x00, 0xFC,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8,
  0x0F, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x30, 0x38, 0x31, 0xF1, 0xC7, 0xCF, 0xCE,
  0xFE, 0xFF, 0xAF, 0xF8, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1D, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x3C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0x80, 0xC0, 0x04, 0x04, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78,
  0x7C, 0x3C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1,
  0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x3C, 0x7F, 0x9F, 0x3F, 0xCF, 0x9F, 0xE7, 0x8F,
  0xF0, 0x87, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xF0, 0x3E, 0x7F, 0x7F, 0x3F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7E,
  0xF0, 0x3F, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0xC0, 0xC0, 0xF0, 0x20, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x7D,
  0xF0, 0x3E, 0x7F, 0xBF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x7E, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFB,
  0xFB, 0xF0, 0x7F, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x3E, 0x7F, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x7E, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xCF, 0xE3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0x9E,
  0x01, 0xF3, 0xE0, 0x3E, 0x3F, 0xBF, 0x87, 0xFF, 0xF0, 0x7F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0x9F, 0x07, 0xC7, 0xCF, 0xC1, 0xFF,
  0xC0, 0x7F, 0x80, 0x7F, 0xF0, 0x7E, 0xFC, 0x7C, 0x1F, 0x7C, 0x07, 0xBC,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFF, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE,
  0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xEF, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xFD, 0xFF, 0xFF, 0xF7, 0xC0, 0x1F,
  0x1F, 0xCF, 0xE7, 0xF3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1,
  0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0x7E, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0x70, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x08, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0x0F, 0xC3, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF,
  0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x43, 0xFC, 0x0F, 0xDF, 0xE0, 0xFF,
  0xFF, 0x0F, 0x8F, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0,
  0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F, 0x07,
  0xF8, 0x78, 0x3F, 0xC3, 0xC3, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x7F, 0x80,
  0xF3, 0xDC, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x07, 0x9E, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF8,
  0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x3E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x1F, 0x3C, 0x03,
  0xEF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3,
  0xC0, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xC1, 0xFC, 0xF0,
  0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFB, 0xC0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xC3,
  0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1,
  0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x07,
  0xF7, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1,
  0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x7D, 0xF0,
  0x3F, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0xF0, 0x07,
  0xDE, 0x00, 0xFB, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x01, 0xF1, 0xE0, 0x3E,
  0x3C, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC3, 0xE0,
  0x78, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x03, 0xE1,
  0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x0F, 0x9E, 0x01, 0xF3,
  0xC0, 0x1F, 0x78, 0x03, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xB8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xF1, 0xDF, 0xDC, 0x77, 0xF7, 0x1D, 0xFD, 0xEE, 0x7F,
  0x3B, 0x9F, 0xCE, 0xE7, 0xF3, 0xB9, 0xFC, 0x7C, 0xFF, 0x1F, 0x3F, 0xC7,
  0xCF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xF7, 0x07, 0xFB,
  0xC3, 0xFD, 0xE1, 0xFE, 0x70, 0xFF, 0x3C, 0x7F, 0x9E, 0x3F, 0xC7, 0x1F,
  0xE3, 0xCF, 0xF1, 0xE7, 0xF8, 0x73, 0xFC, 0x3D, 0xFE, 0x1E, 0xFF, 0x07,
  0x7F, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF,
  0xEF, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x3E, 0x7F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xF0, 0x1F, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0x7F, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0xE0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x1F, 0xBC, 0x03, 0xEF,
  0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0,
  0x3E, 0xF0, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x8F,
  0x01, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0xFB, 0xC0,
  0x1F, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F,
  0xDF, 0x01, 0xF7, 0x80, 0x3D, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x1F, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF8, 0x3E, 0x7F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xF8,
  0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C,
  0x1E, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x7D,
  0xE0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3D, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xF0, 0xF0, 0x7F,
  0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0D, 0x87, 0xF8, 0x6C,
  0x3F, 0xC3, 0x61, 0xDE, 0x1B, 0x0E, 0x70, 0xD8, 0x73, 0x8E, 0xC7, 0x9E,
  0x77, 0x3C, 0xF3, 0xB9, 0xE7, 0x99, 0xCF, 0x3C, 0xCE, 0x79, 0xE6, 0x33,
  0xCF, 0x31, 0x9C, 0x79, 0x8C, 0xE1, 0xDC, 0x67, 0x0E, 0xE3, 0x38, 0x77,
  0x1D, 0xC3, 0xB8, 0xFE, 0x1D, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0x81, 0xF0, 0x7C,
  0x0F, 0x83, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0xDF, 0x00, 0x1E,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xF7,
  0x80, 0x0F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF8, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0x7D, 0xF0, 0x03,
  0xF0, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF0, 0x0F, 0x0F,
  0x80, 0x7C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xF7, 0x00, 0x7B, 0xC0, 0x39, 0xE0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E,
  0x0F, 0x0F, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFE,
  0xFE, 0x3C, 0x07, 0xDF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC3, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x78, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xDF, 0x07, 0xF7, 0xFF, 0xFC, 0xFF,
  0xDF, 0x1F, 0xE7, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE3, 0xF0, 0xF3, 0xFE, 0x7B,
  0xFF, 0xBD, 0xFF, 0xDF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF7, 0x7F, 0x7B, 0xFF, 0xBC,
  0xFF, 0x9E, 0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF,
  0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x1F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xBF, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x3F, 0x9F, 0x3F, 0xEF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0x7F, 0x7F, 0xBF, 0xFF, 0xCF, 0xFB, 0xE3, 0xF9,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC7, 0xEF, 0x80, 0xF7,
  0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0xBE, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xCF, 0x9F, 0xF7, 0xDF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xF8, 0x7F, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFB, 0xE0, 0xE1, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE3, 0xF0, 0xF3, 0xFE,
  0x7B, 0xFF, 0xBD, 0xFF, 0xDF, 0x83, 0xEF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7,
  0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x01, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0xF8, 0x07, 0x9F, 0x01, 0xF3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7C, 0x7C, 0x0F, 0x87,
  0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x01,
  0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF7, 0xCF, 0x9F, 0xFB, 0xFB, 0xFF, 0xFF, 0x7C,
  0xF9, 0xFF, 0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0,
  0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x0E, 0x1F, 0xE1,
  0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3,
  0x87, 0xF8, 0x70, 0xFF, 0x0E, 0x1E, 0xF1, 0xF8, 0x79, 0xFF, 0x3D, 0xFF,
  0xDE, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF,
  0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80,
  0xF1, 0xF8, 0x79, 0xFF, 0x3D, 0xFF, 0xDE, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFB, 0xBF, 0xBD, 0xFF, 0xDE, 0x7F, 0xCF, 0x1F, 0xC7, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xCF, 0x9F, 0xF7, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xBF, 0xBF, 0xDF, 0xFF, 0xE7, 0xFD, 0xF1, 0xFC, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0xF3, 0xF8, 0x7B, 0xFF, 0x3D, 0xFF, 0xDF, 0xEF, 0xEF, 0x81, 0xF7, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xC7, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xDF,
  0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0x80, 0xFF, 0x80, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x3C,
  0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x7C, 0x0F, 0x8F, 0x00, 0xF1, 0xE0, 0x1E,
  0x7C, 0x03, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0x83, 0xFC,
  0x3E, 0x1F, 0xE1, 0xF0, 0xE7, 0x0D, 0x87, 0x38, 0x6C, 0x39, 0xE3, 0x63,
  0xCF, 0x3B, 0x1E, 0x79, 0xD8, 0xF3, 0xCE, 0xE7, 0x1E, 0x67, 0x38, 0x73,
  0x19, 0xC3, 0x98, 0xCE, 0x1C, 0xC6, 0xF0, 0xFE, 0x37, 0x87, 0xF1, 0xF8,
  0x3F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x00, 0x7C, 0x01, 0xF3, 0xE0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x8F, 0x80, 0x79, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3D,
  0xE0, 0x07, 0xDF, 0x00, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0x7C, 0x3E,
  0x03, 0xE7, 0xE0, 0x3E, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x7D,
  0xE0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0xCF, 0x00,
  0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x7E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x07, 0xF0,
  0x3D, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0x1F, 0x1F, 0xE1, 0xFF, 0xFC, 0x1F,
  0xF7, 0x83, 0xFC, 0x00, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 13, 12, 23, 5, -28 },
  { 46, 21, 28, 23, 1, -28 },
  { 120, 18, 38, 23, 2, -33 },
  { 206, 23, 28, 23, 0, -28 },
  { 287, 20, 28, 23, 2, -28 },
  { 357, 5, 12, 23, 9, -28 },
  { 365, 11, 37, 23, 7, -32 },
  { 416, 12, 37, 23, 4, -32 },
  { 472, 21, 20, 23, 1, -23 },
  { 525, 18, 18, 23, 2, -22 },
  { 566, 9, 12, 23, 6, -6 },
  { 580, 12, 4, 23, 5, -15 },
  { 586, 7, 7, 23, 8, -7 },
  { 593, 18, 36, 23, 2, -32 },
  { 674, 17, 28, 23, 3, -28 },
  { 734, 18, 28, 23, 3, -28 },
  { 797, 18, 28, 23, 2, -28 },
  { 860, 18, 28, 23, 2, -28 },
  { 923, 16, 28, 23, 3, -28 },
  { 979, 17, 28, 23, 3, -28 },
  { 1039, 19, 28, 23, 2, -28 },
  { 1106, 19, 28, 23, 2, -28 },
  { 1173, 17, 28, 23, 3, -28 },
  { 1233, 19, 28, 23, 2, -28 },
  { 1300, 7, 21, 23, 8, -21 },
  { 1319, 9, 27, 23, 6, -21 },
  { 1350, 17, 21, 23, 3, -23 },
  { 1395, 17, 13, 23, 3, -19 },
  { 1423, 17, 21, 23, 3, -23 },
  { 1468, 14, 28, 23, 5, -28 },
  { 1517, 21, 35, 23, 1, -28 },
  { 1609, 20, 28, 23, 1, -28 },
  { 1679, 18, 28, 23, 3, -28 },
  { 1742, 17, 28, 23, 3, -28 },
  { 1802, 17, 28, 23, 3, -28 },
  { 1862, 17, 28, 23, 3, -28 },
  { 1922, 17, 28, 23, 3, -28 },
  { 1982, 17, 28, 23, 3, -28 },
  { 2042, 17, 28, 23, 3, -28 },
  { 2102, 15, 28, 23, 4, -28 },
  { 2155, 18, 28, 23, 1, -28 },
  { 2218, 19, 28, 23, 3, -28 },
  { 2285, 16, 28, 23, 4, -28 },
  { 2341, 18, 28, 23, 2, -28 },
  { 2404, 17, 28, 23, 3, -28 },
  { 2464, 17, 28, 23, 3, -28 },
  { 2524, 18, 28, 23, 3, -28 },
  { 2587, 17, 35, 23, 3, -28 },
  { 2662, 18, 28, 23, 3, -28 },
  { 2725, 18, 28, 23, 2, -28 },
  { 2788, 19, 28, 23, 2, -28 },
  { 2855, 17, 28, 23, 3, -28 },
  { 2915, 20, 28, 23, 1, -28 },
  { 2985, 21, 28, 23, 1, -28 },
  { 3059, 21, 28, 23, 1, -28 },
  { 3133, 21, 28, 23, 1, -28 },
  { 3207, 17, 28, 23, 3, -28 },
  { 3267, 11, 36, 23, 7, -32 },
  { 3317, 18, 36, 23, 2, -32 },
  { 3398, 11, 36, 23, 5, -32 },
  { 3448, 17, 15, 23, 3, -28 },
  { 3480, 19, 4, 23, 2, 1 },
  { 3490, 9, 5, 23, 6, -30 },
  { 3496, 18, 21, 23, 2, -21 },
  { 3544, 17, 28, 23, 3, -28 },
  { 3604, 17, 21, 23, 3, -21 },
  { 3649, 17, 28, 23, 3, -28 },
  { 3709, 17, 21, 23, 3, -21 },
  { 3754, 19, 28, 23, 2, -28 },
  { 3821, 17, 28, 23, 3, -21 },
  { 3881, 17, 28, 23, 3, -28 },
  { 3941, 18, 30, 23, 3, -30 },
  { 4009, 15, 37, 23, 3, -30 },
  { 4079, 19, 28, 23, 3, -28 },
  { 4146, 20, 28, 23, 1, -28 },
  { 4216, 19, 21, 23, 2, -21 },
  { 4266, 17, 21, 23, 3, -21 },
  { 4311, 17, 21, 23, 3, -21 },
  { 4356, 17, 28, 23, 3, -21 },
  { 4416, 17, 28, 23, 3, -21 },
  { 4476, 17, 21, 23, 4, -21 },
  { 4521, 17, 21, 23, 3, -21 },
  { 4566, 18, 27, 23, 2, -27 },
  { 4627, 17, 21, 23, 3, -21 },
  { 4672, 19, 21, 23, 2, -21 },
  { 4722, 21, 21, 23, 1, -21 },
  { 4778, 20, 21, 23, 1, -21 },
  { 4831, 19, 28, 23, 2, -21 },
  { 4898, 17, 21, 23, 3, -21 },
  { 4943, 17, 36, 23, 3, -32 },
  { 5020, 5, 36, 23, 9, -32 },
  { 5043, 17, 36, 23, 3, -32 },
  { 5120, 19, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_SemiBold38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_SEMIBOLD38PT7B_H_
