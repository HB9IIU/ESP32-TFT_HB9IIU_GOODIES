#ifndef _JETBRAINSMONO_SEMIBOLD42PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0x78, 0xF1, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF7, 0xFF, 0xFF, 0xDF, 0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x3C,
  0x01, 0xE0, 0x78, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF0, 0x38, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x70, 0x03,
  0xC0, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78,
  0x1E, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x07, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xCE, 0x7E, 0xF8, 0xE3, 0xEF, 0x8E, 0x3E, 0xF8, 0xE0, 0x0F,
  0x8E, 0x00, 0xFC, 0xE0, 0x07, 0xEE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0E, 0x7E, 0x00, 0xE3, 0xE0, 0x0E, 0x1F, 0x00, 0xE1, 0xFF, 0x0E,
  0x1F, 0xF8, 0xE3, 0xEF, 0x8E, 0x3E, 0xFE, 0xE7, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x07, 0x9F, 0xF0, 0x03, 0x9F, 0xFC, 0x03, 0xCF, 0x1E, 0x03, 0xC7, 0x07,
  0x81, 0xC3, 0x83, 0xC1, 0xE1, 0xC1, 0xE1, 0xE0, 0xE0, 0xF1, 0xE0, 0x70,
  0x78, 0xE0, 0x38, 0x3C, 0xF0, 0x1E, 0x3C, 0xF0, 0x0F, 0xFE, 0x70, 0x03,
  0xFE, 0x78, 0x00, 0xFE, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x1C, 0xFF, 0x80, 0x1E, 0xFF,
  0xE0, 0x1E, 0x78, 0xF0, 0x0E, 0x38, 0x3C, 0x0F, 0x1C, 0x1E, 0x0F, 0x0E,
  0x0F, 0x07, 0x07, 0x07, 0x87, 0x83, 0x83, 0xC7, 0x81, 0xC1, 0xE7, 0x80,
  0xF1, 0xE3, 0x80, 0x7F, 0xF3, 0xC0, 0x1F, 0xF3, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFD, 0xF0, 0x7F, 0xE7, 0xC3,
  0xEF, 0x8F, 0x8F, 0x3E, 0x1F, 0x7C, 0xF8, 0x7F, 0xE3, 0xE0, 0xFF, 0x8F,
  0x81, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC1,
  0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xE3, 0xE1, 0xFF, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18,
  0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x87, 0xF0, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFC,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x08, 0x0E, 0x03, 0x3E, 0x1C, 0x3E, 0x7F, 0x39, 0xFD, 0xFF, 0x37,
  0xFD, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80,
  0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0xF0, 0x1E, 0x00, 0x40, 0x10, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8,
  0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0,
  0xFC, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF1, 0xC3, 0xFE, 0x7C,
  0x7F, 0xCF, 0x8F, 0xF9, 0xF1, 0xFF, 0x1E, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x7D, 0xF8, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0x87, 0xC0, 0xC0, 0xF8,
  0x10, 0x1F, 0x02, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xF1, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x3F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0xF3, 0xF0, 0x3D, 0xF8, 0x0F, 0x7C, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x7F, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF0, 0x7E, 0x7C, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFD, 0xF8, 0x3F, 0x3F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x7F, 0x07, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xF0,
  0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x00,
  0x7D, 0xF0, 0x1F, 0x3F, 0x03, 0xE3, 0xF1, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0x07, 0xF7, 0xF1, 0xF8, 0x3F, 0x3E, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x7D, 0xF8, 0x1F, 0xBF, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xF8, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1E,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0xC0,
  0x1F, 0xBE, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xDF, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xBE, 0x04, 0x0F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF3, 0xF1, 0xF8, 0xF8,
  0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0x83, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3E, 0x01,
  0xF1, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x43, 0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC3,
  0xFF, 0xFF, 0x0F, 0x87, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0,
  0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF,
  0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x7F, 0xC3, 0xF3, 0xFF, 0x07,
  0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x0F, 0x1E, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x80, 0xFC, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xF1, 0xFC, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x3F, 0x1F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xF1, 0xFC, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x3F, 0x1F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7F, 0x07,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xC3, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7E, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFE,
  0xE0, 0xFF, 0xEE, 0x0E, 0xFE, 0xF0, 0xEF, 0xE7, 0x1E, 0xFF, 0x71, 0xCF,
  0xF7, 0x9C, 0xFF, 0x7B, 0xDF, 0xF3, 0xBD, 0xFF, 0x3B, 0x9F, 0xF3, 0xF9,
  0xFF, 0x1F, 0x9F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xF0, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xBC, 0x1F,
  0xF7, 0x83, 0xFE, 0xF0, 0x7F, 0xEF, 0x0F, 0xFD, 0xE1, 0xFF, 0x9E, 0x3F,
  0xF3, 0xC7, 0xFE, 0x78, 0xFF, 0xC7, 0x9F, 0xF8, 0xF3, 0xFF, 0x1E, 0x7F,
  0xE1, 0xE7, 0xFC, 0x3C, 0xFF, 0x87, 0x9F, 0xF0, 0x7B, 0xFE, 0x0F, 0x7F,
  0xC1, 0xEF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xF8, 0x0F, 0xBF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x3F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0x7F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0x1F, 0xC7, 0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0x7E, 0x0F, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xEF, 0x80, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07,
  0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7,
  0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xFE, 0x07, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x07, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x7D, 0xF0, 0x00, 0xF7, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x3C, 0x1F, 0xE0, 0xF8,
  0x3F, 0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFF, 0x0D, 0x83,
  0xFE, 0x1B, 0x87, 0xBC, 0x37, 0x0F, 0x78, 0x6E, 0x3E, 0xF1, 0xDC, 0x79,
  0xE3, 0xB8, 0xF3, 0xC7, 0x71, 0xE7, 0x8E, 0x63, 0xCF, 0x1C, 0xC7, 0x9E,
  0x39, 0x8F, 0x3C, 0x63, 0x9E, 0x7C, 0xC7, 0x3C, 0x7B, 0x8E, 0x78, 0xF7,
  0x1C, 0xE1, 0xEE, 0x3B, 0xC3, 0xDC, 0x77, 0x87, 0xB8, 0xEF, 0x0F, 0x70,
  0xDE, 0x1E, 0xC1, 0xBC, 0x3D, 0x83, 0xF8, 0x7B, 0x07, 0xF0, 0x7E, 0x0F,
  0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xE0, 0xF8, 0x0F,
  0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x03, 0xE3, 0xF0,
  0x07, 0xC7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE1, 0xF0, 0x0F, 0x83,
  0xE0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0xFD, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x7D, 0xF0, 0x00,
  0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1F,
  0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1F, 0xF8,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x30, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x3E, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xF0,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7F, 0x1F,
  0xF3, 0xFF, 0xFF, 0x3F, 0xFD, 0xF0, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x80, 0xF8, 0xFE, 0x1F, 0x7F, 0xF3, 0xEF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F,
  0x7F, 0xFF, 0xEF, 0xBF, 0xF9, 0xF3, 0xFF, 0x3E, 0x3F, 0x80, 0x00, 0x60,
  0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x0F, 0xBF, 0x07, 0xF7, 0xFF, 0xFC,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x08, 0x1F, 0x0F, 0xF3, 0xE3, 0xFF, 0x7C, 0xFF, 0xEF, 0xBF, 0xFF, 0xF7,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFD, 0xF8, 0x3F, 0xBF,
  0xFF, 0xF3, 0xFF, 0xBE, 0x3F, 0xF7, 0xC3, 0xF8, 0xF8, 0x00, 0x40, 0x00,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF9, 0xFC, 0xF8, 0x0F, 0xBE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xBE, 0x03, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F,
  0xFD, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xEF, 0xC1, 0xFD, 0xFF,
  0xFF, 0x9F, 0xFD, 0xF3, 0xFF, 0xBE, 0x1F, 0xE7, 0xC0, 0x60, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x80, 0xF8, 0xFE, 0x1F, 0x7F, 0xF3, 0xEF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xE0, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C,
  0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7C, 0x3F, 0x03, 0xE0,
  0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xF1,
  0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xE0, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x80, 0x87, 0x9F, 0x1F, 0x3D, 0xFD, 0xFD, 0xEF, 0xFF, 0xEF,
  0x8F, 0x8F, 0xFC, 0x3C, 0x7F, 0xE1, 0xC1, 0xFF, 0x0E, 0x0F, 0xF8, 0x70,
  0x7F, 0xC3, 0x83, 0xFE, 0x1C, 0x1F, 0xF0, 0xE0, 0xFF, 0x87, 0x07, 0xFC,
  0x38, 0x3F, 0xE1, 0xC1, 0xFF, 0x0E, 0x0F, 0xF8, 0x70, 0x7F, 0xC3, 0x83,
  0xFE, 0x1C, 0x1F, 0xF0, 0xE0, 0xFF, 0x87, 0x07, 0xFC, 0x38, 0x3F, 0xE1,
  0xC1, 0xFF, 0x0E, 0x0F, 0x00, 0x10, 0x1F, 0x1F, 0xC3, 0xEF, 0xFE, 0x7D,
  0xFF, 0xCF, 0xFF, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE0,
  0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x3F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x10, 0x1F, 0x1F,
  0xC3, 0xEF, 0xFE, 0x7D, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xEF, 0xFF, 0xFD, 0xF7, 0xFF,
  0x3E, 0x7F, 0xE7, 0xC7, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0x00, 0x01, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F, 0xFD, 0xF7, 0xFF, 0xFE,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBF, 0x07, 0xF7,
  0xFF, 0xFE, 0x7F, 0xF7, 0xC7, 0xFE, 0xF8, 0x7F, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x10, 0x1F, 0x3F, 0xC3, 0xEF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0xDE, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xF9, 0xF8, 0x3F, 0x1F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1E,
  0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF9, 0xE0,
  0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x3C, 0x1F, 0xE0, 0xF8,
  0x3F, 0xC1, 0xF0, 0x7B, 0xC3, 0xE0, 0xF7, 0x86, 0xC1, 0xCF, 0x0D, 0x87,
  0x9E, 0x1B, 0x8F, 0x3C, 0x77, 0x1E, 0x78, 0xEE, 0x3C, 0xF1, 0xDC, 0x78,
  0xF3, 0x98, 0xF1, 0xE6, 0x31, 0xC3, 0xCC, 0x77, 0x87, 0x98, 0xEF, 0x0F,
  0x71, 0xDE, 0x1E, 0xE3, 0xBC, 0x1D, 0xC7, 0x78, 0x3B, 0x86, 0xE0, 0x7E,
  0x0D, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x07, 0xC1,
  0xF8, 0x1F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F,
  0x80, 0x7E, 0x3F, 0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xF1,
  0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xDF,
  0x00, 0x7E, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xFC, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x00, 0x02, 0x00,
  0x01, 0xFE, 0x03, 0xDF, 0xF8, 0x1E, 0xFF, 0xE0, 0xFF, 0xDF, 0x87, 0xFC,
  0x7E, 0x7F, 0xC1, 0xFF, 0xFE, 0x07, 0xFE, 0xF0, 0x1F, 0xE0, 0x00, 0x7E,
  0x00,
};

const GFXglyph JetBrainsMono_SemiBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -31 },
  { 29, 14, 13, 25, 6, -31 },
  { 52, 23, 31, 25, 1, -31 },
  { 142, 20, 43, 25, 3, -37 },
  { 250, 25, 31, 25, 0, -31 },
  { 347, 22, 31, 25, 2, -31 },
  { 433, 5, 13, 25, 10, -31 },
  { 442, 13, 40, 25, 7, -35 },
  { 507, 13, 40, 25, 5, -35 },
  { 572, 23, 22, 25, 1, -26 },
  { 636, 20, 20, 25, 3, -24 },
  { 686, 10, 13, 25, 6, -6 },
  { 703, 13, 4, 25, 6, -16 },
  { 710, 7, 7, 25, 9, -7 },
  { 717, 20, 40, 25, 3, -35 },
  { 817, 19, 31, 25, 3, -31 },
  { 891, 19, 31, 25, 4, -31 },
  { 965, 19, 31, 25, 3, -31 },
  { 1039, 19, 31, 25, 3, -31 },
  { 1113, 18, 31, 25, 3, -31 },
  { 1183, 19, 31, 25, 3, -31 },
  { 1257, 21, 31, 25, 2, -31 },
  { 1339, 20, 31, 25, 3, -31 },
  { 1417, 19, 31, 25, 3, -31 },
  { 1491, 21, 31, 25, 2, -31 },
  { 1573, 7, 24, 25, 9, -24 },
  { 1594, 9, 31, 25, 7, -24 },
  { 1629, 19, 23, 25, 3, -25 },
  { 1684, 19, 14, 25, 3, -21 },
  { 1718, 19, 23, 25, 3, -25 },
  { 1773, 16, 31, 25, 5, -31 },
  { 1835, 22, 39, 25, 2, -31 },
  { 1943, 22, 31, 25, 2, -31 },
  { 2029, 20, 31, 25, 3, -31 },
  { 2107, 19, 31, 25, 3, -31 },
  { 2181, 19, 31, 25, 3, -31 },
  { 2255, 18, 31, 25, 4, -31 },
  { 2325, 18, 31, 25, 4, -31 },
  { 2395, 19, 31, 25, 3, -31 },
  { 2469, 19, 31, 25, 3, -31 },
  { 2543, 17, 31, 25, 4, -31 },
  { 2609, 20, 31, 25, 1, -31 },
  { 2687, 21, 31, 25, 3, -31 },
  { 2769, 19, 31, 25, 4, -31 },
  { 2843, 20, 31, 25, 3, -31 },
  { 2921, 19, 31, 25, 3, -31 },
  { 2995, 19, 31, 25, 3, -31 },
  { 3069, 20, 31, 25, 3, -31 },
  { 3147, 20, 39, 25, 3, -31 },
  { 3245, 20, 31, 25, 3, -31 },
  { 3323, 20, 31, 25, 3, -31 },
  { 3401, 21, 31, 25, 2, -31 },
  { 3483, 19, 31, 25, 3, -31 },
  { 3557, 22, 31, 25, 2, -31 },
  { 3643, 23, 31, 25, 1, -31 },
  { 3733, 23, 31, 25, 1, -31 },
  { 3823, 23, 31, 25, 1, -31 },
  { 3913, 19, 31, 25, 3, -31 },
  { 3987, 11, 40, 25, 8, -35 },
  { 4042, 20, 40, 25, 3, -35 },
  { 4142, 11, 40, 25, 6, -35 },
  { 4197, 19, 17, 25, 3, -31 },
  { 4238, 20, 4, 25, 3, 1 },
  { 4248, 10, 6, 25, 7, -33 },
  { 4256, 20, 24, 25, 2, -24 },
  { 4316, 19, 31, 25, 3, -31 },
  { 4390, 19, 24, 25, 3, -24 },
  { 4447, 19, 31, 25, 3, -31 },
  { 4521, 19, 24, 25, 3, -24 },
  { 4578, 21, 31, 25, 2, -31 },
  { 4660, 19, 32, 25, 3, -24 },
  { 4736, 19, 31, 25, 3, -31 },
  { 4810, 20, 33, 25, 3, -33 },
  { 4893, 17, 41, 25, 3, -33 },
  { 4981, 21, 31, 25, 3, -31 },
  { 5063, 22, 31, 25, 1, -31 },
  { 5149, 21, 24, 25, 2, -24 },
  { 5212, 19, 24, 25, 3, -24 },
  { 5269, 19, 23, 25, 3, -23 },
  { 5324, 19, 32, 25, 3, -24 },
  { 5400, 19, 32, 25, 3, -24 },
  { 5476, 19, 24, 25, 4, -24 },
  { 5533, 19, 23, 25, 3, -23 },
  { 5588, 20, 30, 25, 2, -30 },
  { 5663, 19, 23, 25, 3, -23 },
  { 5718, 21, 23, 25, 2, -23 },
  { 5779, 23, 23, 25, 1, -23 },
  { 5846, 22, 23, 25, 2, -23 },
  { 5910, 21, 31, 25, 2, -23 },
  { 5992, 19, 23, 25, 3, -23 },
  { 6047, 19, 40, 25, 3, -35 },
  { 6142, 5, 40, 25, 10, -35 },
  { 6167, 19, 40, 25, 3, -35 },
  { 6262, 21, 10, 25, 2, -20 },
};

const GFXfont JetBrainsMono_SemiBold42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_SEMIBOLD42PT7B_H_
