#ifndef _JETBRAINSMONO_SEMIBOLD46PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x78,
  0x3E, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x0F, 0x03,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xDC, 0xFE, 0x7E,
  0x71, 0xF9, 0xF1, 0xC3, 0xE7, 0xC7, 0x0F, 0x9F, 0x1C, 0x00, 0x7C, 0x70,
  0x01, 0xF9, 0xC0, 0x07, 0xE7, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0x7F, 0x80, 0x1C, 0x7E, 0x00, 0x70, 0xFC, 0x01, 0xC3,
  0xF0, 0x07, 0x0F, 0xFE, 0x1C, 0x3F, 0xF8, 0x70, 0xFF, 0xF1, 0xC3, 0xEF,
  0xE7, 0x1F, 0x9F, 0xFD, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x01,
  0xF1, 0xFF, 0x00, 0x1E, 0x3F, 0xF8, 0x03, 0xC7, 0xFF, 0x80, 0x78, 0x78,
  0x7C, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x3C, 0x07, 0x83, 0xC7, 0x80, 0x78, 0x3C, 0xF8, 0x07,
  0x87, 0xCF, 0x00, 0x7F, 0xF9, 0xE0, 0x03, 0xFF, 0x3C, 0x00, 0x1F, 0xE3,
  0xC0, 0x00, 0x10, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x7C, 0xFF, 0x80, 0x07,
  0x9F, 0xFC, 0x00, 0xF3, 0xE3, 0xE0, 0x1E, 0x3C, 0x1E, 0x01, 0xE3, 0xC1,
  0xE0, 0x3C, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F,
  0x03, 0xC1, 0xE1, 0xE0, 0x3C, 0x1E, 0x3E, 0x03, 0xE3, 0xE3, 0xC0, 0x1F,
  0xFC, 0x78, 0x00, 0xFF, 0x8F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF8, 0x1F, 0x7C, 0xF8, 0x3F, 0xFC, 0xFC, 0x3E, 0xF8, 0x7E, 0x7C, 0xF8,
  0x3E, 0x7C, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8,
  0x07, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0x7E,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0x7E, 0x1F, 0xFE, 0x3E, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x07, 0xC0, 0x07, 0x00, 0x04, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x01, 0xFC,
  0x03, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0xC0, 0x78, 0x0C, 0x78, 0x3C, 0x3E, 0x7F, 0x1C, 0x3F, 0x3F,
  0xEE, 0x7F, 0xFF, 0xFB, 0x7F, 0xE3, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF3, 0xC0,
  0x01, 0xF1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x0E, 0x01, 0xC0, 0x02, 0x00, 0x40, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x3F, 0x81, 0xF9, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE1, 0xC3, 0xFF, 0x1F, 0x1F, 0xF8, 0xFC, 0xFF, 0xC7, 0xE7, 0xFE,
  0x3E, 0x3F, 0xF0, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0xF8,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0xC3, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xBE, 0x03, 0xF9, 0xF0,
  0x1F, 0x8F, 0x80, 0xF0, 0x7C, 0x07, 0x03, 0xE0, 0x30, 0x1F, 0x01, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF1, 0xFC, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x3F, 0x01,
  0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC7, 0xF0, 0x3E, 0x7F, 0xE1, 0xF7,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xCF, 0xF3, 0xF8, 0x1F, 0xDF, 0x80, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xF7,
  0xE0, 0x3F, 0xBF, 0xC3, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x78, 0x03, 0xF7, 0xFC, 0x0F, 0xBF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFF, 0x7F, 0xCF, 0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3E, 0x7E, 0x01, 0xF9,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3E,
  0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x7E, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0xC3,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0x3F, 0x3F, 0x00, 0xFD, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xF7, 0xE0, 0x1F, 0xBF, 0xC3, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xF8, 0x0F, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7E, 0x7F, 0x07, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0x07, 0xFE,
  0xFC, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x07, 0x83, 0xF8, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x02, 0x0F, 0xF0, 0x1F, 0xCF, 0xF0, 0x3F, 0xEF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F,
  0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F,
  0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x1F,
  0xF0, 0x7C, 0x3F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF0, 0x1F, 0xCF,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0x80,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7C, 0x07, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80,
  0x3F, 0x7C, 0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xF0, 0x0F, 0xEF, 0x80, 0x3F, 0x7C, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x81,
  0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0x9F, 0xE7, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0x83, 0xFE, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x81, 0xFD, 0xF8, 0x07,
  0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0xC3,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xBF, 0xC7, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x1F,
  0xBE, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E,
  0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3E, 0x1F, 0x80, 0xF8,
  0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xF3,
  0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFB,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7B, 0xFD, 0xC1,
  0xEF, 0xF7, 0x87, 0xBF, 0xDE, 0x1D, 0xFF, 0x38, 0xF7, 0xFC, 0xF3, 0xDF,
  0xF3, 0xCE, 0x7F, 0xC7, 0x79, 0xFF, 0x9F, 0xE7, 0xFE, 0x7F, 0x9F, 0xF9,
  0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xF0, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xF7, 0x81, 0xFF,
  0x78, 0x1F, 0xF7, 0xC1, 0xFF, 0x3C, 0x1F, 0xF3, 0xC1, 0xFF, 0x3E, 0x1F,
  0xF1, 0xE1, 0xFF, 0x1E, 0x1F, 0xF1, 0xF1, 0xFF, 0x0F, 0x1F, 0xF0, 0xF1,
  0xFF, 0x0F, 0x9F, 0xF0, 0x79, 0xFF, 0x07, 0xDF, 0xF0, 0x7D, 0xFF, 0x03,
  0xDF, 0xF0, 0x3F, 0xFF, 0x03, 0xEF, 0xF0, 0x1E, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0x7C,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0x1F, 0xC7, 0xF8, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xE0, 0x3F,
  0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80,
  0x1F, 0xBE, 0x01, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F,
  0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF,
  0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00,
  0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E,
  0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x7E,
  0x03, 0xF9, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7C, 0x07, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x03, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x83,
  0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xDF,
  0x00, 0x7E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F,
  0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3E, 0xFE, 0x01, 0xF9, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xE7, 0xF1, 0xFE, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC7, 0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x83, 0xE0,
  0x7F, 0xE0, 0xFC, 0x1E, 0xF8, 0x3F, 0x07, 0xBE, 0x0F, 0xC1, 0xEF, 0x83,
  0xF0, 0x79, 0xE0, 0xFC, 0x3E, 0x78, 0x37, 0x0F, 0x9E, 0x1D, 0xC3, 0xE7,
  0x87, 0x70, 0xF9, 0xF1, 0xCC, 0x3E, 0x7C, 0x73, 0x8F, 0x1F, 0x1C, 0xE3,
  0xC7, 0xC7, 0x38, 0xF1, 0xF1, 0xCE, 0x3C, 0x3C, 0x73, 0x8F, 0x0F, 0x38,
  0xE3, 0xC3, 0xCE, 0x39, 0xF0, 0xF3, 0x8E, 0x7C, 0x3C, 0xE1, 0x9F, 0x0F,
  0x38, 0x77, 0x83, 0xEE, 0x1D, 0xE0, 0xFB, 0x87, 0x78, 0x3E, 0xE1, 0xDE,
  0x0F, 0xB0, 0x77, 0x81, 0xFC, 0x1D, 0xE0, 0x7F, 0x07, 0x78, 0x1F, 0xC1,
  0xDE, 0x07, 0xF0, 0x77, 0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7C,
  0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0x3C, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0x80,
  0x3E, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07,
  0xEF, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFB, 0xEF, 0xFF, 0xDF, 0x3F, 0xFC, 0xF8,
  0xFF, 0xC7, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x3C, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xE0, 0xFE, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xEF, 0xBF, 0xFC, 0xF9,
  0xFF, 0x8F, 0x8F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x81, 0xFD, 0xF8, 0x07, 0xEF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x9F,
  0xC3, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0,
  0xF8, 0x7F, 0xC7, 0xC7, 0xFF, 0x3E, 0x7F, 0xFD, 0xF3, 0xFF, 0xEF, 0xBF,
  0x83, 0xFD, 0xF8, 0x0F, 0xEF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E,
  0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0xC3, 0x7C, 0xFF, 0xFB, 0xE7, 0xFF,
  0xDF, 0x1F, 0xFC, 0xF8, 0x3F, 0xC7, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x01, 0xF9, 0xF8,
  0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF7,
  0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC7, 0xC7, 0xFF, 0x3E, 0x7F, 0xFD,
  0xF3, 0xFF, 0xEF, 0xBF, 0x83, 0xFD, 0xF8, 0x0F, 0xEF, 0x80, 0x3F, 0x7C,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0,
  0x0F, 0xDF, 0x80, 0xFE, 0xFF, 0x0F, 0xF3, 0xFF, 0xEF, 0x9F, 0xFF, 0x7C,
  0x7F, 0xF3, 0xE0, 0xFF, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0xCF,
  0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x07, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0xFC,
  0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8,
  0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x03,
  0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xE0,
  0x1F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFE, 0xF8, 0x01, 0xFB, 0xE0, 0x03,
  0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xC0, 0xC3, 0xDF, 0x8F, 0xCF, 0x7F, 0x7F, 0xBF, 0xFD, 0xFF, 0xF8,
  0xFC, 0xFF, 0xE1, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78,
  0x7F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78, 0x7F,
  0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78, 0x7F, 0xC1,
  0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78, 0x7F, 0xC1, 0xE1,
  0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78, 0x7F, 0xC1, 0xE1, 0xF0,
  0x00, 0x3C, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xE0, 0xFE, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xF8, 0x07, 0xEF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xE0, 0x3F,
  0x9F, 0xC7, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x00, 0x3C, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0xCF, 0xBF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xEF,
  0xBF, 0xFC, 0xF9, 0xFF, 0x8F, 0x8F, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC7, 0xC7, 0xFF, 0x3E, 0x7F,
  0xFD, 0xF3, 0xFF, 0xEF, 0xBF, 0x83, 0x7D, 0xF8, 0x0F, 0xEF, 0x80, 0x3F,
  0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB,
  0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0xC3,
  0x7C, 0xFF, 0xFB, 0xE7, 0xFF, 0xDF, 0x1F, 0xFC, 0xF8, 0x3F, 0xC7, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x9F, 0xF0, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0xF9,
  0xF8, 0x07, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7F, 0x1F, 0xE7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF8,
  0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0xF8, 0x1E, 0x07, 0xFE, 0x0F, 0x81, 0xE7, 0x83, 0xE0, 0x79, 0xE0, 0xFC,
  0x1E, 0x78, 0x3F, 0x0F, 0x9E, 0x0F, 0xC3, 0xE7, 0xC3, 0x70, 0xF1, 0xF1,
  0xDC, 0x3C, 0x7C, 0x77, 0x0F, 0x0F, 0x1C, 0xC3, 0xC3, 0xC7, 0x38, 0xF0,
  0xF1, 0xCE, 0x7C, 0x3C, 0x73, 0x9E, 0x0F, 0xB8, 0xE7, 0x83, 0xEE, 0x39,
  0xE0, 0x7B, 0x8E, 0x78, 0x1E, 0xE1, 0xDE, 0x07, 0xB8, 0x77, 0x81, 0xEE,
  0x1F, 0xE0, 0x7B, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xEF,
  0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x81,
  0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x1E, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7B, 0xFF, 0xE0, 0xF7, 0x87, 0xC3,
  0xFF, 0x07, 0xE7, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0xF8, 0x0F, 0xF8,
  0x00, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_SemiBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 34, 28, 10, -34 },
  { 35, 16, 14, 28, 6, -34 },
  { 63, 25, 34, 28, 1, -34 },
  { 170, 22, 46, 28, 3, -40 },
  { 297, 28, 34, 28, 0, -34 },
  { 416, 24, 34, 28, 2, -34 },
  { 518, 5, 14, 28, 11, -34 },
  { 527, 14, 45, 28, 8, -39 },
  { 606, 15, 45, 28, 5, -39 },
  { 691, 25, 24, 28, 1, -28 },
  { 766, 22, 22, 28, 3, -26 },
  { 827, 11, 14, 28, 7, -7 },
  { 847, 15, 5, 28, 6, -18 },
  { 857, 8, 8, 28, 10, -8 },
  { 865, 22, 43, 28, 3, -38 },
  { 984, 21, 34, 28, 3, -34 },
  { 1074, 21, 34, 28, 4, -34 },
  { 1164, 22, 34, 28, 3, -34 },
  { 1258, 21, 34, 28, 3, -34 },
  { 1348, 21, 34, 28, 3, -34 },
  { 1438, 21, 34, 28, 3, -34 },
  { 1528, 22, 34, 28, 3, -34 },
  { 1622, 22, 34, 28, 3, -34 },
  { 1716, 21, 34, 28, 3, -34 },
  { 1806, 22, 34, 28, 3, -34 },
  { 1900, 8, 26, 28, 10, -26 },
  { 1926, 11, 33, 28, 7, -26 },
  { 1972, 20, 25, 28, 4, -28 },
  { 2035, 20, 16, 28, 4, -23 },
  { 2075, 20, 25, 28, 4, -28 },
  { 2138, 17, 34, 28, 6, -34 },
  { 2211, 24, 42, 28, 2, -34 },
  { 2337, 24, 34, 28, 2, -34 },
  { 2439, 21, 34, 28, 4, -34 },
  { 2529, 21, 34, 28, 3, -34 },
  { 2619, 20, 34, 28, 4, -34 },
  { 2704, 20, 34, 28, 4, -34 },
  { 2789, 20, 34, 28, 4, -34 },
  { 2874, 21, 34, 28, 3, -34 },
  { 2964, 20, 34, 28, 4, -34 },
  { 3049, 19, 34, 28, 4, -34 },
  { 3130, 21, 34, 28, 2, -34 },
  { 3220, 22, 34, 28, 4, -34 },
  { 3314, 20, 34, 28, 5, -34 },
  { 3399, 22, 34, 28, 3, -34 },
  { 3493, 20, 34, 28, 4, -34 },
  { 3578, 21, 34, 28, 3, -34 },
  { 3668, 22, 34, 28, 4, -34 },
  { 3762, 22, 42, 28, 3, -34 },
  { 3878, 21, 34, 28, 4, -34 },
  { 3968, 22, 34, 28, 3, -34 },
  { 4062, 23, 34, 28, 2, -34 },
  { 4160, 20, 34, 28, 4, -34 },
  { 4245, 24, 34, 28, 2, -34 },
  { 4347, 26, 34, 28, 1, -34 },
  { 4458, 25, 34, 28, 1, -34 },
  { 4565, 25, 34, 28, 1, -34 },
  { 4672, 20, 34, 28, 4, -34 },
  { 4757, 12, 43, 28, 9, -38 },
  { 4822, 22, 43, 28, 3, -38 },
  { 4941, 13, 43, 28, 6, -38 },
  { 5011, 21, 18, 28, 3, -34 },
  { 5059, 22, 5, 28, 3, 1 },
  { 5073, 11, 6, 28, 8, -36 },
  { 5082, 21, 26, 28, 3, -26 },
  { 5151, 20, 34, 28, 4, -34 },
  { 5236, 21, 26, 28, 3, -26 },
  { 5305, 21, 34, 28, 3, -34 },
  { 5395, 21, 26, 28, 3, -26 },
  { 5464, 22, 34, 28, 3, -34 },
  { 5558, 21, 34, 28, 3, -26 },
  { 5648, 20, 34, 28, 4, -34 },
  { 5733, 22, 36, 28, 4, -36 },
  { 5832, 18, 44, 28, 4, -36 },
  { 5931, 22, 34, 28, 4, -34 },
  { 6025, 25, 34, 28, 1, -34 },
  { 6132, 22, 26, 28, 3, -26 },
  { 6204, 20, 26, 28, 4, -26 },
  { 6269, 21, 26, 28, 3, -26 },
  { 6338, 20, 34, 28, 4, -26 },
  { 6423, 21, 34, 28, 3, -26 },
  { 6513, 20, 26, 28, 5, -26 },
  { 6578, 22, 26, 28, 3, -26 },
  { 6650, 22, 32, 28, 2, -32 },
  { 6738, 20, 25, 28, 4, -25 },
  { 6801, 24, 25, 28, 2, -25 },
  { 6876, 26, 25, 28, 1, -25 },
  { 6958, 24, 25, 28, 2, -25 },
  { 7033, 24, 33, 28, 2, -25 },
  { 7132, 20, 25, 28, 4, -25 },
  { 7195, 20, 43, 28, 4, -38 },
  { 7303, 5, 43, 28, 11, -38 },
  { 7330, 20, 43, 28, 4, -38 },
  { 7438, 23, 10, 28, 2, -21 },
};

const GFXfont JetBrainsMono_SemiBold46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_SEMIBOLD46PT7B_H_
