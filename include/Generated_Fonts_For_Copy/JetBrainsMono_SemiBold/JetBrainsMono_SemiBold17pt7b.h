#ifndef _JETBRAINSMONO_SEMIBOLD17PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x03, 0xE0, 0xCF, 0x3C, 0xF3, 0xCC, 0x19, 0x86,
  0x61, 0x11, 0xFF, 0x11, 0x0C, 0xC3, 0x33, 0xFE, 0xFF, 0x88, 0x82, 0x61,
  0x98, 0x08, 0x08, 0x18, 0x7E, 0x6F, 0xCB, 0xC8, 0x78, 0x7C, 0x1F, 0x0B,
  0x0B, 0xCB, 0x7F, 0x3E, 0x08, 0x08, 0x20, 0x1E, 0x3C, 0x9B, 0x24, 0xCA,
  0x1F, 0x80, 0x40, 0x24, 0x1F, 0xCD, 0x92, 0x65, 0x9B, 0xC3, 0x80, 0x18,
  0x3E, 0x19, 0x88, 0x06, 0x03, 0x03, 0xC1, 0xB7, 0xDF, 0x67, 0x31, 0x9F,
  0xE7, 0xB8, 0xFF, 0xC0, 0x19, 0xDC, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x86,
  0x38, 0xE1, 0xC7, 0x0C, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xBB, 0x90,
  0x18, 0x0C, 0x36, 0xDD, 0xF1, 0x81, 0xE1, 0x98, 0xCC, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x76, 0xEC, 0xC8, 0xFF, 0xF0, 0xDF, 0x00,
  0x03, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30,
  0x60, 0x60, 0x60, 0xC0, 0x18, 0x7E, 0x67, 0xC3, 0xC3, 0xC3, 0xDB, 0xDB,
  0xC3, 0xC3, 0xC3, 0x7E, 0x3E, 0x3C, 0x6C, 0xCC, 0x8C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0xFF, 0xFF, 0x18, 0x7E, 0xE7, 0xC3, 0x03, 0x03, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x7E, 0x06, 0x0C, 0x18, 0x1C, 0x1E,
  0x03, 0x03, 0x03, 0xC3, 0x7E, 0x3C, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x63,
  0xC3, 0xC3, 0xFF, 0x03, 0x03, 0x03, 0x7F, 0x40, 0x40, 0x40, 0x5E, 0x7F,
  0x03, 0x03, 0x03, 0xC3, 0x7E, 0x3E, 0x0C, 0x18, 0x30, 0x30, 0x6C, 0x7E,
  0xE3, 0xC3, 0xC3, 0xC3, 0x7F, 0x3E, 0xFF, 0xC3, 0xC3, 0x06, 0x06, 0x0E,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x18, 0x7E, 0x67, 0xC3, 0xC3, 0x66,
  0x3C, 0x7E, 0xC3, 0xC3, 0xC3, 0x7F, 0x3E, 0x18, 0x7E, 0xE7, 0xC3, 0xC3,
  0xC3, 0xE7, 0x7F, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x5F, 0x80, 0x06, 0xF8,
  0x27, 0x70, 0x00, 0x07, 0x66, 0xCC, 0xC0, 0x03, 0x0F, 0x3C, 0xF0, 0xC0,
  0x70, 0x1E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x0F, 0x3C, 0xE0, 0x80, 0xF8, 0x38, 0x30, 0x30, 0xCF,
  0x9E, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x18, 0x3F, 0x30, 0xD8, 0x38, 0x1C,
  0xFE, 0x67, 0x33, 0x99, 0xCC, 0xE6, 0x71, 0xF8, 0x06, 0x01, 0xC0, 0x78,
  0x1C, 0x1E, 0x0F, 0x06, 0x82, 0x63, 0x31, 0x98, 0xFC, 0x7F, 0x61, 0xB0,
  0xD8, 0x70, 0xFE, 0xC7, 0xC3, 0xC3, 0xC6, 0xFC, 0xC7, 0xC3, 0xC3, 0xC3,
  0xFF, 0xFE, 0x18, 0x7E, 0x67, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC3, 0x7F, 0x3E, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFE, 0xFC, 0xFF, 0x83, 0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83,
  0xFF, 0xF0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x18, 0x7E, 0x67, 0xC3, 0xC0, 0xC0, 0xCF, 0xCF, 0xC3, 0xC3,
  0xC3, 0x7F, 0x3E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x63,
  0xFF, 0xF0, 0x1F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xC6,
  0xFE, 0x7C, 0xC3, 0x63, 0xB1, 0x99, 0xCC, 0xC7, 0xE3, 0x31, 0x9C, 0xC6,
  0x63, 0x30, 0xD8, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0xFF, 0xF0, 0xE7, 0xA7, 0xE5, 0xF5, 0xDF, 0xDB, 0xDB, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xD3, 0xDB, 0xCB, 0xCF, 0xCF,
  0xC7, 0xC7, 0xC7, 0x18, 0x7E, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x7E, 0x3E, 0xFE, 0x63, 0xB0, 0xD8, 0x7C, 0x37, 0xFB, 0xF9,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x18, 0x7E, 0x67, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3E, 0x0E, 0x06, 0x03, 0xFE, 0xC7,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFC, 0xCC, 0xC6, 0xC6, 0xC3, 0xC3, 0x18, 0x7E,
  0x67, 0xC3, 0xC0, 0x70, 0x7C, 0x1F, 0x03, 0x03, 0xC3, 0x7F, 0x3E, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3E, 0xC3,
  0xE1, 0xB0, 0xCC, 0x66, 0x63, 0x31, 0x98, 0x6C, 0x3C, 0x1E, 0x0F, 0x03,
  0x80, 0xCC, 0xD3, 0x34, 0xCD, 0x32, 0x6E, 0x9A, 0xA7, 0xA9, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0xCE, 0xC3, 0x33, 0x19, 0x87, 0x83, 0xC0, 0xC0, 0x70,
  0x78, 0x66, 0x33, 0x30, 0xD8, 0x70, 0xE1, 0xD8, 0x63, 0x30, 0xCC, 0x1A,
  0x07, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0x07, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x60, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0xFF,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x18, 0x3C, 0x34,
  0x66, 0x66, 0xC3, 0xFF, 0xFF, 0xE7, 0x08, 0x7E, 0x67, 0x83, 0x1F, 0x7F,
  0xC3, 0xC3, 0xE7, 0x7B, 0xC0, 0xC0, 0xC8, 0xDE, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE3, 0xFF, 0xDE, 0x08, 0x7E, 0x67, 0xC3, 0xC0, 0xC0, 0xC0, 0xC3,
  0x7F, 0x3E, 0x03, 0x03, 0x13, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x7F, 0x7B, 0x08, 0x7E, 0x67, 0xC3, 0xCF, 0xFF, 0xC0, 0xC0, 0x67, 0x3E,
  0x1F, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7B, 0x03, 0x03, 0x3F,
  0x3E, 0xC0, 0xC0, 0xC8, 0xDE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x1C, 0x1C, 0x00, 0x00, 0x7C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0xFF, 0xFF, 0x0E, 0x1C, 0x00, 0x07, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x61, 0xFF, 0x7C, 0xC0, 0x60, 0x30, 0x38, 0x6C, 0x66, 0x33, 0xF1,
  0xF8, 0xCC, 0x63, 0x31, 0xD8, 0x70, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0xE0, 0xF0, 0x12, 0xFF, 0xDB, 0xD9,
  0xD9, 0xD9, 0xD9, 0xD9, 0xD9, 0xD9, 0x08, 0xDE, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x08, 0x7E, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x7E, 0x3C, 0x08, 0xDE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0xDE,
  0xC0, 0xC0, 0xC0, 0x10, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F,
  0x7B, 0x03, 0x03, 0x03, 0x09, 0xFF, 0x1E, 0x3C, 0x78, 0x30, 0x60, 0xC1,
  0x80, 0x08, 0x7E, 0x63, 0xC0, 0x78, 0x3E, 0x03, 0x03, 0xE7, 0x7E, 0x30,
  0x30, 0x30, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0x1F, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7E, 0x3C, 0xC3, 0xC3, 0x63, 0x66,
  0x66, 0x36, 0x3C, 0x3C, 0x1C, 0xCC, 0xD3, 0x34, 0xC9, 0xB2, 0x6B, 0x9C,
  0xE7, 0x38, 0xCE, 0x33, 0x00, 0xE3, 0x33, 0x0F, 0x07, 0x81, 0x81, 0xE1,
  0xD8, 0xCE, 0xC3, 0x80, 0xC3, 0xE3, 0x66, 0x66, 0x36, 0x3C, 0x3C, 0x1C,
  0x18, 0x18, 0x38, 0x30, 0x7F, 0x07, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xFF,
  0xFF, 0x07, 0x0F, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0xF8, 0xF8, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x18,
  0x18, 0x30, 0x30, 0x38, 0x1F, 0x1F, 0x30, 0x30, 0x30, 0x18, 0x38, 0xF0,
  0xE0, 0x71, 0xF9, 0xDF, 0xCE,
};

const GFXglyph JetBrainsMono_SemiBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 4, -12 },
  { 6, 6, 5, 10, 2, -12 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 8, 17, 10, 1, -15 },
  { 42, 10, 13, 10, 0, -13 },
  { 59, 9, 13, 10, 1, -13 },
  { 74, 2, 5, 10, 4, -12 },
  { 76, 5, 16, 10, 3, -14 },
  { 86, 5, 16, 10, 2, -14 },
  { 96, 9, 8, 10, 1, -10 },
  { 105, 8, 8, 10, 1, -10 },
  { 113, 4, 6, 10, 3, -3 },
  { 116, 6, 2, 10, 2, -7 },
  { 118, 3, 3, 10, 4, -3 },
  { 120, 8, 16, 10, 1, -14 },
  { 136, 8, 13, 10, 1, -13 },
  { 149, 8, 12, 10, 1, -12 },
  { 161, 8, 13, 10, 1, -13 },
  { 174, 8, 12, 10, 1, -12 },
  { 186, 8, 12, 10, 1, -12 },
  { 198, 8, 12, 10, 1, -12 },
  { 210, 8, 12, 10, 1, -12 },
  { 222, 8, 12, 10, 1, -12 },
  { 234, 8, 13, 10, 1, -13 },
  { 247, 8, 13, 10, 1, -13 },
  { 260, 3, 10, 10, 4, -10 },
  { 264, 4, 13, 10, 3, -10 },
  { 271, 8, 9, 10, 1, -10 },
  { 280, 8, 6, 10, 1, -9 },
  { 286, 8, 9, 10, 1, -10 },
  { 295, 7, 12, 10, 2, -12 },
  { 306, 9, 16, 10, 1, -13 },
  { 324, 9, 12, 10, 1, -12 },
  { 338, 8, 12, 10, 1, -12 },
  { 350, 8, 13, 10, 1, -13 },
  { 363, 8, 12, 10, 1, -12 },
  { 375, 7, 12, 10, 2, -12 },
  { 386, 8, 12, 10, 1, -12 },
  { 398, 8, 13, 10, 1, -13 },
  { 411, 8, 12, 10, 1, -12 },
  { 423, 7, 12, 10, 2, -12 },
  { 434, 8, 12, 10, 1, -12 },
  { 446, 9, 12, 10, 1, -12 },
  { 460, 7, 12, 10, 2, -12 },
  { 471, 8, 12, 10, 1, -12 },
  { 483, 8, 12, 10, 1, -12 },
  { 495, 8, 13, 10, 1, -13 },
  { 508, 9, 12, 10, 1, -12 },
  { 522, 8, 16, 10, 1, -13 },
  { 538, 8, 12, 10, 1, -12 },
  { 550, 8, 13, 10, 1, -13 },
  { 563, 8, 12, 10, 1, -12 },
  { 575, 8, 12, 10, 1, -12 },
  { 587, 9, 12, 10, 1, -12 },
  { 601, 10, 12, 10, 0, -12 },
  { 616, 9, 12, 10, 1, -12 },
  { 630, 10, 12, 10, 0, -12 },
  { 645, 8, 12, 10, 1, -12 },
  { 657, 5, 16, 10, 3, -14 },
  { 667, 8, 16, 10, 1, -14 },
  { 683, 5, 16, 10, 2, -14 },
  { 693, 8, 6, 10, 1, -12 },
  { 699, 8, 2, 10, 1, 0 },
  { 701, 4, 2, 10, 3, -13 },
  { 702, 8, 10, 10, 1, -10 },
  { 712, 8, 12, 10, 1, -12 },
  { 724, 8, 10, 10, 1, -10 },
  { 734, 8, 12, 10, 1, -12 },
  { 746, 8, 10, 10, 1, -10 },
  { 756, 8, 12, 10, 1, -12 },
  { 768, 8, 13, 10, 1, -10 },
  { 781, 8, 12, 10, 1, -12 },
  { 793, 8, 13, 10, 1, -13 },
  { 806, 7, 16, 10, 1, -13 },
  { 820, 9, 12, 10, 1, -12 },
  { 834, 9, 12, 10, 0, -12 },
  { 848, 8, 10, 10, 1, -10 },
  { 858, 8, 10, 10, 1, -10 },
  { 868, 8, 10, 10, 1, -10 },
  { 878, 8, 13, 10, 1, -10 },
  { 891, 8, 13, 10, 1, -10 },
  { 904, 7, 10, 10, 2, -10 },
  { 913, 8, 10, 10, 1, -10 },
  { 923, 8, 12, 10, 1, -12 },
  { 935, 8, 9, 10, 1, -9 },
  { 944, 8, 9, 10, 1, -9 },
  { 953, 10, 9, 10, 0, -9 },
  { 965, 9, 9, 10, 1, -9 },
  { 976, 8, 12, 10, 1, -9 },
  { 988, 8, 9, 10, 1, -9 },
  { 997, 8, 16, 10, 1, -14 },
  { 1013, 2, 16, 10, 4, -14 },
  { 1017, 8, 16, 10, 1, -14 },
  { 1033, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_SemiBold17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_SEMIBOLD17PT7B_H_
