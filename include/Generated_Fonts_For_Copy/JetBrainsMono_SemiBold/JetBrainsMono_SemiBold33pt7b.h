#ifndef _JETBRAINSMONO_SEMIBOLD33PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x1C, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xDE, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x0F, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1C, 0x03, 0x87, 0x00,
  0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x06, 0x01, 0xC3, 0x87, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0x83, 0x80, 0xE0, 0xC0, 0x38, 0x70,
  0x0C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE1, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0C, 0x03, 0x87,
  0x00, 0xC1, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x7D, 0xBE, 0x79, 0x9E, 0x71,
  0x8E, 0x71, 0x80, 0x79, 0x80, 0x79, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xBE, 0x01, 0x9F, 0x01, 0x8F, 0x01,
  0x8F, 0xF1, 0x8F, 0xF1, 0x9F, 0x7D, 0xBE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F,
  0x00, 0xF7, 0xF8, 0x0E, 0x73, 0xC1, 0xCE, 0x1C, 0x38, 0xE1, 0xC3, 0x8E,
  0x1C, 0x70, 0xE1, 0xCE, 0x06, 0x1C, 0xC0, 0x7F, 0x9C, 0x03, 0xFB, 0x80,
  0x1E, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0xF8, 0x01, 0xDF,
  0xC0, 0x3B, 0xFE, 0x07, 0x38, 0xE0, 0x63, 0x86, 0x0E, 0x38, 0x61, 0xC3,
  0x86, 0x38, 0x38, 0xE3, 0x83, 0xDE, 0x70, 0x1F, 0xCE, 0x00, 0xF8, 0x0F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0x0F, 0x87, 0x83, 0xC3, 0xC0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xBC, 0x7B, 0x8F, 0x39, 0xC3, 0xFC, 0xE0, 0xFC, 0x70,
  0x7E, 0x38, 0x1E, 0x1C, 0x0F, 0x8F, 0x0F, 0xC7, 0xFF, 0xF1, 0xFF, 0xBC,
  0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x70, 0x7C, 0x3F,
  0x1F, 0x8F, 0x87, 0xC1, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0xC1, 0xF0, 0x3C, 0x01, 0x80,
  0x38, 0x0F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E,
  0x0F, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x41, 0xC0, 0x9E, 0x31, 0xEF, 0xCC, 0xFB, 0xFF, 0xFF, 0x1F, 0xFE, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x1D, 0xE0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE1,
  0xE0, 0xF0, 0x78, 0x0C, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x1F, 0x3E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xCF, 0x3F, 0x9E, 0x7F, 0x3C,
  0xFE, 0x71, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B,
  0xC0, 0xF7, 0xC3, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x07, 0xFE, 0x0F, 0xBC, 0x1C, 0x78, 0x30, 0xF0, 0x41, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC,
  0x7C, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x83, 0xEF, 0xFF, 0x8F,
  0xFE, 0x07, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x79,
  0xE0, 0xF7, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x79, 0xE0, 0xFF, 0xF1, 0xFF, 0xF3, 0xF3, 0xF7, 0x81,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x7B,
  0xC0, 0xF7, 0xC3, 0xEF, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3D, 0xF0, 0x7B, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x78,
  0x1E, 0x78, 0x3C, 0x3E, 0x7C, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x3E,
  0x7C, 0x78, 0x3E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xFB, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x3E,
  0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0xFF,
  0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xC3, 0xFC, 0x0F, 0x80, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFB, 0xF0, 0xF0, 0x1E, 0x78,
  0x03, 0x9C, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x79, 0xF8, 0x3F,
  0x7E, 0x1E, 0x7F, 0x87, 0x0F, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F,
  0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0xFE, 0x1C, 0x3F, 0x87, 0x9F, 0xE0,
  0xFD, 0xF8, 0x3E, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xDE, 0x00,
  0x73, 0x80, 0x3C, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78,
  0x70, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0x80, 0xF1, 0xE0, 0x1C, 0x78, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x7B, 0xC0, 0x1F, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE,
  0x03, 0xDC, 0x07, 0xB8, 0x07, 0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0xF3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFF, 0x9C, 0x0F, 0xB8, 0x0F, 0x70, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDC, 0x03,
  0xB8, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3F, 0x80,
  0x77, 0x81, 0xEF, 0x87, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0xB8, 0x7F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xE7, 0xC3, 0xEF, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x81, 0xEF, 0x87, 0xCF, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF0, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x37, 0xEC,
  0x77, 0xEE, 0x77, 0xEE, 0x77, 0xE6, 0x67, 0xE7, 0xEF, 0xE7, 0xEF, 0xE7,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFB, 0x87, 0xEE, 0x1F, 0xBC, 0x7E, 0x71, 0xF9, 0xC7, 0xE3, 0x9F,
  0x8E, 0x7E, 0x39, 0xF8, 0x77, 0xE1, 0xDF, 0x87, 0x7E, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0x1F, 0xE1, 0xFF, 0xC7, 0xFF,
  0xBE, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x07,
  0xF8, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x87, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xEF,
  0xFF, 0x9F, 0xFE, 0x3F, 0xE0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E,
  0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xE1,
  0xFF, 0xE3, 0xFF, 0xE7, 0x07, 0xEE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC,
  0x38, 0x78, 0x70, 0xF0, 0xE0, 0xF1, 0xC1, 0xE3, 0x81, 0xE7, 0x03, 0xCE,
  0x07, 0xDC, 0x07, 0xB8, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x7C,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x07,
  0xF8, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0E, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xE1, 0xE1, 0xF8, 0x78, 0x7E,
  0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE3, 0xFC, 0x78, 0xFF, 0x3E, 0x3B, 0xCD,
  0xCE, 0x73, 0x33, 0x9C, 0xCC, 0xE7, 0x33, 0x39, 0xCC, 0xCE, 0x73, 0x33,
  0x9C, 0xCC, 0xE7, 0x33, 0x39, 0xDC, 0xDC, 0x76, 0x3F, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0xF8, 0x07, 0x9F, 0x03, 0xE3, 0xC0, 0xF0, 0xF8, 0x78, 0x1E, 0x1E,
  0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x0F,
  0x1F, 0x03, 0xC7, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xDE, 0x01, 0xE7,
  0x80, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x78,
  0x70, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x7F, 0x00, 0xE7, 0x01, 0xCE, 0x07, 0x9E, 0x0E, 0x1C, 0x3C, 0x3C,
  0x70, 0x39, 0xE0, 0x73, 0x80, 0xFF, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xF1, 0xE1, 0xE0, 0x0F, 0xF0, 0x7F, 0xF8, 0xFF,
  0xF3, 0xC1, 0xF7, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xFF, 0x3F, 0xFE,
  0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFE, 0x7F, 0x3C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x7F, 0x3B, 0xFE, 0xEF, 0xFB, 0xE1, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xBF, 0xEE, 0xFF, 0xB9, 0xF8, 0x0F,
  0xF0, 0x7F, 0xF8, 0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x01, 0xEF,
  0x03, 0xDF, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xF7, 0x9F, 0xFF,
  0x7F, 0xFE, 0xF8, 0x7D, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC3,
  0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xEF, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3,
  0xC0, 0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x03, 0xDE, 0x07, 0x9F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x3F, 0xBD, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0xF7, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x7F, 0x3B, 0xFE,
  0xEF, 0xFB, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0xFF,
  0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0,
  0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xEF, 0x3E, 0xFF, 0xFE,
  0xF3, 0xCF, 0xE3, 0x8F, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE7, 0xF3, 0xBF, 0xEE,
  0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xF7,
  0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x77, 0x01, 0xEF, 0x03, 0xDF, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8,
  0x1F, 0xE0, 0xE7, 0xF3, 0xBF, 0xEE, 0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x87, 0xFB, 0xFE, 0xEF, 0xFB, 0x9F, 0xCE, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x3F, 0xBD, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF,
  0x7F, 0xFC, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xF3, 0xF9, 0xEF, 0xFB, 0xFF, 0xF7, 0xC1, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x1E,
  0x00, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3E, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFE,
  0x3F, 0xF0, 0x7F, 0x80, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xE7, 0x01,
  0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0x70, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x07,
  0x1E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xE1, 0xE1, 0xF8, 0x78, 0x7E,
  0x1E, 0x1F, 0xC7, 0x8E, 0x71, 0xE3, 0x9C, 0xF8, 0xE7, 0x36, 0x39, 0xCC,
  0xCE, 0x73, 0x33, 0x9C, 0xCC, 0xC7, 0x33, 0x70, 0xEC, 0xDC, 0x3E, 0x37,
  0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x87, 0x80,
  0x7C, 0x0F, 0x8F, 0x03, 0xC1, 0xE1, 0xE0, 0x78, 0xF8, 0x0F, 0x3C, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE1, 0xE0, 0xF0, 0x3C,
  0x7C, 0x0F, 0xBE, 0x01, 0xF0, 0xF8, 0x07, 0xBC, 0x03, 0xDF, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x0F, 0x3C,
  0x07, 0x9E, 0x01, 0xCF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC3, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x0F, 0xFC, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x7E, 0x07,
  0xFF, 0x07, 0xFF, 0x87, 0xE3, 0xCF, 0xE1, 0xFF, 0xE0, 0xFE, 0xE0, 0x7C,
};

const GFXglyph JetBrainsMono_SemiBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 11, 10, 20, 4, -24 },
  { 33, 18, 24, 20, 1, -24 },
  { 87, 16, 34, 20, 2, -29 },
  { 155, 20, 24, 20, 0, -24 },
  { 215, 17, 24, 20, 2, -24 },
  { 266, 4, 10, 20, 8, -24 },
  { 271, 10, 32, 20, 6, -28 },
  { 311, 10, 32, 20, 4, -28 },
  { 351, 18, 17, 20, 1, -20 },
  { 390, 16, 16, 20, 2, -19 },
  { 422, 8, 10, 20, 5, -5 },
  { 432, 10, 4, 20, 5, -13 },
  { 437, 6, 6, 20, 7, -6 },
  { 442, 16, 31, 20, 2, -27 },
  { 504, 15, 24, 20, 2, -24 },
  { 549, 15, 24, 20, 3, -24 },
  { 594, 16, 24, 20, 2, -24 },
  { 642, 15, 24, 20, 2, -24 },
  { 687, 15, 24, 20, 2, -24 },
  { 732, 15, 24, 20, 2, -24 },
  { 777, 16, 24, 20, 2, -24 },
  { 825, 16, 24, 20, 2, -24 },
  { 873, 16, 24, 20, 2, -24 },
  { 921, 16, 24, 20, 2, -24 },
  { 969, 6, 18, 20, 7, -18 },
  { 983, 8, 23, 20, 5, -18 },
  { 1006, 14, 18, 20, 3, -20 },
  { 1038, 14, 12, 20, 3, -17 },
  { 1059, 14, 18, 20, 3, -20 },
  { 1091, 13, 24, 20, 4, -24 },
  { 1130, 18, 30, 20, 1, -24 },
  { 1198, 18, 24, 20, 1, -24 },
  { 1252, 15, 24, 20, 3, -24 },
  { 1297, 15, 24, 20, 3, -24 },
  { 1342, 14, 24, 20, 3, -24 },
  { 1384, 14, 24, 20, 3, -24 },
  { 1426, 15, 24, 20, 3, -24 },
  { 1471, 15, 24, 20, 3, -24 },
  { 1516, 14, 24, 20, 3, -24 },
  { 1558, 14, 24, 20, 3, -24 },
  { 1600, 16, 24, 20, 1, -24 },
  { 1648, 16, 24, 20, 3, -24 },
  { 1696, 15, 24, 20, 3, -24 },
  { 1741, 16, 24, 20, 2, -24 },
  { 1789, 14, 24, 20, 3, -24 },
  { 1831, 14, 24, 20, 3, -24 },
  { 1873, 15, 24, 20, 3, -24 },
  { 1918, 16, 30, 20, 2, -24 },
  { 1978, 15, 24, 20, 3, -24 },
  { 2023, 16, 24, 20, 2, -24 },
  { 2071, 16, 24, 20, 2, -24 },
  { 2119, 14, 24, 20, 3, -24 },
  { 2161, 18, 24, 20, 1, -24 },
  { 2215, 18, 24, 20, 1, -24 },
  { 2269, 18, 24, 20, 1, -24 },
  { 2323, 18, 24, 20, 1, -24 },
  { 2377, 14, 24, 20, 3, -24 },
  { 2419, 9, 31, 20, 6, -27 },
  { 2454, 16, 31, 20, 2, -27 },
  { 2516, 9, 31, 20, 5, -27 },
  { 2551, 15, 13, 20, 2, -24 },
  { 2576, 16, 3, 20, 2, 1 },
  { 2582, 7, 5, 20, 6, -26 },
  { 2587, 15, 18, 20, 2, -18 },
  { 2621, 14, 24, 20, 3, -24 },
  { 2663, 15, 18, 20, 2, -18 },
  { 2697, 15, 24, 20, 2, -24 },
  { 2742, 15, 18, 20, 2, -18 },
  { 2776, 16, 24, 20, 2, -24 },
  { 2824, 14, 24, 20, 3, -18 },
  { 2866, 14, 24, 20, 3, -24 },
  { 2908, 15, 26, 20, 3, -26 },
  { 2957, 12, 32, 20, 3, -26 },
  { 3005, 16, 24, 20, 3, -24 },
  { 3053, 17, 24, 20, 1, -24 },
  { 3104, 16, 18, 20, 2, -18 },
  { 3140, 14, 18, 20, 3, -18 },
  { 3172, 15, 18, 20, 2, -18 },
  { 3206, 14, 24, 20, 3, -18 },
  { 3248, 14, 24, 20, 3, -18 },
  { 3290, 15, 18, 20, 3, -18 },
  { 3324, 16, 18, 20, 2, -18 },
  { 3360, 15, 23, 20, 2, -23 },
  { 3404, 14, 18, 20, 3, -18 },
  { 3436, 17, 18, 20, 1, -18 },
  { 3475, 18, 18, 20, 1, -18 },
  { 3516, 18, 18, 20, 1, -18 },
  { 3557, 17, 24, 20, 1, -18 },
  { 3608, 14, 18, 20, 3, -18 },
  { 3640, 14, 31, 20, 3, -27 },
  { 3695, 4, 31, 20, 8, -27 },
  { 3711, 14, 31, 20, 3, -27 },
  { 3766, 16, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_SemiBold33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_SEMIBOLD33PT7B_H_
