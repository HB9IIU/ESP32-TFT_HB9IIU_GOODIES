#ifndef _JETBRAINSMONO_SEMIBOLD23PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x00, 0xEF, 0xF0, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x0C, 0x60, 0x86, 0x18, 0x61, 0x8C, 0x18,
  0xCF, 0xFF, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x31, 0x8F, 0xFE, 0xFF,
  0xE6, 0x18, 0x61, 0x06, 0x30, 0x63, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x0F,
  0xC3, 0xFC, 0xFF, 0xDD, 0xBB, 0x37, 0x76, 0x0E, 0xC0, 0xF8, 0x0F, 0xE0,
  0x7E, 0x0D, 0xC1, 0xB8, 0x33, 0xE6, 0x6E, 0xDD, 0xFF, 0x0F, 0xC0, 0x60,
  0x0C, 0x01, 0x80, 0x38, 0x0D, 0xF0, 0x6C, 0x63, 0x31, 0x98, 0xC6, 0x63,
  0x1B, 0x07, 0xD8, 0x0E, 0x60, 0x03, 0x00, 0x19, 0x80, 0x6F, 0x83, 0x66,
  0x19, 0x88, 0xC6, 0x33, 0x19, 0x98, 0x7E, 0xC0, 0xF0, 0x1F, 0x03, 0xF8,
  0x71, 0xC7, 0x1C, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x7C, 0x0E, 0xE7,
  0xE7, 0xEE, 0x7E, 0xE3, 0xCE, 0x1C, 0xE3, 0xC7, 0xFE, 0x3E, 0x70, 0xFF,
  0xF6, 0xD8, 0x06, 0x3C, 0xF3, 0xC7, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xF0, 0xF0, 0xE0, 0x40, 0xC1, 0xC3,
  0xE1, 0xC1, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x1C, 0x79, 0xE7, 0x8E, 0x10, 0x00, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x62,
  0xF6, 0xFF, 0xFF, 0x06, 0x00, 0xF0, 0x1B, 0x83, 0x9C, 0x71, 0xC1, 0x08,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0x7B, 0x9D, 0xCE, 0x63, 0x00, 0xFF, 0xFF, 0xFF,
  0x6F, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x00, 0x3E, 0x1F, 0xEF,
  0x3F, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x33, 0xDC, 0xF3, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x7E, 0x3D, 0xFE, 0x3F, 0x00, 0x1E, 0x07, 0xC1, 0xF8, 0x77,
  0x0C, 0xE1, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xE0, 0x1F, 0x07, 0xF9, 0xE7, 0xB8,
  0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xCF, 0xF9, 0xFF, 0x00,
  0xE0, 0x30, 0x0C, 0x03, 0xC0, 0x7E, 0x0F, 0xC0, 0x1C, 0x03, 0x80, 0x7E,
  0x0E, 0xC1, 0xDC, 0x7B, 0xFE, 0x1F, 0x80, 0x03, 0x81, 0xC0, 0xE0, 0x38,
  0x1C, 0x0E, 0x03, 0x81, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0xF3, 0xFE, 0xF3, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xF0, 0x7E, 0x3D,
  0xFE, 0x3F, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E,
  0x03, 0xBE, 0x7F, 0xEE, 0x1F, 0x81, 0xF0, 0x3E, 0x06, 0xC1, 0xDC, 0x39,
  0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x00, 0x3F, 0x1F, 0xEF, 0x3F, 0x87, 0xC1, 0xF8, 0x7E, 0x39,
  0xFC, 0x3E, 0x1F, 0xEE, 0x1F, 0x07, 0xC0, 0xF0, 0x7E, 0x1D, 0xFE, 0x3F,
  0x00, 0x1F, 0x07, 0xF9, 0xE7, 0xB0, 0x7E, 0x07, 0xC0, 0xF8, 0x1B, 0x87,
  0x7F, 0xE7, 0xDC, 0x37, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C,
  0x00, 0x6F, 0xF6, 0x00, 0x00, 0x04, 0xFF, 0xF0, 0x33, 0xDE, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0xE7, 0x73, 0x98, 0xC0, 0x00, 0x40, 0x70, 0x7C, 0x7C,
  0x7C, 0x3C, 0x0C, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x03, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x38,
  0x0F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0C, 0x1F, 0x1F, 0x9F, 0x0F, 0x03,
  0x00, 0x80, 0x00, 0xF8, 0x7F, 0x3F, 0xC0, 0xE0, 0x30, 0x1C, 0x1C, 0x1E,
  0x3E, 0x1E, 0x0C, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x70, 0x00, 0x1F,
  0x83, 0xFE, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC7, 0xBC, 0x77, 0xCE,
  0x3C, 0xE3, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE7, 0xC7, 0xFC, 0x3B, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x81, 0x98, 0x19, 0x83, 0x98, 0x39, 0xC3, 0x1C, 0x30, 0xC7,
  0xFE, 0x7F, 0xE6, 0x0E, 0x60, 0x6E, 0x07, 0xE0, 0x70, 0xFE, 0x3F, 0xEC,
  0x7F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFE, 0xFF, 0x30, 0xFC, 0x1F, 0x03,
  0xC0, 0xF0, 0x7C, 0x3F, 0xFE, 0xFF, 0x00, 0x3F, 0x1F, 0xEF, 0x3F, 0x87,
  0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF8,
  0x7E, 0x3D, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0xEF, 0xFB, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x7F,
  0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x3F,
  0x1F, 0xEF, 0x3F, 0x87, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC7, 0xF1, 0xFC,
  0x7F, 0x03, 0xC0, 0xF8, 0x7E, 0x1D, 0xFE, 0x3F, 0x00, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7C, 0x0F, 0xC1,
  0xBC, 0x73, 0xFE, 0x3F, 0x00, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xCE, 0x39,
  0xCE, 0x39, 0xC7, 0xF0, 0xFE, 0x1F, 0xE3, 0x9C, 0x73, 0x8E, 0x39, 0xC7,
  0x38, 0x77, 0x0E, 0xE0, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xFF, 0xFF, 0xC0, 0xF0, 0xFE, 0x1F, 0xC7, 0xEC, 0xFF, 0x9F, 0xF2, 0xFB,
  0xDF, 0x7B, 0xEF, 0x7C, 0xCF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x60, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xF6, 0x3D, 0x8F,
  0x73, 0xCC, 0xF3, 0x3C, 0xEF, 0x1B, 0xC6, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xC0, 0x3F, 0x1F, 0xEF, 0x3F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x3D, 0xFE, 0x3F, 0x00, 0xFE,
  0x1F, 0xF3, 0xFF, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xFF, 0xDF,
  0xF3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x3E,
  0x1F, 0xEF, 0x3F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x3D, 0xFE, 0x3F, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0xFE, 0x1F, 0xF3, 0xFF, 0x70, 0xEE, 0x0D, 0xC1, 0xF8, 0x37,
  0x0E, 0xFF, 0x9F, 0xE3, 0x9C, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0x77, 0x0E,
  0xE0, 0xE0, 0x1F, 0x87, 0xF9, 0xE7, 0xB8, 0x76, 0x0E, 0xE0, 0x1C, 0x01,
  0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0x80, 0x30, 0x07, 0xC0, 0xDC, 0x3B, 0xFE,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x3D, 0xFE,
  0x3F, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x66, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xC3, 0x0C, 0x39, 0xC3, 0x9C, 0x19, 0x81, 0x98, 0x1F, 0x81, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE3, 0x1B, 0x18, 0xD9, 0xC6, 0xCE, 0x36, 0x79,
  0xB3, 0xCD, 0x96, 0xEC, 0xB7, 0x74, 0xB3, 0xA5, 0x9D, 0x2C, 0x79, 0x63,
  0xCB, 0x1E, 0x78, 0xF3, 0xC7, 0x1E, 0x38, 0xF0, 0xE0, 0x77, 0x0E, 0x70,
  0xE3, 0x9C, 0x39, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1F,
  0x81, 0xB8, 0x39, 0xC3, 0x1C, 0x70, 0xE6, 0x0E, 0xE0, 0x70, 0xE0, 0x7E,
  0x07, 0x60, 0xE7, 0x0E, 0x31, 0xC3, 0x9C, 0x19, 0x81, 0xF8, 0x1F, 0x00,
  0xF0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0xFF, 0xFF, 0xC0, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xC0, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xFF, 0xFF, 0xF0, 0x0C, 0x07, 0x81, 0xE0, 0xDC, 0x33,
  0x1C, 0xE6, 0x1B, 0x86, 0xC1, 0xC0, 0xFF, 0xFF, 0xFC, 0xE3, 0x8E, 0x0F,
  0x07, 0xF9, 0xE7, 0xB8, 0x70, 0x0E, 0x01, 0xCF, 0xFB, 0x87, 0xE0, 0xFC,
  0x1F, 0x83, 0xBF, 0xF3, 0xEE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x37,
  0xED, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3F,
  0x7E, 0xCF, 0x00, 0x1E, 0x1F, 0xEF, 0xFF, 0x87, 0xC0, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x7E, 0x1D, 0xFE, 0x3F, 0x00, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x3D, 0xDF, 0xFF, 0x7F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF8, 0x7E, 0x3D, 0xFF, 0x7D, 0xC0, 0x1E, 0x1F, 0xEF, 0x3B, 0x87, 0xC1,
  0xF0, 0x3F, 0xFF, 0x00, 0xC0, 0x30, 0x0E, 0x1D, 0xFE, 0x3F, 0x00, 0x03,
  0xE0, 0xFC, 0x3F, 0x86, 0x00, 0xC0, 0x18, 0x3F, 0xFF, 0xFF, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x3D,
  0xDF, 0xFF, 0x7F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0xF7,
  0xFD, 0xF7, 0x01, 0xC0, 0x70, 0x1C, 0xFE, 0x3F, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xEF, 0x3F, 0xED, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x0E, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x03, 0x03, 0xC1, 0xE0,
  0x00, 0x03, 0xF9, 0xFC, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0xC1, 0xEF, 0xE7, 0xE0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x0F, 0xC3, 0xB8, 0x77, 0x1C, 0xE7, 0x1F, 0xE3, 0xF8,
  0x7F, 0x8E, 0x71, 0xC7, 0x38, 0xE7, 0x0E, 0xE0, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xFF, 0x03, 0xF0, 0xFC,
  0xCF, 0xFE, 0xE6, 0x6E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6,
  0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x70, 0xCF, 0x37, 0xED, 0x3F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0,
  0x1E, 0x1F, 0xEF, 0xFB, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8,
  0x7E, 0x3D, 0xFE, 0x3F, 0x00, 0xCF, 0x37, 0xED, 0x3F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3F, 0x7E, 0xEF, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x3D, 0xDF, 0xFF, 0x7F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF8, 0x7E, 0x3D, 0xFF, 0x7D, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xEF, 0x1F, 0xFB, 0xEF, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x3F, 0x1F, 0xEF, 0x3F, 0x87,
  0xE0, 0x3F, 0x07, 0xF8, 0x3F, 0x01, 0xC0, 0x3E, 0x1F, 0xFF, 0x7F, 0x80,
  0x0C, 0x01, 0x80, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0xF8, 0x3F, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x3D,
  0xFE, 0x3F, 0x00, 0xE0, 0x7E, 0x06, 0x60, 0xE7, 0x0E, 0x70, 0xC3, 0x1C,
  0x39, 0xC3, 0x98, 0x19, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xC6,
  0x3C, 0x63, 0xCE, 0x3C, 0xE3, 0xCF, 0x7E, 0xB6, 0xEB, 0x66, 0x96, 0x69,
  0x67, 0x96, 0x79, 0xE7, 0x9C, 0x71, 0xC0, 0xE0, 0xF7, 0x0E, 0x39, 0xC3,
  0x98, 0x1F, 0x80, 0xF0, 0x0E, 0x00, 0xF0, 0x1F, 0x83, 0x9C, 0x39, 0xC7,
  0x0E, 0xE0, 0x70, 0xE0, 0x7E, 0x06, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x9C,
  0x39, 0xC1, 0xD8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xC1,
  0xF0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x0E, 0x3F, 0x8F, 0xC3,
  0xF0, 0x0E, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0x07,
  0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3E, 0x03, 0x80,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xF0, 0xFC, 0x7F, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0x83, 0xE0, 0xF0, 0x30, 0x00,
  0x38, 0x07, 0xC7, 0xEE, 0x7E, 0x7E, 0xE3, 0xE0, 0x08,
};

const GFXglyph JetBrainsMono_SemiBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 8, 7, 14, 3, -17 },
  { 17, 12, 17, 14, 1, -17 },
  { 43, 11, 23, 14, 1, -20 },
  { 75, 14, 17, 14, 0, -17 },
  { 105, 12, 17, 14, 1, -17 },
  { 131, 3, 7, 14, 5, -17 },
  { 134, 7, 22, 14, 4, -19 },
  { 154, 7, 22, 14, 3, -19 },
  { 174, 12, 12, 14, 1, -14 },
  { 192, 11, 11, 14, 1, -13 },
  { 208, 5, 7, 14, 4, -3 },
  { 213, 8, 3, 14, 3, -9 },
  { 216, 4, 4, 14, 5, -4 },
  { 218, 11, 22, 14, 1, -19 },
  { 249, 10, 17, 14, 2, -17 },
  { 271, 11, 17, 14, 2, -17 },
  { 295, 11, 17, 14, 1, -17 },
  { 319, 11, 17, 14, 1, -17 },
  { 343, 10, 17, 14, 2, -17 },
  { 365, 10, 17, 14, 2, -17 },
  { 387, 11, 17, 14, 1, -17 },
  { 411, 11, 17, 14, 1, -17 },
  { 435, 10, 17, 14, 2, -17 },
  { 457, 11, 17, 14, 1, -17 },
  { 481, 4, 13, 14, 5, -13 },
  { 488, 5, 17, 14, 4, -13 },
  { 499, 10, 13, 14, 2, -14 },
  { 516, 10, 8, 14, 2, -12 },
  { 526, 10, 13, 14, 2, -14 },
  { 543, 9, 17, 14, 3, -17 },
  { 563, 12, 21, 14, 1, -17 },
  { 595, 12, 17, 14, 1, -17 },
  { 621, 10, 17, 14, 2, -17 },
  { 643, 10, 17, 14, 2, -17 },
  { 665, 10, 17, 14, 2, -17 },
  { 687, 10, 17, 14, 2, -17 },
  { 709, 10, 17, 14, 2, -17 },
  { 731, 10, 17, 14, 2, -17 },
  { 753, 10, 17, 14, 2, -17 },
  { 775, 10, 17, 14, 2, -17 },
  { 797, 11, 17, 14, 1, -17 },
  { 821, 11, 17, 14, 2, -17 },
  { 845, 10, 17, 14, 2, -17 },
  { 867, 11, 17, 14, 1, -17 },
  { 891, 10, 17, 14, 2, -17 },
  { 913, 10, 17, 14, 2, -17 },
  { 935, 11, 17, 14, 2, -17 },
  { 959, 10, 21, 14, 2, -17 },
  { 986, 11, 17, 14, 2, -17 },
  { 1010, 11, 17, 14, 1, -17 },
  { 1034, 12, 17, 14, 1, -17 },
  { 1060, 10, 17, 14, 2, -17 },
  { 1082, 12, 17, 14, 1, -17 },
  { 1108, 13, 17, 14, 0, -17 },
  { 1136, 12, 17, 14, 1, -17 },
  { 1162, 12, 17, 14, 1, -17 },
  { 1188, 10, 17, 14, 2, -17 },
  { 1210, 7, 22, 14, 4, -19 },
  { 1230, 11, 22, 14, 1, -19 },
  { 1261, 6, 22, 14, 3, -19 },
  { 1278, 10, 9, 14, 2, -17 },
  { 1290, 11, 2, 14, 1, 1 },
  { 1293, 5, 3, 14, 4, -18 },
  { 1295, 11, 13, 14, 1, -13 },
  { 1313, 10, 17, 14, 2, -17 },
  { 1335, 10, 13, 14, 2, -13 },
  { 1352, 10, 17, 14, 2, -17 },
  { 1374, 10, 13, 14, 2, -13 },
  { 1391, 11, 17, 14, 1, -17 },
  { 1415, 10, 17, 14, 2, -13 },
  { 1437, 10, 17, 14, 2, -17 },
  { 1459, 11, 18, 14, 2, -18 },
  { 1484, 9, 22, 14, 2, -18 },
  { 1509, 11, 17, 14, 2, -17 },
  { 1533, 12, 17, 14, 1, -17 },
  { 1559, 12, 13, 14, 1, -13 },
  { 1579, 10, 13, 14, 2, -13 },
  { 1596, 10, 13, 14, 2, -13 },
  { 1613, 10, 17, 14, 2, -13 },
  { 1635, 10, 17, 14, 2, -13 },
  { 1657, 11, 13, 14, 2, -13 },
  { 1675, 10, 13, 14, 2, -13 },
  { 1692, 11, 16, 14, 1, -16 },
  { 1714, 10, 13, 14, 2, -13 },
  { 1731, 12, 13, 14, 1, -13 },
  { 1751, 12, 13, 14, 1, -13 },
  { 1771, 12, 13, 14, 1, -13 },
  { 1791, 12, 17, 14, 1, -13 },
  { 1817, 10, 13, 14, 2, -13 },
  { 1834, 10, 22, 14, 2, -19 },
  { 1862, 2, 22, 14, 6, -19 },
  { 1868, 10, 22, 14, 2, -19 },
  { 1896, 12, 6, 14, 1, -11 },
};

const GFXfont JetBrainsMono_SemiBold23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_SEMIBOLD23PT7B_H_
