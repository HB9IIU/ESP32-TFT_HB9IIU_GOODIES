#ifndef _JETBRAINSMONO_SEMIBOLD15PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x1F, 0x80, 0xDE, 0xF7, 0xBD, 0x80, 0x13, 0x09,
  0x84, 0x8F, 0xF3, 0x21, 0x10, 0x99, 0xFE, 0x24, 0x32, 0x19, 0x00, 0x10,
  0x21, 0xF7, 0xFD, 0x7A, 0x1C, 0x3E, 0x1E, 0x2F, 0x5F, 0xF7, 0xC2, 0x04,
  0x00, 0x71, 0xE8, 0xA6, 0x9A, 0xC7, 0x40, 0x40, 0x5C, 0x6B, 0x2C, 0xA2,
  0xF1, 0xC0, 0x78, 0x6C, 0xC4, 0x40, 0x60, 0xF1, 0x96, 0x9C, 0x8C, 0xDE,
  0x77, 0xF8, 0x13, 0x6C, 0xC8, 0x88, 0x88, 0xCC, 0x63, 0x10, 0x8C, 0x63,
  0x31, 0x11, 0x11, 0x33, 0x6C, 0x80, 0x08, 0x04, 0x1A, 0xDF, 0xF1, 0xC1,
  0xB0, 0xD8, 0x44, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08, 0x76, 0x6C,
  0xFF, 0xC0, 0x5F, 0x80, 0x06, 0x18, 0x30, 0x61, 0x83, 0x04, 0x18, 0x30,
  0x41, 0x83, 0x0C, 0x18, 0x00, 0x7D, 0xDF, 0x1E, 0x3C, 0x7A, 0xF1, 0xE3,
  0xC7, 0xDD, 0xF0, 0x38, 0xF3, 0x64, 0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFF,
  0xF8, 0x7D, 0xDB, 0x18, 0x30, 0x61, 0x86, 0x18, 0x61, 0xFF, 0xF8, 0xFD,
  0xF8, 0x30, 0x83, 0x87, 0x81, 0x83, 0xC7, 0xDD, 0xF0, 0x0C, 0x30, 0x61,
  0x86, 0x0C, 0xF1, 0xFF, 0xFE, 0x0C, 0x18, 0xFF, 0xFF, 0x06, 0x0F, 0xDC,
  0xC1, 0x83, 0xC7, 0xDD, 0xF0, 0x18, 0x20, 0xC3, 0x07, 0x9F, 0xF1, 0xE3,
  0xC7, 0xDD, 0xF0, 0xFF, 0xFF, 0x18, 0x20, 0xC1, 0x86, 0x0C, 0x30, 0x61,
  0xC0, 0x7D, 0xDF, 0x1E, 0x36, 0xC7, 0x1B, 0x63, 0xC7, 0xDD, 0xF0, 0x7D,
  0xDF, 0x1E, 0x3C, 0x7F, 0xDF, 0x06, 0x18, 0x20, 0xC0, 0xFC, 0x00, 0x3F,
  0x77, 0x00, 0x00, 0x76, 0x6C, 0x02, 0x1C, 0xE7, 0x0E, 0x0F, 0x07, 0x81,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC0, 0xE0, 0x70, 0xE7, 0xBC,
  0x40, 0xF3, 0xE0, 0x83, 0x19, 0xE6, 0x18, 0x01, 0x86, 0x00, 0x7C, 0xC6,
  0x82, 0x83, 0x9F, 0x93, 0xB3, 0xB3, 0x93, 0x9F, 0x80, 0xC0, 0x78, 0x38,
  0x38, 0x70, 0xA3, 0x66, 0xCD, 0x91, 0x7F, 0xC7, 0x8E, 0x08, 0xFD, 0xFF,
  0x1E, 0x3C, 0xDF, 0xB1, 0xE3, 0xC7, 0x9F, 0xF0, 0x7C, 0xDF, 0x1E, 0x0C,
  0x18, 0x30, 0x60, 0xC7, 0xDD, 0xF0, 0xF9, 0xFB, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0xFB, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1,
  0xFF, 0xF8, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x00,
  0x7C, 0xDF, 0x1E, 0x0C, 0x1B, 0xF7, 0xE3, 0xC7, 0xDD, 0xF0, 0xC7, 0x8F,
  0x1E, 0x3C, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xFF, 0xFC, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x11, 0xFF, 0xF8, 0x3E, 0x7C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x87, 0x99, 0xE0, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xF8, 0xD8, 0xCC,
  0xCC, 0xC6, 0xC7, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xFF, 0xC0,
  0xC7, 0x8E, 0xAD, 0x5A, 0xBF, 0x71, 0xE3, 0xC7, 0x8F, 0x18, 0xC7, 0xCF,
  0x9F, 0xBF, 0x7A, 0xF7, 0xEF, 0xCF, 0x9F, 0x18, 0x7D, 0xDF, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0xDD, 0xF0, 0xFD, 0xFF, 0x1E, 0x1C, 0x7F, 0xFE,
  0x60, 0xC1, 0x83, 0x00, 0x7D, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xDD, 0xF0, 0x60, 0xC0, 0xC0, 0xFD, 0xFF, 0x1E, 0x3C, 0x7F, 0xBE, 0x66,
  0xCD, 0x8F, 0x18, 0x7D, 0xDF, 0x1E, 0x06, 0x0F, 0x83, 0x83, 0xC7, 0xDD,
  0xF0, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xDD, 0xF0, 0x83, 0x8F, 0x1E,
  0x34, 0x4D, 0x9B, 0x36, 0x28, 0x70, 0xE0, 0xC9, 0xE4, 0xD5, 0x4A, 0xA5,
  0x52, 0xA9, 0x54, 0xAA, 0x77, 0x3B, 0x99, 0xC0, 0x63, 0x31, 0x8D, 0x82,
  0x81, 0xC0, 0xE0, 0x70, 0x6C, 0x36, 0x31, 0xB8, 0xE0, 0xC1, 0xB1, 0x88,
  0x86, 0xC3, 0x60, 0xE0, 0x70, 0x10, 0x08, 0x04, 0x02, 0x00, 0xFF, 0xFC,
  0x30, 0x61, 0x86, 0x0C, 0x30, 0x61, 0xFF, 0xF8, 0xFC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xFF, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10,
  0x30, 0x60, 0x60, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x38,
  0x50, 0xA3, 0x64, 0x58, 0xC0, 0xFF, 0xFC, 0xCC, 0x7D, 0x8C, 0x1B, 0xFC,
  0x78, 0xF3, 0xBF, 0xC1, 0x83, 0x07, 0xEC, 0x78, 0xF1, 0xE3, 0xC7, 0xDF,
  0xF0, 0x7D, 0x8F, 0x1E, 0x0C, 0x18, 0xFB, 0xBE, 0x06, 0x0C, 0x1B, 0xFC,
  0x78, 0xF1, 0xE3, 0xC7, 0xDD, 0xF8, 0x7D, 0x8F, 0x1F, 0xFC, 0x18, 0x31,
  0xBE, 0x1E, 0x7C, 0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x7F,
  0x8F, 0x1E, 0x3C, 0x78, 0xDF, 0x93, 0x06, 0xF9, 0xE0, 0xC1, 0x83, 0x07,
  0xEC, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x18, 0x30, 0x00, 0x07, 0x83,
  0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x0C, 0x30, 0x00, 0x7C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0xEF, 0x00, 0xC1, 0x83, 0x06, 0x3C, 0xD9, 0xBE,
  0x7C, 0xCD, 0x8F, 0x18, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x1F, 0x0F, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xFD, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x7D, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xBE,
  0xFD, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xFE, 0xC1, 0x83, 0x00, 0x7F, 0x8F,
  0x1E, 0x3C, 0x78, 0xFB, 0xBF, 0x06, 0x0C, 0x18, 0xFF, 0xCF, 0x1E, 0x0C,
  0x18, 0x30, 0x60, 0x7D, 0x8F, 0x03, 0xE1, 0xE0, 0xF1, 0xBE, 0x30, 0x60,
  0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x7C, 0x78, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xDB, 0x3E, 0xC7, 0x8D, 0x13, 0x66, 0xC5, 0x0E, 0x1C, 0xC9, 0xAA,
  0x95, 0x4A, 0xA5, 0x53, 0xB9, 0xDC, 0x6C, 0xC6, 0xD8, 0xA1, 0xC3, 0x8D,
  0x9B, 0x63, 0xC7, 0x8D, 0x93, 0x62, 0xC7, 0x0E, 0x0C, 0x30, 0x60, 0x80,
  0xFE, 0x1C, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x0E, 0x30, 0x60, 0xC1, 0x83,
  0x3C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xE0, 0xC0, 0xFF, 0xFC, 0xE0, 0x60,
  0xC1, 0x83, 0x06, 0x07, 0x98, 0x30, 0x60, 0xC1, 0x8F, 0x18, 0x00, 0xE3,
  0xE6, 0x78,
};

const GFXglyph JetBrainsMono_SemiBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 2, -11 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 7, 15, 9, 1, -13 },
  { 37, 9, 11, 9, 0, -11 },
  { 50, 8, 11, 9, 1, -11 },
  { 61, 1, 5, 9, 4, -11 },
  { 62, 4, 15, 9, 3, -13 },
  { 70, 4, 15, 9, 2, -13 },
  { 78, 9, 8, 9, 0, -9 },
  { 87, 7, 8, 9, 1, -9 },
  { 94, 4, 4, 9, 2, -2 },
  { 96, 5, 2, 9, 2, -6 },
  { 98, 3, 3, 9, 3, -3 },
  { 100, 7, 14, 9, 1, -12 },
  { 113, 7, 11, 9, 1, -11 },
  { 123, 7, 11, 9, 1, -11 },
  { 133, 7, 11, 9, 1, -11 },
  { 143, 7, 11, 9, 1, -11 },
  { 153, 7, 11, 9, 1, -11 },
  { 163, 7, 11, 9, 1, -11 },
  { 173, 7, 11, 9, 1, -11 },
  { 183, 7, 11, 9, 1, -11 },
  { 193, 7, 11, 9, 1, -11 },
  { 203, 7, 11, 9, 1, -11 },
  { 213, 3, 8, 9, 3, -8 },
  { 216, 4, 10, 9, 2, -8 },
  { 221, 7, 8, 9, 1, -9 },
  { 228, 7, 6, 9, 1, -8 },
  { 234, 7, 8, 9, 1, -9 },
  { 241, 6, 11, 9, 2, -11 },
  { 250, 8, 14, 9, 1, -11 },
  { 264, 7, 11, 9, 1, -11 },
  { 274, 7, 11, 9, 1, -11 },
  { 284, 7, 11, 9, 1, -11 },
  { 294, 7, 11, 9, 1, -11 },
  { 304, 7, 11, 9, 1, -11 },
  { 314, 7, 11, 9, 1, -11 },
  { 324, 7, 11, 9, 1, -11 },
  { 334, 7, 11, 9, 1, -11 },
  { 344, 7, 11, 9, 1, -11 },
  { 354, 7, 11, 9, 1, -11 },
  { 364, 8, 11, 9, 1, -11 },
  { 375, 6, 11, 9, 2, -11 },
  { 384, 7, 11, 9, 1, -11 },
  { 394, 7, 11, 9, 1, -11 },
  { 404, 7, 11, 9, 1, -11 },
  { 414, 7, 11, 9, 1, -11 },
  { 424, 7, 14, 9, 1, -11 },
  { 437, 7, 11, 9, 1, -11 },
  { 447, 7, 11, 9, 1, -11 },
  { 457, 7, 11, 9, 1, -11 },
  { 467, 7, 11, 9, 1, -11 },
  { 477, 7, 11, 9, 1, -11 },
  { 487, 9, 11, 9, 0, -11 },
  { 500, 9, 11, 9, 0, -11 },
  { 513, 9, 11, 9, 0, -11 },
  { 526, 7, 11, 9, 1, -11 },
  { 536, 4, 14, 9, 3, -12 },
  { 543, 7, 14, 9, 1, -12 },
  { 556, 4, 14, 9, 2, -12 },
  { 563, 7, 6, 9, 1, -11 },
  { 569, 7, 2, 9, 1, 0 },
  { 571, 3, 2, 9, 3, -12 },
  { 572, 7, 8, 9, 1, -8 },
  { 579, 7, 11, 9, 1, -11 },
  { 589, 7, 8, 9, 1, -8 },
  { 596, 7, 11, 9, 1, -11 },
  { 606, 7, 8, 9, 1, -8 },
  { 613, 7, 11, 9, 1, -11 },
  { 623, 7, 11, 9, 1, -8 },
  { 633, 7, 11, 9, 1, -11 },
  { 643, 7, 12, 9, 1, -12 },
  { 654, 6, 15, 9, 1, -12 },
  { 666, 7, 11, 9, 1, -11 },
  { 676, 8, 11, 9, 0, -11 },
  { 687, 7, 8, 9, 1, -8 },
  { 694, 7, 8, 9, 1, -8 },
  { 701, 7, 8, 9, 1, -8 },
  { 708, 7, 11, 9, 1, -8 },
  { 718, 7, 11, 9, 1, -8 },
  { 728, 7, 8, 9, 1, -8 },
  { 735, 7, 8, 9, 1, -8 },
  { 742, 7, 11, 9, 1, -11 },
  { 752, 7, 8, 9, 1, -8 },
  { 759, 7, 8, 9, 1, -8 },
  { 766, 9, 8, 9, 0, -8 },
  { 775, 7, 8, 9, 1, -8 },
  { 782, 7, 11, 9, 1, -8 },
  { 792, 7, 8, 9, 1, -8 },
  { 799, 7, 14, 9, 1, -12 },
  { 812, 1, 14, 9, 4, -12 },
  { 814, 7, 14, 9, 1, -12 },
  { 827, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_SemiBold15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_SEMIBOLD15PT7B_H_
