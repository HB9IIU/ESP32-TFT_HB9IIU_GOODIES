#ifndef _JETBRAINSMONO_SEMIBOLD8PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x57, 0xD4, 0xAF, 0x30, 0x27, 0x76, 0x3B, 0x72,
  0xCD, 0xB8, 0x66, 0xCC, 0x62, 0x91, 0x79, 0x3C, 0xE0, 0x2A, 0x49, 0x11,
  0x95, 0x56, 0x27, 0xC8, 0xA0, 0x22, 0xF2, 0x60, 0xE0, 0x80, 0x25, 0x25,
  0x24, 0xF6, 0xFB, 0xC0, 0x59, 0x25, 0xC0, 0x7D, 0x12, 0x47, 0x72, 0x21,
  0x97, 0x2A, 0x5E, 0x40, 0xF3, 0x93, 0xC0, 0x22, 0x65, 0x97, 0xF4, 0xA5,
  0x80, 0xF6, 0xFB, 0xC0, 0x79, 0x57, 0x26, 0x90, 0x41, 0x80, 0x3A, 0x32,
  0xE3, 0x80, 0x88, 0xE8, 0xC4, 0xA1, 0x80, 0x74, 0x6F, 0x5A, 0xD9, 0x80,
  0x26, 0x55, 0x79, 0xF7, 0xDB, 0xC0, 0xF6, 0x4B, 0xC0, 0xF6, 0xDB, 0xC0,
  0xF3, 0xC9, 0xC0, 0xF2, 0x79, 0x00, 0xF6, 0x7B, 0xC0, 0xB7, 0xDB, 0x40,
  0xE9, 0x25, 0xC0, 0x31, 0x11, 0x97, 0xAA, 0xCC, 0xAB, 0x92, 0x49, 0xC0,
  0xDD, 0xB9, 0x99, 0xB7, 0xFB, 0x40, 0xF6, 0xDB, 0xC0, 0xF6, 0xF9, 0x00,
  0xF6, 0xDB, 0xC8, 0xF6, 0xEB, 0x40, 0x75, 0x43, 0x97, 0xF2, 0x22, 0x22,
  0xB6, 0xDB, 0xC0, 0x95, 0x55, 0x62, 0xAD, 0x7B, 0xE5, 0x28, 0xD2, 0x88,
  0x45, 0x6C, 0x9A, 0x94, 0x42, 0x10, 0xE5, 0x29, 0xC0, 0xEA, 0xAB, 0xC4,
  0x42, 0x22, 0x11, 0xD5, 0x57, 0x56, 0x80, 0xF0, 0xC0, 0x77, 0x97, 0x9A,
  0xDB, 0xC0, 0xF2, 0xF0, 0x2E, 0xDB, 0xC0, 0xFE, 0x70, 0x32, 0xF2, 0x22,
  0xF6, 0xFE, 0x9A, 0xDB, 0x40, 0x43, 0x25, 0xC0, 0x63, 0x92, 0x70, 0x89,
  0xAC, 0xAB, 0xE2, 0x22, 0x23, 0xFB, 0xBB, 0xF6, 0xD0, 0xF6, 0xF0, 0xF6,
  0xF8, 0xF6, 0xF2, 0xF2, 0x40, 0xF8, 0xF0, 0x22, 0xF2, 0x23, 0xB6, 0xF0,
  0xD5, 0x52, 0xAF, 0xB4, 0xA0, 0xD2, 0x6D, 0xD5, 0x62, 0x60, 0xEA, 0x70,
  0x29, 0x2C, 0x91, 0xFF, 0x89, 0x26, 0x94, 0x5B,
};

const GFXglyph JetBrainsMono_SemiBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 0, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 3, 5, 2, -6 },
  { 21, 3, 8, 5, 1, -7 },
  { 24, 2, 8, 5, 1, -7 },
  { 26, 5, 4, 5, 0, -5 },
  { 29, 4, 4, 5, 0, -5 },
  { 31, 2, 2, 5, 1, -1 },
  { 32, 3, 1, 5, 1, -3 },
  { 33, 1, 1, 5, 2, -1 },
  { 34, 3, 8, 5, 1, -7 },
  { 37, 3, 6, 5, 1, -6 },
  { 40, 3, 6, 5, 1, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 3, 6, 5, 1, -6 },
  { 52, 3, 6, 5, 1, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 3, 6, 5, 1, -6 },
  { 61, 3, 6, 5, 1, -6 },
  { 64, 4, 6, 5, 0, -6 },
  { 67, 1, 4, 5, 2, -4 },
  { 68, 2, 5, 5, 1, -4 },
  { 70, 3, 5, 5, 1, -5 },
  { 72, 3, 3, 5, 1, -4 },
  { 74, 3, 5, 5, 1, -5 },
  { 76, 3, 6, 5, 1, -6 },
  { 79, 5, 7, 5, 0, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 3, 6, 5, 1, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 3, 6, 5, 1, -6 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 3, 6, 5, 1, -6 },
  { 108, 3, 6, 5, 1, -6 },
  { 111, 4, 6, 5, 0, -6 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 0, -6 },
  { 123, 3, 6, 5, 1, -6 },
  { 126, 3, 6, 5, 1, -6 },
  { 129, 3, 6, 5, 1, -6 },
  { 132, 3, 7, 5, 1, -6 },
  { 135, 3, 6, 5, 1, -6 },
  { 138, 4, 6, 5, 0, -6 },
  { 141, 4, 6, 5, 0, -6 },
  { 144, 3, 6, 5, 1, -6 },
  { 147, 4, 6, 5, 0, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 3, 6, 5, 1, -6 },
  { 165, 2, 8, 5, 2, -7 },
  { 167, 4, 8, 5, 0, -7 },
  { 171, 2, 8, 5, 1, -7 },
  { 173, 3, 3, 5, 1, -6 },
  { 175, 4, 1, 5, 0, 0 },
  { 176, 2, 1, 5, 1, -6 },
  { 177, 4, 4, 5, 0, -4 },
  { 179, 3, 6, 5, 1, -6 },
  { 182, 3, 4, 5, 1, -4 },
  { 184, 3, 6, 5, 1, -6 },
  { 187, 3, 4, 5, 1, -4 },
  { 189, 4, 6, 5, 0, -6 },
  { 192, 3, 5, 5, 1, -4 },
  { 194, 3, 6, 5, 1, -6 },
  { 197, 3, 6, 5, 1, -6 },
  { 200, 3, 7, 5, 1, -6 },
  { 203, 4, 6, 5, 1, -6 },
  { 206, 4, 6, 5, 0, -6 },
  { 209, 4, 4, 5, 0, -4 },
  { 211, 3, 4, 5, 1, -4 },
  { 213, 3, 4, 5, 1, -4 },
  { 215, 3, 5, 5, 1, -4 },
  { 217, 3, 5, 5, 1, -4 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 3, 4, 5, 1, -4 },
  { 223, 4, 6, 5, 0, -6 },
  { 226, 3, 4, 5, 1, -4 },
  { 228, 4, 4, 5, 0, -4 },
  { 230, 5, 4, 5, 0, -4 },
  { 233, 4, 4, 5, 0, -4 },
  { 235, 4, 5, 5, 0, -4 },
  { 238, 3, 4, 5, 1, -4 },
  { 240, 3, 8, 5, 1, -7 },
  { 243, 1, 8, 5, 2, -7 },
  { 244, 3, 8, 5, 1, -7 },
  { 247, 4, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_SemiBold8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_SEMIBOLD8PT7B_H_
