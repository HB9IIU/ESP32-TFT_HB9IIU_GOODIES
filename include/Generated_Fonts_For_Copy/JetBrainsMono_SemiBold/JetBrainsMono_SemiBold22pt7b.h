#ifndef _JETBRAINSMONO_SEMIBOLD22PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x6D, 0x81, 0xFF, 0xE7, 0xCF, 0x9E, 0x3C, 0x78,
  0xF1, 0x80, 0x18, 0x61, 0x8C, 0x18, 0xC1, 0x8C, 0xFF, 0xFF, 0xFF, 0x31,
  0x83, 0x18, 0x31, 0x83, 0x18, 0xFF, 0xEF, 0xFE, 0x63, 0x06, 0x30, 0x63,
  0x06, 0x30, 0x04, 0x00, 0x80, 0x10, 0x0F, 0xC3, 0xFC, 0xEB, 0x99, 0x3B,
  0x20, 0x74, 0x0F, 0x80, 0xFE, 0x0F, 0xE0, 0x5C, 0x09, 0xC1, 0x3F, 0x27,
  0x75, 0xEF, 0xF8, 0xFE, 0x02, 0x00, 0x40, 0x08, 0x00, 0x7C, 0x1B, 0x61,
  0xB1, 0x99, 0x8C, 0xCC, 0x6C, 0x36, 0xC1, 0xF6, 0x00, 0x60, 0x06, 0x00,
  0x27, 0x83, 0x6E, 0x32, 0x33, 0x11, 0x98, 0x8D, 0x87, 0xF8, 0x1E, 0x1F,
  0x03, 0xF8, 0x71, 0x86, 0x1C, 0x70, 0x03, 0x00, 0x38, 0x07, 0xC0, 0xEC,
  0x6E, 0xEE, 0xC7, 0xCC, 0x3C, 0xC3, 0x8E, 0x3C, 0x7F, 0xE3, 0xE7, 0xFF,
  0xFF, 0xF8, 0x0E, 0x3C, 0xE3, 0x8E, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x38, 0x70, 0x70, 0x70, 0xF8, 0x70, 0x20, 0xC3, 0x87, 0x0E,
  0x1C, 0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC7, 0x39, 0xEF, 0x30,
  0x80, 0x0E, 0x00, 0xE0, 0x86, 0x2E, 0x4E, 0xFD, 0xF3, 0xF8, 0x0A, 0x01,
  0xB0, 0x3B, 0x87, 0x1C, 0x30, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F,
  0xFF, 0xFF, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xDC, 0xE6, 0x33,
  0x80, 0xFF, 0xFC, 0xEF, 0xFE, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x3F, 0x3F, 0xEE,
  0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x9F, 0x77, 0xDD, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF8, 0xE7, 0xF8, 0xF8, 0x1E, 0x1F, 0x8F, 0xE3, 0x38, 0x8E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF,
  0xFF, 0x1F, 0x8F, 0xF9, 0xC7, 0x70, 0x6E, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0xFB, 0xFF, 0x7F,
  0xCF, 0xF8, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x03, 0xE0, 0x7E, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x7E, 0x0C, 0xE3, 0x9F, 0xF1, 0xF8, 0x07, 0x83, 0x83,
  0x83, 0x81, 0x81, 0xC1, 0xC0, 0xC3, 0xE1, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0C, 0x06, 0x03, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x31, 0x0D, 0xF3,
  0xFE, 0xE1, 0x80, 0x70, 0x1C, 0x07, 0xC1, 0xF8, 0xEF, 0xF8, 0xFC, 0x07,
  0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0D, 0xE3, 0xFE, 0x71, 0xDC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE3, 0x8F, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF,
  0x83, 0xF0, 0x6E, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1F, 0x8F, 0xF9, 0xC7, 0x30,
  0x66, 0x0C, 0xE3, 0x8E, 0xE0, 0xF8, 0x3F, 0x8E, 0x39, 0x83, 0x70, 0x76,
  0x0E, 0xE3, 0x9F, 0xF0, 0xFC, 0x1F, 0x8F, 0xF9, 0xC7, 0x70, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3B, 0x8F, 0x7F, 0xC3, 0xB8, 0x0E, 0x01, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0xEF, 0xE0, 0x00, 0x00, 0x0E, 0xFE, 0x38, 0xF3, 0x80,
  0x00, 0x00, 0x00, 0x04, 0xE3, 0x8C, 0x71, 0xC6, 0x38, 0x00, 0x81, 0xC3,
  0xE7, 0xCF, 0x86, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x60, 0x10, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x3E, 0x07,
  0xE0, 0x78, 0x0C, 0x0E, 0x1F, 0x7C, 0x78, 0x30, 0x10, 0x00, 0xF8, 0xFE,
  0x0F, 0x07, 0x07, 0x07, 0x07, 0x7E, 0x7C, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x70, 0x1F, 0x87, 0xFC, 0x60, 0xEE, 0x06, 0xC0, 0x6C, 0x37, 0xC7,
  0xBC, 0xE7, 0xCC, 0x7C, 0xC7, 0xCC, 0x7C, 0xC7, 0xCC, 0x7C, 0x7B, 0xC3,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x01, 0xF0, 0x0E, 0x01, 0xE0, 0x7C,
  0x0D, 0x81, 0xB0, 0x37, 0x0E, 0x61, 0x8C, 0x31, 0x86, 0x39, 0xFF, 0x3F,
  0xE6, 0x0D, 0xC1, 0xF8, 0x3F, 0x03, 0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC1,
  0xF0, 0x6C, 0x7B, 0xF8, 0xFF, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFF,
  0xFB, 0xF8, 0x3F, 0x1F, 0xEE, 0x3B, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC1, 0xF8, 0xE7, 0xF8, 0xFC, 0xFE, 0x3F,
  0xCC, 0x3B, 0x06, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xB1, 0xEF, 0xF3, 0xF8, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE,
  0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x3F, 0x1F,
  0xEE, 0x3B, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF, 0xF3, 0xFC, 0x1F,
  0x07, 0xC1, 0xF8, 0xE7, 0xF8, 0xFC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x03, 0xE1, 0xF8, 0x77,
  0xF8, 0xFC, 0xC1, 0xF0, 0x7C, 0x3B, 0x0E, 0xC7, 0x31, 0xCC, 0xE3, 0xF8,
  0xFE, 0x31, 0x8C, 0x73, 0x0C, 0xC3, 0xB0, 0xEC, 0x1F, 0x07, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0xC7, 0xEC, 0xBD,
  0xB7, 0xF6, 0xFA, 0xDF, 0x73, 0xEE, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF1, 0xF6, 0x7D,
  0x9F, 0x67, 0xCD, 0xF3, 0x7C, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x0F,
  0x3F, 0x1F, 0xEE, 0x3B, 0x06, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xB8, 0xE7, 0xF8, 0xFC, 0xFF, 0x3F, 0xEC, 0x3F,
  0x07, 0xC0, 0xF0, 0x3C, 0x1F, 0xFF, 0xFF, 0xBF, 0x8C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x3F, 0x1F, 0xEE, 0x3B, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xE7, 0xF8, 0xFC,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0xFE, 0x3F, 0xEC, 0x3F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0xFE, 0xFF, 0x3F, 0x8C, 0x73, 0x1C, 0xC3, 0xB0, 0xEC, 0x1B,
  0x07, 0x1F, 0x87, 0xF9, 0xC7, 0x30, 0x76, 0x00, 0xE0, 0x1F, 0x01, 0xFC,
  0x1F, 0xC0, 0x38, 0x03, 0x80, 0x7E, 0x0E, 0xE3, 0xDF, 0xF1, 0xFC, 0xFF,
  0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xB8, 0xE7, 0xF8, 0xFC, 0xE0, 0x7C, 0x1D, 0x83, 0xB0, 0x67, 0x0C,
  0xE3, 0x8C, 0x71, 0x8C, 0x39, 0x87, 0x30, 0x6E, 0x0D, 0x81, 0xB0, 0x3E,
  0x03, 0xC0, 0x70, 0xE7, 0x1B, 0x39, 0xD9, 0xCE, 0xCA, 0x66, 0x53, 0x32,
  0x99, 0x96, 0xCC, 0xB6, 0x6D, 0xB3, 0xED, 0x8F, 0x2C, 0x79, 0x63, 0x8E,
  0x1C, 0x70, 0xE3, 0x87, 0x1C, 0xE0, 0xE7, 0x0C, 0x71, 0xC3, 0x98, 0x3B,
  0x81, 0xF0, 0x1F, 0x00, 0xE0, 0x0E, 0x01, 0xF0, 0x1B, 0x83, 0xB8, 0x31,
  0xC7, 0x1C, 0x60, 0xEE, 0x0F, 0xC0, 0x7E, 0x0E, 0x60, 0xC7, 0x1C, 0x31,
  0x83, 0xB8, 0x1B, 0x81, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x70, 0x30,
  0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8F, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x1C, 0x07, 0x83,
  0x60, 0xD8, 0x73, 0x18, 0xCE, 0x3B, 0x06, 0xC1, 0xC0, 0xFF, 0xFF, 0xFC,
  0xE3, 0x8E, 0x1F, 0x8F, 0xF7, 0x1C, 0x03, 0x00, 0xCF, 0xF7, 0xFF, 0x83,
  0xE0, 0xF8, 0x77, 0xFC, 0xFB, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xDF, 0x37,
  0xEE, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xED, 0xFB,
  0x7C, 0x3F, 0x1F, 0xEE, 0x3B, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC1,
  0xF8, 0xE7, 0xF8, 0xFC, 0x01, 0x80, 0xC0, 0x60, 0x37, 0xDF, 0xFF, 0x8F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x1F, 0xFE, 0xFB, 0x3F, 0x1F,
  0xEE, 0x1B, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x78, 0x67, 0xF8,
  0xFC, 0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x7D,
  0xFF, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3, 0xFF, 0xDF, 0x60,
  0x30, 0x18, 0x1D, 0xFE, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xF6, 0xFF,
  0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x1E,
  0x07, 0x80, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x07, 0x07, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0xFE, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC1,
  0xF0, 0xEC, 0x3B, 0x1C, 0xC6, 0x3F, 0x8F, 0xE3, 0x1C, 0xC7, 0x30, 0xEC,
  0x1F, 0x07, 0xFC, 0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0xF8, 0x3F,
  0xDD, 0xDF, 0xFF, 0x99, 0xF3, 0x3E, 0x67, 0xCC, 0xF9, 0x9F, 0x33, 0xE6,
  0x7C, 0xCF, 0x99, 0xF3, 0x30, 0xDF, 0x6F, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x3F, 0x1F, 0xEE, 0x3B, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xB8, 0xE7, 0xF8, 0xF8, 0xDF, 0x37,
  0xEE, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xED, 0xFB,
  0x7C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7D, 0xFF, 0xF8, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xFF, 0xEF, 0xB0, 0x18, 0x0C, 0x06, 0x03,
  0xEF, 0xBF, 0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x7F, 0x3F, 0xEE, 0x1F, 0x00, 0xE0, 0x1F, 0xC1, 0xF8,
  0x07, 0x01, 0xF0, 0x7F, 0xF9, 0xFC, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x0F,
  0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0xF0, 0x3E, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xF1, 0xDF, 0xE7, 0xC0, 0xE0, 0xFC, 0x1D, 0x83, 0x38, 0x67,
  0x1C, 0x63, 0x0E, 0x61, 0xDC, 0x1B, 0x03, 0xE0, 0x7C, 0x07, 0x00, 0xCE,
  0x3C, 0xE6, 0xCA, 0x6C, 0xA6, 0xCA, 0x6C, 0xB6, 0x6B, 0x67, 0xB4, 0x79,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xE0, 0xEE, 0x38, 0xE6, 0x0D, 0xC1, 0xF0,
  0x1C, 0x03, 0xC0, 0xF8, 0x3B, 0x86, 0x39, 0xC7, 0x70, 0x70, 0xE0, 0xEC,
  0x1D, 0xC3, 0x38, 0xE3, 0x1C, 0x73, 0x06, 0xE0, 0xDC, 0x1F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x3F, 0xFF, 0xF0, 0x07, 0x87,
  0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x7E, 0x3F, 0x01, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x70, 0x18, 0x0F, 0xC3, 0xE3, 0x83, 0x81, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x3E, 0x1E, 0x00, 0x78, 0x7F, 0x8F, 0x39, 0xE3, 0xF0, 0x18,
};

const GFXglyph JetBrainsMono_SemiBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 7, 7, 13, 3, -16 },
  { 14, 12, 16, 13, 1, -16 },
  { 38, 11, 22, 13, 1, -19 },
  { 69, 13, 16, 13, 0, -16 },
  { 95, 12, 16, 13, 1, -16 },
  { 119, 3, 7, 13, 5, -16 },
  { 122, 7, 21, 13, 4, -18 },
  { 141, 6, 21, 13, 3, -18 },
  { 157, 12, 11, 13, 1, -13 },
  { 174, 11, 10, 13, 1, -12 },
  { 188, 5, 7, 13, 3, -3 },
  { 193, 7, 2, 13, 3, -8 },
  { 195, 4, 4, 13, 5, -4 },
  { 197, 11, 20, 13, 1, -18 },
  { 225, 10, 16, 13, 2, -16 },
  { 245, 10, 16, 13, 2, -16 },
  { 265, 11, 16, 13, 1, -16 },
  { 287, 11, 16, 13, 1, -16 },
  { 309, 9, 16, 13, 2, -16 },
  { 327, 10, 16, 13, 2, -16 },
  { 347, 11, 16, 13, 1, -16 },
  { 369, 11, 16, 13, 1, -16 },
  { 391, 11, 16, 13, 1, -16 },
  { 413, 11, 16, 13, 1, -16 },
  { 435, 4, 12, 13, 5, -12 },
  { 441, 6, 16, 13, 3, -12 },
  { 453, 9, 12, 13, 2, -13 },
  { 467, 9, 8, 13, 2, -11 },
  { 476, 9, 12, 13, 2, -13 },
  { 490, 8, 16, 13, 3, -16 },
  { 506, 12, 20, 13, 1, -16 },
  { 536, 11, 16, 13, 1, -16 },
  { 558, 10, 16, 13, 2, -16 },
  { 578, 10, 16, 13, 2, -16 },
  { 598, 10, 16, 13, 2, -16 },
  { 618, 10, 16, 13, 2, -16 },
  { 638, 10, 16, 13, 2, -16 },
  { 658, 10, 16, 13, 2, -16 },
  { 678, 9, 16, 13, 2, -16 },
  { 696, 9, 16, 13, 2, -16 },
  { 714, 10, 16, 13, 1, -16 },
  { 734, 10, 16, 13, 2, -16 },
  { 754, 10, 16, 13, 2, -16 },
  { 774, 11, 16, 13, 1, -16 },
  { 796, 10, 16, 13, 2, -16 },
  { 816, 10, 16, 13, 2, -16 },
  { 836, 10, 16, 13, 2, -16 },
  { 856, 10, 20, 13, 2, -16 },
  { 881, 10, 16, 13, 2, -16 },
  { 901, 11, 16, 13, 1, -16 },
  { 923, 11, 16, 13, 1, -16 },
  { 945, 10, 16, 13, 2, -16 },
  { 965, 11, 16, 13, 1, -16 },
  { 987, 13, 16, 13, 0, -16 },
  { 1013, 12, 16, 13, 1, -16 },
  { 1037, 12, 16, 13, 1, -16 },
  { 1061, 9, 16, 13, 2, -16 },
  { 1079, 6, 20, 13, 4, -18 },
  { 1094, 11, 20, 13, 1, -18 },
  { 1122, 6, 20, 13, 3, -18 },
  { 1137, 10, 9, 13, 2, -16 },
  { 1149, 11, 2, 13, 1, 1 },
  { 1152, 5, 3, 13, 4, -17 },
  { 1154, 10, 12, 13, 1, -12 },
  { 1169, 10, 16, 13, 2, -16 },
  { 1189, 10, 12, 13, 2, -12 },
  { 1204, 9, 16, 13, 2, -16 },
  { 1222, 10, 12, 13, 2, -12 },
  { 1237, 11, 16, 13, 1, -16 },
  { 1259, 9, 16, 13, 2, -12 },
  { 1277, 9, 16, 13, 2, -16 },
  { 1295, 10, 17, 13, 2, -17 },
  { 1317, 8, 21, 13, 2, -17 },
  { 1338, 10, 16, 13, 2, -16 },
  { 1358, 11, 16, 13, 1, -16 },
  { 1380, 11, 12, 13, 1, -12 },
  { 1397, 9, 12, 13, 2, -12 },
  { 1411, 10, 12, 13, 2, -12 },
  { 1426, 10, 16, 13, 2, -12 },
  { 1446, 9, 16, 13, 2, -12 },
  { 1464, 10, 12, 13, 2, -12 },
  { 1479, 10, 12, 13, 2, -12 },
  { 1494, 11, 16, 13, 1, -16 },
  { 1516, 9, 12, 13, 2, -12 },
  { 1530, 11, 12, 13, 1, -12 },
  { 1547, 12, 12, 13, 1, -12 },
  { 1565, 11, 12, 13, 1, -12 },
  { 1582, 11, 16, 13, 1, -12 },
  { 1604, 9, 12, 13, 2, -12 },
  { 1618, 9, 20, 13, 2, -18 },
  { 1641, 3, 20, 13, 5, -18 },
  { 1649, 9, 20, 13, 2, -18 },
  { 1672, 11, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_SemiBold22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_SEMIBOLD22PT7B_H_
