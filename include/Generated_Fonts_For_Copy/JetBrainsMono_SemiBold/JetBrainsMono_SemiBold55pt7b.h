#ifndef _JETBRAINSMONO_SEMIBOLD55PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F,
  0x3F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x7C,
  0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x3C,
  0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0x9C, 0xFF,
  0x0F, 0xE3, 0x8F, 0xE1, 0xF8, 0x70, 0xFE, 0x7F, 0x0E, 0x1F, 0xCF, 0xE1,
  0xC1, 0xF9, 0xFC, 0x38, 0x00, 0x3F, 0x87, 0x00, 0x07, 0xF0, 0xE0, 0x00,
  0x7F, 0x1C, 0x00, 0x0F, 0xF3, 0x80, 0x01, 0xFF, 0x70, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0E, 0x3F, 0xC0, 0x01, 0xC3, 0xF8, 0x00, 0x38, 0x3F, 0x00,
  0x07, 0x07, 0xF0, 0x00, 0xE0, 0xFF, 0xFC, 0x1C, 0x1F, 0xFF, 0x83, 0x83,
  0xFB, 0xF0, 0x70, 0x7E, 0x7F, 0x0E, 0x1F, 0xCF, 0xF1, 0xC7, 0xF8, 0xFF,
  0xB9, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0x8F, 0xFE, 0x00, 0x0F, 0x8F, 0xFF, 0x80, 0x0F, 0x8F, 0xFF,
  0xE0, 0x07, 0x87, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x78, 0x07, 0xC1, 0xE0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x3C,
  0x07, 0xC3, 0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x0F, 0x01, 0xF1, 0xF0, 0x07,
  0xC1, 0xF1, 0xF0, 0x03, 0xF1, 0xF8, 0xF0, 0x00, 0xFF, 0xFC, 0xF8, 0x00,
  0x7F, 0xFC, 0xF8, 0x00, 0x1F, 0xFC, 0xF8, 0x00, 0x03, 0xF8, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x1E, 0x3F,
  0xF8, 0x00, 0x1F, 0x3F, 0xFE, 0x00, 0x1F, 0x3F, 0xFF, 0x00, 0x1F, 0x1F,
  0x0F, 0xC0, 0x0F, 0x8F, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0xF0, 0x0F, 0x87,
  0xC0, 0x78, 0x07, 0xC3, 0xE0, 0x3C, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x0F, 0x03, 0xC0, 0x7C, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xE3, 0xE0, 0x07, 0xFF, 0xE1, 0xF0, 0x01, 0xFF, 0xF1, 0xF0,
  0x00, 0x7F, 0xF1, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x7E, 0x07, 0xFF, 0xC7, 0xF0, 0x7E, 0xFC, 0x3F, 0x8F, 0xCF, 0xC1,
  0xF8, 0xFC, 0xFC, 0x0F, 0xDF, 0x8F, 0xC0, 0xFF, 0xF8, 0xFC, 0x07, 0xFF,
  0x0F, 0xC0, 0x3F, 0xF0, 0xFC, 0x03, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x7F,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xE1,
  0xFF, 0xF0, 0x7E, 0x0F, 0xFE, 0x03, 0xF0, 0x04, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0x9F, 0x3E,
  0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x40,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x70, 0x0F, 0x80, 0x73, 0xF0, 0x7C, 0x1F,
  0x9F, 0xE1, 0xE3, 0xFD, 0xFF, 0x8E, 0x3F, 0xFF, 0xFF, 0x77, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x8F, 0xF9, 0xFF, 0x3F,
  0xEF, 0xFE, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F, 0x81, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFE,
  0x03, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x0E, 0x0F,
  0xFF, 0x0F, 0x87, 0xFF, 0x8F, 0xE3, 0xFF, 0xC7, 0xF1, 0xFF, 0xE3, 0xF8,
  0xFF, 0xF1, 0xFC, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFE,
  0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7C, 0x1F, 0xC0, 0x3C,
  0x0F, 0xE0, 0x18, 0x07, 0xF0, 0x08, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF9, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x9F, 0xE0,
  0x0F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x16, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x3F, 0xC0, 0x3F, 0x3F, 0x80,
  0x3F, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0x80,
  0xFC, 0xFF, 0xF0, 0x7E, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xCF, 0xF8, 0x3F, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x9F,
  0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x1E, 0x00, 0x1F, 0xDF, 0xF8, 0x03, 0xF7, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF, 0x00, 0x7F,
  0x9F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x1F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFE, 0x03,
  0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xFC,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xFB, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F,
  0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x01,
  0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE3, 0xFF,
  0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xF8,
  0x03, 0xFE, 0x7F, 0x00, 0x06, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x07,
  0xF1, 0xFF, 0x3F, 0xEF, 0xFE, 0xFF, 0x9F, 0xF3, 0xFE, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0xCF, 0xF9, 0xFF, 0x7F,
  0xF7, 0xFC, 0xFF, 0x8F, 0xE0, 0x60, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x3F,
  0xE3, 0xFF, 0x9F, 0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x21, 0xFE, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xE3, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xFE,
  0xFF, 0xC0, 0x7F, 0xFB, 0xFE, 0x07, 0xF0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF,
  0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0x80, 0x7F, 0xE0, 0x7C, 0x03, 0xFF, 0x03,
  0xE0, 0x1F, 0xF8, 0x1F, 0x00, 0xFF, 0xC0, 0xF8, 0x07, 0xFE, 0x07, 0xC0,
  0x3F, 0xF0, 0x3E, 0x01, 0xFF, 0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0x80, 0x7F,
  0xE0, 0x7C, 0x03, 0xFF, 0x03, 0xE0, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xDF, 0xF0, 0x1F, 0xFC, 0xFF, 0x80, 0x7F,
  0xCF, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0xFF,
  0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x07, 0xFE,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x7F, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0x03,
  0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xF8, 0x07,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFF, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF8, 0x3F,
  0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xE7, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0xF0, 0x1E,
  0xFF, 0xDE, 0x03, 0xDF, 0xFB, 0xE0, 0xFB, 0xFF, 0x3C, 0x1E, 0x7F, 0xE7,
  0x83, 0xDF, 0xFE, 0xF8, 0xFB, 0xFF, 0xDF, 0x1F, 0x7F, 0xF9, 0xE3, 0xCF,
  0xFF, 0x3E, 0x79, 0xFF, 0xE7, 0xDF, 0x3F, 0xFC, 0x7B, 0xC7, 0xFF, 0x8F,
  0x78, 0xFF, 0xF1, 0xFF, 0x1F, 0xFE, 0x1F, 0xE3, 0xFF, 0xC3, 0xF8, 0x7F,
  0xF8, 0x7F, 0x0F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xF7, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0x7C, 0x07, 0xFF, 0xBE, 0x03, 0xFF, 0xDF, 0x81, 0xFF, 0xE7, 0xC0, 0xFF,
  0xF3, 0xE0, 0x7F, 0xF9, 0xF8, 0x3F, 0xFC, 0x7C, 0x1F, 0xFE, 0x3E, 0x0F,
  0xFF, 0x1F, 0x87, 0xFF, 0x87, 0xC3, 0xFF, 0xC3, 0xE1, 0xFF, 0xE1, 0xF8,
  0xFF, 0xF0, 0x7C, 0x7F, 0xF8, 0x3E, 0x3F, 0xFC, 0x1F, 0x9F, 0xFE, 0x07,
  0xCF, 0xFF, 0x03, 0xE7, 0xFF, 0x80, 0xFB, 0xFF, 0xC0, 0x7D, 0xFF, 0xE0,
  0x3E, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF8,
  0x3F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x0F,
  0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xEF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xF0, 0x7F, 0xC7, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80,
  0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x7E,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0xF8,
  0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0,
  0xFE, 0x07, 0xEF, 0x81, 0xDC, 0x0F, 0x9F, 0x03, 0xB8, 0x1F, 0x3E, 0x07,
  0x70, 0x3E, 0x7C, 0x0E, 0xE0, 0x7C, 0xFC, 0x1D, 0xE0, 0xF9, 0xF8, 0x3B,
  0xC3, 0xF3, 0xF0, 0xF7, 0x87, 0xE7, 0xE1, 0xEF, 0x0F, 0xCF, 0xC3, 0xDE,
  0x1F, 0x8F, 0x87, 0x9C, 0x3E, 0x1F, 0x0E, 0x38, 0x7C, 0x3E, 0x1C, 0x70,
  0xF8, 0x7C, 0x38, 0xE1, 0xF0, 0xF8, 0x71, 0xE3, 0xE1, 0xF1, 0xE3, 0xC7,
  0xC3, 0xF3, 0xC7, 0x8F, 0x87, 0xE7, 0x8F, 0x3F, 0x0F, 0xCF, 0x1E, 0x7E,
  0x1F, 0x9C, 0x1C, 0xF8, 0x1F, 0x38, 0x39, 0xF0, 0x3E, 0x70, 0x73, 0xE0,
  0x7C, 0xE0, 0xE7, 0xC0, 0xFB, 0xC1, 0xEF, 0x81, 0xF7, 0x83, 0xDF, 0x03,
  0xEF, 0x07, 0xBE, 0x07, 0xDE, 0x0F, 0x7C, 0x0F, 0xBC, 0x1E, 0xF8, 0x1F,
  0x70, 0x3D, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x01,
  0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE3, 0xFC, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xDF, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xF7, 0xFE, 0x3F, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xC7, 0xFF, 0xE7, 0xF0, 0x7F, 0xF1,
  0xFC, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x3F,
  0x8F, 0xFC, 0x1F, 0xCF, 0xFF, 0x0F, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFD, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xBF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7,
  0xF7, 0xFF, 0xE3, 0xF9, 0xFF, 0xE1, 0xFC, 0x7F, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFC, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFE, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0xE0, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7C, 0x1F,
  0xC1, 0xFF, 0x8F, 0xE1, 0xFF, 0xE7, 0xF1, 0xFF, 0xFB, 0xF9, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xBF, 0x80, 0x7F, 0xDF, 0xF0, 0x7F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFB,
  0xF8, 0xFF, 0xFD, 0xFC, 0x3F, 0xFC, 0xFE, 0x0F, 0xFC, 0x7F, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xF1, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x3F, 0xC0, 0x3F, 0x8F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x1F, 0xC3, 0xFF, 0xCF, 0xE3, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFE, 0x07, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0xEF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xDF, 0xC7, 0xFF, 0xEF, 0xE1, 0xFF, 0xE7,
  0xF0, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x3F, 0x8F, 0xFC, 0x1F, 0xCF, 0xFF, 0x0F, 0xEF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x7F,
  0x80, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFE,
  0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xCF, 0xC0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF0, 0xFC, 0x03, 0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xF0, 0x7F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xFC, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xFC, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x1F, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F,
  0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x70, 0x1E, 0x1F,
  0x3F, 0x8F, 0xF3, 0xEF, 0xF9, 0xFE, 0x7D, 0xFF, 0x7F, 0xEF, 0xBF, 0xEF,
  0xFD, 0xFC, 0x7F, 0x1F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC,
  0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83,
  0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0,
  0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F,
  0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07,
  0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF,
  0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E,
  0x0F, 0xFF, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x1F, 0xF8, 0x3F,
  0x9F, 0xFE, 0x1F, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB,
  0xFE, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x7F,
  0x3F, 0xE0, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0x1F, 0xF8, 0x3F, 0x9F, 0xFE, 0x1F, 0xDF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0x7F, 0xE0, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xCF, 0xEF, 0xFF, 0xC7, 0xF3, 0xFF, 0xC3, 0xF8, 0xFF, 0xC1, 0xFC,
  0x04, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x1F, 0xC3, 0xFF, 0xCF, 0xE3, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFE, 0x07, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0xFF, 0xBF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF7, 0xF1, 0xFF,
  0xFB, 0xF8, 0x7F, 0xF9, 0xFC, 0x1F, 0xF8, 0xFE, 0x00, 0x40, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x1F, 0xF8, 0x3F, 0x9F,
  0xFF, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFE,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xDF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF0, 0x01,
  0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0xC1, 0xFE, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0x9F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0xF8, 0x0F,
  0x80, 0xF9, 0xF0, 0x3F, 0x01, 0xF3, 0xE0, 0x7F, 0x03, 0xE7, 0xC0, 0xFE,
  0x07, 0xCF, 0x81, 0xDC, 0x0F, 0x9F, 0x83, 0xB8, 0x1F, 0x3F, 0x07, 0x70,
  0x7C, 0x3E, 0x0E, 0xE0, 0xF8, 0x7C, 0x3D, 0xE1, 0xF0, 0xF8, 0x7B, 0xC3,
  0xE1, 0xF0, 0xF7, 0x87, 0xC3, 0xE1, 0xC7, 0x0F, 0x87, 0xE3, 0x8E, 0x1F,
  0x07, 0xC7, 0x1C, 0x7C, 0x0F, 0x9E, 0x3C, 0xF8, 0x1F, 0x3C, 0x79, 0xF0,
  0x3E, 0x78, 0xF3, 0xE0, 0x7C, 0xE1, 0xE7, 0xC0, 0xF9, 0xC1, 0xCF, 0x81,
  0xFB, 0x83, 0x9E, 0x01, 0xF7, 0x07, 0x7C, 0x03, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFD, 0xFC, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x7C, 0xFF, 0xE0,
  0x0F, 0xBF, 0xFE, 0x01, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0xDF, 0x01, 0xFF,
  0xFB, 0xE0, 0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 9, 40, 33, 12, -40 },
  { 46, 19, 16, 33, 7, -40 },
  { 84, 29, 40, 33, 2, -40 },
  { 229, 27, 56, 33, 3, -48 },
  { 418, 33, 40, 33, 0, -40 },
  { 583, 28, 42, 33, 3, -41 },
  { 730, 7, 16, 33, 13, -40 },
  { 744, 18, 53, 33, 9, -46 },
  { 864, 18, 53, 33, 6, -46 },
  { 984, 29, 29, 33, 2, -34 },
  { 1090, 27, 26, 33, 3, -31 },
  { 1178, 13, 17, 33, 8, -8 },
  { 1206, 17, 6, 33, 8, -21 },
  { 1219, 11, 10, 33, 11, -9 },
  { 1233, 25, 52, 33, 4, -46 },
  { 1396, 25, 42, 33, 4, -41 },
  { 1528, 25, 40, 33, 5, -40 },
  { 1653, 26, 41, 33, 3, -41 },
  { 1787, 26, 41, 33, 3, -40 },
  { 1921, 24, 40, 33, 4, -40 },
  { 2041, 25, 41, 33, 4, -40 },
  { 2170, 27, 41, 33, 3, -40 },
  { 2309, 26, 40, 33, 4, -40 },
  { 2439, 25, 42, 33, 4, -41 },
  { 2571, 27, 41, 33, 3, -41 },
  { 2710, 11, 32, 33, 11, -31 },
  { 2754, 13, 40, 33, 9, -31 },
  { 2819, 25, 30, 33, 4, -33 },
  { 2913, 23, 19, 33, 5, -28 },
  { 2968, 25, 30, 33, 4, -33 },
  { 3062, 21, 40, 33, 7, -40 },
  { 3167, 29, 51, 33, 2, -41 },
  { 3352, 29, 40, 33, 2, -40 },
  { 3497, 26, 40, 33, 4, -40 },
  { 3627, 25, 42, 33, 4, -41 },
  { 3759, 25, 40, 33, 4, -40 },
  { 3884, 24, 40, 33, 5, -40 },
  { 4004, 24, 40, 33, 5, -40 },
  { 4124, 25, 42, 33, 4, -41 },
  { 4256, 25, 40, 33, 4, -40 },
  { 4381, 23, 40, 33, 5, -40 },
  { 4496, 26, 41, 33, 2, -40 },
  { 4630, 27, 40, 33, 4, -40 },
  { 4765, 24, 40, 33, 6, -40 },
  { 4885, 27, 40, 33, 3, -40 },
  { 5020, 25, 40, 33, 4, -40 },
  { 5145, 25, 42, 33, 4, -41 },
  { 5277, 27, 40, 33, 4, -40 },
  { 5412, 26, 51, 33, 4, -41 },
  { 5578, 26, 40, 33, 4, -40 },
  { 5708, 27, 42, 33, 3, -41 },
  { 5850, 27, 40, 33, 3, -40 },
  { 5985, 25, 41, 33, 4, -40 },
  { 6114, 29, 40, 33, 2, -40 },
  { 6259, 31, 40, 33, 1, -40 },
  { 6414, 29, 40, 33, 2, -40 },
  { 6559, 31, 40, 33, 1, -40 },
  { 6714, 25, 40, 33, 4, -40 },
  { 6839, 15, 52, 33, 10, -46 },
  { 6937, 26, 52, 33, 3, -46 },
  { 7106, 15, 52, 33, 8, -46 },
  { 7204, 25, 21, 33, 4, -40 },
  { 7270, 27, 6, 33, 3, 1 },
  { 7291, 13, 8, 33, 9, -43 },
  { 7304, 26, 32, 33, 3, -31 },
  { 7408, 25, 41, 33, 4, -40 },
  { 7537, 25, 32, 33, 4, -31 },
  { 7637, 25, 41, 33, 4, -40 },
  { 7766, 25, 32, 33, 4, -31 },
  { 7866, 27, 40, 33, 3, -40 },
  { 8001, 25, 41, 33, 4, -31 },
  { 8130, 25, 40, 33, 4, -40 },
  { 8255, 27, 43, 33, 4, -43 },
  { 8401, 21, 53, 33, 5, -43 },
  { 8541, 26, 40, 33, 5, -40 },
  { 8671, 29, 40, 33, 2, -40 },
  { 8816, 27, 31, 33, 3, -31 },
  { 8921, 25, 31, 33, 4, -31 },
  { 9018, 25, 32, 33, 4, -31 },
  { 9118, 25, 41, 33, 4, -31 },
  { 9247, 25, 41, 33, 4, -31 },
  { 9376, 25, 31, 33, 5, -31 },
  { 9473, 25, 32, 33, 4, -31 },
  { 9573, 26, 39, 33, 3, -39 },
  { 9700, 25, 31, 33, 4, -30 },
  { 9797, 29, 30, 33, 2, -30 },
  { 9906, 31, 30, 33, 1, -30 },
  { 10023, 29, 30, 33, 2, -30 },
  { 10132, 29, 40, 33, 2, -30 },
  { 10277, 25, 30, 33, 4, -30 },
  { 10371, 25, 52, 33, 4, -46 },
  { 10534, 7, 52, 33, 13, -46 },
  { 10580, 25, 52, 33, 4, -46 },
  { 10743, 27, 13, 33, 3, -26 },
};

const GFXfont JetBrainsMono_SemiBold55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_SEMIBOLD55PT7B_H_
