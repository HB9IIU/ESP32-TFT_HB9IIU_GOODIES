#ifndef _JETBRAINSMONO_SEMIBOLD48PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7E,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F,
  0x80, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x3E, 0x0F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78,
  0x0F, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x80,
  0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xF3, 0x9F, 0xCF,
  0xC7, 0x1F, 0x9F, 0x0E, 0x1F, 0x3E, 0x1C, 0x3E, 0x7C, 0x38, 0x00, 0xF8,
  0x70, 0x01, 0xF8, 0xE0, 0x03, 0xF9, 0xC0, 0x03, 0xFB, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0x9F, 0xC0, 0x07, 0x1F,
  0x80, 0x0E, 0x1F, 0x80, 0x1C, 0x3F, 0x00, 0x38, 0x7F, 0xF8, 0x70, 0xFF,
  0xF0, 0xE1, 0xFF, 0xE1, 0xC7, 0xE7, 0xE3, 0x9F, 0xCF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0xFF,
  0xC0, 0x0F, 0x8F, 0xFE, 0x00, 0x78, 0xF8, 0xF8, 0x07, 0x87, 0x83, 0xC0,
  0x7C, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x83, 0xC0,
  0x78, 0x3C, 0x1E, 0x03, 0xC1, 0xE1, 0xE0, 0x1E, 0x0F, 0x1E, 0x00, 0xF0,
  0x79, 0xF0, 0x07, 0xFF, 0xCF, 0x00, 0x1F, 0xFC, 0xF0, 0x00, 0x7F, 0xCF,
  0x80, 0x00, 0x70, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0xFC, 0x00,
  0x3E, 0x7F, 0xF0, 0x01, 0xE7, 0xFF, 0x80, 0x1E, 0x3C, 0x3E, 0x01, 0xF3,
  0xE0, 0xF0, 0x0F, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x78, 0x07, 0x83, 0xC7,
  0xC0, 0x3F, 0x7E, 0x3C, 0x01, 0xFF, 0xE3, 0xC0, 0x07, 0xFE, 0x3E, 0x00,
  0x0F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xDF, 0x83, 0xFF, 0xC7, 0xC1, 0xF7, 0xE3, 0xF1, 0xFB, 0xF0,
  0xFC, 0xF9, 0xF8, 0x3F, 0xFC, 0xFC, 0x1F, 0xFC, 0x7E, 0x07, 0xFE, 0x3F,
  0x01, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC3,
  0xF0, 0x1F, 0xF0, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xDF,
  0x87, 0xFF, 0x87, 0xC1, 0xFF, 0x83, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF0, 0x00, 0x06, 0x00, 0x7C, 0x01, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x40, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x02, 0x01, 0xF0, 0x18, 0xF0,
  0x78, 0x1E, 0x7F, 0x0E, 0x1F, 0x9F, 0xF3, 0x9F, 0xFF, 0xFE, 0xEF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0x7C, 0x07, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x00, 0x20, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0x1F, 0xE7, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x0E, 0x1F, 0xFC, 0x7C, 0x7F, 0xF3, 0xF1, 0xFF, 0xCF,
  0xC7, 0xFF, 0x3F, 0x1F, 0xFC, 0x7C, 0x7F, 0xF0, 0x41, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xF0, 0x1F, 0xCF, 0xF1,
  0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x03, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x1F, 0x80, 0xF0, 0x7E,
  0x03, 0x81, 0xF8, 0x0C, 0x07, 0xE0, 0x20, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xFC, 0xFF, 0x8F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF7,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x7E, 0xFF, 0xE3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFD, 0xFF, 0x7F, 0xCF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF1, 0x80, 0x0F,
  0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFC,
  0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F, 0xF3, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x1F, 0xC0,
  0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xE0, 0xFC,
  0x0F, 0xF7, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0x01, 0xFE, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0xE3,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0xFC, 0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0xFF, 0x7E, 0x00, 0x10, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x3F, 0xBF,
  0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0x80, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0x87, 0xF1,
  0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x3F, 0xC0,
  0x7F, 0xDF, 0xE0, 0x7F, 0xEF, 0xF0, 0x3E, 0x1F, 0xF8, 0x3E, 0x07, 0xFC,
  0x1F, 0x03, 0xFE, 0x0F, 0x80, 0xFF, 0x07, 0xC0, 0x7F, 0x83, 0xE0, 0x3F,
  0xC1, 0xF0, 0x1F, 0xE0, 0xF8, 0x0F, 0xF0, 0x7C, 0x07, 0xF8, 0x3E, 0x03,
  0xFC, 0x1F, 0x01, 0xFE, 0x0F, 0x81, 0xFF, 0x07, 0xC0, 0xFF, 0x81, 0xF8,
  0xFF, 0xC0, 0xFF, 0xDF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xE7, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xC0, 0x1F,
  0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xE0, 0x0F, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E,
  0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8,
  0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3E, 0x01, 0xFC, 0xF8, 0x01, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xEF, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xEF, 0xFB, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7C, 0x07, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xEF, 0xFB, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0xFB, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xE7, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xF7,
  0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7C,
  0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0,
  0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xC1, 0xF8,
  0x0F, 0x83, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x8F,
  0x80, 0x3F, 0x1F, 0x00, 0x7F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0xF8,
  0x00, 0xFD, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0xE0, 0x7B, 0xFD, 0xE0, 0xF7,
  0xFB, 0xC1, 0xEF, 0xF7, 0x83, 0xBF, 0xE7, 0x8F, 0x7F, 0xEF, 0x1E, 0xFF,
  0xDE, 0x3D, 0xFF, 0x9E, 0xF3, 0xFF, 0x3D, 0xE7, 0xFE, 0x7B, 0xCF, 0xFC,
  0x77, 0x1F, 0xF8, 0xFE, 0x3F, 0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC3,
  0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFE, 0xF0, 0x1F, 0xF7, 0xC0, 0xFF, 0xFE, 0x07, 0xFE,
  0xF0, 0x3F, 0xF7, 0xC1, 0xFF, 0xBE, 0x0F, 0xFC, 0xF0, 0x7F, 0xE7, 0xC3,
  0xFF, 0x3E, 0x1F, 0xF8, 0xF0, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF0,
  0xF1, 0xFF, 0x87, 0xCF, 0xFC, 0x1E, 0x7F, 0xE0, 0xF3, 0xFF, 0x07, 0xDF,
  0xF8, 0x1E, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xEF, 0xFB, 0xF8, 0x0F, 0xDF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xCF, 0xFB, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x00, 0x7F, 0xBE, 0x00, 0x3F,
  0x7C, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7C,
  0x00, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFD, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8,
  0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00,
  0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F,
  0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F,
  0xC0, 0x7F, 0x1F, 0xF7, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x00, 0x7F,
  0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB,
  0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBE,
  0x00, 0x7E, 0x7C, 0x03, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x1F,
  0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF8,
  0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0xF7, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x01, 0xF9, 0xFF, 0x7F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x1F, 0x03, 0xFF,
  0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x83, 0xB0,
  0x3D, 0xF0, 0x77, 0x07, 0x9E, 0x0E, 0xE1, 0xF3, 0xC1, 0xDC, 0x3E, 0x7C,
  0x3B, 0x87, 0xCF, 0x87, 0x70, 0xF9, 0xF0, 0xEE, 0x1F, 0x3E, 0x1D, 0xC3,
  0xE7, 0xC3, 0xB8, 0x7C, 0xF8, 0xE7, 0x0F, 0x1F, 0x1C, 0x71, 0xE1, 0xE3,
  0x8E, 0x3C, 0x3C, 0x71, 0xC7, 0x87, 0x8E, 0x39, 0xF0, 0xF1, 0xC7, 0x3E,
  0x1F, 0x38, 0xE7, 0xC3, 0xE7, 0x1C, 0xF8, 0x7D, 0xE3, 0x9F, 0x0F, 0xB8,
  0x73, 0xC1, 0xF7, 0x0F, 0x78, 0x3E, 0xE0, 0xEF, 0x03, 0xDC, 0x1D, 0xE0,
  0x7B, 0x83, 0xBC, 0x0F, 0x70, 0x77, 0x81, 0xEE, 0x0E, 0xF0, 0x3D, 0xC1,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xCF, 0xC0,
  0x07, 0xE3, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xDF, 0x7F, 0xFF,
  0x7C, 0xFF, 0xF9, 0xF0, 0xFF, 0x87, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF9,
  0xF7, 0xFF, 0xCF, 0xBF, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0xEF, 0x7F, 0xDF, 0x7F, 0xFE, 0xFB, 0xFF, 0xE7, 0xCF, 0xFE,
  0x3E, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01,
  0xFD, 0xFF, 0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xE1, 0xF8, 0xFF, 0xCF, 0xCF, 0xFF, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x7F, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFD, 0xF8, 0xFF, 0xEF, 0xC3, 0xFC, 0x7E, 0x01, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xFC, 0x1F, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xCF, 0xCF, 0xFF, 0x7E, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xF7, 0xFD, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFF, 0xF7, 0xE3, 0xFF, 0xBF, 0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF9, 0xF7, 0xFF, 0xCF, 0xBF, 0xFF, 0x7F,
  0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x30, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80,
  0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF0, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF8, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xE0, 0xF1, 0xE7,
  0xE3, 0xF3, 0xDF, 0xEF, 0xF7, 0xBF, 0xFF, 0xFF, 0xCF, 0xE7, 0xFF, 0x0F,
  0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3C, 0x1F, 0xF8, 0x78, 0x3F, 0xF0, 0xF0,
  0x7F, 0xE1, 0xE0, 0xFF, 0xC3, 0xC1, 0xFF, 0x87, 0x83, 0xFF, 0x0F, 0x07,
  0xFE, 0x1E, 0x0F, 0xFC, 0x3C, 0x1F, 0xF8, 0x78, 0x3F, 0xF0, 0xF0, 0x7F,
  0xE1, 0xE0, 0xFF, 0xC3, 0xC1, 0xFF, 0x87, 0x83, 0xFF, 0x0F, 0x07, 0xFE,
  0x1E, 0x0F, 0xFC, 0x3C, 0x1F, 0xF8, 0x78, 0x3F, 0xF0, 0xF0, 0x7F, 0xE1,
  0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF9, 0xF7, 0xFF,
  0xCF, 0xBF, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0x83, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xF9, 0xFF,
  0x7F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x3E, 0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF9, 0xF7, 0xFF, 0xCF, 0xBF,
  0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xEF, 0x7F,
  0xDF, 0x7F, 0xFE, 0xFB, 0xFF, 0xE7, 0xCF, 0xFE, 0x3E, 0x3F, 0xE1, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xCF, 0xCF, 0xFF, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFD, 0xFF, 0x7F, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFD, 0xF8, 0xFF, 0xEF, 0xC3, 0xFC, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xF9, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x1F,
  0x9F, 0xC0, 0x7F, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0x3F, 0xEF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x3C, 0x0F,
  0x81, 0xE7, 0xC3, 0xF0, 0x7C, 0xF8, 0x77, 0x0F, 0x9F, 0x0E, 0xE1, 0xF3,
  0xE1, 0xDC, 0x3C, 0x3C, 0x3B, 0x87, 0x87, 0x87, 0x70, 0xF0, 0xF1, 0xCE,
  0x1E, 0x1E, 0x39, 0xC7, 0xC3, 0xE7, 0x1C, 0xF8, 0x7C, 0xE3, 0x9E, 0x0F,
  0x9C, 0x73, 0xC0, 0xF3, 0x8E, 0x78, 0x1E, 0x71, 0xCF, 0x03, 0xDC, 0x39,
  0xE0, 0x7B, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFE,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xF0,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7,
  0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xCF,
  0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x3E, 0xFF, 0xC0, 0x7D, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xC3, 0xFE, 0x0F, 0xC7, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFE, 0xF0, 0x1F, 0xFD, 0xE0, 0x0F, 0xE0, 0x00, 0x06, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 35, 29, 10, -35 },
  { 36, 16, 14, 29, 6, -35 },
  { 64, 26, 35, 29, 1, -35 },
  { 178, 23, 49, 29, 3, -42 },
  { 319, 29, 35, 29, 0, -35 },
  { 446, 25, 36, 29, 2, -36 },
  { 559, 6, 14, 29, 11, -35 },
  { 570, 15, 46, 29, 8, -40 },
  { 657, 15, 46, 29, 6, -40 },
  { 744, 26, 25, 29, 1, -29 },
  { 826, 23, 23, 29, 3, -27 },
  { 893, 12, 15, 29, 7, -7 },
  { 916, 15, 5, 29, 7, -18 },
  { 926, 9, 8, 29, 10, -8 },
  { 935, 23, 45, 29, 3, -40 },
  { 1065, 22, 36, 29, 3, -36 },
  { 1164, 22, 35, 29, 4, -35 },
  { 1261, 23, 36, 29, 3, -36 },
  { 1365, 22, 35, 29, 3, -35 },
  { 1462, 22, 35, 29, 3, -35 },
  { 1559, 21, 35, 29, 4, -35 },
  { 1651, 23, 35, 29, 3, -35 },
  { 1752, 23, 35, 29, 3, -35 },
  { 1853, 23, 36, 29, 3, -36 },
  { 1957, 23, 36, 29, 3, -36 },
  { 2061, 9, 27, 29, 10, -27 },
  { 2092, 11, 35, 29, 8, -27 },
  { 2141, 21, 26, 29, 4, -29 },
  { 2210, 21, 17, 29, 4, -24 },
  { 2255, 21, 26, 29, 4, -29 },
  { 2324, 18, 35, 29, 6, -35 },
  { 2403, 25, 45, 29, 2, -36 },
  { 2544, 25, 35, 29, 2, -35 },
  { 2654, 22, 35, 29, 4, -35 },
  { 2751, 21, 36, 29, 4, -36 },
  { 2846, 21, 35, 29, 4, -35 },
  { 2938, 21, 35, 29, 4, -35 },
  { 3030, 22, 35, 29, 4, -35 },
  { 3127, 21, 36, 29, 4, -36 },
  { 3222, 21, 35, 29, 4, -35 },
  { 3314, 19, 35, 29, 5, -35 },
  { 3398, 22, 35, 29, 2, -35 },
  { 3495, 23, 35, 29, 4, -35 },
  { 3596, 21, 35, 29, 5, -35 },
  { 3688, 23, 35, 29, 3, -35 },
  { 3789, 21, 35, 29, 4, -35 },
  { 3881, 21, 36, 29, 4, -36 },
  { 3976, 23, 35, 29, 4, -35 },
  { 4077, 23, 45, 29, 3, -36 },
  { 4207, 23, 35, 29, 4, -35 },
  { 4308, 23, 36, 29, 3, -36 },
  { 4412, 25, 35, 29, 2, -35 },
  { 4522, 21, 35, 29, 4, -35 },
  { 4614, 25, 35, 29, 2, -35 },
  { 4724, 27, 35, 29, 1, -35 },
  { 4843, 26, 35, 29, 1, -35 },
  { 4957, 27, 35, 29, 1, -35 },
  { 5076, 21, 35, 29, 4, -35 },
  { 5168, 13, 45, 29, 9, -40 },
  { 5242, 23, 45, 29, 3, -40 },
  { 5372, 13, 45, 29, 7, -40 },
  { 5446, 22, 19, 29, 3, -35 },
  { 5499, 23, 5, 29, 3, 1 },
  { 5514, 11, 7, 29, 8, -38 },
  { 5524, 22, 27, 29, 3, -27 },
  { 5599, 21, 35, 29, 4, -35 },
  { 5691, 21, 27, 29, 4, -27 },
  { 5762, 21, 35, 29, 4, -35 },
  { 5854, 21, 27, 29, 4, -27 },
  { 5925, 23, 35, 29, 3, -35 },
  { 6026, 21, 36, 29, 4, -27 },
  { 6121, 21, 35, 29, 4, -35 },
  { 6213, 23, 38, 29, 4, -38 },
  { 6323, 18, 47, 29, 4, -38 },
  { 6429, 23, 35, 29, 4, -35 },
  { 6530, 26, 35, 29, 1, -35 },
  { 6644, 23, 27, 29, 3, -27 },
  { 6722, 21, 27, 29, 4, -27 },
  { 6793, 21, 27, 29, 4, -27 },
  { 6864, 21, 36, 29, 4, -27 },
  { 6959, 21, 36, 29, 4, -27 },
  { 7054, 21, 27, 29, 5, -27 },
  { 7125, 23, 27, 29, 3, -27 },
  { 7203, 23, 34, 29, 2, -34 },
  { 7301, 21, 26, 29, 4, -26 },
  { 7370, 25, 26, 29, 2, -26 },
  { 7452, 27, 26, 29, 1, -26 },
  { 7540, 25, 26, 29, 2, -26 },
  { 7622, 25, 35, 29, 2, -26 },
  { 7732, 21, 26, 29, 4, -26 },
  { 7801, 21, 45, 29, 4, -40 },
  { 7920, 5, 45, 29, 12, -40 },
  { 7949, 21, 45, 29, 4, -40 },
  { 8068, 23, 11, 29, 3, -22 },
};

const GFXfont JetBrainsMono_SemiBold48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_SEMIBOLD48PT7B_H_
