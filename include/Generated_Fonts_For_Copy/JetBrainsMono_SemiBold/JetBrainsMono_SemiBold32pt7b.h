#ifndef _JETBRAINSMONO_SEMIBOLD32PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xEF, 0xFF, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7B, 0x8F, 0x71, 0xE0, 0x07, 0x07, 0x03, 0x83, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0x70, 0xE0, 0x30, 0x71, 0xFF, 0xFE, 0xFF, 0xFF, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x07, 0x01, 0x83, 0x81, 0xC1, 0x80, 0xE0, 0xC3, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x1C, 0x1C, 0x0E, 0x0C, 0x07, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0x81, 0xC1, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x3C, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x79, 0xBE, 0xE3,
  0x3F, 0xC6, 0x7F, 0x8C, 0x07, 0x98, 0x0F, 0xB0, 0x1F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0C, 0xF0, 0x19, 0xE0, 0x31, 0xFC,
  0x67, 0xF8, 0xCF, 0xF9, 0xBE, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x07, 0xE0, 0x1D, 0xFE,
  0x07, 0x30, 0xC1, 0xCE, 0x1C, 0x31, 0xC3, 0x8E, 0x38, 0x73, 0x87, 0x0E,
  0x60, 0x73, 0x9C, 0x0F, 0xF7, 0x00, 0xFD, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x84, 0x00, 0x67, 0xE0, 0x1D, 0xFE, 0x07, 0x38, 0xE0, 0xC6,
  0x1C, 0x38, 0xC3, 0x8E, 0x18, 0x73, 0x83, 0x8E, 0x70, 0x73, 0xDC, 0x0F,
  0xF7, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x83,
  0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x7B, 0xDE, 0x3F, 0xC7, 0xBD, 0xE3,
  0xDE, 0xF0, 0xFE, 0x78, 0x3E, 0x3C, 0x0F, 0x0E, 0x07, 0x87, 0x87, 0xE3,
  0xFF, 0xF8, 0xFF, 0xBC, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60,
  0x3C, 0x1F, 0x87, 0xF1, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7E, 0x07,
  0xF0, 0x7E, 0x03, 0xC0, 0x18, 0x80, 0x38, 0x0F, 0x83, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x0F,
  0x07, 0xC7, 0xE3, 0xF0, 0xF8, 0x38, 0x08, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x0E, 0x1B, 0xE7, 0x3F, 0xFD,
  0x7F, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0xF7, 0x80,
  0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x3C, 0x08, 0x08, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x1E, 0x38, 0xF1, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x23, 0xEF, 0xBF, 0xFB, 0xE0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xCE, 0x7F, 0x9E, 0xFF, 0x3D, 0xFE, 0x73, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0x80, 0xF7, 0x83, 0xCF,
  0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xFF, 0x07, 0xDE,
  0x0F, 0x3C, 0x18, 0x78, 0x20, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDE, 0x03,
  0xFC, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC1, 0xE7,
  0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC1, 0xDE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7B, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xC1, 0xE7, 0x81, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B, 0xC1,
  0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF7, 0xE1, 0xFF, 0xF3, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC1, 0xF7, 0xFF, 0xC7, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xCE, 0x03, 0xDC, 0x07,
  0xB8, 0x0F, 0x78, 0x3C, 0x78, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0x07,
  0xDF, 0x1F, 0x0F, 0x3C, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xF7, 0x83, 0xEF, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0x03, 0x80, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC1, 0xF7, 0xFF, 0xE7, 0xFF, 0x87, 0xEF,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x73, 0xEF, 0xFE, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xCF, 0xBF, 0xFB, 0xE0, 0x1C, 0x3E, 0x3F, 0x3E, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0x3E, 0x3C,
  0x3C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0xE0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x0F,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x0E, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0x3E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3E, 0x3F, 0xE3, 0xFC,
  0x3F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x7E, 0x07, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xC3, 0xE7, 0x80, 0x73, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x73,
  0xF0, 0x7D, 0xF8, 0x7F, 0x7C, 0x38, 0x7E, 0x3C, 0x3F, 0x1E, 0x1F, 0x8F,
  0x0F, 0xC7, 0x87, 0xE3, 0xC3, 0xF1, 0xE1, 0xF8, 0xF0, 0xFC, 0x38, 0xFE,
  0x1F, 0xFF, 0x07, 0xDF, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0xC0, 0x3D, 0xE0,
  0x1E, 0x70, 0x0E, 0x38, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC3, 0x81, 0xC1,
  0xC0, 0xE0, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1C, 0x07, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x1E, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0xB8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7B, 0xFF, 0xCF, 0xFC, 0x3F, 0xFC, 0xE1, 0xFB, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFB, 0xFF,
  0xCF, 0xFC, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83,
  0xEE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x3F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC3, 0xC7, 0xFF, 0x8F, 0xFE, 0x07, 0xF8,
  0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x3E, 0xE0, 0x7F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xB8, 0x7E, 0xFF,
  0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83,
  0xEE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC3, 0xC7, 0xFF, 0x8F, 0xFE, 0x07, 0xF8,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC1, 0xF7, 0xFF, 0xC7, 0xFF,
  0x03, 0xFC, 0x00, 0xE0, 0x3F, 0xC0, 0x7B, 0x81, 0xF7, 0x03, 0xCE, 0x0F,
  0x9C, 0x1E, 0x38, 0x3C, 0x70, 0xF0, 0xE1, 0xE1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x78, 0xE0, 0xF1, 0xC1,
  0xF3, 0x81, 0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xDF, 0xE1, 0xFF,
  0xC7, 0xFD, 0x8F, 0xFB, 0x9B, 0xF7, 0x77, 0xE6, 0xEF, 0xCD, 0x9F, 0x9F,
  0x3F, 0x3E, 0x7E, 0x3C, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0x80,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFB, 0x8F, 0xF7, 0x1F, 0xEF, 0x3F, 0xCE, 0x7F, 0x9C, 0xFF, 0x3D,
  0xFE, 0x3B, 0xFC, 0x77, 0xF8, 0x7F, 0xF0, 0xEF, 0xE1, 0xDF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0x80, 0x03, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC3, 0xC7,
  0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x03,
  0xEE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7B,
  0x87, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7B, 0xC0, 0xF7, 0xC3, 0xCF, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xE1,
  0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x07, 0x70,
  0x0E, 0xE0, 0x3D, 0xC0, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8,
  0x38, 0x78, 0x70, 0xF0, 0xE0, 0xF1, 0xC1, 0xE3, 0x81, 0xE7, 0x03, 0xCE,
  0x07, 0xDC, 0x07, 0xB8, 0x0F, 0x80, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0x83, 0xEE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xEF, 0xFF, 0x8F,
  0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0,
  0x7B, 0xC1, 0xE3, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xF0, 0x07, 0xBC,
  0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x70, 0xF0, 0x38,
  0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0E, 0x07, 0x87, 0x03, 0xC7, 0x80, 0xE3,
  0xC0, 0x71, 0xC0, 0x3C, 0xE0, 0x1E, 0xF0, 0x07, 0x78, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xE1, 0xC3,
  0xF8, 0x78, 0xEE, 0x1E, 0x3B, 0x87, 0x8E, 0xE3, 0x63, 0xB8, 0xD8, 0xEE,
  0x36, 0x3B, 0xCD, 0x8E, 0x73, 0x63, 0x9C, 0xD9, 0xE7, 0x37, 0x71, 0xCC,
  0xDC, 0x77, 0x37, 0x1D, 0x8D, 0xC7, 0x63, 0x71, 0xD8, 0xDC, 0x76, 0x37,
  0x1D, 0x8D, 0xC3, 0xE3, 0x70, 0xF8, 0xF8, 0x3E, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF8, 0x0F, 0xBE, 0x07, 0x8F, 0x07, 0x87, 0xC3, 0xC1, 0xE3,
  0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1D, 0xE0, 0x1E, 0xF0,
  0x0E, 0x3C, 0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0xC0,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xC7, 0x01, 0xE3,
  0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x0F, 0x38, 0x07, 0xBC,
  0x01, 0xDC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x77, 0x00, 0xEF, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x1C, 0x38, 0x38, 0xF0,
  0x79, 0xC0, 0x77, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x3C, 0x1E, 0x1F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0x81,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x3F, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x7F, 0xDE, 0x7F,
  0x3C, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x8F, 0x0E,
  0xFF, 0x3B, 0xFE, 0xFC, 0xFB, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x1E,
  0xFF, 0xFB, 0xBF, 0xCE, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xF3, 0xE7, 0x81, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x01, 0xEF, 0x03, 0xDF, 0x0F, 0x3F, 0xFE,
  0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE1, 0xE3, 0xCF, 0xF7, 0xBF, 0xFF, 0x7C, 0x7E, 0xF0, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3D, 0xE0, 0xFB, 0xC1, 0xF7, 0xFF, 0xE7, 0xFB, 0xC7, 0xE7, 0x80,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x81, 0xDE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x03, 0xDE, 0x0F, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0x01, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x9E, 0x7F, 0xBC, 0xFF, 0xFB,
  0xE3, 0xF7, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7B, 0x80, 0xF7, 0x83, 0xEF, 0x8F, 0xCF, 0xFF, 0x9F, 0xEF,
  0x0F, 0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0xC3, 0xFF, 0x87,
  0xFE, 0x0F, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x8F, 0x0E, 0xFF, 0x3B, 0xFE, 0xF8, 0xFB, 0xC1, 0xEE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFC, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0xF8, 0x0F, 0x70, 0x3E,
  0xE0, 0x79, 0xC1, 0xE3, 0x83, 0xC7, 0x0F, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xF0, 0xE1, 0xE1, 0xC1, 0xE3, 0x83, 0xC7, 0x03, 0xCE, 0x07,
  0xDC, 0x07, 0xB8, 0x07, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0xEE, 0x3D, 0xFE, 0xFF, 0xFF, 0xFF,
  0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7,
  0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7,
  0xE3, 0x8F, 0xC7, 0x1C, 0xE3, 0xC3, 0xBF, 0xCE, 0xFF, 0xBF, 0x3E, 0xF0,
  0x7B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xF0,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xDE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xEF, 0x03, 0xDF, 0x0F, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0xE3, 0xC3,
  0xBF, 0xCE, 0xFF, 0xBF, 0x3E, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x87,
  0xBF, 0xFE, 0xEF, 0xF3, 0x9F, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x0F, 0x1E, 0x7F, 0xBC, 0xFF, 0x7B, 0xE3, 0xF7,
  0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xEF, 0x07, 0xDE, 0x0F, 0xBF, 0xFF, 0x3F, 0xDE,
  0x3F, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xE3, 0xEF, 0x83, 0xDE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F,
  0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0xEE, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xBF, 0xFE, 0x3F, 0xFC, 0x3F, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x01, 0xEF, 0x07, 0x9F, 0x0F, 0x1F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0xF0, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCF,
  0x01, 0xE3, 0x80, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x3C,
  0x0F, 0x1E, 0x03, 0x8F, 0x01, 0xE7, 0x00, 0xF7, 0x80, 0x3B, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xE1, 0xC3, 0xF0, 0xE1,
  0xF8, 0x70, 0xFC, 0x3C, 0x7E, 0x36, 0x3B, 0x9B, 0x1D, 0xCD, 0x8C, 0xE6,
  0xCE, 0x73, 0x67, 0x39, 0xBB, 0x9C, 0xCD, 0xCE, 0xC6, 0xE3, 0xE3, 0x71,
  0xF1, 0xB0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x1E, 0x0F, 0x00, 0x78,
  0x0F, 0xBE, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x81, 0xF3, 0xC0, 0x7B, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0xF7, 0x80, 0xF1, 0xE0, 0x78, 0xF8, 0x78, 0x3C, 0x78, 0x0F, 0x7C,
  0x07, 0xC0, 0xF0, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xC7, 0x81, 0xE3, 0xC1,
  0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x0E, 0x3C, 0x07, 0x9E, 0x03,
  0xDE, 0x00, 0xEF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x03, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F,
  0x07, 0xFC, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0,
  0x0C, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x1F, 0xFE, 0x3F, 0x3C, 0x7E, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 11, 9, 19, 4, -23 },
  { 29, 17, 23, 19, 1, -23 },
  { 78, 15, 32, 19, 2, -28 },
  { 138, 19, 24, 19, 0, -24 },
  { 195, 17, 24, 19, 1, -24 },
  { 246, 3, 9, 19, 8, -23 },
  { 250, 11, 31, 19, 5, -27 },
  { 293, 10, 31, 19, 4, -27 },
  { 332, 17, 17, 19, 1, -20 },
  { 369, 15, 15, 19, 2, -18 },
  { 398, 7, 10, 19, 5, -5 },
  { 407, 11, 3, 19, 4, -12 },
  { 412, 6, 6, 19, 7, -6 },
  { 417, 15, 31, 19, 2, -27 },
  { 476, 15, 24, 19, 2, -24 },
  { 521, 15, 23, 19, 3, -23 },
  { 565, 15, 24, 19, 2, -24 },
  { 610, 15, 23, 19, 2, -23 },
  { 654, 14, 23, 19, 2, -23 },
  { 695, 15, 23, 19, 2, -23 },
  { 739, 15, 23, 19, 2, -23 },
  { 783, 15, 23, 19, 2, -23 },
  { 827, 15, 24, 19, 2, -24 },
  { 872, 15, 24, 19, 2, -24 },
  { 917, 6, 18, 19, 7, -18 },
  { 931, 8, 23, 19, 5, -18 },
  { 954, 15, 17, 19, 2, -19 },
  { 986, 14, 11, 19, 3, -16 },
  { 1006, 15, 17, 19, 2, -19 },
  { 1038, 12, 23, 19, 4, -23 },
  { 1073, 17, 30, 19, 1, -24 },
  { 1137, 17, 23, 19, 1, -23 },
  { 1186, 14, 23, 19, 3, -23 },
  { 1227, 15, 24, 19, 2, -24 },
  { 1272, 14, 23, 19, 3, -23 },
  { 1313, 14, 23, 19, 3, -23 },
  { 1354, 14, 23, 19, 3, -23 },
  { 1395, 15, 24, 19, 2, -24 },
  { 1440, 14, 23, 19, 3, -23 },
  { 1481, 13, 23, 19, 3, -23 },
  { 1519, 15, 23, 19, 1, -23 },
  { 1563, 15, 23, 19, 3, -23 },
  { 1607, 14, 23, 19, 3, -23 },
  { 1648, 15, 23, 19, 2, -23 },
  { 1692, 15, 23, 19, 2, -23 },
  { 1736, 15, 24, 19, 2, -24 },
  { 1781, 15, 23, 19, 3, -23 },
  { 1825, 15, 30, 19, 2, -24 },
  { 1882, 15, 23, 19, 3, -23 },
  { 1926, 15, 24, 19, 2, -24 },
  { 1971, 16, 23, 19, 2, -23 },
  { 2017, 15, 23, 19, 2, -23 },
  { 2061, 17, 23, 19, 1, -23 },
  { 2110, 18, 23, 19, 1, -23 },
  { 2162, 17, 23, 19, 1, -23 },
  { 2211, 17, 23, 19, 1, -23 },
  { 2260, 14, 23, 19, 3, -23 },
  { 2301, 9, 31, 19, 6, -27 },
  { 2336, 15, 31, 19, 2, -27 },
  { 2395, 9, 31, 19, 4, -27 },
  { 2430, 15, 12, 19, 2, -23 },
  { 2453, 15, 3, 19, 2, 1 },
  { 2459, 8, 4, 19, 5, -25 },
  { 2463, 15, 18, 19, 2, -18 },
  { 2497, 14, 23, 19, 3, -23 },
  { 2538, 15, 18, 19, 2, -18 },
  { 2572, 15, 23, 19, 2, -23 },
  { 2616, 15, 18, 19, 2, -18 },
  { 2650, 15, 23, 19, 2, -23 },
  { 2694, 15, 24, 19, 2, -18 },
  { 2739, 14, 23, 19, 3, -23 },
  { 2780, 16, 25, 19, 2, -25 },
  { 2830, 12, 31, 19, 3, -25 },
  { 2877, 15, 23, 19, 3, -23 },
  { 2921, 17, 23, 19, 1, -23 },
  { 2970, 15, 18, 19, 2, -18 },
  { 3004, 14, 18, 19, 3, -18 },
  { 3036, 15, 18, 19, 2, -18 },
  { 3070, 14, 24, 19, 3, -18 },
  { 3112, 15, 24, 19, 2, -18 },
  { 3157, 15, 18, 19, 3, -18 },
  { 3191, 15, 18, 19, 2, -18 },
  { 3225, 16, 23, 19, 1, -23 },
  { 3271, 15, 18, 19, 2, -18 },
  { 3305, 17, 18, 19, 1, -18 },
  { 3344, 17, 18, 19, 1, -18 },
  { 3383, 17, 18, 19, 1, -18 },
  { 3422, 17, 24, 19, 1, -18 },
  { 3473, 14, 18, 19, 3, -18 },
  { 3505, 14, 31, 19, 3, -27 },
  { 3560, 3, 31, 19, 8, -27 },
  { 3572, 14, 31, 19, 3, -27 },
  { 3627, 15, 7, 19, 2, -15 },
};

const GFXfont JetBrainsMono_SemiBold32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_SEMIBOLD32PT7B_H_
