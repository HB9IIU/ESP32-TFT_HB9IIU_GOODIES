#ifndef _JETBRAINSMONO_SEMIBOLD7PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x5F, 0x6F, 0xA0, 0x27, 0xA6, 0xB6, 0x20, 0xDE, 0x27,
  0xB0, 0x64, 0xDA, 0xF0, 0xC0, 0x6A, 0x94, 0x95, 0x58, 0x2F, 0x60, 0x2F,
  0x20, 0xE0, 0xC0, 0xC0, 0x12, 0x22, 0x44, 0x80, 0x69, 0xB9, 0x60, 0xD9,
  0x2E, 0x69, 0x24, 0x70, 0x62, 0x79, 0x60, 0x24, 0x5F, 0x10, 0xF3, 0x9C,
  0x24, 0x79, 0x60, 0xF1, 0x22, 0x40, 0x65, 0x69, 0x60, 0x79, 0x72, 0x40,
  0xC3, 0xC1, 0x80, 0x73, 0x10, 0xE3, 0x80, 0x8F, 0x40, 0xC7, 0x48, 0x7B,
  0xDD, 0xB6, 0x66, 0x67, 0x90, 0xD7, 0x5C, 0xF2, 0x5C, 0xD6, 0xDC, 0xF3,
  0x4E, 0xF3, 0xC8, 0xF3, 0xDC, 0xB7, 0xDA, 0xE9, 0x2E, 0x31, 0x19, 0x60,
  0xBB, 0x6A, 0x92, 0x4E, 0xDF, 0xB9, 0x90, 0xB6, 0xFE, 0xD6, 0xDC, 0xF7,
  0xC8, 0x69, 0x99, 0x63, 0xF7, 0x6A, 0x78, 0x69, 0x60, 0xF2, 0x22, 0x20,
  0xB6, 0xDC, 0x95, 0x66, 0x60, 0xBB, 0xF7, 0x50, 0xD6, 0x26, 0x90, 0x96,
  0x62, 0x20, 0xE9, 0x4E, 0xEA, 0xAC, 0x84, 0x42, 0x22, 0x10, 0xD5, 0x5C,
  0x66, 0x90, 0xF0, 0xC0, 0x63, 0xD7, 0x9A, 0xDC, 0xD6, 0x70, 0x3E, 0xDE,
  0xD7, 0x70, 0x3F, 0x44, 0x40, 0xF6, 0xFE, 0x9A, 0xDA, 0x59, 0x2E, 0x75,
  0x70, 0x97, 0x6A, 0xC4, 0x44, 0x30, 0xFB, 0xBB, 0xD6, 0xD0, 0xD6, 0xE0,
  0xD6, 0xE8, 0xF6, 0xF2, 0xF6, 0x40, 0x74, 0xB7, 0x4F, 0x44, 0x30, 0xB6,
  0xE0, 0x95, 0x66, 0xBB, 0x77, 0xD6, 0x6D, 0x96, 0x62, 0x40, 0xEA, 0x70,
  0x69, 0x44, 0x98, 0xFE, 0x92, 0x39, 0x20, 0xF0,
};

const GFXglyph JetBrainsMono_SemiBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 2, 7, 4, 1, -6 },
  { 19, 2, 7, 4, 1, -6 },
  { 21, 4, 3, 4, 0, -4 },
  { 23, 4, 3, 4, 0, -4 },
  { 25, 2, 2, 4, 1, -1 },
  { 26, 2, 1, 4, 1, -3 },
  { 27, 2, 1, 4, 1, -1 },
  { 28, 4, 7, 4, 0, -6 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 1, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 1, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 2, 5, 4, 1, -4 },
  { 63, 3, 4, 4, 1, -4 },
  { 65, 3, 3, 4, 1, -4 },
  { 67, 3, 4, 4, 1, -4 },
  { 69, 3, 5, 4, 1, -5 },
  { 71, 4, 6, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 3, 5, 4, 1, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 3, 5, 4, 1, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 4, 1, -5 },
  { 98, 3, 5, 4, 1, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 3, 5, 4, 1, -5 },
  { 105, 3, 5, 4, 1, -5 },
  { 107, 3, 5, 4, 1, -5 },
  { 109, 4, 6, 4, 0, -5 },
  { 112, 3, 5, 4, 1, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 3, 5, 4, 1, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 3, 5, 4, 1, -5 },
  { 136, 2, 7, 4, 1, -6 },
  { 138, 4, 7, 4, 0, -6 },
  { 142, 2, 7, 4, 1, -6 },
  { 144, 4, 3, 4, 0, -5 },
  { 146, 4, 1, 4, 0, 0 },
  { 147, 2, 1, 4, 1, -6 },
  { 148, 4, 4, 4, 0, -4 },
  { 150, 3, 5, 4, 1, -5 },
  { 152, 3, 4, 4, 1, -4 },
  { 154, 3, 5, 4, 1, -5 },
  { 156, 3, 4, 4, 1, -4 },
  { 158, 4, 5, 4, 0, -5 },
  { 161, 3, 5, 4, 1, -4 },
  { 163, 3, 5, 4, 1, -5 },
  { 165, 3, 5, 4, 1, -5 },
  { 167, 2, 6, 4, 1, -5 },
  { 169, 3, 5, 4, 1, -5 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 4, 4, 4, 0, -4 },
  { 176, 3, 4, 4, 1, -4 },
  { 178, 3, 4, 4, 1, -4 },
  { 180, 3, 5, 4, 1, -4 },
  { 182, 3, 5, 4, 1, -4 },
  { 184, 3, 4, 4, 1, -4 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 4, 5, 4, 0, -5 },
  { 191, 3, 4, 4, 1, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 4, 5, 4, 0, -4 },
  { 202, 3, 4, 4, 1, -4 },
  { 204, 3, 7, 4, 1, -6 },
  { 207, 1, 7, 4, 2, -6 },
  { 208, 3, 7, 4, 1, -6 },
  { 211, 4, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_SemiBold7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_SEMIBOLD7PT7B_H_
