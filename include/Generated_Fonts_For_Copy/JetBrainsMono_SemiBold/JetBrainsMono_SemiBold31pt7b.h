#ifndef _JETBRAINSMONO_SEMIBOLD31PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xEF, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1D, 0xE3,
  0xBC, 0x77, 0x8E, 0xF1, 0xDC, 0x38, 0x07, 0x06, 0x03, 0x87, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0x60, 0xC0, 0x30, 0x61, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0x86, 0x0E, 0x03, 0x06, 0x03, 0x83, 0x01, 0xC3, 0x80, 0xE1, 0xC0,
  0x70, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x1C, 0x18, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0x87, 0x01, 0x83, 0x01, 0xC1, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xBE, 0x73, 0x3D,
  0xE6, 0x3B, 0xCC, 0x07, 0x98, 0x07, 0xB0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x0C, 0xF0, 0x18, 0xF0, 0x31, 0xFE, 0x63,
  0xFC, 0xC7, 0xFD, 0x9E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xEF, 0xE0, 0x39, 0xFE,
  0x0E, 0x70, 0xC1, 0x8E, 0x18, 0x71, 0xC3, 0x1C, 0x38, 0x63, 0x03, 0x1C,
  0xE0, 0x7F, 0xB8, 0x07, 0xEE, 0x00, 0x21, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x3E, 0x00, 0xEF, 0xE0, 0x3B, 0xCE, 0x06, 0x70, 0xC1, 0xCE,
  0x18, 0x71, 0xC3, 0x1C, 0x38, 0xE3, 0x07, 0x9C, 0xE0, 0x7F, 0x38, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0x8F, 0x83, 0x83, 0xC1,
  0xC1, 0xE0, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x17, 0xB8, 0x77, 0x9E, 0x7B, 0xC7, 0xB9, 0xE1, 0xFC, 0xF0,
  0xFC, 0x78, 0x3E, 0x3C, 0x1F, 0x0F, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0x78,
  0x7E, 0x1E, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x00, 0xC0, 0xF0, 0x7C, 0x3F,
  0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x01, 0xC0, 0x10, 0x80, 0x70, 0x3E,
  0x1F, 0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x3F, 0x3F, 0x1F, 0x0E, 0x04, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x04, 0x1C, 0x13, 0x8C, 0x7B, 0xF6, 0xFC, 0xFD, 0xFF,
  0x0F, 0xF8, 0x01, 0xE0, 0x01, 0xD8, 0x01, 0xEE, 0x01, 0xE7, 0x80, 0xF1,
  0xE0, 0xF0, 0x70, 0x10, 0x30, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x78,
  0xF3, 0xE7, 0x8F, 0x1C, 0x78, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x79,
  0xFF, 0xDF, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9F, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x39, 0xFD, 0xE7, 0xF7, 0x9F, 0xCC, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xDE, 0x0F, 0x7F, 0xF8, 0xFF,
  0xC0, 0xFE, 0x00, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xE0, 0xF3, 0x83,
  0x8E, 0x0C, 0x38, 0x20, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1,
  0xFF, 0xE3, 0xE7, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x7F, 0x81,
  0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xC0, 0x7F,
  0x03, 0xFE, 0x1F, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC3, 0xDE, 0x0F, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x73, 0xE1, 0xDF, 0xC7, 0xFF, 0x9F, 0x1F, 0x78,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0x03, 0xDE,
  0x0F, 0x7F, 0xF8, 0xFF, 0xE1, 0xFE, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x7B, 0xC1, 0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x73, 0xC1, 0xE7, 0xFF, 0x87, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFE, 0x07, 0xBC, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1F, 0x70, 0x3F, 0xC0, 0xF7, 0x03, 0xDC,
  0x0F, 0x78, 0x38, 0xF3, 0xE1, 0xFF, 0x03, 0xF8, 0x3F, 0xF1, 0xF1, 0xE7,
  0x83, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDE, 0x0F, 0x7F, 0xFC,
  0xFF, 0xE1, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0xE1, 0xFF, 0xE3, 0xE3, 0xEF,
  0x03, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0xF3, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x79, 0xFF, 0xDF, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xFF, 0xDF,
  0x78, 0x3E, 0x7D, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE7, 0xCF, 0x1E, 0x78, 0xF1, 0xE3, 0x8F, 0x1C, 0x00, 0x00, 0x04, 0x00,
  0x30, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x07, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x1C, 0x00, 0xF0, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x3C,
  0x00, 0xC0, 0x00, 0xF8, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x3F, 0xE3, 0xFC, 0x3F, 0x83, 0x80,
  0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x07, 0xC0,
  0x3C, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0x81, 0xE7, 0x80,
  0x73, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0xFB, 0xF0, 0xFD, 0xF8,
  0xF1, 0xFC, 0x70, 0xFE, 0x38, 0x3F, 0x1C, 0x1F, 0x8E, 0x0F, 0xC7, 0x07,
  0xE3, 0x83, 0xF1, 0xC3, 0xF8, 0xF1, 0xFC, 0x3F, 0x7E, 0x0F, 0xBF, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x0E, 0x38,
  0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x3C, 0x1C, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0x7E, 0xE0, 0x7B, 0x80,
  0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0x83, 0xCF, 0xFE, 0x3F, 0xF8, 0xFF,
  0xF3, 0x81, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x3E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF,
  0x9F, 0x1F, 0x78, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x77, 0x03, 0xDE, 0x0F, 0x7F, 0xF8, 0xFF, 0xE0, 0xFE, 0x00,
  0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xBF, 0xFE, 0xF0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x3F, 0xFF,
  0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF,
  0xEF, 0xFF, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0x1F, 0x78, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x03, 0xDE, 0x0F, 0x7F, 0xF8, 0xFF, 0xE0,
  0xFE, 0x00, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x73, 0xC1, 0xE7, 0xFF, 0xC7, 0xFF, 0x07,
  0xF8, 0x00, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0x8D, 0xFB, 0x1B, 0xF6, 0x77, 0xEE, 0xCF, 0xCD, 0x9F,
  0x9F, 0x7F, 0x3E, 0xFE, 0x79, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0x80, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xB8, 0x7E,
  0xE1, 0xFF, 0x87, 0xF7, 0x1F, 0xDC, 0x7F, 0x71, 0xFC, 0xE7, 0xF3, 0x9F,
  0xCE, 0x7F, 0x1D, 0xFC, 0x77, 0xF1, 0xDF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xC0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F,
  0x1F, 0x78, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x77, 0x03, 0xDE, 0x1F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0xE3, 0xFF, 0xF7, 0xFF, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F,
  0xFE, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xE3, 0xE7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1D,
  0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78,
  0x0E, 0xF0, 0x1D, 0xE0, 0x3B, 0xC0, 0xF3, 0xC3, 0xE7, 0xFF, 0x87, 0xFE,
  0x03, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xDE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xC1, 0xF7, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFC, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0xF3,
  0xC1, 0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x80, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x03, 0xDE, 0x03, 0xBC, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xE7,
  0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77,
  0x03, 0xDE, 0x1F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xF0, 0x07, 0xF0,
  0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x38, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x0E,
  0x38, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0x70, 0xFC, 0x78, 0x7E, 0x3C, 0x3F, 0x1B, 0x3B, 0x8D, 0x9D, 0xC6, 0xCE,
  0xE3, 0x67, 0x39, 0xB3, 0x9C, 0xD9, 0xCE, 0xCC, 0xE7, 0x66, 0x73, 0xB3,
  0x39, 0xD8, 0xD8, 0xEC, 0x6C, 0x76, 0x3E, 0x3B, 0x1F, 0x1D, 0x8F, 0x86,
  0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0xF0, 0x0F, 0x3C, 0x07,
  0x9E, 0x07, 0x87, 0x83, 0xC1, 0xC3, 0xC0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x0F, 0x0F,
  0x07, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3E, 0xF0, 0x07, 0xF8,
  0x03, 0x9E, 0x03, 0xCF, 0x01, 0xC3, 0x81, 0xE1, 0xE0, 0xE0, 0x70, 0xF0,
  0x3C, 0x70, 0x0E, 0x78, 0x07, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x1F,
  0x00, 0x7C, 0x03, 0xB0, 0x0E, 0xE0, 0x73, 0x81, 0xC7, 0x0F, 0x1C, 0x38,
  0x78, 0xE0, 0xE7, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF8, 0x3C, 0x1C, 0x1F, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0x9E, 0x0F, 0x70,
  0x3C, 0x00, 0x70, 0x01, 0xC7, 0xFF, 0x7F, 0xFF, 0xE0, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0xDD, 0xDF, 0xF7, 0x3F, 0x9C, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3F, 0x3D, 0xFE,
  0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x0F, 0xFF, 0xFB, 0xDF,
  0xEF, 0x3F, 0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0x9E, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x07,
  0xF0, 0x3D, 0xE0, 0xF7, 0xFF, 0x8F, 0xFE, 0x0F, 0xE0, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x71, 0xF9, 0xCF, 0xF7, 0x7F,
  0xDD, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1F, 0x7F, 0xDC, 0xFF, 0x71,
  0xF9, 0xC0, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0xF7, 0xFF, 0x8F, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x1F, 0xBC, 0xFF, 0x77, 0xFD, 0xDE, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC,
  0x0F, 0x7C, 0x7D, 0xFF, 0x73, 0xFD, 0xC3, 0xC7, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x3F, 0x1F, 0xF8, 0x7F, 0xC1, 0xF8, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3F, 0x3D, 0xFE, 0xFF,
  0xFB, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0x80, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x0F, 0x70, 0x3C, 0xE0,
  0x79, 0xC1, 0xE3, 0x87, 0xC7, 0x0F, 0x0E, 0x3C, 0x1F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xE0, 0xE3, 0xE1, 0xC3, 0xC3, 0x83, 0xC7, 0x07, 0x8E, 0x07, 0x9C,
  0x07, 0xB8, 0x0F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xEF, 0x7D, 0xFE, 0xFB, 0xDF, 0x7F, 0x1C, 0x7E, 0x38, 0xFC,
  0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C,
  0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8E, 0xF3, 0xF3,
  0xDF, 0xEF, 0xFF, 0xBE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1C, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3D, 0xE1, 0xF7, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xF3, 0xF3,
  0xDF, 0xEF, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xBD, 0xFE, 0xF3, 0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x1F, 0x9C, 0xFF, 0x77, 0xFD, 0xDE, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3D, 0xE1, 0xF7, 0xFD, 0xCF, 0xF7, 0x1F, 0x9C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xE7, 0xE3, 0xBF, 0xEE,
  0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1, 0xE7, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0xEF, 0x01, 0xFE, 0x07, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0x70, 0x3D, 0xE1, 0xF7, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xF0, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C,
  0x1C, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0x70,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xE1, 0xC3, 0xF0, 0xE1,
  0xF8, 0xF0, 0xDC, 0x78, 0xEE, 0x34, 0x73, 0x9B, 0x39, 0xCD, 0x9C, 0xE6,
  0xCE, 0x72, 0x67, 0x3B, 0x33, 0x1D, 0x9B, 0x86, 0xC7, 0xC3, 0x63, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x00, 0x78, 0x0F, 0x3C,
  0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E,
  0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78,
  0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x0E,
  0x38, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x7F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFF,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x1E, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00,
  0x7E, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x1E, 0xFE, 0x3F, 0xDC, 0x3F, 0x80,
  0x08, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 11, 10, 19, 4, -23 },
  { 30, 17, 23, 19, 1, -23 },
  { 79, 15, 31, 19, 2, -27 },
  { 138, 19, 23, 19, 0, -23 },
  { 193, 17, 23, 19, 1, -23 },
  { 242, 4, 10, 19, 7, -23 },
  { 247, 10, 30, 19, 5, -26 },
  { 285, 9, 30, 19, 4, -26 },
  { 319, 17, 16, 19, 1, -19 },
  { 353, 15, 15, 19, 2, -18 },
  { 382, 7, 10, 19, 5, -5 },
  { 391, 10, 3, 19, 4, -12 },
  { 395, 6, 5, 19, 6, -5 },
  { 399, 15, 29, 19, 2, -26 },
  { 454, 14, 23, 19, 2, -23 },
  { 495, 14, 23, 19, 3, -23 },
  { 536, 15, 23, 19, 2, -23 },
  { 580, 14, 23, 19, 2, -23 },
  { 621, 14, 23, 19, 2, -23 },
  { 662, 14, 23, 19, 2, -23 },
  { 703, 15, 23, 19, 2, -23 },
  { 747, 15, 23, 19, 2, -23 },
  { 791, 14, 23, 19, 2, -23 },
  { 832, 15, 23, 19, 2, -23 },
  { 876, 6, 17, 19, 6, -17 },
  { 889, 7, 22, 19, 5, -17 },
  { 909, 14, 17, 19, 2, -19 },
  { 939, 13, 11, 19, 3, -16 },
  { 957, 14, 17, 19, 2, -19 },
  { 987, 12, 23, 19, 4, -23 },
  { 1022, 17, 29, 19, 1, -23 },
  { 1084, 16, 23, 19, 1, -23 },
  { 1130, 14, 23, 19, 3, -23 },
  { 1171, 14, 23, 19, 2, -23 },
  { 1212, 14, 23, 19, 2, -23 },
  { 1253, 13, 23, 19, 3, -23 },
  { 1291, 13, 23, 19, 3, -23 },
  { 1329, 14, 23, 19, 2, -23 },
  { 1370, 13, 23, 19, 3, -23 },
  { 1408, 13, 23, 19, 3, -23 },
  { 1446, 15, 23, 19, 1, -23 },
  { 1490, 16, 23, 19, 2, -23 },
  { 1536, 14, 23, 19, 3, -23 },
  { 1577, 15, 23, 19, 2, -23 },
  { 1621, 14, 23, 19, 2, -23 },
  { 1662, 14, 23, 19, 2, -23 },
  { 1703, 15, 23, 19, 2, -23 },
  { 1747, 15, 29, 19, 2, -23 },
  { 1802, 15, 23, 19, 2, -23 },
  { 1846, 15, 23, 19, 2, -23 },
  { 1890, 16, 23, 19, 1, -23 },
  { 1936, 14, 23, 19, 2, -23 },
  { 1977, 16, 23, 19, 1, -23 },
  { 2023, 17, 23, 19, 1, -23 },
  { 2072, 17, 23, 19, 1, -23 },
  { 2121, 17, 23, 19, 1, -23 },
  { 2170, 13, 23, 19, 3, -23 },
  { 2208, 8, 29, 19, 6, -26 },
  { 2237, 15, 29, 19, 2, -26 },
  { 2292, 9, 29, 19, 4, -26 },
  { 2325, 14, 12, 19, 2, -23 },
  { 2346, 15, 3, 19, 2, 1 },
  { 2352, 8, 4, 19, 5, -24 },
  { 2356, 14, 17, 19, 2, -17 },
  { 2386, 14, 23, 19, 2, -23 },
  { 2427, 14, 17, 19, 2, -17 },
  { 2457, 14, 23, 19, 2, -23 },
  { 2498, 14, 17, 19, 2, -17 },
  { 2528, 15, 23, 19, 2, -23 },
  { 2572, 14, 23, 19, 2, -17 },
  { 2613, 14, 23, 19, 2, -23 },
  { 2654, 15, 24, 19, 2, -24 },
  { 2699, 12, 30, 19, 3, -24 },
  { 2744, 15, 23, 19, 3, -23 },
  { 2788, 16, 23, 19, 1, -23 },
  { 2834, 15, 17, 19, 2, -17 },
  { 2866, 14, 17, 19, 2, -17 },
  { 2896, 14, 17, 19, 2, -17 },
  { 2926, 14, 23, 19, 2, -17 },
  { 2967, 14, 23, 19, 2, -17 },
  { 3008, 14, 17, 19, 3, -17 },
  { 3038, 15, 17, 19, 2, -17 },
  { 3070, 15, 22, 19, 1, -22 },
  { 3112, 14, 17, 19, 2, -17 },
  { 3142, 16, 17, 19, 1, -17 },
  { 3176, 17, 17, 19, 1, -17 },
  { 3213, 16, 17, 19, 1, -17 },
  { 3247, 16, 23, 19, 1, -17 },
  { 3293, 13, 17, 19, 3, -17 },
  { 3321, 13, 29, 19, 3, -26 },
  { 3369, 4, 29, 19, 7, -26 },
  { 3384, 13, 29, 19, 3, -26 },
  { 3432, 15, 7, 19, 2, -14 },
};

const GFXfont JetBrainsMono_SemiBold31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_SEMIBOLD31PT7B_H_
