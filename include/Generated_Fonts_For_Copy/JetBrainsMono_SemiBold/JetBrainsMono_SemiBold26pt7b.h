#ifndef _JETBRAINSMONO_SEMIBOLD26PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x60, 0x00, 0xFF, 0xF0, 0xF3,
  0xF9, 0xFC, 0xFE, 0x76, 0x3B, 0x1D, 0x8E, 0xC7, 0x0E, 0x38, 0x30, 0xC0,
  0xC3, 0x03, 0x0C, 0x0C, 0x31, 0xFF, 0xF7, 0xFF, 0xC6, 0x18, 0x18, 0x60,
  0x61, 0x81, 0x8E, 0x0E, 0x38, 0xFF, 0xFB, 0xFF, 0xE3, 0x0C, 0x0C, 0x30,
  0x71, 0xC1, 0xC7, 0x06, 0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x1F, 0x87, 0xFC, 0x7F, 0xEE, 0x6F, 0xE6, 0x7E, 0x60, 0xF6, 0x07, 0xE0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x06, 0x70, 0x67, 0xE6, 0x7E, 0x67,
  0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C,
  0x07, 0x7E, 0x0E, 0xE7, 0x0C, 0xE3, 0x18, 0xE3, 0x30, 0xE3, 0x70, 0x77,
  0x60, 0x7E, 0xC0, 0x19, 0xC0, 0x01, 0x80, 0x03, 0x10, 0x07, 0x7C, 0x06,
  0xEE, 0x0C, 0xC6, 0x18, 0xC6, 0x38, 0xC6, 0x30, 0xC6, 0x60, 0xFE, 0xE0,
  0x7C, 0x1F, 0x80, 0xFF, 0x83, 0x9E, 0x1C, 0x38, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x3C, 0x01, 0xF8, 0x1F, 0x73, 0xB9, 0xEE, 0xE3, 0xF3,
  0x87, 0xCE, 0x0E, 0x38, 0x38, 0x73, 0xF1, 0xFE, 0xE3, 0xF3, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0x83, 0xC3, 0xE3, 0xE3, 0xC1, 0xC1, 0xC0, 0xE0, 0x70,
  0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0x80, 0x80, 0xE0, 0xF8, 0x7C, 0x1C,
  0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0x0E, 0x1E, 0x3C, 0xF8, 0xF0, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0xE3, 0x3B, 0xED, 0xF7, 0xFF, 0x80, 0xC0, 0x07, 0x80,
  0x37, 0x01, 0xCE, 0x0E, 0x3C, 0x38, 0x60, 0x41, 0x00, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0xE7, 0x9E, 0x71, 0xCE, 0x38, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFE, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x79, 0xEE,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xEE, 0x7E, 0xE7, 0xEE, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x79, 0xE7, 0xFC, 0x3F, 0x80,
  0x0F, 0x03, 0xF0, 0x7F, 0x0F, 0x70, 0xE7, 0x08, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0,
  0xFE, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xF8, 0x0F, 0xC0,
  0x3E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0xE0, 0xFE, 0x0E, 0xF9, 0xE7,
  0xFC, 0x3F, 0x80, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07,
  0x01, 0xC0, 0x78, 0xEE, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xFC, 0xFF, 0xEF, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0xE0, 0x7E, 0x0E, 0xFB, 0xE7, 0xFC, 0x3F, 0x80, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x38, 0x7F,
  0xCF, 0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF9,
  0xE7, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0xEE,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x00, 0x3F, 0x87, 0xFC,
  0x79, 0xEE, 0x0E, 0xE0, 0xFE, 0x0E, 0xF0, 0xE7, 0x9E, 0x3F, 0x81, 0xF8,
  0x7F, 0xCF, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xF9, 0xE7, 0xFE,
  0x3F, 0x80, 0x1F, 0x87, 0xFC, 0xF9, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0xFF, 0xFE, 0x7F, 0xE1, 0xDC, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x00, 0x23, 0xFE, 0xF3, 0x00, 0x00,
  0x00, 0x00, 0xE7, 0xFD, 0xE0, 0x10, 0xF7, 0xCF, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x3C, 0xE7, 0x9C, 0x71, 0x8E, 0x00, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x0C, 0x00, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0x01, 0xF0, 0x7E, 0x3F, 0x0F, 0xC0,
  0xF0, 0x0C, 0x00, 0xFE, 0x3F, 0xCF, 0xF8, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x3F, 0x8F, 0xE3, 0xE0, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x1F, 0x03, 0x80, 0x0F, 0xE0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0xE0, 0x1F,
  0x80, 0x7E, 0x1D, 0xF0, 0xFB, 0xC7, 0x3F, 0x1C, 0x7C, 0x71, 0xF1, 0xC7,
  0xC7, 0x1F, 0x1C, 0x7C, 0x71, 0xF1, 0xEF, 0xC3, 0xEF, 0x82, 0x4E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x0D, 0xC0, 0x77, 0x01, 0xCC, 0x07, 0x38, 0x1C,
  0xE0, 0xE3, 0x83, 0x86, 0x0E, 0x1C, 0x3F, 0xF1, 0xFF, 0xC7, 0x07, 0x1C,
  0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x03, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xFC, 0xE1, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF, 0xFE, 0xFF, 0x80,
  0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7E, 0x0F,
  0x7B, 0xE7, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x7F,
  0xEF, 0x0F, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0x79, 0xE7, 0xFC, 0x1F,
  0x80, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x79, 0xE7, 0xFE,
  0x1F, 0x80, 0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3,
  0x8E, 0x1C, 0x70, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xC7, 0x0E, 0x3C, 0x70,
  0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xF7, 0x03, 0xB8, 0x1E, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1B, 0xD9, 0xBD, 0x9B, 0xDB, 0xFD, 0xF7,
  0xCF, 0x7C, 0xF7, 0xCE, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x70, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0xC7, 0xEC, 0x7E, 0xC7, 0xEE, 0x7E, 0x67, 0xE6, 0x7E, 0x77, 0xE3,
  0x7E, 0x37, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xF0, 0x1F, 0x87,
  0xFC, 0x7B, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x7B, 0xE7,
  0xFC, 0x1F, 0x80, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC0, 0xEE, 0x07, 0x70,
  0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0xF7, 0xFF, 0x3F, 0xF1, 0xFC, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x1F, 0x87,
  0xFC, 0x7B, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x7B, 0xE7,
  0xFC, 0x1F, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xFF, 0x8F,
  0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE1, 0xEF,
  0xFE, 0xFF, 0x8E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE,
  0x0F, 0xE0, 0x70, 0x1F, 0x87, 0xFC, 0x7B, 0xEE, 0x0F, 0xE0, 0x7E, 0x00,
  0xF0, 0x07, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x70, 0x07,
  0xE0, 0x7E, 0x07, 0xFB, 0xE7, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFF, 0x0E, 0x7B, 0xE7, 0xFC, 0x3F, 0x80, 0xE0, 0x3F, 0x80, 0xE7,
  0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60,
  0xE3, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x77, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xE3, 0x8E, 0xC7, 0x1D, 0x8E, 0x3B,
  0x1E, 0x77, 0x3C, 0xEE, 0x79, 0xDC, 0xB3, 0x39, 0x66, 0x76, 0xCC, 0xEC,
  0x98, 0xD9, 0x31, 0xB2, 0xE3, 0x67, 0xC6, 0xCF, 0x8D, 0x1F, 0x1A, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0xF0, 0x39, 0xC1, 0xE7, 0x87, 0x0E,
  0x3C, 0x1C, 0xE0, 0x77, 0x80, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xF0, 0x1D, 0xC0, 0x73, 0x83, 0x8E, 0x0E, 0x1C, 0x70, 0x71,
  0xC0, 0xEE, 0x03, 0xC0, 0xE0, 0x1F, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x38,
  0x70, 0xE3, 0x81, 0xCE, 0x07, 0x70, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x3F, 0xFF, 0xFE, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xF8, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xB8, 0x39,
  0x83, 0x9C, 0x71, 0xC7, 0x0E, 0x60, 0xEE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x70, 0x78, 0x04, 0x03, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0xF0, 0x07, 0x00,
  0x77, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xFF, 0xF7, 0x7E,
  0x70, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE2, 0x0E, 0xFC, 0xFF, 0xEF,
  0x1E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x0E, 0xF9, 0xEF, 0xFE, 0xEF, 0xC0, 0x04, 0x03, 0xFC, 0x7F, 0xEF, 0x1E,
  0xE0, 0xFE, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7E, 0x0F,
  0x79, 0xE7, 0xFC, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08,
  0x73, 0xF7, 0x7F, 0x7F, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF9, 0x77, 0xF7, 0x3E, 0x70, 0x04, 0x03,
  0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0E, 0x07, 0x71, 0xE7, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1E, 0x00, 0xE0, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x08, 0x03, 0xFF, 0x7F, 0x7F, 0x1F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0xF7, 0x7F, 0x73,
  0xEF, 0x00, 0xF0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xC3, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE2, 0x0E, 0xFC, 0xFF, 0xEF, 0x1E, 0xE0, 0xEE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC1,
  0xEF, 0xFB, 0xFC, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x3B, 0x83, 0x9C, 0x3C, 0xE1, 0xC7, 0x1E, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF8, 0x71, 0xC3, 0x87, 0x1C, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x1E,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0x04, 0x27, 0xF7, 0xBF, 0xFF,
  0xC6, 0x7E, 0x33, 0xF1, 0x9F, 0x8C, 0xFC, 0x67, 0xE3, 0x3F, 0x19, 0xF8,
  0xCF, 0xC6, 0x7E, 0x33, 0xF1, 0x9F, 0x8C, 0xE0, 0x02, 0x0E, 0xFC, 0xFF,
  0xEF, 0x1E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x06, 0x03, 0xFC, 0x7F, 0xEF,
  0x1E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0x7B, 0xE7, 0xFC, 0x1F, 0x80, 0x02, 0x0E, 0xFC, 0xFF, 0xEF, 0x1E,
  0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0E,
  0xF9, 0xEF, 0xFE, 0xEF, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x08, 0x03, 0xF7, 0x7F, 0x7F, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF9, 0x77, 0xF7, 0x3E, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x02, 0x1B, 0xFB, 0x7F, 0x78, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x06, 0x03, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x0E, 0x00,
  0x7E, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0x00, 0x7E, 0x07, 0xF1, 0xF7, 0xFE,
  0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xFC,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF0,
  0xE7, 0xBE, 0x7F, 0xC1, 0xF8, 0xE0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xE3,
  0x87, 0x1C, 0x38, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0xEE, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x03, 0xC0, 0xC7, 0x1F, 0x1C, 0x7E, 0x71, 0xF9, 0xE6, 0xE5,
  0x99, 0x96, 0x66, 0x59, 0x9B, 0x2E, 0x6C, 0xB9, 0xF3, 0xC7, 0xCF, 0x1E,
  0x3C, 0x38, 0xF0, 0xE3, 0xC0, 0xF0, 0x78, 0xE1, 0xC3, 0xCE, 0x07, 0x78,
  0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x83, 0xCE,
  0x0E, 0x1C, 0x70, 0x7B, 0xC0, 0xF0, 0xF0, 0x3D, 0xC0, 0xE7, 0x07, 0x8E,
  0x1C, 0x38, 0x70, 0xF3, 0x81, 0xCE, 0x07, 0x38, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x3F, 0x03, 0xF0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xF0, 0xFC, 0x0F, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0xF0,
  0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xFF, 0x03, 0xF0, 0xFF, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFC, 0x0F,
  0x80, 0xF0, 0x00, 0x3C, 0x1B, 0xF0, 0xFD, 0xC7, 0xC7, 0xFE, 0x1F, 0x00,
  0x70,
};

const GFXglyph JetBrainsMono_SemiBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 9, 8, 16, 3, -19 },
  { 20, 14, 19, 16, 1, -19 },
  { 54, 12, 27, 16, 2, -23 },
  { 95, 16, 19, 16, 0, -19 },
  { 133, 14, 19, 16, 1, -19 },
  { 167, 3, 8, 16, 6, -19 },
  { 170, 9, 25, 16, 4, -22 },
  { 199, 8, 25, 16, 3, -22 },
  { 224, 14, 14, 16, 1, -16 },
  { 249, 12, 13, 16, 2, -15 },
  { 269, 6, 8, 16, 4, -4 },
  { 275, 8, 3, 16, 4, -10 },
  { 278, 5, 4, 16, 5, -4 },
  { 281, 12, 25, 16, 2, -22 },
  { 319, 12, 19, 16, 2, -19 },
  { 348, 12, 19, 16, 2, -19 },
  { 377, 12, 19, 16, 2, -19 },
  { 406, 12, 19, 16, 2, -19 },
  { 435, 11, 19, 16, 2, -19 },
  { 462, 12, 19, 16, 2, -19 },
  { 491, 12, 19, 16, 2, -19 },
  { 520, 12, 19, 16, 2, -19 },
  { 549, 12, 19, 16, 2, -19 },
  { 578, 12, 19, 16, 2, -19 },
  { 607, 5, 15, 16, 5, -15 },
  { 617, 6, 19, 16, 4, -15 },
  { 632, 12, 14, 16, 2, -16 },
  { 653, 11, 9, 16, 2, -13 },
  { 666, 12, 14, 16, 2, -16 },
  { 687, 10, 19, 16, 3, -19 },
  { 711, 14, 24, 16, 1, -19 },
  { 753, 14, 19, 16, 1, -19 },
  { 787, 12, 19, 16, 2, -19 },
  { 816, 12, 19, 16, 2, -19 },
  { 845, 12, 19, 16, 2, -19 },
  { 874, 12, 19, 16, 2, -19 },
  { 903, 12, 19, 16, 2, -19 },
  { 932, 12, 19, 16, 2, -19 },
  { 961, 12, 19, 16, 2, -19 },
  { 990, 11, 19, 16, 2, -19 },
  { 1017, 12, 19, 16, 1, -19 },
  { 1046, 13, 19, 16, 2, -19 },
  { 1077, 11, 19, 16, 3, -19 },
  { 1104, 12, 19, 16, 2, -19 },
  { 1133, 12, 19, 16, 2, -19 },
  { 1162, 12, 19, 16, 2, -19 },
  { 1191, 13, 19, 16, 2, -19 },
  { 1222, 12, 24, 16, 2, -19 },
  { 1258, 12, 19, 16, 2, -19 },
  { 1287, 12, 19, 16, 2, -19 },
  { 1316, 13, 19, 16, 1, -19 },
  { 1347, 12, 19, 16, 2, -19 },
  { 1376, 14, 19, 16, 1, -19 },
  { 1410, 15, 19, 16, 0, -19 },
  { 1446, 14, 19, 16, 1, -19 },
  { 1480, 14, 19, 16, 1, -19 },
  { 1514, 12, 19, 16, 2, -19 },
  { 1543, 7, 25, 16, 5, -22 },
  { 1565, 12, 25, 16, 2, -22 },
  { 1603, 7, 25, 16, 4, -22 },
  { 1625, 12, 10, 16, 2, -19 },
  { 1640, 12, 2, 16, 2, 1 },
  { 1643, 7, 3, 16, 4, -20 },
  { 1646, 12, 15, 16, 2, -15 },
  { 1669, 12, 19, 16, 2, -19 },
  { 1698, 12, 15, 16, 2, -15 },
  { 1721, 12, 19, 16, 2, -19 },
  { 1750, 12, 15, 16, 2, -15 },
  { 1773, 13, 19, 16, 1, -19 },
  { 1804, 12, 20, 16, 2, -15 },
  { 1834, 12, 19, 16, 2, -19 },
  { 1863, 12, 20, 16, 2, -20 },
  { 1893, 10, 25, 16, 2, -20 },
  { 1925, 13, 19, 16, 2, -19 },
  { 1956, 13, 19, 16, 1, -19 },
  { 1987, 13, 15, 16, 1, -15 },
  { 2012, 12, 15, 16, 2, -15 },
  { 2035, 12, 15, 16, 2, -15 },
  { 2058, 12, 20, 16, 2, -15 },
  { 2088, 12, 20, 16, 2, -15 },
  { 2118, 11, 15, 16, 3, -15 },
  { 2139, 12, 15, 16, 2, -15 },
  { 2162, 13, 18, 16, 1, -18 },
  { 2192, 12, 14, 16, 2, -14 },
  { 2213, 13, 14, 16, 1, -14 },
  { 2236, 14, 14, 16, 1, -14 },
  { 2261, 14, 14, 16, 1, -14 },
  { 2286, 14, 19, 16, 1, -14 },
  { 2320, 12, 14, 16, 2, -14 },
  { 2341, 12, 25, 16, 2, -22 },
  { 2379, 3, 25, 16, 6, -22 },
  { 2389, 12, 25, 16, 2, -22 },
  { 2427, 13, 6, 16, 1, -12 },
};

const GFXfont JetBrainsMono_SemiBold26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_SEMIBOLD26PT7B_H_
