#ifndef _JETBRAINSMONO_SEMIBOLD10PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x8C, 0xF9, 0x90, 0x28, 0xF4, 0x92, 0xF9, 0x45, 0x00, 0x22,
  0xFB, 0xA7, 0x3B, 0xF2, 0xEE, 0xAF, 0x08, 0x3D, 0x59, 0xC0, 0x79, 0x06,
  0x1B, 0xDB, 0x67, 0xC0, 0xF8, 0x7A, 0x49, 0x26, 0x60, 0xCC, 0x92, 0x4B,
  0xC0, 0x31, 0xAF, 0xCC, 0x48, 0x66, 0xF6, 0x60, 0xEA, 0xF0, 0xF0, 0x13,
  0x22, 0x64, 0x48, 0x80, 0xF9, 0x9F, 0x99, 0xF0, 0xEA, 0x22, 0x22, 0xF0,
  0xF9, 0x13, 0x6C, 0xF0, 0xF2, 0x61, 0x19, 0xF0, 0x36, 0x49, 0xFF, 0x10,
  0xF8, 0xE9, 0x19, 0xF0, 0x64, 0xE9, 0x99, 0xF0, 0xF9, 0x12, 0x24, 0x40,
  0xF9, 0x96, 0x99, 0xF0, 0xF9, 0x9F, 0x32, 0x40, 0xB0, 0xB0, 0xB0, 0xEA,
  0x16, 0x8C, 0x30, 0xF0, 0xF0, 0x86, 0x13, 0xC0, 0xF1, 0x16, 0x40, 0x40,
  0x7B, 0x19, 0xE9, 0xA6, 0xB9, 0x10, 0x30, 0x30, 0xC3, 0x12, 0x79, 0x2C,
  0xC0, 0xF9, 0x9F, 0x99, 0xF0, 0xF9, 0x88, 0x89, 0xF0, 0xF9, 0x99, 0x99,
  0xF0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0xF9, 0x8B, 0x99,
  0xF0, 0x99, 0x9F, 0x99, 0x90, 0xF6, 0x66, 0x66, 0xF0, 0x38, 0x42, 0x10,
  0xE5, 0xC0, 0x9D, 0xA9, 0xCB, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0x9F,
  0xFF, 0x99, 0x90, 0x9D, 0xDB, 0xBB, 0x90, 0xF9, 0x99, 0x99, 0xF0, 0xF4,
  0xE7, 0xE8, 0x42, 0x00, 0xF9, 0x99, 0x99, 0xF3, 0x10, 0xF4, 0xA5, 0xEA,
  0x4A, 0x60, 0xF9, 0x87, 0x19, 0xF0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x00,
  0x99, 0x99, 0x99, 0xF0, 0xCD, 0x24, 0x92, 0x30, 0xC3, 0x00, 0xB6, 0xDB,
  0x5E, 0x79, 0x24, 0x80, 0xCD, 0xE3, 0x0C, 0x31, 0x2C, 0xC0, 0xCD, 0x23,
  0x0C, 0x30, 0xC3, 0x00, 0xF3, 0x24, 0x48, 0xF0, 0xF2, 0x49, 0x24, 0xE0,
  0x8C, 0x44, 0x62, 0x21, 0x10, 0xE4, 0x92, 0x49, 0xE0, 0x66, 0x99, 0xF0,
  0x90, 0x69, 0x1F, 0x9F, 0x8A, 0xD9, 0x99, 0xF0, 0x6D, 0x88, 0x9F, 0x15,
  0xB9, 0x99, 0xF0, 0x69, 0x9F, 0x8F, 0x74, 0xF4, 0x44, 0x40, 0x5B, 0x99,
  0xB5, 0x16, 0x8A, 0xD9, 0x99, 0x90, 0x61, 0x39, 0xC2, 0x10, 0x9F, 0x32,
  0xFF, 0x33, 0x33, 0x2E, 0x84, 0xE5, 0x4E, 0x5A, 0x60, 0xE0, 0x82, 0x08,
  0x20, 0x81, 0xC0, 0xDF, 0xDD, 0xDD, 0xAD, 0x99, 0x99, 0x6F, 0x99, 0x9F,
  0xAD, 0x99, 0x9F, 0x88, 0x5B, 0x99, 0x9F, 0x11, 0xA6, 0xA7, 0x08, 0x40,
  0x69, 0x87, 0x1F, 0x27, 0xFE, 0x42, 0x10, 0xE0, 0x99, 0x99, 0x9F, 0xCD,
  0x24, 0x9E, 0x30, 0xC0, 0xA6, 0xD7, 0x9E, 0x79, 0x20, 0x49, 0x23, 0x0C,
  0x7B, 0x30, 0xCD, 0x24, 0x8C, 0x30, 0xC2, 0x08, 0xFF, 0x24, 0xCF, 0x32,
  0x22, 0xC2, 0x22, 0x30, 0xFF, 0xFF, 0xC0, 0xC4, 0x44, 0x34, 0x44, 0xC0,
  0xDF, 0x30,
};

const GFXglyph JetBrainsMono_SemiBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 4, 10, 6, 1, -9 },
  { 16, 6, 7, 6, 0, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 2, 3, 6, 2, -7 },
  { 29, 3, 9, 6, 2, -8 },
  { 33, 3, 9, 6, 1, -8 },
  { 37, 6, 5, 6, 0, -6 },
  { 41, 4, 5, 6, 1, -6 },
  { 44, 2, 4, 6, 2, -2 },
  { 45, 4, 1, 6, 1, -4 },
  { 46, 2, 2, 6, 2, -2 },
  { 47, 4, 9, 6, 1, -8 },
  { 52, 4, 7, 6, 1, -7 },
  { 56, 4, 7, 6, 1, -7 },
  { 60, 4, 7, 6, 1, -7 },
  { 64, 4, 7, 6, 1, -7 },
  { 68, 4, 7, 6, 1, -7 },
  { 72, 4, 7, 6, 1, -7 },
  { 76, 4, 7, 6, 1, -7 },
  { 80, 4, 7, 6, 1, -7 },
  { 84, 4, 7, 6, 1, -7 },
  { 88, 4, 7, 6, 1, -7 },
  { 92, 2, 6, 6, 2, -6 },
  { 94, 2, 8, 6, 2, -6 },
  { 96, 4, 5, 6, 1, -6 },
  { 99, 4, 3, 6, 1, -5 },
  { 101, 4, 5, 6, 1, -6 },
  { 104, 4, 7, 6, 1, -7 },
  { 108, 6, 9, 6, 0, -7 },
  { 115, 6, 7, 6, 0, -7 },
  { 121, 4, 7, 6, 1, -7 },
  { 125, 4, 7, 6, 1, -7 },
  { 129, 4, 7, 6, 1, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 4, 7, 6, 1, -7 },
  { 141, 4, 7, 6, 1, -7 },
  { 145, 4, 7, 6, 1, -7 },
  { 149, 4, 7, 6, 1, -7 },
  { 153, 5, 7, 6, 0, -7 },
  { 158, 5, 7, 6, 1, -7 },
  { 163, 4, 7, 6, 1, -7 },
  { 167, 4, 7, 6, 1, -7 },
  { 171, 4, 7, 6, 1, -7 },
  { 175, 4, 7, 6, 1, -7 },
  { 179, 5, 7, 6, 1, -7 },
  { 184, 4, 9, 6, 1, -7 },
  { 189, 5, 7, 6, 1, -7 },
  { 194, 4, 7, 6, 1, -7 },
  { 198, 6, 7, 6, 0, -7 },
  { 204, 4, 7, 6, 1, -7 },
  { 208, 6, 7, 6, 0, -7 },
  { 214, 6, 7, 6, 0, -7 },
  { 220, 6, 7, 6, 0, -7 },
  { 226, 6, 7, 6, 0, -7 },
  { 232, 4, 7, 6, 1, -7 },
  { 236, 3, 9, 6, 2, -8 },
  { 240, 4, 9, 6, 1, -8 },
  { 245, 3, 9, 6, 1, -8 },
  { 249, 4, 4, 6, 1, -7 },
  { 251, 4, 1, 6, 1, 0 },
  { 252, 2, 2, 6, 2, -8 },
  { 253, 4, 6, 6, 1, -6 },
  { 256, 4, 7, 6, 1, -7 },
  { 260, 4, 6, 6, 1, -6 },
  { 263, 4, 7, 6, 1, -7 },
  { 267, 4, 6, 6, 1, -6 },
  { 270, 4, 7, 6, 1, -7 },
  { 274, 4, 8, 6, 1, -6 },
  { 278, 4, 7, 6, 1, -7 },
  { 282, 5, 8, 6, 1, -8 },
  { 287, 4, 10, 6, 1, -8 },
  { 292, 5, 7, 6, 1, -7 },
  { 297, 6, 7, 6, 0, -7 },
  { 303, 4, 6, 6, 1, -6 },
  { 306, 4, 6, 6, 1, -6 },
  { 309, 4, 6, 6, 1, -6 },
  { 312, 4, 8, 6, 1, -6 },
  { 316, 4, 8, 6, 1, -6 },
  { 320, 5, 6, 6, 1, -6 },
  { 324, 4, 6, 6, 1, -6 },
  { 327, 5, 7, 6, 0, -7 },
  { 332, 4, 6, 6, 1, -6 },
  { 335, 6, 6, 6, 0, -6 },
  { 340, 6, 6, 6, 0, -6 },
  { 345, 6, 6, 6, 0, -6 },
  { 350, 6, 8, 6, 0, -6 },
  { 356, 4, 6, 6, 1, -6 },
  { 359, 4, 9, 6, 1, -8 },
  { 364, 2, 9, 6, 2, -8 },
  { 367, 4, 9, 6, 1, -8 },
  { 372, 4, 3, 6, 1, -5 },
};

const GFXfont JetBrainsMono_SemiBold10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_SEMIBOLD10PT7B_H_
