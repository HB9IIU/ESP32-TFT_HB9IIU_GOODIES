#ifndef _JETBRAINSMONO_SEMIBOLD52PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x3F, 0xFF, 0xFF, 0xF7, 0xF1, 0xF8, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x7C,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0,
  0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC3, 0xF9, 0xCF, 0xF3, 0xF8, 0xE3, 0xF9, 0xF8, 0x70, 0xFC, 0xFC,
  0x38, 0x7E, 0x7E, 0x1C, 0x3F, 0xBF, 0x0E, 0x00, 0x1F, 0x87, 0x00, 0x0F,
  0xE3, 0x80, 0x07, 0xF1, 0xC0, 0x01, 0xFE, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x71,
  0xFC, 0x00, 0x38, 0x7F, 0x00, 0x1C, 0x3F, 0x80, 0x0E, 0x0F, 0xC0, 0x07,
  0x07, 0xFF, 0x83, 0x83, 0xFF, 0xC1, 0xC1, 0xFF, 0xF0, 0xE1, 0xFD, 0xFC,
  0x70, 0xFC, 0xFF, 0x39, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x3F,
  0xF0, 0x00, 0x78, 0xFF, 0xF0, 0x01, 0xE3, 0xFF, 0xF0, 0x07, 0xC7, 0xC3,
  0xE0, 0x1F, 0x0F, 0x03, 0xE0, 0x3C, 0x1E, 0x07, 0xC0, 0xF8, 0x3C, 0x0F,
  0x83, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0x3E, 0x1F, 0x01, 0xE0, 0x7C,
  0x7C, 0x03, 0xC0, 0xF8, 0xF0, 0x07, 0xC3, 0xE3, 0xC0, 0x0F, 0xFF, 0xCF,
  0x80, 0x0F, 0xFF, 0x3E, 0x00, 0x0F, 0xFC, 0x78, 0x00, 0x07, 0xF1, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x07, 0x8F, 0xFC,
  0x00, 0x1F, 0x3F, 0xFC, 0x00, 0x7C, 0xFF, 0xFC, 0x00, 0xF1, 0xF0, 0xF8,
  0x03, 0xE3, 0xC0, 0xF0, 0x0F, 0x87, 0x81, 0xF0, 0x1E, 0x0F, 0x03, 0xE0,
  0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xC0, 0x78, 0x1F, 0x0F,
  0x00, 0xF0, 0x3C, 0x3E, 0x01, 0xF0, 0xF8, 0xF8, 0x03, 0xFF, 0xF1, 0xE0,
  0x03, 0xFF, 0xC7, 0xC0, 0x03, 0xFF, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x7E, 0x7E, 0x7E, 0x07,
  0xE7, 0xE3, 0xF0, 0xFC, 0xFC, 0x3F, 0x8F, 0xCF, 0xC1, 0xF9, 0xF8, 0xFC,
  0x0F, 0xDF, 0x8F, 0xC0, 0x7F, 0xF0, 0xFC, 0x07, 0xFF, 0x0F, 0xC0, 0x3F,
  0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0xE0, 0x7F, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0x87, 0xE0, 0x7F, 0xE0, 0x7F,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x06, 0x01, 0xF0, 0x04, 0x78, 0x1F, 0x03, 0xC7, 0xE0, 0xF0,
  0xFE, 0xFF, 0x8E, 0x3F, 0xEF, 0xFE, 0xE7, 0xFE, 0xFF, 0xF7, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x78, 0x03, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x7F, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0xFE, 0x3F, 0xF8, 0xFE, 0x3F,
  0xF8, 0xFE, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFE, 0xFC, 0x01, 0xFE, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3C, 0x0F, 0xC0, 0x18, 0x07,
  0xE0, 0x08, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFC, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x80,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x7F, 0x00, 0xFC, 0xFC,
  0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC7,
  0xF0, 0x1F, 0xBF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF9, 0xFE, 0x0F, 0xF3, 0xF8, 0x07, 0xF7, 0xE0, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x7F, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0xC0, 0x3F, 0xBF, 0xF8, 0x1F, 0xBF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x01, 0xFB, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x01, 0xFC,
  0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0xFC,
  0x3F, 0x81, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8,
  0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE3, 0xFC, 0x07, 0xF9, 0xFC, 0x01,
  0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x3F, 0x8F,
  0xF8, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xF3, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF0, 0x40,
  0x07, 0xC0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0x83, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0x1F, 0xF8, 0x0F, 0xFD, 0xFF, 0x81, 0xFF,
  0xDF, 0xF8, 0x1F, 0xCF, 0xFF, 0x83, 0xF0, 0x3F, 0xF8, 0x3E, 0x03, 0xFF,
  0x83, 0xE0, 0x3F, 0xF8, 0x3E, 0x03, 0xFF, 0x83, 0xE0, 0x3F, 0xF8, 0x3E,
  0x03, 0xFF, 0x83, 0xE0, 0x3F, 0xF8, 0x3E, 0x03, 0xFF, 0x83, 0xE0, 0x3F,
  0xF8, 0x3E, 0x03, 0xFF, 0x83, 0xE0, 0x3F, 0xF8, 0x3E, 0x03, 0xFF, 0x83,
  0xF0, 0x3F, 0xF8, 0x3F, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFD,
  0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x03, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFC, 0x03, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x03, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC,
  0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x81, 0xFE, 0x7E,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC,
  0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x7F, 0x81, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0,
  0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x78, 0x0F, 0xFF, 0xFC,
  0x07, 0xBF, 0xFF, 0x03, 0xDF, 0xF7, 0x83, 0xFF, 0xFB, 0xC1, 0xEF, 0xFD,
  0xE0, 0xF7, 0xFE, 0xF8, 0x7B, 0xFF, 0x3C, 0x7D, 0xFF, 0x9E, 0x3C, 0xFF,
  0xCF, 0x9E, 0x7F, 0xE3, 0xDF, 0x3F, 0xF1, 0xEF, 0x1F, 0xFC, 0xF7, 0x8F,
  0xFE, 0x3F, 0xC7, 0xFF, 0x1F, 0xC3, 0xFF, 0x8F, 0xE3, 0xFF, 0xC7, 0xF1,
  0xFF, 0xE1, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xF7, 0xC0, 0x7F, 0xEF,
  0x80, 0xFF, 0xCF, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0x3E, 0x07, 0xFE, 0x3E,
  0x0F, 0xFC, 0x7C, 0x1F, 0xFC, 0xF8, 0x3F, 0xF8, 0xF8, 0x7F, 0xF1, 0xF0,
  0xFF, 0xE3, 0xE1, 0xFF, 0xC3, 0xE3, 0xFF, 0x87, 0xC7, 0xFF, 0x0F, 0x8F,
  0xFE, 0x0F, 0x9F, 0xFC, 0x1F, 0x3F, 0xF8, 0x3E, 0x7F, 0xF0, 0x3E, 0xFF,
  0xE0, 0x7D, 0xFF, 0xC0, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xF0,
  0x3F, 0x9F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x1F, 0xBF, 0x00, 0x7F, 0x7F, 0x81, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xF0, 0x03, 0xFD, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x01, 0xFF, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x7F, 0x81, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE,
  0x7F, 0x81, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xE0, 0x3F, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC,
  0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFE,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80,
  0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0x3F, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x81, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0xF8,
  0x1F, 0x81, 0xFF, 0xC1, 0xFC, 0x0F, 0xBE, 0x0F, 0xE0, 0xFD, 0xF0, 0x77,
  0x07, 0xEF, 0x83, 0xB8, 0x3E, 0x7C, 0x1D, 0xC1, 0xF3, 0xE0, 0xEE, 0x0F,
  0x9F, 0x07, 0x78, 0x7C, 0xF8, 0x3B, 0xC3, 0xE7, 0xC1, 0xDE, 0x1F, 0x3F,
  0x1E, 0x70, 0xF9, 0xF8, 0xF3, 0x87, 0xC7, 0xC7, 0x9C, 0x3E, 0x3E, 0x38,
  0xE3, 0xE1, 0xF1, 0xC7, 0x1F, 0x0F, 0x8E, 0x38, 0xF8, 0x7C, 0x71, 0xE7,
  0xC3, 0xE3, 0x8F, 0x3E, 0x1F, 0x3C, 0x79, 0xF0, 0xF9, 0xE1, 0xCF, 0x87,
  0xCF, 0x0E, 0x7C, 0x1F, 0x70, 0x73, 0xE0, 0xFB, 0x83, 0x9E, 0x07, 0xDC,
  0x1C, 0xF0, 0x3E, 0xE0, 0xE7, 0x81, 0xF7, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x81,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x03,
  0xEF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x3F,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x01,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7F,
  0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x0F,
  0xFE, 0x3F, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x03, 0xF1, 0xFF,
  0x87, 0xE7, 0xFF, 0x8F, 0xDF, 0xFF, 0x9F, 0xBF, 0xFF, 0xBF, 0xF0, 0xFF,
  0x7F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xFF, 0xF7, 0xEF, 0xFF,
  0xCF, 0xCF, 0xFF, 0x1F, 0x8F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0xFC, 0x3F, 0xF9, 0xF8,
  0xFF, 0xFB, 0xF3, 0xFF, 0xF7, 0xEF, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0x7F, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFD, 0xF9, 0xFF, 0xFB, 0xF1,
  0xFF, 0xE7, 0xE0, 0xFF, 0x8F, 0xC0, 0x30, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x1F, 0xBF, 0x80, 0x7F, 0x7F, 0xC3, 0xFC, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x7E, 0x1F, 0xFC, 0xFC, 0x7F, 0xFD, 0xF9, 0xFF, 0xFB, 0xF7, 0xFF,
  0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xEF,
  0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0xBF, 0x1F, 0xFF, 0x7E, 0x1F,
  0xFC, 0xFC, 0x1F, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x03, 0xF1, 0xFF, 0x87, 0xE7, 0xFF, 0x8F,
  0xDF, 0xFF, 0x9F, 0xBF, 0xFF, 0xBF, 0xE0, 0xFF, 0x7F, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07,
  0xF3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x03,
  0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x07,
  0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF9, 0xF0, 0x7C, 0x7D, 0xFC, 0x7F, 0x3E,
  0xFF, 0x7F, 0xDF, 0xFF, 0xBF, 0xFF, 0xE7, 0xF1, 0xFF, 0xE1, 0xF0, 0x7F,
  0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07,
  0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0,
  0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F,
  0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1,
  0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC,
  0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xF8,
  0xFC, 0x3F, 0x81, 0xF8, 0xFF, 0xC3, 0xF3, 0xFF, 0xC7, 0xEF, 0xFF, 0xCF,
  0xDF, 0xFF, 0xDF, 0xF0, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xBF, 0xC0, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFC, 0x3F, 0x81, 0xF8, 0xFF, 0xC3, 0xF3, 0xFF, 0xC7, 0xEF, 0xFF, 0xCF,
  0xDF, 0xFF, 0xDF, 0xF8, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFB, 0xFF, 0xFB, 0xF7, 0xFF, 0xE7, 0xE7, 0xFF, 0x8F, 0xC3, 0xFC, 0x1F,
  0x80, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x7E, 0x1F, 0xFC, 0xFC, 0x7F, 0xFD, 0xF9, 0xFF,
  0xFB, 0xF7, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x81, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFE, 0xFC, 0xFF, 0xFD, 0xF8, 0xFF, 0xF3, 0xF0, 0x7F,
  0xC7, 0xE0, 0x18, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0xC0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F,
  0xBF, 0xC1, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xF8,
  0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xDF, 0x03, 0xE0, 0x3E, 0xF8, 0x1F,
  0x81, 0xE7, 0xC0, 0xFC, 0x1F, 0x3E, 0x0F, 0xE0, 0xF9, 0xF0, 0x77, 0x07,
  0xCF, 0x83, 0xB8, 0x3E, 0x7C, 0x1D, 0xC1, 0xF1, 0xF0, 0xEE, 0x0F, 0x8F,
  0x87, 0x78, 0x78, 0x7C, 0x79, 0xC7, 0xC3, 0xE3, 0xCE, 0x3E, 0x1F, 0x1C,
  0x71, 0xF0, 0xF8, 0xE3, 0x8F, 0x83, 0xC7, 0x1C, 0x7C, 0x1F, 0x38, 0xF3,
  0xC0, 0xFB, 0xC7, 0x9E, 0x07, 0xDE, 0x1D, 0xF0, 0x3E, 0xE0, 0xEF, 0x81,
  0xF7, 0x07, 0x7C, 0x0F, 0xB8, 0x3B, 0xE0, 0x3D, 0xC1, 0xDE, 0x01, 0xEE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xEF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07,
  0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x07, 0xDF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xF8, 0x7F, 0xE0, 0xFE,
  0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0x7C, 0x03, 0xFF, 0xBE, 0x00,
  0xFF, 0x00, 0x00, 0x0C, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 38, 31, 11, -38 },
  { 44, 17, 16, 31, 7, -38 },
  { 78, 29, 38, 31, 1, -38 },
  { 216, 25, 52, 31, 3, -45 },
  { 379, 31, 38, 31, 0, -38 },
  { 527, 28, 39, 31, 2, -38 },
  { 664, 7, 16, 31, 12, -38 },
  { 678, 16, 50, 31, 9, -44 },
  { 778, 16, 50, 31, 6, -44 },
  { 878, 28, 27, 31, 2, -32 },
  { 973, 25, 24, 31, 3, -29 },
  { 1048, 12, 16, 31, 8, -8 },
  { 1072, 17, 6, 31, 7, -20 },
  { 1085, 9, 10, 31, 11, -9 },
  { 1097, 25, 49, 31, 3, -43 },
  { 1251, 24, 39, 31, 4, -38 },
  { 1368, 25, 38, 31, 4, -38 },
  { 1487, 25, 38, 31, 3, -38 },
  { 1606, 24, 39, 31, 3, -38 },
  { 1723, 23, 38, 31, 4, -38 },
  { 1833, 23, 39, 31, 4, -38 },
  { 1946, 25, 39, 31, 3, -38 },
  { 2068, 25, 38, 31, 3, -38 },
  { 2187, 24, 40, 31, 4, -39 },
  { 2307, 25, 38, 31, 3, -38 },
  { 2426, 9, 30, 31, 11, -29 },
  { 2460, 12, 37, 31, 8, -29 },
  { 2516, 23, 28, 31, 4, -31 },
  { 2597, 23, 18, 31, 4, -26 },
  { 2649, 23, 28, 31, 4, -31 },
  { 2730, 20, 38, 31, 6, -38 },
  { 2825, 28, 47, 31, 2, -38 },
  { 2990, 27, 38, 31, 2, -38 },
  { 3119, 24, 38, 31, 4, -38 },
  { 3233, 24, 39, 31, 4, -38 },
  { 3350, 24, 38, 31, 4, -38 },
  { 3464, 22, 38, 31, 5, -38 },
  { 3569, 24, 38, 31, 4, -38 },
  { 3683, 24, 39, 31, 4, -38 },
  { 3800, 23, 38, 31, 4, -38 },
  { 3910, 21, 38, 31, 5, -38 },
  { 4010, 24, 39, 31, 2, -38 },
  { 4127, 25, 38, 31, 4, -38 },
  { 4246, 22, 38, 31, 6, -38 },
  { 4351, 25, 38, 31, 3, -38 },
  { 4470, 23, 38, 31, 4, -38 },
  { 4580, 23, 39, 31, 4, -38 },
  { 4693, 25, 38, 31, 4, -38 },
  { 4812, 24, 47, 31, 4, -38 },
  { 4953, 25, 38, 31, 4, -38 },
  { 5072, 25, 40, 31, 3, -39 },
  { 5197, 27, 38, 31, 2, -38 },
  { 5326, 23, 39, 31, 4, -38 },
  { 5439, 27, 38, 31, 2, -38 },
  { 5568, 29, 38, 31, 1, -38 },
  { 5706, 28, 38, 31, 2, -38 },
  { 5839, 29, 38, 31, 1, -38 },
  { 5977, 23, 38, 31, 4, -38 },
  { 6087, 14, 49, 31, 10, -43 },
  { 6173, 25, 49, 31, 3, -43 },
  { 6327, 14, 49, 31, 7, -43 },
  { 6413, 24, 20, 31, 4, -38 },
  { 6473, 25, 6, 31, 3, 1 },
  { 6492, 12, 7, 31, 9, -41 },
  { 6503, 24, 30, 31, 3, -29 },
  { 6593, 23, 39, 31, 4, -38 },
  { 6706, 24, 30, 31, 4, -29 },
  { 6796, 23, 39, 31, 4, -38 },
  { 6909, 23, 30, 31, 4, -29 },
  { 6996, 25, 38, 31, 3, -38 },
  { 7115, 23, 38, 31, 4, -29 },
  { 7225, 23, 38, 31, 4, -38 },
  { 7335, 25, 41, 31, 4, -41 },
  { 7464, 20, 50, 31, 4, -41 },
  { 7589, 25, 38, 31, 4, -38 },
  { 7708, 28, 38, 31, 1, -38 },
  { 7841, 25, 29, 31, 3, -29 },
  { 7932, 23, 29, 31, 4, -29 },
  { 8016, 23, 29, 31, 4, -29 },
  { 8100, 23, 38, 31, 4, -29 },
  { 8210, 23, 38, 31, 4, -29 },
  { 8320, 24, 29, 31, 5, -29 },
  { 8407, 24, 29, 31, 4, -29 },
  { 8494, 25, 37, 31, 2, -37 },
  { 8610, 23, 30, 31, 4, -29 },
  { 8697, 27, 29, 31, 2, -29 },
  { 8795, 29, 29, 31, 1, -29 },
  { 8901, 27, 29, 31, 2, -29 },
  { 8999, 27, 38, 31, 2, -29 },
  { 9128, 23, 29, 31, 4, -29 },
  { 9212, 23, 49, 31, 4, -43 },
  { 9353, 6, 49, 31, 13, -43 },
  { 9390, 23, 49, 31, 4, -43 },
  { 9531, 25, 12, 31, 3, -24 },
};

const GFXfont JetBrainsMono_SemiBold52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_SEMIBOLD52PT7B_H_
