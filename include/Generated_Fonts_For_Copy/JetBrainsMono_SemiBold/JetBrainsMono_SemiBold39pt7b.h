#ifndef _JETBRAINSMONO_SEMIBOLD39PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x7F, 0xFD,
  0xFB, 0xE0, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0x83, 0xDC, 0x1E, 0x01, 0xC0, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC1, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C,
  0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x70, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xED, 0xF9, 0xF1, 0x9F,
  0x3E, 0x31, 0xE7, 0xC6, 0x3E, 0xF8, 0xC0, 0x1F, 0x18, 0x03, 0xF3, 0x00,
  0x3F, 0x60, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0x3F, 0x00, 0x63, 0xE0, 0x0C, 0x7F,
  0xE1, 0x8F, 0xFC, 0x31, 0xF7, 0x86, 0x3E, 0xF8, 0xCF, 0x9F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x80,
  0x3D, 0xFF, 0x80, 0x73, 0xCF, 0x01, 0xC7, 0x0F, 0x07, 0x9E, 0x1E, 0x1E,
  0x3C, 0x3C, 0x38, 0x78, 0x78, 0xF0, 0x70, 0xF3, 0xC0, 0xE1, 0xE7, 0x01,
  0xFF, 0x9C, 0x01, 0xFF, 0x78, 0x01, 0xFC, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x71, 0xF0, 0x01, 0xEF, 0xF0, 0x07,
  0xBF, 0xF0, 0x0E, 0x78, 0xF0, 0x38, 0xE1, 0xE0, 0xF1, 0xC1, 0xC1, 0xC3,
  0x83, 0x87, 0x07, 0x07, 0x1E, 0x0E, 0x0E, 0x78, 0x1C, 0x3C, 0xE0, 0x3F,
  0xF3, 0xC0, 0x3F, 0xEF, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3E, 0x1F, 0x03, 0xC0, 0xF8, 0x3C, 0x0F,
  0x83, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x1F, 0xF9,
  0xE1, 0xEF, 0x1F, 0x3E, 0xF0, 0xFB, 0xCF, 0x07, 0xFC, 0xF0, 0x3F, 0x8F,
  0x03, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF8, 0x3F, 0x8F, 0xEF, 0xFC,
  0x7F, 0xFB, 0xE3, 0xFF, 0x1E, 0x1F, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xDE, 0x00, 0x10, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xFC,
  0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0xF0, 0x01,
  0x80, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x00,
  0x40, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x20, 0x3C, 0x09, 0xE1, 0xC1, 0xCF, 0xCE, 0x3F, 0xFF,
  0x37, 0xFB, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x0D, 0xC0,
  0x00, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8,
  0x3E, 0x07, 0xC0, 0xF0, 0x0C, 0x07, 0x00, 0x20, 0x10, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBE, 0x03,
  0xEF, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF1, 0xC7, 0xFC, 0xF9, 0xFF, 0x3E, 0x7F, 0xCF, 0x9F, 0xF1,
  0xE7, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x1E, 0xFC, 0x0F, 0x9F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0xFC, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0x03, 0xC0, 0x80,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xF8, 0x0F, 0x9F, 0x01,
  0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x7D, 0xF0, 0x1F, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0xFB,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x3C, 0x07, 0xBF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0x87, 0xE7, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x01, 0xEF, 0x80, 0xFB,
  0xF0, 0x3E, 0x7F, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x40, 0x1F, 0x7F, 0x83, 0xDF, 0xF8, 0xFF, 0xFF, 0x9F, 0x83, 0xF3, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1E, 0xF0, 0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBE, 0x03, 0xEF, 0x80,
  0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7C,
  0x3F, 0x7E, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0x3F, 0x1F,
  0x07, 0xCF, 0x80, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8,
  0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC7, 0xF0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F,
  0xDF, 0xEF, 0xF1, 0xFF, 0xFE, 0x1F, 0xF7, 0x80, 0xFD, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x38, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x0F, 0x0F, 0xCF, 0xE7,
  0xF3, 0xF8, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x3C, 0x1E, 0x1F, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xDF, 0xC3, 0xE0, 0x1F, 0x1E, 0x00,
  0x79, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x07, 0xDF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x7C, 0x3F, 0xC3, 0xC1,
  0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1,
  0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1F, 0x1F,
  0xF0, 0x7F, 0xBF, 0x81, 0xFD, 0xFC, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x07,
  0xBC, 0x00, 0x79, 0xE0, 0x0F, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF1, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF8,
  0x3E, 0x07, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xE1, 0xFE, 0xF8, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E,
  0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBE, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xF8, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xEF,
  0xEE, 0x1D, 0xFD, 0xC7, 0xFF, 0xB8, 0xEF, 0xF7, 0x9D, 0xFE, 0x73, 0xBF,
  0xCE, 0xE7, 0xF9, 0xDC, 0xFF, 0x1F, 0x9F, 0xE3, 0xF3, 0xFE, 0x7C, 0x7F,
  0xC7, 0x8F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF0, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xEE, 0x0F,
  0xF7, 0x87, 0xFB, 0xC3, 0xFC, 0xE1, 0xFE, 0x78, 0xFF, 0x3C, 0x7F, 0x8E,
  0x3F, 0xC7, 0x9F, 0xE3, 0xCF, 0xF0, 0xF7, 0xF8, 0x7B, 0xFC, 0x3D, 0xFE,
  0x0F, 0xFF, 0x07, 0xBF, 0x81, 0xDF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x7C, 0x0F,
  0xBF, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xEF, 0x81, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7E, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xFC, 0x0F,
  0x9F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x80,
  0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00,
  0xF3, 0xE0, 0x1F, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFB, 0xC0, 0x1F, 0x7E, 0x07, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E, 0xF8, 0x1F, 0x7F, 0xFF, 0x1F,
  0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0xF8,
  0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC3,
  0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F,
  0x00, 0xF1, 0xE0, 0x0F, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0x7B,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xEF, 0x0F, 0x87,
  0xBC, 0x3E, 0x1E, 0xF0, 0xF8, 0x7B, 0xC3, 0xE1, 0xEF, 0x0D, 0xC7, 0x9C,
  0x37, 0x1E, 0x78, 0xDC, 0x79, 0xE3, 0x71, 0xE7, 0x9C, 0xC7, 0x1E, 0x73,
  0x1C, 0x79, 0xCC, 0x71, 0xE7, 0x33, 0xC7, 0x98, 0xCF, 0x1E, 0x63, 0xBC,
  0x79, 0x8E, 0xF0, 0xE6, 0x3B, 0xC3, 0xB8, 0xEF, 0x0F, 0xE3, 0xB8, 0x3F,
  0x86, 0xE0, 0xFE, 0x1B, 0x83, 0xF8, 0x6E, 0x0F, 0xC1, 0xB8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x7C, 0x01, 0xF9,
  0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0xC3,
  0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C,
  0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E,
  0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x3C,
  0x7C, 0x01, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0x78, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x07,
  0xBE, 0x01, 0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x01, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFE, 0x3E, 0x0F, 0xDF, 0x01, 0xF7,
  0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x7F, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7E, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xF7, 0xE1, 0xFD, 0xFF, 0xEF, 0x3F, 0xFB, 0xC7, 0xF8, 0xF0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x8F, 0x83, 0xEF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xE1,
  0xFB, 0xF0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xEF, 0x80, 0xFB, 0xF0, 0x3E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xBF,
  0xE3, 0xE7, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7E, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xBF, 0x03, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x1E, 0x1E, 0x3F, 0xCF, 0x3F, 0xF7,
  0xBF, 0xFB, 0xDF, 0x87, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7F, 0xFF, 0xBF, 0xFB,
  0xCF, 0xFD, 0xE3, 0xF8, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7C, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xBE, 0x03, 0xE7, 0xE1, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x0F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFE, 0xF7, 0xE1,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0x7E, 0x3F, 0xBF, 0xFB, 0xCF, 0xFD, 0xE3, 0xFC, 0xF0, 0x78, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE3, 0xE1, 0xF7, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xFB, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83,
  0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x01,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0x87, 0x9E, 0xF9, 0xFB, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0x0F, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1,
  0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x0E, 0x1F, 0xE1, 0xC3,
  0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87,
  0xF8, 0x70, 0xFF, 0x0E, 0x1F, 0xE1, 0xC3, 0xC0, 0x00, 0xF8, 0x7D, 0xFF,
  0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3C, 0x03, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1E, 0xF8, 0x0F, 0x9F, 0x03, 0xE7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x3E,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80,
  0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0xF8, 0x0F, 0xBF,
  0x03, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFB, 0xFE, 0x3E, 0x7F, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFE, 0xF7,
  0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xDF, 0xFF, 0xEF, 0xFE, 0xF3, 0xFF, 0x78,
  0xFE, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x79, 0xFF, 0x3D, 0xFF, 0xDF,
  0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE1, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x7C,
  0x1F, 0xBF, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0xF8, 0x01,
  0xFF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC3, 0xC0,
  0x7C, 0x3E, 0x07, 0x83, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x1F,
  0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF9, 0xE0, 0x07, 0x9E, 0x00,
  0x7B, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0xF0, 0x78, 0x3F, 0x83, 0xC3, 0xFC, 0x3E, 0x1E, 0xE1,
  0xF0, 0xF7, 0x0D, 0x87, 0xBC, 0x6C, 0x3D, 0xE3, 0x71, 0xCF, 0x1B, 0x8E,
  0x79, 0xDC, 0xF3, 0xCE, 0x67, 0x8E, 0x73, 0x3C, 0x73, 0x19, 0xE3, 0xD8,
  0xEE, 0x1E, 0xC7, 0x70, 0xF6, 0x3B, 0x87, 0xF0, 0xDC, 0x1F, 0x87, 0xE0,
  0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0xFC,
  0x03, 0xE7, 0xC0, 0x7C, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x00,
  0xFB, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x0F, 0x9E,
  0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0,
  0x3E, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x07, 0x9E,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xEF, 0xF8,
  0x3D, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0x1F, 0x1F, 0xE1, 0xFF, 0xFC, 0x1F,
  0xF7, 0x81, 0xFC, 0x00, 0x0E, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 13, 11, 23, 5, -28 },
  { 44, 21, 28, 23, 1, -28 },
  { 118, 19, 39, 23, 2, -34 },
  { 211, 23, 29, 23, 0, -29 },
  { 295, 20, 29, 23, 2, -29 },
  { 368, 5, 11, 23, 9, -28 },
  { 375, 12, 38, 23, 7, -33 },
  { 432, 13, 38, 23, 4, -33 },
  { 494, 21, 21, 23, 1, -24 },
  { 550, 19, 18, 23, 2, -22 },
  { 593, 9, 12, 23, 6, -6 },
  { 607, 13, 4, 23, 5, -15 },
  { 614, 7, 7, 23, 8, -7 },
  { 621, 19, 36, 23, 2, -32 },
  { 707, 18, 29, 23, 3, -29 },
  { 773, 18, 28, 23, 3, -28 },
  { 836, 19, 29, 23, 2, -29 },
  { 905, 18, 28, 23, 2, -28 },
  { 968, 17, 28, 23, 3, -28 },
  { 1028, 18, 28, 23, 3, -28 },
  { 1091, 19, 28, 23, 2, -28 },
  { 1158, 18, 28, 23, 3, -28 },
  { 1221, 18, 29, 23, 3, -29 },
  { 1287, 19, 29, 23, 2, -29 },
  { 1356, 7, 22, 23, 8, -22 },
  { 1376, 9, 28, 23, 6, -22 },
  { 1408, 17, 21, 23, 3, -23 },
  { 1453, 17, 14, 23, 3, -20 },
  { 1483, 17, 21, 23, 3, -23 },
  { 1528, 15, 28, 23, 5, -28 },
  { 1581, 21, 36, 23, 1, -29 },
  { 1676, 20, 28, 23, 2, -28 },
  { 1746, 18, 28, 23, 3, -28 },
  { 1809, 18, 29, 23, 3, -29 },
  { 1875, 18, 28, 23, 3, -28 },
  { 1938, 16, 28, 23, 4, -28 },
  { 1994, 18, 29, 23, 3, -29 },
  { 2060, 18, 29, 23, 3, -29 },
  { 2126, 17, 28, 23, 3, -28 },
  { 2186, 16, 28, 23, 4, -28 },
  { 2242, 19, 28, 23, 1, -28 },
  { 2309, 19, 28, 23, 3, -28 },
  { 2376, 17, 28, 23, 4, -28 },
  { 2436, 19, 28, 23, 2, -28 },
  { 2503, 17, 28, 23, 3, -28 },
  { 2563, 17, 29, 23, 3, -29 },
  { 2625, 19, 28, 23, 3, -28 },
  { 2692, 18, 36, 23, 3, -29 },
  { 2773, 19, 28, 23, 3, -28 },
  { 2840, 19, 29, 23, 2, -29 },
  { 2909, 20, 29, 23, 2, -29 },
  { 2982, 17, 28, 23, 3, -28 },
  { 3042, 20, 28, 23, 2, -28 },
  { 3112, 22, 28, 23, 1, -28 },
  { 3189, 21, 28, 23, 1, -28 },
  { 3263, 21, 28, 23, 1, -28 },
  { 3337, 17, 28, 23, 3, -28 },
  { 3397, 11, 36, 23, 7, -32 },
  { 3447, 19, 36, 23, 2, -32 },
  { 3533, 11, 36, 23, 5, -32 },
  { 3583, 18, 15, 23, 3, -28 },
  { 3617, 19, 4, 23, 2, 1 },
  { 3627, 9, 6, 23, 7, -31 },
  { 3634, 18, 22, 23, 2, -22 },
  { 3684, 18, 28, 23, 3, -28 },
  { 3747, 18, 22, 23, 3, -22 },
  { 3797, 17, 28, 23, 3, -28 },
  { 3857, 18, 22, 23, 3, -22 },
  { 3907, 19, 28, 23, 2, -28 },
  { 3974, 17, 29, 23, 3, -22 },
  { 4036, 17, 28, 23, 3, -28 },
  { 4096, 19, 31, 23, 3, -31 },
  { 4170, 15, 38, 23, 3, -31 },
  { 4242, 19, 28, 23, 3, -28 },
  { 4309, 21, 28, 23, 1, -28 },
  { 4383, 19, 22, 23, 2, -22 },
  { 4436, 17, 22, 23, 3, -22 },
  { 4483, 18, 22, 23, 3, -22 },
  { 4533, 18, 29, 23, 3, -22 },
  { 4599, 17, 29, 23, 3, -22 },
  { 4661, 17, 22, 23, 4, -22 },
  { 4708, 18, 22, 23, 3, -22 },
  { 4758, 19, 28, 23, 2, -28 },
  { 4825, 17, 21, 23, 3, -21 },
  { 4870, 20, 21, 23, 2, -21 },
  { 4923, 21, 21, 23, 1, -21 },
  { 4979, 20, 21, 23, 2, -21 },
  { 5032, 20, 28, 23, 2, -21 },
  { 5102, 17, 21, 23, 3, -21 },
  { 5147, 17, 36, 23, 3, -32 },
  { 5224, 5, 36, 23, 9, -32 },
  { 5247, 17, 36, 23, 3, -32 },
  { 5324, 19, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_SemiBold39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_SEMIBOLD39PT7B_H_
