#ifndef _JETBRAINSMONO_SEMIBOLD35PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0x83, 0x80, 0x03, 0x83,
  0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0E, 0x0E,
  0x01, 0xC1, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x38, 0x1C,
  0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70,
  0x1C, 0x1C, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x0E, 0x0E, 0x01, 0xC1, 0xC0,
  0x38, 0x38, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3E, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7D, 0xDF, 0x3C, 0xE7, 0x9E, 0x73, 0xEF,
  0x38, 0x07, 0x9C, 0x03, 0xEE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1C, 0xF0, 0x0E, 0x7C, 0x07,
  0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xFC, 0xE7, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x39, 0xFC, 0x03, 0x9F, 0xF0, 0x3C, 0xE3,
  0x81, 0xCE, 0x0E, 0x1C, 0x70, 0x71, 0xC3, 0x83, 0x8E, 0x1C, 0x1C, 0xE0,
  0x71, 0xCE, 0x03, 0xFE, 0x70, 0x0F, 0xE7, 0x00, 0x3E, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x84, 0x00, 0x39, 0xFC, 0x01, 0xDF, 0xF0,
  0x1C, 0xE3, 0x81, 0xCF, 0x1E, 0x0E, 0x70, 0x70, 0xE3, 0x83, 0x8E, 0x1C,
  0x1C, 0xF0, 0x71, 0xC7, 0x03, 0xDE, 0x70, 0x1F, 0xF7, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x3E, 0x1E,
  0x07, 0x87, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0xFF, 0x3C, 0x7B, 0xCF, 0x9E,
  0xF1, 0xEF, 0x3C, 0x3F, 0xCF, 0x0F, 0xE3, 0xC1, 0xF8, 0xF0, 0x3C, 0x3C,
  0x1F, 0x8F, 0x8F, 0xF3, 0xFF, 0xFC, 0x7F, 0xE7, 0x8F, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDE, 0x73, 0x9C, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0xF1,
  0xF8, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1,
  0xF8, 0x0F, 0x00, 0x60, 0xE0, 0x1F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF1, 0xFC, 0x3F, 0x07, 0x80,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x04,
  0x0E, 0x04, 0xF1, 0xC7, 0x9F, 0x39, 0xF7, 0xFA, 0xFF, 0x3F, 0xFF, 0x80,
  0x3C, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x07,
  0xC7, 0xC0, 0xF0, 0x78, 0x0E, 0x0E, 0x00, 0x80, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x8F,
  0x8F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x38, 0xFB, 0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3D,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x38, 0xFF, 0x3E,
  0x7F, 0x9F, 0x3F, 0xC7, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xF8, 0xFC, 0x7F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFD, 0xE0, 0xF9, 0xE0, 0xE1, 0xE0, 0xC1, 0xE0, 0x81, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78,
  0x1F, 0x7C, 0x3F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x0F, 0x3E, 0x0F, 0x7C,
  0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE3, 0xC3, 0xDF, 0xE7, 0xFF, 0xEF,
  0xFF, 0xFF, 0x07, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x1F, 0xBF, 0xFE, 0x3F, 0xF8,
  0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0xBC, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFB, 0xFB, 0xF0, 0x7D, 0xF0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFB, 0xC0,
  0x79, 0xF8, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0F, 0x3E, 0x0F, 0x8F, 0x8F, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xC0,
  0x7D, 0xF0, 0x78, 0x3C, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0xFB, 0xC0, 0x79, 0xF8, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1,
  0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x01, 0xF7, 0xC1, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xBC,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x10, 0xFB,
  0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0xFF, 0xFF, 0xFB, 0xE0, 0x08, 0x3E, 0x7F, 0x7F, 0x3E, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C,
  0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xC0,
  0x03, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFE,
  0x3F, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x7E, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0x87, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0x9F, 0xC3, 0xFB, 0xF8, 0x79, 0xFF, 0x1E, 0x1F,
  0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xE1, 0xFE, 0x3C, 0x3F,
  0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F, 0xE1, 0xFF, 0xFC, 0x3F, 0xBF,
  0x83, 0xE7, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01,
  0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xE3, 0x80, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x1C, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x78, 0xF8,
  0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7C, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0xF8, 0xF0, 0xFE, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xF8,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x1E, 0xFC,
  0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x1E,
  0xFC, 0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0x79, 0xF8, 0xFC, 0x7F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07,
  0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0,
  0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xE3, 0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F,
  0x8F, 0x03, 0xC7, 0x81, 0xF3, 0xC0, 0x79, 0xE0, 0x3E, 0xF0, 0x0F, 0x78,
  0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0x71, 0xDF, 0xB8, 0xEF, 0xDC, 0x77, 0xE7, 0x37, 0xFB, 0xBB,
  0xFD, 0xDD, 0xFE, 0x6C, 0xFF, 0x3E, 0x7F, 0x9F, 0x3F, 0xCF, 0x9F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFB, 0x83,
  0xF7, 0x07, 0xEF, 0x0F, 0xCE, 0x1F, 0x9C, 0x3F, 0x3C, 0x7E, 0x38, 0xFC,
  0x71, 0xF8, 0xF3, 0xF0, 0xE7, 0xE1, 0xCF, 0xC3, 0xDF, 0x83, 0xBF, 0x07,
  0x7E, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xF3, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xBF, 0xFE, 0x3F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xF7,
  0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03,
  0xDE, 0x03, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3D,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xF8, 0xFC, 0x7F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0x03, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3E,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x79, 0xF8, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xBF, 0xFE, 0x3F, 0xF8,
  0x3F, 0xE0, 0xF8, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x83,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3E, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0xC3, 0xF8,
  0xF8, 0x7F, 0x1B, 0x1F, 0xE3, 0x63, 0xFC, 0x6C, 0x7F, 0x8D, 0x8F, 0xF1,
  0xB1, 0xEE, 0x36, 0x39, 0xC6, 0xC7, 0x39, 0xDC, 0xE7, 0x3B, 0x9C, 0xE6,
  0x33, 0x9E, 0xC6, 0x73, 0xD8, 0xDE, 0x7B, 0x1B, 0xCF, 0x63, 0x70, 0xEC,
  0x6E, 0x1F, 0x8D, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x03, 0xEF, 0x80, 0x78, 0xF0,
  0x1E, 0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x7D,
  0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x3C, 0xF8, 0x07, 0x8F, 0x01, 0xE1, 0xF0, 0x3C, 0x1E, 0x0F, 0x01,
  0xE3, 0xE0, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7C, 0xF0, 0x01, 0xFF, 0x00,
  0x7D, 0xE0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE,
  0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x77,
  0x00, 0x7B, 0xC0, 0x38, 0xE0, 0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x0E, 0x0F,
  0x07, 0x87, 0x01, 0xC7, 0x80, 0xF7, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3C, 0x3E, 0x1F, 0x01, 0x80, 0x0F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1F, 0x78, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xFF, 0x7F, 0xEF, 0x1F,
  0xCF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x30, 0x79, 0xFC, 0xF7, 0xFD, 0xFF, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xFE, 0xF7, 0xFD,
  0xE7, 0xE0, 0x01, 0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0xF8, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xFC, 0x7E,
  0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC1, 0x87, 0x9F, 0xCF, 0x7F, 0xDE, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFF,
  0x1F, 0xBF, 0xFF, 0x7F, 0xDE, 0x3F, 0x3C, 0x01, 0x00, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x0F, 0xF8, 0x3E, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x7F, 0xBD, 0xFF, 0x7B, 0xFF,
  0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x7F,
  0xFE, 0x7F, 0xBC, 0x3C, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x30, 0x7B, 0xFC, 0xF7, 0xFD, 0xFF,
  0xFB, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x03, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x03, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x0F, 0x1E, 0x0F,
  0x8F, 0x0F, 0x87, 0x87, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0x83, 0xE3, 0xC0, 0xF9,
  0xE0, 0x3C, 0xF0, 0x1F, 0x78, 0x07, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0x04, 0x77,
  0xCF, 0xBB, 0xFF, 0xDE, 0x7C, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7, 0x1F,
  0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0x71, 0xFE, 0x38, 0xFF, 0x1C,
  0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC,
  0x71, 0xFE, 0x38, 0xF0, 0x00, 0xC1, 0xEF, 0xF3, 0xDF, 0xF7, 0xFF, 0xEF,
  0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0x03, 0x00, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0xFC, 0x7E, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xC1, 0xE7, 0xF3,
  0xDF, 0xF7, 0xFF, 0xEF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x7F, 0xFF, 0xFB, 0xDF, 0xF7, 0x9F, 0x8F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x7F,
  0x3D, 0xFF, 0x7B, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xFC, 0x7E, 0xFF, 0xFD, 0xFF, 0x78, 0xFC, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xC0,
  0xF3, 0xFC, 0xF7, 0xFE, 0xF7, 0xFE, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xF8, 0x1E,
  0xF0, 0x1E, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E,
  0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F,
  0xFE, 0x3E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0xF8, 0x03, 0xEF, 0x00,
  0x79, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x0F, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0xE0, 0xFE, 0x1C, 0x1F, 0xC7,
  0xC7, 0xF8, 0xD8, 0xF7, 0x1B, 0x1C, 0xE3, 0x63, 0x9C, 0x6C, 0x73, 0x8D,
  0x8E, 0x73, 0xB1, 0xCF, 0x77, 0x79, 0xEC, 0x6E, 0x1D, 0x8D, 0xC3, 0xB1,
  0xB8, 0x76, 0x37, 0x0E, 0xC6, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x00, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0x78, 0x3C, 0x0F,
  0x8F, 0x80, 0xF9, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F,
  0x7C, 0x07, 0xC7, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x8F, 0x80, 0xFB, 0xE0,
  0x0F, 0x80, 0xF8, 0x03, 0xEF, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3,
  0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01,
  0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0x3F,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E,
  0x00, 0xF0, 0x00, 0x3F, 0x03, 0xBF, 0xC1, 0xFF, 0xF0, 0xFE, 0x7C, 0xFE,
  0x1F, 0xFF, 0x07, 0xFB, 0x81, 0xFC, 0x00, 0x30,
};

const GFXglyph JetBrainsMono_SemiBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 26, 21, 8, -26 },
  { 18, 11, 11, 21, 5, -26 },
  { 34, 19, 26, 21, 1, -26 },
  { 96, 17, 35, 21, 2, -30 },
  { 171, 21, 26, 21, 0, -26 },
  { 240, 18, 26, 21, 2, -26 },
  { 299, 5, 11, 21, 8, -26 },
  { 306, 11, 33, 21, 6, -29 },
  { 352, 11, 33, 21, 4, -29 },
  { 398, 19, 18, 21, 1, -21 },
  { 441, 17, 17, 21, 2, -20 },
  { 478, 9, 11, 21, 5, -5 },
  { 491, 11, 3, 21, 5, -13 },
  { 496, 7, 6, 21, 7, -6 },
  { 502, 17, 33, 21, 2, -29 },
  { 573, 17, 26, 21, 2, -26 },
  { 629, 16, 26, 21, 3, -26 },
  { 681, 17, 26, 21, 2, -26 },
  { 737, 16, 26, 21, 2, -26 },
  { 789, 16, 26, 21, 2, -26 },
  { 841, 15, 26, 21, 3, -26 },
  { 890, 17, 26, 21, 2, -26 },
  { 946, 17, 26, 21, 2, -26 },
  { 1002, 17, 26, 21, 2, -26 },
  { 1058, 17, 26, 21, 2, -26 },
  { 1114, 7, 20, 21, 7, -20 },
  { 1132, 8, 26, 21, 6, -20 },
  { 1158, 15, 19, 21, 3, -21 },
  { 1194, 15, 13, 21, 3, -18 },
  { 1219, 15, 19, 21, 3, -21 },
  { 1255, 14, 26, 21, 4, -26 },
  { 1301, 19, 32, 21, 1, -26 },
  { 1377, 19, 26, 21, 1, -26 },
  { 1439, 16, 26, 21, 3, -26 },
  { 1491, 16, 26, 21, 3, -26 },
  { 1543, 16, 26, 21, 3, -26 },
  { 1595, 15, 26, 21, 3, -26 },
  { 1644, 16, 26, 21, 3, -26 },
  { 1696, 16, 26, 21, 3, -26 },
  { 1748, 15, 26, 21, 3, -26 },
  { 1797, 15, 26, 21, 3, -26 },
  { 1846, 17, 26, 21, 1, -26 },
  { 1902, 17, 26, 21, 3, -26 },
  { 1958, 15, 26, 21, 4, -26 },
  { 2007, 17, 26, 21, 2, -26 },
  { 2063, 15, 26, 21, 3, -26 },
  { 2112, 15, 26, 21, 3, -26 },
  { 2161, 17, 26, 21, 3, -26 },
  { 2217, 17, 32, 21, 2, -26 },
  { 2285, 16, 26, 21, 3, -26 },
  { 2337, 17, 26, 21, 2, -26 },
  { 2393, 17, 26, 21, 2, -26 },
  { 2449, 15, 26, 21, 3, -26 },
  { 2498, 19, 26, 21, 1, -26 },
  { 2560, 19, 26, 21, 1, -26 },
  { 2622, 19, 26, 21, 1, -26 },
  { 2684, 19, 26, 21, 1, -26 },
  { 2746, 15, 26, 21, 3, -26 },
  { 2795, 9, 33, 21, 7, -29 },
  { 2833, 17, 33, 21, 2, -29 },
  { 2904, 9, 33, 21, 5, -29 },
  { 2942, 17, 14, 21, 2, -26 },
  { 2972, 17, 4, 21, 2, 1 },
  { 2981, 8, 4, 21, 6, -27 },
  { 2985, 16, 20, 21, 2, -20 },
  { 3025, 15, 26, 21, 3, -26 },
  { 3074, 16, 20, 21, 3, -20 },
  { 3114, 15, 26, 21, 3, -26 },
  { 3163, 15, 20, 21, 3, -20 },
  { 3201, 17, 26, 21, 2, -26 },
  { 3257, 15, 26, 21, 3, -20 },
  { 3306, 15, 26, 21, 3, -26 },
  { 3355, 17, 27, 21, 3, -27 },
  { 3413, 13, 33, 21, 3, -27 },
  { 3467, 17, 26, 21, 3, -26 },
  { 3523, 19, 26, 21, 1, -26 },
  { 3585, 17, 20, 21, 2, -20 },
  { 3628, 15, 20, 21, 3, -20 },
  { 3666, 15, 20, 21, 3, -20 },
  { 3704, 15, 26, 21, 3, -20 },
  { 3753, 15, 26, 21, 3, -20 },
  { 3802, 16, 20, 21, 3, -20 },
  { 3842, 16, 20, 21, 3, -20 },
  { 3882, 16, 25, 21, 2, -25 },
  { 3932, 15, 19, 21, 3, -19 },
  { 3968, 19, 19, 21, 1, -19 },
  { 4014, 19, 19, 21, 1, -19 },
  { 4060, 19, 19, 21, 1, -19 },
  { 4106, 19, 25, 21, 1, -19 },
  { 4166, 15, 19, 21, 3, -19 },
  { 4202, 15, 33, 21, 3, -29 },
  { 4264, 5, 33, 21, 8, -29 },
  { 4285, 15, 33, 21, 3, -29 },
  { 4347, 17, 8, 21, 2, -16 },
};

const GFXfont JetBrainsMono_SemiBold35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_SEMIBOLD35PT7B_H_
