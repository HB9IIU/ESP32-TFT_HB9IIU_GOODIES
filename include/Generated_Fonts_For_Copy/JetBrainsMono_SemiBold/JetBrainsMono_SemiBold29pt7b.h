#ifndef _JETBRAINSMONO_SEMIBOLD29PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x01,
  0xBF, 0xF7, 0x80, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xEE, 0x3B,
  0x8E, 0xE3, 0x80, 0x07, 0x0C, 0x06, 0x1C, 0x06, 0x1C, 0x0E, 0x1C, 0x0E,
  0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x1C, 0x38, 0x1C, 0x30, 0x1C,
  0x30, 0x18, 0x30, 0x18, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x38,
  0x60, 0x30, 0x60, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBC, 0xDE, 0xF3,
  0x3B, 0xCC, 0x0F, 0x30, 0x1E, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x0C, 0xE0, 0x33, 0xF8, 0xCF, 0xE3, 0x3F, 0xCD, 0xE7,
  0xFF, 0x9F, 0xFC, 0x1F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x3E, 0x03, 0xBF, 0x81, 0xB8, 0xE1, 0xDC, 0x71, 0xCE, 0x38, 0xC7, 0x1C,
  0xC3, 0x8E, 0xE0, 0xFE, 0xE0, 0x3E, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x31, 0x00, 0x3B, 0xF0, 0x3B, 0xFC, 0x19, 0x8E, 0x18, 0xC3, 0x1C, 0x61,
  0x9C, 0x30, 0xCC, 0x1C, 0xEE, 0x0F, 0xEE, 0x03, 0xE0, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3E, 0xF0, 0x38, 0x78, 0x38, 0x38, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x77, 0x8E, 0xF3, 0xDC, 0xF1,
  0xDC, 0xF1, 0xF8, 0xF0, 0xF8, 0xF0, 0x70, 0xF0, 0xF8, 0x7F, 0xFC, 0x7F,
  0xDE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x83, 0xC3, 0xE3, 0xE3,
  0xC3, 0xC1, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x83,
  0xC0, 0xE0, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xF0, 0x78, 0x78, 0x7C, 0x7C, 0xFC, 0x7C, 0x38, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x43, 0x86, 0xF1, 0x9E, 0xFD, 0xFE, 0x7F,
  0xFD, 0x03, 0x80, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0x70, 0x1C, 0x78, 0x3C,
  0x38, 0x18, 0x30, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x78, 0xF1, 0xE3, 0x8F, 0x1C, 0x38, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x9F, 0x7F, 0xE0,
  0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE2, 0x3F, 0x39, 0xF9, 0xEF,
  0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xDF,
  0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x3E, 0xE0,
  0xF3, 0x83, 0x0E, 0x08, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC3, 0xFF, 0x9F, 0xFD, 0xE0,
  0xFE, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7C, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xDF, 0xFC,
  0xFF, 0xE1, 0xFC, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC3, 0xDE, 0x1F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x78, 0x7F, 0xF3, 0xFF, 0x9E, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0x83, 0xDF, 0xFC, 0x7F, 0xE1,
  0xFC, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x7B, 0xE1, 0xDF, 0xCF, 0xFF, 0xBC, 0x1E, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0xC1, 0xE7, 0xFF, 0x8F,
  0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3B,
  0x81, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x1F, 0xE1, 0xFF, 0x9F, 0x7D, 0xE0, 0xFF, 0x03,
  0xF8, 0x1D, 0xC1, 0xEF, 0x0E, 0x3D, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0xE7,
  0x87, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xDF, 0xFE, 0x7F,
  0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xDF, 0xBC, 0x1E, 0xE0, 0x3B,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xE7, 0xFF, 0x8F, 0xFE,
  0x1E, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xEF, 0x3D, 0xF7, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D,
  0xF7, 0x9E, 0x73, 0xCE, 0x38, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xE0, 0x03, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x78, 0x03,
  0x00, 0x00, 0xFE, 0x1F, 0xF3, 0xFE, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC7, 0xF8, 0xFE, 0x1F, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x3C,
  0x3C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE1, 0xF7, 0xE3,
  0xFF, 0xE3, 0x8F, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0x8F, 0xE3, 0xFF, 0xE1, 0xF7, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xBC,
  0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xE0, 0xE1, 0xC3, 0xC3, 0x87,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x78, 0x1C, 0xE0, 0x39, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3B,
  0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xF1, 0xF3, 0xFF, 0x8F, 0xFE, 0x3C, 0x7E,
  0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0x9F, 0xFE, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x07, 0xF0, 0x3B, 0x83, 0xDF, 0xFE, 0x7F,
  0xE1, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x87, 0xFF, 0xFD, 0xFF, 0xCF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0xE1, 0xFF,
  0x9F, 0xFE, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3B, 0x83, 0xDF, 0xFE, 0x7F, 0xE1, 0xFC, 0x00, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3B, 0xC1, 0xE7, 0xFF,
  0x8F, 0xFC, 0x1F, 0xC0, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0xF0,
  0xF3, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xEF,
  0x07, 0xBC, 0x0F, 0xF0, 0x3C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xF6, 0x3F, 0xD8,
  0xFF, 0x73, 0x7E, 0xCD, 0xFB, 0x77, 0xED, 0x9F, 0xBE, 0x7E, 0x79, 0xF9,
  0xCF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC3, 0xF6, 0x1F, 0xB8, 0xFD, 0xC7, 0xE6, 0x3F, 0x39, 0xF9, 0xCF, 0xC6,
  0x7E, 0x3B, 0xF1, 0xDF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x07, 0x80, 0x1F, 0xE1, 0xFF, 0x9F, 0xFC, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0x83, 0xDF, 0xFC, 0x7F,
  0xE1, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xEF, 0xFF, 0xBF, 0xFC,
  0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBC, 0x1E, 0xF0,
  0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8,
  0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xF0, 0x3B, 0xC1, 0xE7,
  0xFF, 0x0F, 0xFC, 0x1F, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xF3,
  0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0xF0, 0xF3, 0xC1, 0xCF, 0x07, 0xBC,
  0x0E, 0xF0, 0x3C, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBC, 0x1E, 0xF0, 0x3B,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xE7, 0xFF,
  0x9F, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3B,
  0x83, 0xDF, 0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0xF0, 0x0E, 0xE0, 0x3D, 0xC0,
  0x7B, 0x80, 0xE7, 0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0x70, 0x71, 0xE0, 0xE3, 0x81, 0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x07,
  0x70, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE3, 0xC6, 0xE3, 0xC6, 0xE2, 0xCE, 0xE6,
  0xCE, 0xE6, 0xCE, 0xE6, 0xCE, 0x66, 0xCE, 0x66, 0x4E, 0x76, 0x6E, 0x76,
  0x6C, 0x74, 0x6C, 0x74, 0x6C, 0x7C, 0x6C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0xF0, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C,
  0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x1C,
  0x78, 0x3C, 0x78, 0x38, 0x3C, 0x78, 0x3C, 0x70, 0x1E, 0xF0, 0x1F, 0xF0,
  0x0F, 0x70, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x38, 0x38, 0x3C, 0x38, 0x1C,
  0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xFF, 0xFF, 0xF8, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x7C, 0x03, 0xF0,
  0x3B, 0x81, 0xDC, 0x0E, 0x70, 0xE3, 0x87, 0x0E, 0x70, 0x73, 0x81, 0xF8,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0xE0, 0xF0, 0x1F,
  0xC1, 0xFF, 0x9F, 0xFE, 0xE0, 0xFF, 0x03, 0x80, 0x1C, 0x00, 0xE7, 0xFF,
  0x7F, 0xFF, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xFC, 0x7D, 0xFE, 0xE7,
  0xE7, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xF3, 0xFF,
  0xDF, 0xFF, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0xEF, 0x7E, 0x00,
  0x1F, 0xC1, 0xFF, 0x9F, 0xFE, 0xE0, 0xFF, 0x03, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x77, 0x07, 0xBF, 0xFC, 0xFF,
  0xC3, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x8F, 0x9C,
  0xFE, 0xEF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xDF, 0xFE, 0xFF, 0x71, 0xF3,
  0x80, 0x1F, 0xC1, 0xFF, 0x9F, 0x7C, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x07, 0xBE, 0xFC,
  0xFF, 0xC3, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFF, 0xE0, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1E, 0xF0, 0xF7,
  0xFF, 0x9F, 0xDC, 0x7C, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xCF, 0xFE, 0x7F,
  0xE3, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7B,
  0xF3, 0xFF, 0xDF, 0xFF, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0x80, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x1E, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE7, 0xFE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xEF, 0xFC, 0xFF, 0x8F,
  0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xFF,
  0x03, 0xBC, 0x1E, 0xF0, 0xF3, 0xC3, 0x8F, 0x1E, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0x1C, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0xBC, 0x0F,
  0xF0, 0x3C, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0xDE, 0x7B, 0x7F, 0xEE, 0x7B, 0xF9,
  0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E,
  0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xF7, 0xE7,
  0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0x1F, 0xC1, 0xFF, 0x9F, 0xFC, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x07, 0xBF, 0xF8, 0xFF,
  0xC3, 0xF8, 0xF7, 0xE7, 0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xFF,
  0xFF, 0xFF, 0xDE, 0xFC, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xBF, 0xFD,
  0xFE, 0xE3, 0xE7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0xE7, 0xC7, 0x7F, 0xBF, 0xFD, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x1F, 0xE3, 0xFF, 0x9F, 0xFE, 0xE0, 0x77, 0x00, 0x38, 0x01,
  0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x7F, 0x03, 0xBF,
  0xFD, 0xFF, 0xC3, 0xFC, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x87,
  0xBF, 0xF8, 0xFF, 0x83, 0xF8, 0xF0, 0x0E, 0xE0, 0x3D, 0xC0, 0x73, 0xC0,
  0xE3, 0x83, 0xC7, 0x07, 0x0F, 0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x3C, 0xE0,
  0x3B, 0xC0, 0x77, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0xE3,
  0x87, 0xE3, 0x86, 0xE3, 0x86, 0xE3, 0xCE, 0xE2, 0xCE, 0x66, 0xCE, 0x66,
  0xCE, 0x76, 0xCE, 0x76, 0x4C, 0x76, 0x6C, 0x76, 0x7C, 0x74, 0x7C, 0x3C,
  0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x38, 0x78, 0x1E, 0x70, 0x78, 0xF1,
  0xE0, 0xF3, 0xC0, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x3B, 0xC0, 0xF7, 0x83, 0xC7, 0x87, 0x87, 0x9E, 0x0F, 0x78,
  0x0F, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0x71, 0xC1, 0xE3, 0xC3, 0xC7, 0x87,
  0x07, 0x1E, 0x0F, 0x38, 0x0E, 0x70, 0x1D, 0xE0, 0x3F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xC0, 0xFE,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x0F, 0xF8, 0x7E, 0x03, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xF8,
  0x0F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7F, 0x80,
  0xFC, 0x1F, 0xE1, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x00, 0x10, 0x01,
  0xF8, 0x7F, 0xE1, 0xFB, 0xC7, 0xC7, 0xFF, 0x0F, 0xEC, 0x0F, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 10, 9, 17, 4, -21 },
  { 27, 16, 21, 17, 1, -21 },
  { 69, 14, 29, 17, 2, -25 },
  { 120, 17, 21, 17, 0, -21 },
  { 165, 16, 21, 17, 1, -21 },
  { 207, 3, 9, 17, 7, -21 },
  { 211, 9, 27, 17, 5, -24 },
  { 242, 9, 27, 17, 3, -24 },
  { 273, 16, 15, 17, 1, -18 },
  { 303, 14, 13, 17, 2, -16 },
  { 326, 7, 9, 17, 4, -4 },
  { 334, 9, 3, 17, 4, -11 },
  { 338, 5, 5, 17, 6, -5 },
  { 342, 14, 27, 17, 2, -24 },
  { 390, 13, 21, 17, 2, -21 },
  { 425, 14, 21, 17, 2, -21 },
  { 462, 13, 21, 17, 2, -21 },
  { 497, 13, 21, 17, 2, -21 },
  { 532, 13, 21, 17, 2, -21 },
  { 567, 13, 21, 17, 2, -21 },
  { 602, 14, 21, 17, 2, -21 },
  { 639, 14, 21, 17, 2, -21 },
  { 676, 13, 21, 17, 2, -21 },
  { 711, 14, 21, 17, 2, -21 },
  { 748, 5, 16, 17, 6, -16 },
  { 758, 6, 21, 17, 5, -16 },
  { 774, 13, 15, 17, 2, -17 },
  { 799, 13, 11, 17, 2, -15 },
  { 817, 13, 15, 17, 2, -17 },
  { 842, 11, 21, 17, 4, -21 },
  { 871, 16, 26, 17, 1, -21 },
  { 923, 15, 21, 17, 1, -21 },
  { 963, 14, 21, 17, 2, -21 },
  { 1000, 13, 21, 17, 2, -21 },
  { 1035, 13, 21, 17, 2, -21 },
  { 1070, 12, 21, 17, 3, -21 },
  { 1102, 13, 21, 17, 2, -21 },
  { 1137, 13, 21, 17, 2, -21 },
  { 1172, 13, 21, 17, 2, -21 },
  { 1207, 12, 21, 17, 3, -21 },
  { 1239, 14, 21, 17, 1, -21 },
  { 1276, 14, 21, 17, 2, -21 },
  { 1313, 13, 21, 17, 3, -21 },
  { 1348, 14, 21, 17, 2, -21 },
  { 1385, 13, 21, 17, 2, -21 },
  { 1420, 13, 21, 17, 2, -21 },
  { 1455, 14, 21, 17, 2, -21 },
  { 1492, 14, 26, 17, 2, -21 },
  { 1538, 14, 21, 17, 2, -21 },
  { 1575, 14, 21, 17, 2, -21 },
  { 1612, 15, 21, 17, 1, -21 },
  { 1652, 13, 21, 17, 2, -21 },
  { 1687, 15, 21, 17, 1, -21 },
  { 1727, 16, 21, 17, 1, -21 },
  { 1769, 16, 21, 17, 1, -21 },
  { 1811, 16, 21, 17, 1, -21 },
  { 1853, 13, 21, 17, 2, -21 },
  { 1888, 7, 27, 17, 6, -24 },
  { 1912, 14, 27, 17, 2, -24 },
  { 1960, 8, 27, 17, 4, -24 },
  { 1987, 13, 11, 17, 2, -21 },
  { 2005, 14, 3, 17, 2, 1 },
  { 2011, 7, 4, 17, 5, -23 },
  { 2015, 13, 16, 17, 2, -16 },
  { 2041, 13, 21, 17, 2, -21 },
  { 2076, 13, 16, 17, 2, -16 },
  { 2102, 13, 21, 17, 2, -21 },
  { 2137, 13, 16, 17, 2, -16 },
  { 2163, 14, 21, 17, 2, -21 },
  { 2200, 13, 21, 17, 2, -16 },
  { 2235, 13, 21, 17, 2, -21 },
  { 2270, 14, 23, 17, 2, -23 },
  { 2311, 12, 28, 17, 2, -23 },
  { 2353, 14, 21, 17, 2, -21 },
  { 2390, 15, 21, 17, 1, -21 },
  { 2430, 14, 16, 17, 2, -16 },
  { 2458, 13, 16, 17, 2, -16 },
  { 2484, 13, 16, 17, 2, -16 },
  { 2510, 13, 21, 17, 2, -16 },
  { 2545, 13, 21, 17, 2, -16 },
  { 2580, 13, 16, 17, 3, -16 },
  { 2606, 13, 16, 17, 2, -16 },
  { 2632, 14, 20, 17, 1, -20 },
  { 2667, 13, 16, 17, 2, -16 },
  { 2693, 15, 16, 17, 1, -16 },
  { 2723, 16, 16, 17, 1, -16 },
  { 2755, 15, 16, 17, 1, -16 },
  { 2785, 15, 21, 17, 1, -16 },
  { 2825, 13, 16, 17, 2, -16 },
  { 2851, 13, 27, 17, 2, -24 },
  { 2895, 3, 27, 17, 7, -24 },
  { 2906, 13, 27, 17, 2, -24 },
  { 2950, 14, 7, 17, 2, -14 },
};

const GFXfont JetBrainsMono_SemiBold29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_SEMIBOLD29PT7B_H_
