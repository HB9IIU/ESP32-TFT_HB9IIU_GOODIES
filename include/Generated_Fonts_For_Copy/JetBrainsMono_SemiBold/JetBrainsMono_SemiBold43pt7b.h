#ifndef _JETBRAINSMONO_SEMIBOLD43PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xEF, 0xDF, 0x80, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x70, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03,
  0xC0, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x0E, 0x03, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7E, 0x67, 0xE7, 0xC6, 0x3E, 0xF8, 0x61, 0xFF, 0x86, 0x1F,
  0xF8, 0x60, 0x0F, 0xC6, 0x00, 0x7C, 0x60, 0x07, 0xE6, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x6F, 0xE0, 0x06, 0x3F, 0x00, 0x61, 0xF0, 0x06, 0x1F, 0x00,
  0x61, 0xFF, 0x86, 0x1F, 0xF8, 0x61, 0xFF, 0xC6, 0x3F, 0xFE, 0x67, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x47, 0xF8, 0x01, 0xE3, 0xFF, 0x00, 0x71, 0xFF,
  0xC0, 0x3C, 0x78, 0x78, 0x1E, 0x1C, 0x1E, 0x07, 0x07, 0x07, 0x83, 0xC1,
  0xC1, 0xE1, 0xE0, 0x70, 0x78, 0xF0, 0x1C, 0x1E, 0x3C, 0x07, 0x87, 0x9E,
  0x01, 0xF7, 0xCF, 0x00, 0x3F, 0xF3, 0x80, 0x07, 0xF9, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x8F, 0xC0, 0x01, 0xEF, 0xFC, 0x00, 0xF3, 0xFF, 0x00, 0x79, 0xE1,
  0xE0, 0x1C, 0x78, 0x78, 0x0F, 0x1E, 0x0E, 0x07, 0x87, 0x83, 0x81, 0xC1,
  0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x78, 0x1E, 0x1E, 0x3C, 0x07, 0x87, 0x8F,
  0x00, 0xFF, 0xC7, 0x80, 0x3F, 0xF3, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0,
  0xFB, 0xE3, 0xE3, 0xE7, 0xC3, 0xE7, 0xCF, 0x87, 0xDF, 0x1F, 0x07, 0xFE,
  0x3E, 0x07, 0xF8, 0x7C, 0x0F, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x3F, 0x87, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF, 0x0F,
  0xFF, 0x3F, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE,
  0xF7, 0x80, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x0C, 0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F,
  0x8F, 0xF8, 0x7F, 0x03, 0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x08,
  0x07, 0x80, 0x8E, 0x0F, 0x07, 0x3F, 0x1C, 0x3F, 0x7F, 0x99, 0xFF, 0xFF,
  0xB7, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF3, 0xC0, 0x07, 0xE7, 0xC0, 0x0F, 0x87,
  0xC0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x70, 0x1E, 0x00, 0x60, 0x18,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE1,
  0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0xFC, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x84, 0x1F, 0xF8, 0xF1, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9,
  0xFF, 0x9F, 0x1F, 0xF8, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x80,
  0xFE, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0E, 0x0F, 0x80, 0xC0, 0xF8,
  0x08, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0xFC,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7D, 0xF8, 0x3F, 0xBF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x07, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x38, 0x07,
  0xDF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E,
  0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xE7, 0xC0,
  0x3E, 0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF7, 0xF8,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x03, 0xF3, 0xF0,
  0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0,
  0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF,
  0xC0, 0x3E, 0xF8, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E,
  0x3E, 0x0F, 0xC1, 0xF9, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0xF8, 0x3F, 0x1F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xF7, 0xE0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0xFB, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF8, 0x07, 0xE7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF0, 0xFF,
  0xEF, 0x83, 0xFE, 0xF8, 0x07, 0xEF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x1F, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xC7, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0x01, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xCF,
  0xF0, 0x3F, 0x9F, 0xC1, 0xFF, 0x7F, 0x0F, 0xC7, 0xFC, 0x3E, 0x0F, 0xF0,
  0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0,
  0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F,
  0xC3, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0,
  0x18, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3D, 0xF0,
  0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xC1,
  0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x7C,
  0x00, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x7E, 0xF8, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xF0, 0xFE, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xEF, 0x80, 0x7E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF,
  0x80, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03,
  0xEF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0x7C, 0x03, 0xE7, 0xF0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0x9F,
  0xC1, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF,
  0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F,
  0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x77, 0xEE, 0x07, 0x7E, 0xF0, 0xFF,
  0xEF, 0x0F, 0xFF, 0x70, 0xEF, 0xF7, 0x1E, 0xFF, 0x79, 0xEF, 0xF7, 0x9C,
  0xFF, 0x39, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xF1, 0xF8, 0xFF, 0x1F,
  0x8F, 0xF1, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xF0, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0x78, 0x3F, 0xEF, 0x07, 0xFC, 0xF0, 0xFF, 0x9E, 0x1F, 0xF3, 0xC3,
  0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xFF, 0x0F, 0x3F, 0xE1, 0xE7,
  0xFC, 0x3C, 0xFF, 0x83, 0xDF, 0xF0, 0x7B, 0xFE, 0x0F, 0x7F, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0x80, 0x7F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80,
  0x3F, 0x7C, 0x07, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0xFD, 0xF8, 0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0x80, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1E, 0x78, 0x7E, 0x1E,
  0x78, 0x7E, 0x1E, 0x78, 0x6E, 0x1E, 0x78, 0x66, 0x1E, 0x78, 0xE6, 0x1E,
  0x78, 0xE7, 0x1E, 0x78, 0xE7, 0x3E, 0x78, 0xE7, 0x3E, 0x7C, 0xE7, 0x3C,
  0x7C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xC7, 0x3C, 0x3C, 0xC3, 0x3C,
  0x3D, 0xC3, 0x3C, 0x3D, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC,
  0x3D, 0xC3, 0xB8, 0x3D, 0xC3, 0xF8, 0x3D, 0x83, 0xF8, 0x1D, 0x83, 0xF8,
  0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x7E, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x03,
  0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xF0,
  0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xE0, 0x07, 0xCF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x9E, 0x00, 0xF1, 0xF0,
  0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0x3C, 0x03,
  0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x3F, 0x87, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF7, 0xF0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x9E, 0xF3, 0xFF, 0xEF,
  0x1F, 0xFC, 0xF0, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87,
  0xE0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFB, 0xFF, 0xCF, 0xF9, 0xFE, 0xFE,
  0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFF, 0x0F,
  0xEF, 0xBF, 0xFE, 0xFB, 0xFF, 0xCF, 0x9F, 0xF8, 0xF8, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7,
  0xE0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xF0,
  0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x1F, 0x1F, 0xFB, 0xE7, 0xFF, 0x7D, 0xFF,
  0xFF, 0xBF, 0x8F, 0xF7, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0x80,
  0xFD, 0xF8, 0x3F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xF7, 0xC3, 0xFC,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E,
  0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE3, 0xE3, 0xFF, 0x7C, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xF1, 0xFE, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0x7C, 0x07, 0xEF, 0xC1, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF,
  0xBE, 0x1F, 0xE7, 0xC0, 0x60, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0xF9, 0xFF,
  0x9F, 0x7F, 0xFB, 0xEF, 0xFF, 0x7F, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E,
  0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F,
  0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xF9,
  0xE3, 0xE7, 0xFF, 0xBF, 0xBF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x87,
  0xFC, 0x3C, 0x3F, 0xE1, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC3,
  0xC3, 0xFE, 0x1E, 0x1F, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xFC, 0x3C, 0x3F,
  0xE1, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3, 0xFE, 0x1E,
  0x1F, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xFC, 0x3C, 0x3F, 0xE1, 0xE1, 0xFF,
  0x0F, 0x0F, 0xF8, 0x7E, 0x1F, 0x3F, 0xF3, 0xEF, 0xFF, 0x7D, 0xFF, 0xEF,
  0xF9, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7,
  0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xF0,
  0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xF8,
  0x7E, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0x9F, 0xEF,
  0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xF0,
  0xFE, 0xFB, 0xFF, 0xEF, 0xBF, 0xFC, 0xF9, 0xFF, 0x8F, 0x8F, 0xF0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE3, 0xE3, 0xFF, 0x7C,
  0xFF, 0xEF, 0x9F, 0xFF, 0xF7, 0xF1, 0xFE, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0x07, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFE, 0xF8, 0x7F, 0x9F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0xFE, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF,
  0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x07, 0xE7,
  0xC0, 0x3E, 0x7C, 0x00, 0x17, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x1F, 0xBF, 0x87, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF8, 0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x1E,
  0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x6E, 0x1E, 0x78, 0x66, 0x1C,
  0x78, 0xE6, 0x3C, 0x3C, 0xE6, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C,
  0x3C, 0xE7, 0x3C, 0x3C, 0xC7, 0x3C, 0x3C, 0xC3, 0x38, 0x3D, 0xC3, 0x78,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8,
  0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFC, 0x00, 0xFD,
  0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x87, 0xE0, 0x3E,
  0x1F, 0x00, 0xFC, 0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x01, 0xF8,
  0x7C, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0xBF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x83, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0x03, 0xDF, 0xFC, 0x1E, 0xFF, 0xE0, 0xFF, 0x8F, 0x87, 0xFC,
  0x3F, 0x7F, 0xE0, 0xFF, 0xFF, 0x07, 0xFE, 0xF8, 0x1F, 0xE0, 0x00, 0x1C,
  0x00,
};

const GFXglyph JetBrainsMono_SemiBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 31, 26, 9, -31 },
  { 29, 14, 13, 26, 6, -31 },
  { 52, 24, 31, 26, 1, -31 },
  { 145, 20, 43, 26, 3, -37 },
  { 253, 26, 32, 26, 0, -32 },
  { 357, 23, 32, 26, 2, -32 },
  { 449, 5, 13, 26, 10, -31 },
  { 458, 14, 41, 26, 7, -36 },
  { 530, 13, 41, 26, 5, -36 },
  { 597, 23, 22, 26, 1, -26 },
  { 661, 20, 20, 26, 3, -24 },
  { 711, 10, 14, 26, 7, -7 },
  { 729, 14, 4, 26, 6, -16 },
  { 736, 8, 7, 26, 9, -7 },
  { 743, 20, 41, 26, 3, -36 },
  { 846, 20, 32, 26, 3, -32 },
  { 926, 20, 31, 26, 4, -31 },
  { 1004, 20, 32, 26, 3, -32 },
  { 1084, 19, 31, 26, 3, -31 },
  { 1158, 19, 31, 26, 3, -31 },
  { 1232, 20, 31, 26, 3, -31 },
  { 1310, 21, 31, 26, 2, -31 },
  { 1392, 20, 31, 26, 3, -31 },
  { 1470, 20, 32, 26, 3, -32 },
  { 1550, 21, 32, 26, 2, -32 },
  { 1634, 8, 24, 26, 9, -24 },
  { 1658, 10, 31, 26, 7, -24 },
  { 1697, 19, 24, 26, 3, -26 },
  { 1754, 18, 15, 26, 4, -22 },
  { 1788, 19, 24, 26, 3, -26 },
  { 1845, 17, 31, 26, 5, -31 },
  { 1911, 22, 40, 26, 2, -32 },
  { 2021, 22, 31, 26, 2, -31 },
  { 2107, 20, 31, 26, 3, -31 },
  { 2185, 20, 32, 26, 3, -32 },
  { 2265, 20, 31, 26, 3, -31 },
  { 2343, 19, 31, 26, 4, -31 },
  { 2417, 19, 31, 26, 4, -31 },
  { 2491, 20, 32, 26, 3, -32 },
  { 2571, 19, 31, 26, 3, -31 },
  { 2645, 18, 31, 26, 4, -31 },
  { 2715, 21, 31, 26, 1, -31 },
  { 2797, 21, 31, 26, 3, -31 },
  { 2879, 18, 31, 26, 5, -31 },
  { 2949, 20, 31, 26, 3, -31 },
  { 3027, 19, 31, 26, 3, -31 },
  { 3101, 20, 32, 26, 3, -32 },
  { 3181, 21, 31, 26, 3, -31 },
  { 3263, 20, 40, 26, 3, -32 },
  { 3363, 21, 31, 26, 3, -31 },
  { 3445, 20, 32, 26, 3, -32 },
  { 3525, 22, 31, 26, 2, -31 },
  { 3611, 19, 31, 26, 3, -31 },
  { 3685, 22, 31, 26, 2, -31 },
  { 3771, 24, 31, 26, 1, -31 },
  { 3864, 23, 31, 26, 1, -31 },
  { 3954, 24, 31, 26, 1, -31 },
  { 4047, 19, 31, 26, 3, -31 },
  { 4121, 12, 41, 26, 8, -36 },
  { 4183, 20, 41, 26, 3, -36 },
  { 4286, 12, 41, 26, 6, -36 },
  { 4348, 20, 16, 26, 3, -31 },
  { 4388, 20, 5, 26, 3, 1 },
  { 4401, 10, 6, 26, 7, -34 },
  { 4409, 20, 24, 26, 2, -24 },
  { 4469, 20, 31, 26, 3, -31 },
  { 4547, 20, 24, 26, 3, -24 },
  { 4607, 19, 31, 26, 3, -31 },
  { 4681, 20, 24, 26, 3, -24 },
  { 4741, 21, 31, 26, 2, -31 },
  { 4823, 19, 32, 26, 3, -24 },
  { 4899, 19, 31, 26, 3, -31 },
  { 4973, 21, 34, 26, 3, -34 },
  { 5063, 16, 42, 26, 4, -34 },
  { 5147, 20, 31, 26, 4, -31 },
  { 5225, 23, 31, 26, 1, -31 },
  { 5315, 21, 24, 26, 2, -24 },
  { 5378, 19, 24, 26, 3, -24 },
  { 5435, 20, 24, 26, 3, -24 },
  { 5495, 20, 32, 26, 3, -24 },
  { 5575, 19, 32, 26, 3, -24 },
  { 5651, 20, 24, 26, 4, -24 },
  { 5711, 20, 24, 26, 3, -24 },
  { 5771, 21, 30, 26, 2, -30 },
  { 5850, 19, 24, 26, 3, -24 },
  { 5907, 22, 24, 26, 2, -24 },
  { 5973, 24, 24, 26, 1, -24 },
  { 6045, 22, 24, 26, 2, -24 },
  { 6111, 22, 32, 26, 2, -24 },
  { 6199, 19, 24, 26, 3, -24 },
  { 6256, 19, 41, 26, 3, -36 },
  { 6354, 5, 41, 26, 10, -36 },
  { 6380, 19, 41, 26, 3, -36 },
  { 6478, 21, 10, 26, 2, -20 },
};

const GFXfont JetBrainsMono_SemiBold43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_SEMIBOLD43PT7B_H_
