#ifndef _JETBRAINSMONO_SEMIBOLD12PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA0, 0xC0, 0xBB, 0xBA, 0x34, 0x49, 0xF9, 0x22, 0xC5, 0x3F,
  0x24, 0x48, 0x23, 0xBF, 0x5E, 0x38, 0xE5, 0xAB, 0xC8, 0x40, 0x63, 0x2A,
  0x57, 0x41, 0x07, 0xCA, 0xA5, 0x8E, 0x73, 0x68, 0x10, 0xE6, 0xA9, 0xA6,
  0xEC, 0xF0, 0x36, 0x4C, 0x88, 0x8C, 0xC6, 0x30, 0xC6, 0x31, 0x11, 0x11,
  0x32, 0xC0, 0x10, 0xA7, 0xF8, 0xC2, 0x8C, 0x80, 0x21, 0x3F, 0xF2, 0x10,
  0x7B, 0x40, 0xFF, 0xF0, 0x08, 0xC6, 0x23, 0x10, 0x8C, 0x46, 0x30, 0x76,
  0xE3, 0x1A, 0xC6, 0x39, 0x70, 0x33, 0xCB, 0x0C, 0x30, 0xC3, 0x0C, 0xFC,
  0x76, 0xE2, 0x11, 0x99, 0x98, 0xF8, 0xF8, 0xCC, 0x43, 0x84, 0x31, 0x70,
  0x19, 0x88, 0xCC, 0xC7, 0xE1, 0x08, 0xFF, 0xE1, 0x6D, 0x84, 0x39, 0x78,
  0x30, 0x86, 0x10, 0xFA, 0x28, 0xF2, 0x78, 0xFF, 0xF8, 0x86, 0x10, 0xC2,
  0x08, 0x60, 0x76, 0xE3, 0xB7, 0x6E, 0x39, 0x78, 0x73, 0x68, 0xA3, 0xD9,
  0xE1, 0x0C, 0x60, 0xB0, 0x2C, 0x5C, 0x00, 0xD6, 0x80, 0x09, 0xB1, 0x87,
  0x04, 0xF8, 0x01, 0xF0, 0x83, 0x86, 0x37, 0x60, 0xF7, 0xC2, 0x37, 0x30,
  0x00, 0x60, 0x38, 0xC9, 0x0E, 0xDD, 0x7A, 0x74, 0xEF, 0x40, 0x80, 0xE0,
  0x18, 0x70, 0xA1, 0x42, 0xCD, 0x9F, 0x22, 0xC6, 0xF2, 0x68, 0xA2, 0xF2,
  0x28, 0xE2, 0xF8, 0x76, 0xE3, 0x08, 0x42, 0x19, 0x78, 0xF7, 0xE3, 0x18,
  0xC6, 0x33, 0xF0, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0xF8, 0xFF, 0xE1, 0x0F,
  0xC2, 0x10, 0x80, 0x76, 0xE3, 0x0B, 0xDE, 0x39, 0x78, 0x8C, 0x63, 0x1F,
  0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42, 0x10, 0x84, 0xF8, 0x1C, 0x70, 0x41,
  0x04, 0x1C, 0x53, 0x78, 0x8E, 0x29, 0xA4, 0xF2, 0x49, 0xA2, 0x8C, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xF8, 0xCE, 0xF7, 0xBA, 0xC6, 0x31, 0x88, 0xCE,
  0x73, 0x5A, 0xD6, 0x73, 0x98, 0x76, 0xE3, 0x18, 0xC6, 0x39, 0x70, 0xF3,
  0xE8, 0xE3, 0xFB, 0xC8, 0x20, 0x80, 0x76, 0xE3, 0x18, 0xC6, 0x39, 0x78,
  0x82, 0xF2, 0x68, 0xE2, 0xFA, 0x49, 0x26, 0x8C, 0x76, 0xE3, 0x87, 0x0C,
  0x31, 0x78, 0xFF, 0xF2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x63, 0x18,
  0xC6, 0x39, 0x78, 0xC6, 0x89, 0x13, 0x22, 0xC5, 0x0A, 0x1C, 0x18, 0x93,
  0xA7, 0x4B, 0x76, 0xED, 0x9B, 0x36, 0x6C, 0x46, 0xC8, 0xA1, 0xC1, 0x07,
  0x0A, 0x36, 0xC6, 0xC6, 0x89, 0xB1, 0x43, 0x82, 0x04, 0x08, 0x10, 0xFF,
  0xC6, 0x62, 0x31, 0x18, 0xF8, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0x86,
  0x10, 0xC6, 0x10, 0xC2, 0x10, 0xC2, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x23,
  0x95, 0xB8, 0x80, 0xFF, 0xC0, 0xE0, 0x76, 0xC2, 0xF8, 0xC7, 0xE0, 0x84,
  0x2D, 0xB8, 0xC6, 0x39, 0xB8, 0x77, 0xE3, 0x08, 0x65, 0xE0, 0x08, 0x5B,
  0xB8, 0xC6, 0x39, 0x78, 0x76, 0xE3, 0xF8, 0x45, 0xE0, 0x39, 0x09, 0xF2,
  0x10, 0x84, 0x20, 0x6E, 0xE3, 0x18, 0xFD, 0xA1, 0x78, 0x84, 0x2D, 0xB8,
  0xC6, 0x31, 0x88, 0x30, 0x0F, 0x3C, 0x30, 0xC3, 0x0C, 0xFC, 0x18, 0x3D,
  0xE1, 0x08, 0x42, 0x10, 0xBC, 0x82, 0x08, 0xE6, 0x93, 0xC9, 0x26, 0x8C,
  0xF1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x1E, 0xFA, 0xBA, 0xEB, 0xAE,
  0xBA, 0xC0, 0xB6, 0xE3, 0x18, 0xC6, 0x20, 0x77, 0xE3, 0x18, 0xE5, 0xC0,
  0xB6, 0xE3, 0x18, 0xE6, 0xF0, 0x80, 0x6E, 0xE3, 0x18, 0xE5, 0xE1, 0x08,
  0xF3, 0x6C, 0xF0, 0xC3, 0x0C, 0x00, 0x76, 0xE0, 0xE0, 0xC7, 0xE0, 0x67,
  0xFE, 0xC6, 0x31, 0x87, 0x8C, 0x63, 0x18, 0xE5, 0xC0, 0x8E, 0x2C, 0x96,
  0x51, 0xC3, 0x00, 0x93, 0xA5, 0x5B, 0x66, 0xCD, 0x9B, 0x00, 0x46, 0xD8,
  0xE0, 0x83, 0x8D, 0xB1, 0x80, 0xC6, 0x89, 0xB1, 0x63, 0x83, 0x04, 0x08,
  0x30, 0xFF, 0xC4, 0x66, 0x63, 0xE0, 0x19, 0x8C, 0x63, 0x70, 0xC6, 0x31,
  0x86, 0xFF, 0xE0, 0xC3, 0x18, 0xC6, 0x1C, 0x8C, 0x63, 0x38, 0x43, 0xBB,
  0x80,
};

const GFXglyph JetBrainsMono_SemiBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 9, 7, 3, -9 },
  { 4, 4, 4, 7, 2, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 5, 12, 7, 1, -10 },
  { 22, 7, 9, 7, 0, -9 },
  { 30, 6, 9, 7, 1, -9 },
  { 37, 1, 4, 7, 3, -9 },
  { 38, 4, 11, 7, 2, -10 },
  { 44, 4, 11, 7, 1, -10 },
  { 50, 7, 6, 7, 0, -7 },
  { 56, 5, 6, 7, 1, -7 },
  { 60, 3, 4, 7, 2, -2 },
  { 62, 4, 2, 7, 2, -5 },
  { 63, 2, 2, 7, 3, -2 },
  { 64, 5, 11, 7, 1, -10 },
  { 71, 5, 9, 7, 1, -9 },
  { 77, 6, 9, 7, 1, -9 },
  { 84, 5, 9, 7, 1, -9 },
  { 90, 5, 9, 7, 1, -9 },
  { 96, 5, 9, 7, 1, -9 },
  { 102, 5, 9, 7, 1, -9 },
  { 108, 6, 9, 7, 1, -9 },
  { 115, 6, 9, 7, 1, -9 },
  { 122, 5, 9, 7, 1, -9 },
  { 128, 6, 9, 7, 1, -9 },
  { 135, 2, 7, 7, 3, -7 },
  { 137, 3, 9, 7, 2, -7 },
  { 141, 5, 6, 7, 1, -7 },
  { 145, 5, 4, 7, 1, -6 },
  { 148, 5, 6, 7, 1, -7 },
  { 152, 5, 9, 7, 1, -9 },
  { 158, 7, 11, 7, 0, -9 },
  { 168, 7, 9, 7, 0, -9 },
  { 176, 6, 9, 7, 1, -9 },
  { 183, 5, 9, 7, 1, -9 },
  { 189, 5, 9, 7, 1, -9 },
  { 195, 5, 9, 7, 1, -9 },
  { 201, 5, 9, 7, 1, -9 },
  { 207, 5, 9, 7, 1, -9 },
  { 213, 5, 9, 7, 1, -9 },
  { 219, 5, 9, 7, 1, -9 },
  { 225, 6, 9, 7, 0, -9 },
  { 232, 6, 9, 7, 1, -9 },
  { 239, 5, 9, 7, 1, -9 },
  { 245, 5, 9, 7, 1, -9 },
  { 251, 5, 9, 7, 1, -9 },
  { 257, 5, 9, 7, 1, -9 },
  { 263, 6, 9, 7, 1, -9 },
  { 270, 5, 11, 7, 1, -9 },
  { 277, 6, 9, 7, 1, -9 },
  { 284, 5, 9, 7, 1, -9 },
  { 290, 6, 9, 7, 1, -9 },
  { 297, 5, 9, 7, 1, -9 },
  { 303, 7, 9, 7, 0, -9 },
  { 311, 7, 9, 7, 0, -9 },
  { 319, 7, 9, 7, 0, -9 },
  { 327, 7, 9, 7, 0, -9 },
  { 335, 5, 9, 7, 1, -9 },
  { 341, 4, 11, 7, 2, -10 },
  { 347, 5, 11, 7, 1, -10 },
  { 354, 3, 11, 7, 2, -10 },
  { 359, 5, 5, 7, 1, -9 },
  { 363, 5, 2, 7, 1, 0 },
  { 365, 3, 1, 7, 2, -9 },
  { 366, 5, 7, 7, 1, -7 },
  { 371, 5, 9, 7, 1, -9 },
  { 377, 5, 7, 7, 1, -7 },
  { 382, 5, 9, 7, 1, -9 },
  { 388, 5, 7, 7, 1, -7 },
  { 393, 5, 9, 7, 1, -9 },
  { 399, 5, 9, 7, 1, -7 },
  { 405, 5, 9, 7, 1, -9 },
  { 411, 6, 9, 7, 1, -9 },
  { 418, 5, 11, 7, 1, -9 },
  { 425, 6, 9, 7, 1, -9 },
  { 432, 7, 9, 7, 0, -9 },
  { 440, 6, 7, 7, 1, -7 },
  { 446, 5, 7, 7, 1, -7 },
  { 451, 5, 7, 7, 1, -7 },
  { 456, 5, 9, 7, 1, -7 },
  { 462, 5, 9, 7, 1, -7 },
  { 468, 6, 7, 7, 1, -7 },
  { 474, 5, 7, 7, 1, -7 },
  { 479, 5, 8, 7, 1, -8 },
  { 484, 5, 7, 7, 1, -7 },
  { 489, 6, 7, 7, 1, -7 },
  { 495, 7, 7, 7, 0, -7 },
  { 502, 7, 7, 7, 0, -7 },
  { 509, 7, 9, 7, 0, -7 },
  { 517, 5, 7, 7, 1, -7 },
  { 522, 5, 11, 7, 1, -10 },
  { 529, 1, 11, 7, 3, -10 },
  { 531, 5, 11, 7, 1, -10 },
  { 538, 6, 3, 7, 1, -6 },
};

const GFXfont JetBrainsMono_SemiBold12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_SEMIBOLD12PT7B_H_
