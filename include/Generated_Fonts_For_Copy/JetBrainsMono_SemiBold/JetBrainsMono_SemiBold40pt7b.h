#ifndef _JETBRAINSMONO_SEMIBOLD40PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFC, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x01, 0xE0, 0xF0, 0x07,
  0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x07,
  0x80, 0x3C, 0x1E, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x78, 0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70,
  0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE1, 0xE0, 0xF0, 0x07,
  0x83, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x03,
  0x80, 0x3C, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x67, 0xE7, 0xC6, 0x3E, 0x7C, 0x63,
  0xE7, 0xC6, 0x00, 0x7C, 0x60, 0x07, 0xC6, 0x00, 0x3E, 0x60, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xC0, 0x06, 0x7E, 0x00, 0x63, 0xE0, 0x06, 0x1E, 0x00, 0x61, 0xFF,
  0x86, 0x1F, 0xF8, 0x61, 0xE7, 0xC6, 0x3E, 0x7E, 0x67, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0xC0, 0x0F, 0x3F, 0xE0, 0x1E, 0x7F, 0xF0, 0x1C, 0x70, 0xF0, 0x38, 0x70,
  0x70, 0x78, 0x70, 0x70, 0xF0, 0x70, 0x70, 0xE0, 0x70, 0x71, 0xE0, 0x70,
  0x73, 0xC0, 0x78, 0xF3, 0x80, 0x7F, 0xE7, 0x00, 0x3F, 0xCF, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x71, 0xF8, 0x00, 0xF7, 0xFC, 0x01, 0xE7, 0xFE, 0x01, 0xCF, 0x0E, 0x03,
  0x8E, 0x0E, 0x07, 0x8E, 0x0E, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E,
  0x0E, 0x0E, 0x3C, 0x0F, 0x0E, 0x38, 0x07, 0xFE, 0x78, 0x07, 0xFC, 0xF0,
  0x01, 0xF8, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE,
  0x03, 0xF3, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFB, 0xE0, 0xF7, 0xCF,
  0x8F, 0xBC, 0x3E, 0x79, 0xE0, 0xF7, 0xCF, 0x07, 0xFC, 0x78, 0x1F, 0xE3,
  0xC0, 0x7E, 0x1E, 0x03, 0xE0, 0xF8, 0x1F, 0x87, 0xC1, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0x9F, 0x0F, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFD, 0xEF, 0x7B, 0xDE, 0xF0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x3F, 0x07,
  0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x01,
  0xF0, 0x07, 0x00, 0x10, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF8, 0xFF, 0x0F, 0xC0, 0xF8, 0x0E,
  0x00, 0x80, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x01, 0x81, 0xE0, 0x67, 0xC7, 0x8F, 0x9F, 0xCC,
  0xFE, 0xFF, 0xB7, 0xFC, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x0F,
  0x87, 0xC0, 0x7E, 0x1F, 0x80, 0xF0, 0x3C, 0x01, 0x80, 0x60, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x8F,
  0xC7, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E,
  0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F,
  0xBF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xCF,
  0xCF, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0x81, 0xF9, 0xF0, 0x3E,
  0x3E, 0x07, 0x07, 0xC0, 0xC0, 0xF8, 0x10, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFC, 0x0F, 0x9F, 0x00, 0xFB, 0xC0,
  0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xDE, 0x00,
  0xFB, 0xE0, 0x1F, 0x7E, 0x07, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x79, 0xF0, 0x3D, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x9F, 0xC1, 0xEF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE7, 0xC0, 0xFD, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x0F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF7, 0xE0, 0x3E, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7E,
  0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0xF9, 0xF0, 0x3E,
  0x3F, 0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F,
  0x87, 0xC7, 0xC0, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0x9F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0x80,
  0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0,
  0xFF, 0x7C, 0x03, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x7E, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x1F, 0x87, 0xE3, 0xFC, 0xFF, 0x1F,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF0,
  0x7C, 0x1F, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0x80, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0x01, 0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x63, 0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xF3, 0xFF, 0x0F, 0x87, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3,
  0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0,
  0xFF, 0x0F, 0x03, 0xFC, 0x3E, 0x1F, 0xF0, 0x78, 0x7F, 0xC1, 0xFF, 0xFF,
  0x03, 0xFB, 0xDE, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF9, 0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xE0, 0x7C, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1E, 0x7C, 0x0F, 0xCF,
  0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xF8, 0x0F, 0xDF,
  0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xDF, 0x03, 0xF7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03,
  0xF7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xE0, 0x1F, 0x7E,
  0x07, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xF8,
  0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xF0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0x70, 0xEF, 0xF7, 0x0E, 0xFF, 0x70, 0xEF, 0xF7, 0x9E,
  0xFF, 0x39, 0xCF, 0xF3, 0x9C, 0xFF, 0x3D, 0xDF, 0xF9, 0xF9, 0xFF, 0x9F,
  0x9F, 0xF9, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xDE, 0x0F, 0xF7, 0x83, 0xFD,
  0xE0, 0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3F, 0xC7, 0x8F, 0xF0, 0xF3, 0xFC, 0x3C, 0xFF, 0x07, 0x3F, 0xC1, 0xEF,
  0xF0, 0x7B, 0xFC, 0x0E, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0x80, 0xFD, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFE, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xF9, 0xF8, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xCF, 0x81, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xEF, 0x80,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xC0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x01,
  0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0x7C, 0x0F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78,
  0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x78,
  0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x9F,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0xDE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1F,
  0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xDE, 0x3F, 0x0E,
  0x78, 0xEC, 0x79, 0xE3, 0x31, 0xE7, 0x8C, 0xC7, 0x9E, 0x33, 0x1E, 0x78,
  0xCE, 0x79, 0xE7, 0x39, 0xE7, 0x9C, 0xE7, 0x9E, 0x73, 0x9E, 0x79, 0xCE,
  0x70, 0xE6, 0x19, 0xC3, 0xD8, 0x67, 0x0F, 0x61, 0xBC, 0x3D, 0x86, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x1F, 0x00, 0x3E, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x7C, 0xF8,
  0x00, 0xF3, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0x78,
  0x1E, 0x1E, 0x0F, 0x87, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x9E,
  0x01, 0xEF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xE0, 0x7C, 0xF8, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF,
  0xF7, 0xE0, 0x3E, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0xFD, 0xF8, 0x7F, 0xBF, 0xFF, 0xF3, 0xFF, 0xBE, 0x1F, 0xE7,
  0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE7, 0xF0, 0xFB, 0xFF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xEF, 0xFC, 0xF9, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03, 0xF7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x3F, 0x9F, 0x3F, 0xF7, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF,
  0x0F, 0xE7, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFC, 0xFE,
  0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xF1, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE7, 0xCF, 0xFD, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7C, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0x7F, 0x3F, 0xDF, 0xFF, 0xF3, 0xFF,
  0x7C, 0x7F, 0x9F, 0x03, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE7, 0xF0, 0xFB, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xF0, 0x3E, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x80,
  0x7C, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8,
  0x7E, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0,
  0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xF7, 0xC7, 0xCF, 0x7E, 0xFE, 0xFF,
  0xEF, 0xEF, 0x8F, 0x1F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF9, 0xFC, 0x3E, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x0F,
  0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xF9, 0xFC, 0x3E, 0xFF, 0xCF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFB, 0xFF, 0x3E, 0x7F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xE7, 0xCF, 0xFD, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7C, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xDF, 0x03, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7, 0xC3, 0xF9,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xF1, 0xFC, 0x3C, 0xFF, 0xCF, 0x7F, 0xFB,
  0xDF, 0xFE, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF9, 0xFC, 0xFF, 0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xF3, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78,
  0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x03, 0xC3,
  0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF8,
  0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xDE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F,
  0x70, 0xFC, 0x39, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x33, 0x1E, 0x78,
  0xCC, 0x79, 0xE3, 0x31, 0xE3, 0x9C, 0xE7, 0x0E, 0x73, 0x9C, 0x3D, 0xCE,
  0xF0, 0xF7, 0x3B, 0xC3, 0xD8, 0x6F, 0x0F, 0x61, 0xBC, 0x3D, 0x86, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C,
  0x0F, 0x80, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xF0, 0xFC,
  0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E,
  0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F,
  0x80, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x7D, 0xE0, 0x07, 0xDE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x0F,
  0x7F, 0xE0, 0xF7, 0xFE, 0x0F, 0xF9, 0xF0, 0xFF, 0x0F, 0x9F, 0xF0, 0x7F,
  0xEF, 0x03, 0xFE, 0xF0, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 29, 24, 9, -29 },
  { 23, 14, 12, 24, 5, -29 },
  { 44, 22, 29, 24, 1, -29 },
  { 124, 20, 41, 24, 2, -35 },
  { 227, 24, 29, 24, 0, -29 },
  { 314, 21, 30, 24, 2, -30 },
  { 393, 5, 12, 24, 9, -29 },
  { 401, 12, 39, 24, 7, -34 },
  { 460, 12, 39, 24, 5, -34 },
  { 519, 22, 20, 24, 1, -24 },
  { 574, 20, 19, 24, 2, -23 },
  { 622, 9, 12, 24, 6, -6 },
  { 636, 12, 4, 24, 6, -15 },
  { 642, 8, 7, 24, 8, -7 },
  { 649, 18, 37, 24, 3, -33 },
  { 733, 18, 30, 24, 3, -30 },
  { 801, 19, 29, 24, 3, -29 },
  { 870, 19, 30, 24, 2, -30 },
  { 942, 19, 29, 24, 2, -29 },
  { 1011, 17, 29, 24, 3, -29 },
  { 1073, 18, 29, 24, 3, -29 },
  { 1139, 20, 29, 24, 2, -29 },
  { 1212, 19, 29, 24, 3, -29 },
  { 1281, 18, 30, 24, 3, -30 },
  { 1349, 20, 30, 24, 2, -30 },
  { 1424, 8, 22, 24, 8, -22 },
  { 1446, 10, 28, 24, 6, -22 },
  { 1481, 18, 22, 24, 3, -24 },
  { 1531, 18, 14, 24, 3, -20 },
  { 1563, 18, 22, 24, 3, -24 },
  { 1613, 15, 29, 24, 5, -29 },
  { 1668, 22, 37, 24, 1, -30 },
  { 1770, 20, 29, 24, 2, -29 },
  { 1843, 19, 29, 24, 3, -29 },
  { 1912, 18, 30, 24, 3, -30 },
  { 1980, 18, 29, 24, 3, -29 },
  { 2046, 17, 29, 24, 4, -29 },
  { 2108, 18, 29, 24, 3, -29 },
  { 2174, 18, 30, 24, 3, -30 },
  { 2242, 18, 29, 24, 3, -29 },
  { 2308, 16, 29, 24, 4, -29 },
  { 2366, 19, 29, 24, 1, -29 },
  { 2435, 20, 29, 24, 3, -29 },
  { 2508, 17, 29, 24, 4, -29 },
  { 2570, 20, 29, 24, 2, -29 },
  { 2643, 18, 29, 24, 3, -29 },
  { 2709, 18, 30, 24, 3, -30 },
  { 2777, 19, 29, 24, 3, -29 },
  { 2846, 19, 37, 24, 3, -30 },
  { 2934, 19, 29, 24, 3, -29 },
  { 3003, 20, 30, 24, 2, -30 },
  { 3078, 20, 29, 24, 2, -29 },
  { 3151, 18, 29, 24, 3, -29 },
  { 3217, 20, 29, 24, 2, -29 },
  { 3290, 22, 29, 24, 1, -29 },
  { 3370, 22, 29, 24, 1, -29 },
  { 3450, 22, 29, 24, 1, -29 },
  { 3530, 18, 29, 24, 3, -29 },
  { 3596, 10, 37, 24, 8, -33 },
  { 3643, 18, 37, 24, 3, -33 },
  { 3727, 10, 37, 24, 6, -33 },
  { 3774, 18, 15, 24, 3, -29 },
  { 3808, 20, 4, 24, 2, 1 },
  { 3818, 9, 5, 24, 7, -31 },
  { 3824, 19, 22, 24, 2, -22 },
  { 3877, 18, 29, 24, 3, -29 },
  { 3943, 18, 22, 24, 3, -22 },
  { 3993, 18, 29, 24, 3, -29 },
  { 4059, 18, 22, 24, 3, -22 },
  { 4109, 20, 29, 24, 2, -29 },
  { 4182, 18, 29, 24, 3, -22 },
  { 4248, 18, 29, 24, 3, -29 },
  { 4314, 19, 31, 24, 3, -31 },
  { 4388, 16, 38, 24, 3, -31 },
  { 4464, 20, 29, 24, 3, -29 },
  { 4537, 21, 29, 24, 1, -29 },
  { 4614, 20, 22, 24, 2, -22 },
  { 4669, 18, 22, 24, 3, -22 },
  { 4719, 18, 22, 24, 3, -22 },
  { 4769, 18, 29, 24, 3, -22 },
  { 4835, 18, 29, 24, 3, -22 },
  { 4901, 18, 22, 24, 4, -22 },
  { 4951, 18, 22, 24, 3, -22 },
  { 5001, 19, 28, 24, 2, -28 },
  { 5068, 18, 22, 24, 3, -22 },
  { 5118, 20, 22, 24, 2, -22 },
  { 5173, 22, 22, 24, 1, -22 },
  { 5234, 20, 22, 24, 2, -22 },
  { 5289, 20, 29, 24, 2, -22 },
  { 5362, 18, 22, 24, 3, -22 },
  { 5412, 18, 37, 24, 3, -33 },
  { 5496, 4, 37, 24, 10, -33 },
  { 5515, 18, 37, 24, 3, -33 },
  { 5599, 20, 9, 24, 2, -19 },
};

const GFXfont JetBrainsMono_SemiBold40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_SEMIBOLD40PT7B_H_
