#ifndef _JETBRAINSMONO_SEMIBOLD20PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x0F, 0x60, 0xCF, 0x3C, 0xF3,
  0xCF, 0x30, 0x18, 0x86, 0x21, 0x18, 0x46, 0xFF, 0xFF, 0xF3, 0x10, 0xCC,
  0x23, 0x08, 0xCF, 0xFD, 0x88, 0x62, 0x19, 0x84, 0x60, 0x0C, 0x03, 0x01,
  0xE0, 0xFE, 0x7F, 0x9B, 0x76, 0xC1, 0xB0, 0x7C, 0x0F, 0xC0, 0xF8, 0x37,
  0x0D, 0xFB, 0x7E, 0xDD, 0xFE, 0x3F, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x37,
  0xC6, 0xCC, 0x6C, 0xCC, 0xCD, 0x8F, 0xD0, 0x7B, 0x00, 0x60, 0x04, 0xC0,
  0xFE, 0x1B, 0x33, 0x33, 0x33, 0x36, 0x37, 0xC1, 0xE0, 0x1C, 0x0F, 0xC7,
  0x31, 0x8E, 0x60, 0x1C, 0x03, 0x01, 0xE0, 0xDC, 0xF3, 0xEC, 0x7B, 0x0C,
  0xC7, 0xBF, 0xE7, 0xCC, 0xFF, 0xF0, 0x02, 0x1C, 0x79, 0xC7, 0x0C, 0x18,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x18, 0x38, 0x38, 0x3C, 0x38, 0x81,
  0xC3, 0xC1, 0xC1, 0xC1, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x83,
  0x0E, 0x39, 0xE3, 0x80, 0x0C, 0x03, 0x08, 0xC7, 0xB7, 0xFB, 0xC3, 0x01,
  0xE0, 0xCC, 0x73, 0x88, 0x40, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC3,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x3B, 0x9C, 0xC6, 0x60, 0xFF, 0xF0, 0xFF,
  0xF0, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E,
  0x00, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0xE1, 0xF8, 0x7E, 0xDF, 0xB7, 0xED,
  0xF8, 0x7E, 0x1F, 0x87, 0x61, 0x9F, 0xE3, 0xF0, 0x1C, 0x1E, 0x3B, 0x19,
  0x88, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF,
  0xFE, 0x1E, 0x1F, 0xC7, 0x3B, 0x86, 0xE1, 0x80, 0x60, 0x38, 0x0C, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1F, 0xF7, 0xFC, 0x7F, 0xBF, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x7C, 0x3F, 0x01, 0x80, 0xC0, 0x7C, 0x3E, 0x1B, 0xFC,
  0xFC, 0x03, 0x83, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0xE3, 0xE1, 0xF0,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x7F, 0x9F, 0xE7, 0xF9, 0x80, 0x60,
  0x19, 0x87, 0xF9, 0xCE, 0x01, 0x80, 0x70, 0x1E, 0x06, 0x61, 0x9F, 0xE3,
  0xF0, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0xF1, 0xFE, 0xE1,
  0xF8, 0x7C, 0x0F, 0x87, 0x61, 0x9F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x86, 0xE1, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0x61, 0x98, 0x63, 0xF0,
  0x78, 0x3F, 0x18, 0x6E, 0x1F, 0x87, 0x61, 0x9F, 0xE3, 0xF0, 0x1E, 0x1F,
  0xC7, 0x3B, 0x87, 0xC0, 0xF0, 0x3E, 0x1D, 0xCE, 0x3D, 0x80, 0xC0, 0x70,
  0x18, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0x60, 0x00, 0x00, 0x6F, 0xF0, 0x7B,
  0xCC, 0x00, 0x00, 0x00, 0x3B, 0x9C, 0xC6, 0x70, 0x01, 0x07, 0x1F, 0x7C,
  0xE0, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x01, 0x0F, 0x3E, 0xF0, 0xC0,
  0x80, 0xF0, 0xFE, 0xFE, 0x07, 0x03, 0x03, 0x07, 0x3E, 0x3C, 0x30, 0x30,
  0x00, 0x00, 0x78, 0x30, 0x1E, 0x1F, 0xE6, 0x1F, 0x03, 0xC0, 0xF1, 0xFC,
  0xF7, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCF, 0xF1, 0xDC, 0x03, 0x00,
  0x70, 0x0F, 0x80, 0xE0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3F, 0x0C, 0xC3,
  0x30, 0xCC, 0x73, 0x9F, 0xE7, 0xF9, 0x86, 0xE1, 0xF8, 0x3C, 0x0C, 0xF8,
  0x7F, 0x31, 0xD8, 0x6C, 0x3E, 0x1B, 0xFD, 0xFC, 0xC7, 0x61, 0xF0, 0x78,
  0x7C, 0x3F, 0xFB, 0xF8, 0x3C, 0x3F, 0xB9, 0xD8, 0x7C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x7C, 0x37, 0xF9, 0xF8, 0xF8, 0x7F, 0x3F,
  0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77,
  0xFB, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x03,
  0x01, 0xFE, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x3C, 0x3F,
  0xB9, 0xD8, 0x7C, 0x06, 0x03, 0x01, 0x9F, 0xCF, 0xE1, 0xF0, 0xF8, 0x7C,
  0x37, 0xF9, 0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x1F, 0x8F, 0xC7,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x78, 0x3E, 0x3B,
  0xF8, 0xF8, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x66, 0x73, 0xF1, 0xF8, 0xFC,
  0x67, 0x31, 0x98, 0xEC, 0x36, 0x1F, 0x0E, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE,
  0xE1, 0xF8, 0x7F, 0x3F, 0xCF, 0xD2, 0xF7, 0xBD, 0xEF, 0x33, 0xCC, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xC3, 0xE3, 0xE3, 0xA3, 0xF3,
  0xF3, 0xDB, 0xDB, 0xDB, 0xCF, 0xCF, 0xCD, 0xC7, 0xC7, 0xC7, 0x3C, 0x7E,
  0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0x7E, 0xFC, 0x7F, 0xBF, 0xF8, 0x7C, 0x1E, 0x0F, 0x0F, 0xFE, 0xFE, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x61, 0x9F, 0xE3,
  0xF0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0xF8, 0x7F, 0xB1, 0xD8, 0x7C, 0x1E,
  0x1F, 0x0F, 0xFE, 0xFE, 0x66, 0x33, 0x98, 0xCC, 0x76, 0x1B, 0x0E, 0x1E,
  0x0F, 0xE7, 0x39, 0x87, 0x60, 0x18, 0x07, 0x80, 0xFC, 0x0F, 0x80, 0x70,
  0x1F, 0x87, 0xE1, 0xDF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFF, 0x7E, 0xC0, 0xF0, 0x3E, 0x1D, 0x86, 0x61, 0x98, 0x67,
  0x38, 0xCC, 0x33, 0x0C, 0xC3, 0xB0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xC6,
  0x3E, 0x63, 0x66, 0x66, 0x66, 0x67, 0x66, 0xF6, 0x6F, 0x66, 0x96, 0x69,
  0x66, 0x96, 0x69, 0x62, 0x94, 0x29, 0x43, 0x9C, 0x39, 0xC0, 0xE0, 0xF8,
  0x77, 0x18, 0xCC, 0x3F, 0x07, 0x81, 0xE0, 0x30, 0x1E, 0x07, 0x83, 0x70,
  0xCC, 0x63, 0xB8, 0x7C, 0x0C, 0xC0, 0xF0, 0x3E, 0x1D, 0x86, 0x73, 0x8C,
  0xC3, 0xF0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC7, 0xFE, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x1F, 0xFE, 0x0C, 0x07, 0x81, 0xE0, 0x6C, 0x33, 0x0C, 0xC6, 0x1B,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0x8E, 0x3F, 0x3F, 0xD8, 0x60, 0x30,
  0x1B, 0xFF, 0x87, 0x83, 0xE1, 0xBF, 0xDF, 0x60, 0xC0, 0x60, 0x30, 0x18,
  0x0D, 0xE7, 0xFB, 0x0D, 0x86, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x37, 0xFB,
  0x78, 0x3F, 0x1F, 0xE6, 0x19, 0x87, 0xE0, 0x38, 0x0E, 0x01, 0x87, 0x61,
  0x9F, 0xE3, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xDB, 0xFD, 0x86, 0xC3,
  0xE1, 0xF0, 0xF8, 0x6C, 0x36, 0x1B, 0xFC, 0xF6, 0x3F, 0x1F, 0xE6, 0x19,
  0x86, 0xE1, 0xFF, 0xFE, 0x01, 0x80, 0x61, 0x9F, 0xE3, 0xF0, 0x03, 0xC3,
  0xF1, 0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7B, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0x7B, 0x03, 0x03, 0x07, 0x7E, 0x7C, 0xC0, 0xC0, 0xC0, 0xC0,
  0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x18,
  0x0E, 0x07, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0x06, 0x1C, 0x38, 0x00, 0x1F, 0xFF, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0F, 0xFF, 0xF7, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x3E, 0x1B, 0x1D, 0x9C, 0xFC, 0x7E, 0x33, 0x98,
  0xCC, 0x76, 0x1B, 0x0E, 0xF8, 0x3E, 0x0F, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0xF0, 0x7C, 0xDB,
  0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C,
  0xCC, 0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x3F, 0x1F, 0xE6, 0x19, 0x86, 0xE1, 0xF8, 0x7E, 0x1D, 0x86, 0x61, 0x9F,
  0xE3, 0xF0, 0xDE, 0x7F, 0xB0, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x86, 0xC3,
  0x7F, 0xB7, 0x98, 0x0C, 0x06, 0x03, 0x00, 0x7B, 0xFF, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x7B, 0x03, 0x03, 0x03, 0x03, 0xDF, 0x7F,
  0xB8, 0xF8, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x3F,
  0x1F, 0xE6, 0x1D, 0x80, 0x7C, 0x0F, 0xE0, 0x38, 0x07, 0xE1, 0xDF, 0xE3,
  0xF0, 0x18, 0x06, 0x01, 0x83, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x1F, 0x83, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x7E, 0xC0, 0xF8, 0x76, 0x19, 0x86, 0x73,
  0x8C, 0xC3, 0x30, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0xE6, 0x36, 0x66, 0x66,
  0x66, 0x66, 0x6F, 0x66, 0x96, 0x69, 0x42, 0x94, 0x39, 0xC3, 0x9C, 0x39,
  0xC0, 0xE1, 0xDC, 0xE3, 0x30, 0xFC, 0x1E, 0x03, 0x01, 0xE0, 0xFC, 0x73,
  0x98, 0x6E, 0x1C, 0xE0, 0xF8, 0x76, 0x19, 0xCE, 0x33, 0x8C, 0xC3, 0xF0,
  0x78, 0x1E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xFF, 0xFF,
  0x07, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0x03, 0x0F, 0x0F,
  0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0xF8, 0xF8, 0x1C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x0C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xF0, 0xF0,
  0x38, 0x30, 0x30, 0x30, 0x30, 0x38, 0x1F, 0x1F, 0x38, 0x30, 0x30, 0x30,
  0x38, 0x30, 0xF0, 0xE0, 0x78, 0xFF, 0x3C, 0xFF, 0x1E,
};

const GFXglyph JetBrainsMono_SemiBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 6, 6, 12, 3, -15 },
  { 14, 10, 15, 12, 1, -15 },
  { 33, 10, 20, 12, 1, -17 },
  { 58, 12, 15, 12, 0, -15 },
  { 81, 10, 15, 12, 1, -15 },
  { 100, 2, 6, 12, 5, -15 },
  { 102, 7, 19, 12, 3, -17 },
  { 119, 7, 19, 12, 2, -17 },
  { 136, 10, 10, 12, 1, -12 },
  { 149, 10, 9, 12, 1, -11 },
  { 161, 5, 6, 12, 3, -3 },
  { 165, 6, 2, 12, 3, -8 },
  { 167, 4, 3, 12, 4, -3 },
  { 169, 10, 19, 12, 1, -17 },
  { 193, 10, 15, 12, 1, -15 },
  { 212, 9, 15, 12, 2, -15 },
  { 229, 10, 15, 12, 1, -15 },
  { 248, 9, 15, 12, 1, -15 },
  { 265, 9, 15, 12, 1, -15 },
  { 282, 10, 15, 12, 1, -15 },
  { 301, 10, 15, 12, 1, -15 },
  { 320, 10, 15, 12, 1, -15 },
  { 339, 10, 15, 12, 1, -15 },
  { 358, 10, 15, 12, 1, -15 },
  { 377, 4, 11, 12, 4, -11 },
  { 383, 5, 14, 12, 3, -11 },
  { 392, 8, 11, 12, 2, -12 },
  { 403, 8, 7, 12, 2, -10 },
  { 410, 8, 11, 12, 2, -12 },
  { 421, 8, 15, 12, 2, -15 },
  { 436, 10, 19, 12, 1, -15 },
  { 460, 10, 15, 12, 1, -15 },
  { 479, 9, 15, 12, 2, -15 },
  { 496, 9, 15, 12, 2, -15 },
  { 513, 9, 15, 12, 2, -15 },
  { 530, 8, 15, 12, 2, -15 },
  { 545, 9, 15, 12, 2, -15 },
  { 562, 9, 15, 12, 2, -15 },
  { 579, 8, 15, 12, 2, -15 },
  { 594, 8, 15, 12, 2, -15 },
  { 609, 9, 15, 12, 1, -15 },
  { 626, 9, 15, 12, 2, -15 },
  { 643, 9, 15, 12, 2, -15 },
  { 660, 10, 15, 12, 1, -15 },
  { 679, 8, 15, 12, 2, -15 },
  { 694, 8, 15, 12, 2, -15 },
  { 709, 9, 15, 12, 2, -15 },
  { 726, 10, 19, 12, 1, -15 },
  { 750, 9, 15, 12, 2, -15 },
  { 767, 10, 15, 12, 1, -15 },
  { 786, 10, 15, 12, 1, -15 },
  { 805, 8, 15, 12, 2, -15 },
  { 820, 10, 15, 12, 1, -15 },
  { 839, 12, 15, 12, 0, -15 },
  { 862, 10, 15, 12, 1, -15 },
  { 881, 10, 15, 12, 1, -15 },
  { 900, 8, 15, 12, 2, -15 },
  { 915, 5, 19, 12, 4, -17 },
  { 927, 10, 19, 12, 1, -17 },
  { 951, 5, 19, 12, 3, -17 },
  { 963, 10, 8, 12, 1, -15 },
  { 973, 10, 3, 12, 1, 0 },
  { 977, 5, 3, 12, 3, -16 },
  { 979, 9, 11, 12, 1, -11 },
  { 992, 9, 15, 12, 2, -15 },
  { 1009, 10, 11, 12, 1, -11 },
  { 1023, 9, 15, 12, 1, -15 },
  { 1040, 10, 11, 12, 1, -11 },
  { 1054, 10, 15, 12, 1, -15 },
  { 1073, 8, 15, 12, 2, -11 },
  { 1088, 8, 15, 12, 2, -15 },
  { 1103, 9, 16, 12, 2, -16 },
  { 1121, 7, 20, 12, 2, -16 },
  { 1139, 9, 15, 12, 2, -15 },
  { 1156, 10, 15, 12, 1, -15 },
  { 1175, 10, 11, 12, 1, -11 },
  { 1189, 8, 11, 12, 2, -11 },
  { 1200, 10, 11, 12, 1, -11 },
  { 1214, 9, 15, 12, 2, -11 },
  { 1231, 8, 15, 12, 2, -11 },
  { 1246, 9, 11, 12, 2, -11 },
  { 1259, 10, 11, 12, 1, -11 },
  { 1273, 10, 14, 12, 1, -14 },
  { 1291, 8, 11, 12, 2, -11 },
  { 1302, 10, 11, 12, 1, -11 },
  { 1316, 12, 11, 12, 0, -11 },
  { 1333, 10, 11, 12, 1, -11 },
  { 1347, 10, 15, 12, 1, -11 },
  { 1366, 8, 11, 12, 2, -11 },
  { 1377, 8, 19, 12, 2, -17 },
  { 1396, 2, 19, 12, 5, -17 },
  { 1401, 8, 19, 12, 2, -17 },
  { 1420, 10, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_SemiBold20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_SEMIBOLD20PT7B_H_
