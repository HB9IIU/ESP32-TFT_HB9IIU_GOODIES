#ifndef _JETBRAINSMONO_SEMIBOLD9PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x29, 0x5E, 0xAF, 0xA9, 0x40, 0x46, 0xFC, 0xE7,
  0xDE, 0x40, 0x4D, 0x6C, 0xC3, 0xAE, 0x60, 0x22, 0x90, 0xCA, 0xC9, 0xA0,
  0xE0, 0x7A, 0xAA, 0x40, 0x99, 0x92, 0x4A, 0x80, 0x27, 0xCC, 0xA0, 0x44,
  0xF4, 0x70, 0xE0, 0xB0, 0x32, 0x24, 0x44, 0x88, 0x6B, 0x9D, 0x99, 0xE0,
  0x6E, 0xE6, 0x66, 0xF0, 0x6B, 0x12, 0x6C, 0xF0, 0xE2, 0x46, 0x19, 0xE0,
  0x26, 0x49, 0x9F, 0x10, 0xF8, 0x8F, 0x19, 0xE0, 0x24, 0xCE, 0x99, 0xE0,
  0xF9, 0x22, 0x24, 0xC0, 0x6B, 0x96, 0xB9, 0xE0, 0x6B, 0x9B, 0x62, 0x40,
  0xC0, 0xC0, 0x60, 0x15, 0x80, 0x3C, 0xC3, 0xF0, 0x0F, 0xC3, 0x3C, 0xC2,
  0x36, 0x40, 0x40, 0x32, 0x67, 0x5A, 0xD6, 0x48, 0x30, 0x21, 0x94, 0xA7,
  0x27, 0x20, 0xCB, 0x9E, 0x99, 0xE0, 0x6B, 0x88, 0x89, 0xE0, 0xCB, 0x99,
  0x99, 0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x6B, 0x88,
  0xB9, 0xE0, 0x99, 0x9F, 0x99, 0x90, 0xF4, 0x44, 0x44, 0xF0, 0x38, 0x42,
  0x10, 0xCD, 0xC0, 0x9B, 0xAE, 0xAA, 0x90, 0x88, 0x88, 0x88, 0xF0, 0x9B,
  0xBD, 0x99, 0x90, 0x99, 0xDD, 0xDB, 0xB0, 0x6B, 0x99, 0x99, 0xE0, 0xEB,
  0x9F, 0x88, 0x80, 0x6B, 0x99, 0x99, 0xE2, 0x10, 0xCB, 0x9F, 0xAA, 0x90,
  0x6B, 0x8E, 0x39, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x99, 0x99, 0x99,
  0xE0, 0x8A, 0x52, 0xA5, 0x18, 0xC0, 0xAD, 0x6B, 0x75, 0xAD, 0x60, 0xCA,
  0x9C, 0x43, 0x2B, 0x20, 0x8A, 0x54, 0x62, 0x10, 0x80, 0xF3, 0x24, 0x48,
  0xF0, 0xEA, 0xAB, 0x88, 0x44, 0x62, 0x21, 0xE4, 0x92, 0x4F, 0x46, 0xA9,
  0xF0, 0xC0, 0xE1, 0xF9, 0xF0, 0x88, 0xE9, 0x99, 0xE0, 0xE9, 0x89, 0xE0,
  0x11, 0xDB, 0x99, 0xF0, 0xE9, 0xF9, 0xE0, 0x19, 0x09, 0xF2, 0x10, 0x80,
  0xDB, 0x9B, 0xD1, 0xE0, 0x88, 0xE9, 0x99, 0x90, 0x60, 0xC4, 0x44, 0xF0,
  0x23, 0x92, 0x49, 0xC0, 0x88, 0x9A, 0xEA, 0x90, 0xE1, 0x08, 0x42, 0x10,
  0xE0, 0xFD, 0x6B, 0x5A, 0x80, 0xE9, 0x99, 0x90, 0xE9, 0x99, 0xE0, 0xE9,
  0x99, 0xE8, 0x80, 0xDB, 0x99, 0xF1, 0x10, 0xF9, 0x88, 0x80, 0xF8, 0xE1,
  0xF0, 0x27, 0xC8, 0x42, 0x1C, 0x99, 0x99, 0xE0, 0xCA, 0xD4, 0x63, 0x00,
  0xAD, 0x56, 0xB5, 0x00, 0xDB, 0x88, 0xEC, 0x80, 0xCA, 0x94, 0x62, 0x10,
  0x80, 0xF2, 0x48, 0xF0, 0x36, 0x2C, 0x62, 0x63, 0xFF, 0xC4, 0x47, 0x44,
  0x4C, 0x6C, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 7, 5, 2, -7 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 5, 1, -8 },
  { 14, 5, 7, 5, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 3, 5, 2, -7 },
  { 25, 2, 9, 5, 2, -8 },
  { 28, 3, 9, 5, 1, -8 },
  { 32, 5, 4, 5, 0, -5 },
  { 35, 4, 4, 5, 1, -5 },
  { 37, 2, 2, 5, 1, -1 },
  { 38, 3, 1, 5, 1, -3 },
  { 39, 2, 2, 5, 2, -2 },
  { 40, 4, 8, 5, 1, -7 },
  { 44, 4, 7, 5, 1, -7 },
  { 48, 4, 7, 5, 1, -7 },
  { 52, 4, 7, 5, 1, -7 },
  { 56, 4, 7, 5, 1, -7 },
  { 60, 4, 7, 5, 1, -7 },
  { 64, 4, 7, 5, 1, -7 },
  { 68, 4, 7, 5, 1, -7 },
  { 72, 4, 7, 5, 1, -7 },
  { 76, 4, 7, 5, 1, -7 },
  { 80, 4, 7, 5, 1, -7 },
  { 84, 2, 5, 5, 2, -5 },
  { 86, 3, 6, 5, 1, -5 },
  { 89, 4, 4, 5, 1, -5 },
  { 91, 4, 4, 5, 1, -5 },
  { 93, 4, 4, 5, 1, -5 },
  { 95, 4, 7, 5, 1, -7 },
  { 99, 5, 9, 5, 0, -7 },
  { 105, 5, 7, 5, 0, -7 },
  { 110, 4, 7, 5, 1, -7 },
  { 114, 4, 7, 5, 1, -7 },
  { 118, 4, 7, 5, 1, -7 },
  { 122, 4, 7, 5, 1, -7 },
  { 126, 4, 7, 5, 1, -7 },
  { 130, 4, 7, 5, 1, -7 },
  { 134, 4, 7, 5, 1, -7 },
  { 138, 4, 7, 5, 1, -7 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 4, 7, 5, 1, -7 },
  { 151, 4, 7, 5, 1, -7 },
  { 155, 4, 7, 5, 1, -7 },
  { 159, 4, 7, 5, 1, -7 },
  { 163, 4, 7, 5, 1, -7 },
  { 167, 4, 7, 5, 1, -7 },
  { 171, 4, 9, 5, 1, -7 },
  { 176, 4, 7, 5, 1, -7 },
  { 180, 4, 7, 5, 1, -7 },
  { 184, 5, 7, 5, 0, -7 },
  { 189, 4, 7, 5, 1, -7 },
  { 193, 5, 7, 5, 0, -7 },
  { 198, 5, 7, 5, 0, -7 },
  { 203, 5, 7, 5, 0, -7 },
  { 208, 5, 7, 5, 0, -7 },
  { 213, 4, 7, 5, 1, -7 },
  { 217, 2, 8, 5, 2, -7 },
  { 219, 4, 8, 5, 1, -7 },
  { 223, 3, 8, 5, 1, -7 },
  { 226, 4, 4, 5, 1, -7 },
  { 228, 4, 1, 5, 1, 0 },
  { 229, 2, 1, 5, 2, -7 },
  { 230, 4, 5, 5, 1, -5 },
  { 233, 4, 7, 5, 1, -7 },
  { 237, 4, 5, 5, 1, -5 },
  { 240, 4, 7, 5, 1, -7 },
  { 244, 4, 5, 5, 1, -5 },
  { 247, 5, 7, 5, 0, -7 },
  { 252, 4, 7, 5, 1, -5 },
  { 256, 4, 7, 5, 1, -7 },
  { 260, 4, 7, 5, 1, -7 },
  { 264, 3, 9, 5, 1, -7 },
  { 268, 4, 7, 5, 1, -7 },
  { 272, 5, 7, 5, 0, -7 },
  { 277, 5, 5, 5, 0, -5 },
  { 281, 4, 5, 5, 1, -5 },
  { 284, 4, 5, 5, 1, -5 },
  { 287, 4, 7, 5, 1, -5 },
  { 291, 4, 7, 5, 1, -5 },
  { 295, 4, 5, 5, 1, -5 },
  { 298, 4, 5, 5, 1, -5 },
  { 301, 5, 6, 5, 0, -6 },
  { 305, 4, 5, 5, 1, -5 },
  { 308, 5, 5, 5, 0, -5 },
  { 312, 5, 5, 5, 0, -5 },
  { 316, 5, 5, 5, 0, -5 },
  { 320, 5, 7, 5, 0, -5 },
  { 325, 4, 5, 5, 1, -5 },
  { 328, 4, 8, 5, 1, -7 },
  { 332, 1, 8, 5, 2, -7 },
  { 333, 4, 8, 5, 1, -7 },
  { 337, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_SemiBold9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_SEMIBOLD9PT7B_H_
