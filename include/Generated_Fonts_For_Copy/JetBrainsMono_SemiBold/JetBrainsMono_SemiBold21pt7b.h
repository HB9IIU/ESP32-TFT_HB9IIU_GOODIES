#ifndef _JETBRAINSMONO_SEMIBOLD21PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xB6, 0xD8, 0x0D, 0xF8, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8,
  0xC0, 0x18, 0xC3, 0x18, 0x62, 0x08, 0x4F, 0xFE, 0x63, 0x0C, 0x61, 0x8C,
  0x31, 0x1F, 0xFB, 0xFF, 0x31, 0x86, 0x30, 0xC6, 0x19, 0x80, 0x04, 0x01,
  0x00, 0x40, 0xFE, 0x7F, 0xD9, 0x76, 0x4D, 0x90, 0x74, 0x0F, 0x81, 0xF8,
  0x1F, 0x05, 0xC1, 0x3E, 0x4D, 0x97, 0x7F, 0x8F, 0xC0, 0x40, 0x10, 0x04,
  0x00, 0x7C, 0x3E, 0x63, 0x31, 0x19, 0x89, 0x8C, 0xD8, 0x3E, 0x80, 0xCC,
  0x00, 0xC0, 0x04, 0xE0, 0x6F, 0x86, 0xC4, 0x66, 0x23, 0x31, 0x30, 0xDB,
  0x07, 0x80, 0x0C, 0x07, 0xE1, 0xFE, 0x30, 0xC6, 0x00, 0xE0, 0x0C, 0x03,
  0xC0, 0xFC, 0xF9, 0x9B, 0x1F, 0x63, 0xCC, 0x39, 0xC7, 0x3F, 0xF3, 0xE7,
  0xFF, 0xED, 0x80, 0x04, 0x73, 0xDC, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x38, 0x71, 0xE3, 0xC3, 0x04, 0x81, 0xC3, 0xC1, 0xC1, 0xC1,
  0x83, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x1C, 0x73, 0xC7,
  0x08, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x66, 0x2F, 0x5E, 0xFF, 0x83, 0x00,
  0xD8, 0x3B, 0x8E, 0x30, 0x86, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF,
  0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x3B, 0x9C, 0xE6, 0x70, 0xFF,
  0xFC, 0x27, 0xF7, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70,
  0x1C, 0x0E, 0x00, 0x04, 0x0F, 0xE7, 0xF9, 0x87, 0x60, 0xF8, 0x3E, 0x0F,
  0xB3, 0xEE, 0xF9, 0x3E, 0x0F, 0x83, 0x60, 0xDC, 0x77, 0xF8, 0xFC, 0x3C,
  0x1F, 0x0E, 0xC3, 0x30, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x0C, 0x0F, 0xE7, 0xF9, 0x87, 0xE1,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07,
  0xFD, 0xFF, 0x7F, 0x9F, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xF8, 0x0F,
  0x01, 0xC0, 0x30, 0x0F, 0x87, 0x61, 0xDF, 0xE3, 0xF0, 0x03, 0x81, 0xC0,
  0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x1D, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF,
  0x01, 0xC0, 0x70, 0x1C, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0xF3, 0xFD,
  0xC7, 0x01, 0x80, 0xC0, 0x78, 0x3E, 0x3F, 0xF9, 0xF8, 0x07, 0x03, 0x80,
  0xC0, 0x70, 0x38, 0x0C, 0x07, 0xF9, 0xEF, 0xE1, 0xF8, 0x3E, 0x0F, 0x83,
  0x71, 0xDF, 0xE1, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0x80, 0x0C,
  0x0F, 0xE7, 0xF9, 0x87, 0x61, 0xD8, 0x77, 0x18, 0xFC, 0x1F, 0x1C, 0xE6,
  0x1F, 0x83, 0xE0, 0xDC, 0x77, 0xF8, 0xFC, 0x0C, 0x0F, 0xE7, 0xFD, 0x87,
  0xE0, 0xF8, 0x3E, 0x0D, 0x87, 0x7F, 0xCF, 0x60, 0x38, 0x1C, 0x07, 0x03,
  0x80, 0xC0, 0x70, 0x6F, 0xF6, 0x00, 0x00, 0x07, 0xF7, 0x33, 0xDE, 0x60,
  0x00, 0x00, 0x01, 0xCE, 0xE7, 0x33, 0x80, 0x00, 0x80, 0xC1, 0xE7, 0xCF,
  0x87, 0x03, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0x10, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x60, 0x3C, 0x0F, 0x81, 0xF0,
  0x1C, 0x0E, 0x1F, 0x3E, 0x78, 0x30, 0x10, 0x00, 0xFC, 0xFE, 0x0E, 0x06,
  0x07, 0x06, 0x7E, 0x7C, 0x70, 0x60, 0x60, 0x00, 0x60, 0x70, 0x70, 0x04,
  0x07, 0xF1, 0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF1, 0xFE, 0x77, 0xCC, 0x79,
  0x8F, 0x31, 0xE6, 0x3C, 0xC7, 0x9F, 0xF1, 0xDE, 0x00, 0xE0, 0x0E, 0x00,
  0xF8, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x7C, 0x0D, 0x83, 0xB0, 0x76, 0x0C,
  0xE1, 0x8C, 0x71, 0x8F, 0xF1, 0xFF, 0x30, 0xEE, 0x0D, 0xC1, 0xB0, 0x38,
  0xFE, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x1F, 0xFD, 0xFE, 0xC3, 0xE0, 0xF0,
  0x78, 0x3C, 0x3F, 0xFB, 0xF8, 0x08, 0x3F, 0xBF, 0xF8, 0x7C, 0x1E, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x1F, 0x1F, 0xFC, 0x7C, 0xFE,
  0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x7C, 0x7F, 0xFB, 0xF8, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD,
  0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x08, 0x3F, 0xBF, 0xF8, 0x7C, 0x1E, 0x03, 0x01, 0x80, 0xCF,
  0xE7, 0xF0, 0x78, 0x3C, 0x1F, 0x1F, 0xFC, 0x7C, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0E, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x0F, 0xC3, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x1F, 0x07, 0xE3, 0x9F, 0xE3,
  0xF0, 0xC1, 0xF0, 0xEC, 0x33, 0x1C, 0xC6, 0x33, 0x8F, 0xC3, 0xF0, 0xCE,
  0x31, 0x8C, 0x73, 0x0C, 0xC3, 0xB0, 0xEC, 0x1C, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF,
  0xFE, 0xE1, 0xFC, 0x7F, 0x1F, 0x4F, 0xDB, 0xF6, 0xBC, 0xEF, 0xBB, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0C, 0xE1, 0xF0, 0xFC, 0x7E,
  0x3F, 0x1E, 0xCF, 0x67, 0xB3, 0xCD, 0xE6, 0xF3, 0x78, 0xFC, 0x7E, 0x3F,
  0x0E, 0x18, 0x3F, 0xBF, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3F, 0x1F, 0xFC, 0xFC, 0xFF, 0x3F, 0xEC, 0x1B, 0x07,
  0xC1, 0xF0, 0x7C, 0x3B, 0xFE, 0xFE, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x04, 0x0F, 0xE7, 0xF9, 0x87, 0x60, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x60, 0xDC, 0x77, 0xF8, 0x7C, 0x03, 0x00,
  0xE0, 0x1C, 0x07, 0xFF, 0x3F, 0xEC, 0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x7B,
  0xFC, 0xFE, 0x33, 0x8C, 0x73, 0x1C, 0xC3, 0x30, 0xEC, 0x1C, 0x0C, 0x0F,
  0xE7, 0xFD, 0x87, 0x60, 0xD8, 0x07, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x1C,
  0x03, 0xE0, 0xD8, 0x77, 0xF8, 0xFC, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x7E, 0x3F, 0xF9, 0xF8, 0xE0, 0xFC, 0x19, 0x83,
  0x30, 0xE6, 0x1C, 0xE3, 0x0C, 0x61, 0x9C, 0x33, 0x87, 0x60, 0x6C, 0x0D,
  0x81, 0xF0, 0x3C, 0x03, 0x80, 0xE6, 0x36, 0x73, 0x67, 0x36, 0x53, 0x65,
  0x36, 0x53, 0x6D, 0x66, 0xD6, 0x6D, 0x66, 0x9E, 0x39, 0xE3, 0x9E, 0x39,
  0xE3, 0x8E, 0x38, 0xE0, 0xE0, 0xEE, 0x39, 0xC6, 0x1D, 0xC1, 0xB0, 0x3E,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0xEE, 0x19, 0xC7, 0x1D, 0xC3, 0xB8,
  0x38, 0xC0, 0xFC, 0x19, 0x87, 0x38, 0xC3, 0x38, 0x76, 0x06, 0xC0, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xFF,
  0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0C,
  0x07, 0xFF, 0xFE, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x0E, 0x07, 0x81,
  0xB0, 0xEC, 0x33, 0x8C, 0x66, 0x1F, 0x83, 0xFF, 0xFF, 0xF0, 0xE7, 0x0E,
  0x0F, 0xE7, 0x1D, 0x87, 0x01, 0xCF, 0xF7, 0xFF, 0x87, 0xE1, 0xF8, 0x77,
  0xEC, 0xFB, 0xC0, 0x60, 0x30, 0x19, 0xCD, 0xF7, 0x3F, 0x0F, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3E, 0x3F, 0xFB, 0x78, 0x1C, 0x3F, 0xB9, 0xF8, 0x7C,
  0x06, 0x03, 0x01, 0x80, 0xC1, 0xF1, 0xFF, 0xC7, 0xC0, 0x03, 0x81, 0xC0,
  0xE7, 0x77, 0xDF, 0x2F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F,
  0xFD, 0xFE, 0x1C, 0x3F, 0xB8, 0xF8, 0x7C, 0x1F, 0xFF, 0xFF, 0x80, 0xC0,
  0x61, 0xFF, 0xC7, 0xC0, 0x0F, 0xC3, 0xF1, 0xC0, 0x70, 0x1C, 0x3F, 0xFF,
  0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x3B,
  0xBF, 0xF9, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xFE, 0xDF, 0xE0,
  0x70, 0x38, 0x1D, 0xFC, 0xFC, 0xC0, 0x60, 0x30, 0x19, 0xCD, 0xF7, 0x3F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0E, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x1E,
  0xFC, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xC3, 0xB0, 0xEC, 0x73, 0x38,
  0xFE, 0x3F, 0x8C, 0xE3, 0x1C, 0xC3, 0x30, 0xEC, 0x1C, 0xFC, 0x1F, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x1F, 0xC1, 0xF8, 0xD9, 0xBF, 0xFC, 0xCF, 0x33, 0xCC,
  0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCE, 0x6F, 0xB9,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x70, 0x1C,
  0x3F, 0xBD, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xFF, 0xC7,
  0xC0, 0xCE, 0x6F, 0xB9, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1,
  0xFF, 0xDB, 0xCC, 0x06, 0x03, 0x01, 0x80, 0x3B, 0xBF, 0xF9, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xFF, 0x6F, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0xCE, 0x37, 0xEF, 0x3B, 0x86, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x3E, 0x3F, 0xB8, 0xF8, 0x0E, 0x07, 0xF0, 0xFC,
  0x07, 0x01, 0xE0, 0xFF, 0xEF, 0xE0, 0x1C, 0x07, 0x01, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xF0,
  0x7C, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1,
  0xFF, 0xC7, 0xC0, 0xC0, 0xFC, 0x19, 0x83, 0x30, 0xE7, 0x18, 0x63, 0x0C,
  0xE1, 0xD8, 0x1B, 0x03, 0xE0, 0x78, 0x07, 0x00, 0xE6, 0x36, 0x63, 0x67,
  0x36, 0x73, 0x65, 0x26, 0x56, 0x6D, 0x63, 0xD6, 0x39, 0xE3, 0x9E, 0x39,
  0xE3, 0x8C, 0xE0, 0xEE, 0x39, 0xCE, 0x1D, 0x81, 0xF0, 0x1C, 0x03, 0x80,
  0xF8, 0x3B, 0x06, 0x71, 0xC7, 0x70, 0x70, 0xE0, 0xFC, 0x19, 0x87, 0x38,
  0xE7, 0x18, 0x67, 0x0E, 0xE0, 0xD8, 0x1F, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x60, 0x70, 0x70, 0x3F, 0xFF, 0xF0, 0x07, 0x87, 0xC3, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0xFC, 0x78, 0x3F, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x7C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1F, 0x87,
  0xC7, 0xE7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x7C, 0x3C, 0x00, 0x38,
  0x1F, 0x3C, 0xEF, 0x1F, 0xC3, 0x80,
};

const GFXglyph JetBrainsMono_SemiBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 7, 6, 13, 3, -15 },
  { 13, 11, 15, 13, 1, -15 },
  { 34, 10, 21, 13, 1, -18 },
  { 61, 13, 15, 13, 0, -15 },
  { 86, 11, 16, 13, 1, -16 },
  { 108, 3, 6, 13, 5, -15 },
  { 111, 6, 21, 13, 4, -18 },
  { 127, 7, 21, 13, 2, -18 },
  { 146, 11, 11, 13, 1, -13 },
  { 162, 10, 10, 13, 1, -12 },
  { 175, 5, 6, 13, 3, -3 },
  { 179, 7, 2, 13, 3, -8 },
  { 181, 4, 4, 13, 4, -4 },
  { 183, 10, 19, 13, 1, -17 },
  { 207, 10, 16, 13, 1, -16 },
  { 227, 10, 15, 13, 2, -15 },
  { 246, 10, 16, 13, 1, -16 },
  { 266, 10, 15, 13, 1, -15 },
  { 285, 10, 15, 13, 1, -15 },
  { 304, 9, 15, 13, 2, -15 },
  { 321, 10, 15, 13, 1, -15 },
  { 340, 10, 15, 13, 1, -15 },
  { 359, 10, 16, 13, 1, -16 },
  { 379, 10, 16, 13, 1, -16 },
  { 399, 4, 12, 13, 4, -12 },
  { 405, 5, 15, 13, 3, -12 },
  { 415, 9, 12, 13, 2, -13 },
  { 429, 9, 8, 13, 2, -11 },
  { 438, 9, 12, 13, 2, -13 },
  { 452, 8, 15, 13, 3, -15 },
  { 467, 11, 20, 13, 1, -16 },
  { 495, 11, 15, 13, 1, -15 },
  { 516, 9, 15, 13, 2, -15 },
  { 533, 9, 16, 13, 2, -16 },
  { 551, 9, 15, 13, 2, -15 },
  { 568, 9, 15, 13, 2, -15 },
  { 585, 9, 15, 13, 2, -15 },
  { 602, 9, 16, 13, 2, -16 },
  { 620, 9, 15, 13, 2, -15 },
  { 637, 9, 15, 13, 2, -15 },
  { 654, 10, 15, 13, 1, -15 },
  { 673, 10, 15, 13, 2, -15 },
  { 692, 9, 15, 13, 2, -15 },
  { 709, 10, 15, 13, 1, -15 },
  { 728, 9, 15, 13, 2, -15 },
  { 745, 9, 16, 13, 2, -16 },
  { 763, 10, 15, 13, 2, -15 },
  { 782, 10, 20, 13, 1, -16 },
  { 807, 10, 15, 13, 2, -15 },
  { 826, 10, 16, 13, 1, -16 },
  { 846, 11, 15, 13, 1, -15 },
  { 867, 9, 15, 13, 2, -15 },
  { 884, 11, 15, 13, 1, -15 },
  { 905, 12, 15, 13, 0, -15 },
  { 928, 11, 15, 13, 1, -15 },
  { 949, 11, 15, 13, 1, -15 },
  { 970, 9, 15, 13, 2, -15 },
  { 987, 6, 19, 13, 4, -17 },
  { 1002, 10, 19, 13, 1, -17 },
  { 1026, 6, 19, 13, 3, -17 },
  { 1041, 10, 8, 13, 1, -15 },
  { 1051, 10, 2, 13, 1, 1 },
  { 1054, 4, 2, 13, 4, -16 },
  { 1055, 10, 12, 13, 1, -12 },
  { 1070, 9, 15, 13, 2, -15 },
  { 1087, 9, 12, 13, 2, -12 },
  { 1101, 9, 15, 13, 2, -15 },
  { 1118, 9, 12, 13, 2, -12 },
  { 1132, 10, 15, 13, 1, -15 },
  { 1151, 9, 16, 13, 2, -12 },
  { 1169, 9, 15, 13, 2, -15 },
  { 1186, 10, 16, 13, 2, -16 },
  { 1206, 8, 20, 13, 2, -16 },
  { 1226, 10, 15, 13, 2, -15 },
  { 1245, 11, 15, 13, 1, -15 },
  { 1266, 10, 12, 13, 1, -12 },
  { 1281, 9, 12, 13, 2, -12 },
  { 1295, 9, 12, 13, 2, -12 },
  { 1309, 9, 16, 13, 2, -12 },
  { 1327, 9, 16, 13, 2, -12 },
  { 1345, 10, 12, 13, 2, -12 },
  { 1360, 9, 12, 13, 2, -12 },
  { 1374, 10, 15, 13, 1, -15 },
  { 1393, 9, 12, 13, 2, -12 },
  { 1407, 11, 12, 13, 1, -12 },
  { 1424, 12, 12, 13, 0, -12 },
  { 1442, 11, 12, 13, 1, -12 },
  { 1459, 11, 16, 13, 1, -12 },
  { 1481, 9, 12, 13, 2, -12 },
  { 1495, 9, 19, 13, 2, -17 },
  { 1517, 3, 19, 13, 5, -17 },
  { 1525, 9, 19, 13, 2, -17 },
  { 1547, 10, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_SemiBold21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_SEMIBOLD21PT7B_H_
