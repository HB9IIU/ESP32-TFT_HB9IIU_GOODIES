#ifndef _JETBRAINSMONO_SEMIBOLD13PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE3, 0xC0, 0x99, 0x90, 0x12, 0x49, 0xF9, 0x22, 0x44, 0xBF,
  0xA4, 0x48, 0x20, 0xCF, 0xBB, 0xE3, 0x83, 0x8B, 0xAF, 0xB7, 0x88, 0x20,
  0x61, 0xF2, 0x94, 0x94, 0x68, 0x10, 0x3E, 0x29, 0x49, 0x8E, 0x33, 0xEC,
  0xB0, 0x63, 0x9B, 0xE6, 0x9B, 0xD0, 0xFC, 0x13, 0x6C, 0xCC, 0xCC, 0xC4,
  0x63, 0x10, 0xC7, 0x0C, 0x21, 0x8C, 0x63, 0x10, 0x8D, 0xC8, 0x00, 0x18,
  0x33, 0xD9, 0xE1, 0x85, 0x99, 0x00, 0x30, 0xCF, 0xCC, 0x30, 0xC0, 0x6B,
  0x60, 0xF0, 0xF0, 0x0C, 0x20, 0x86, 0x10, 0xC3, 0x08, 0x61, 0x84, 0x30,
  0x33, 0xEC, 0xE3, 0xAE, 0xF8, 0xE3, 0xCD, 0xE0, 0x73, 0x49, 0x04, 0x10,
  0x41, 0x04, 0xFC, 0x33, 0xE8, 0xC3, 0x08, 0x63, 0x18, 0xC3, 0xF0, 0xF8,
  0x63, 0x0E, 0x0C, 0x38, 0xF3, 0x78, 0x18, 0xC2, 0x18, 0xCE, 0x3F, 0xC3,
  0x0C, 0xFF, 0x0C, 0x3E, 0xCC, 0x30, 0xF3, 0x78, 0x38, 0x86, 0x3E, 0xCE,
  0x38, 0x73, 0x78, 0xFE, 0x30, 0x86, 0x18, 0x43, 0x08, 0x60, 0x33, 0xEC,
  0xF3, 0x79, 0xEC, 0xE3, 0xCD, 0xE0, 0x33, 0xE8, 0xE1, 0xCF, 0xF1, 0x84,
  0x31, 0x80, 0xF0, 0x3C, 0x6C, 0x00, 0xD6, 0xC0, 0x04, 0x77, 0x30, 0xE0,
  0xE0, 0xC0, 0xFF, 0xF0, 0x00, 0xFC, 0x83, 0x83, 0x83, 0x1D, 0xCC, 0x00,
  0xF0, 0x86, 0x66, 0x20, 0x08, 0xC0, 0x18, 0xFD, 0x0A, 0x1D, 0xFA, 0x74,
  0xE9, 0xDE, 0x81, 0x01, 0xC0, 0x18, 0x70, 0xF1, 0x62, 0x4F, 0x9F, 0xA3,
  0xC2, 0xFB, 0x3C, 0xFE, 0xFB, 0x3C, 0x73, 0xF8, 0x33, 0xEC, 0xF0, 0xC3,
  0x0C, 0x33, 0xCD, 0xE0, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xF8, 0xFF,
  0x0C, 0x3E, 0xFB, 0x0C, 0x30, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0xFC, 0x30,
  0xC3, 0x00, 0x33, 0xEC, 0xF0, 0xC3, 0x7C, 0xF3, 0xCD, 0xE0, 0xCF, 0x3C,
  0xFF, 0xFF, 0x3C, 0xF3, 0xCC, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC,
  0x1E, 0x0C, 0x18, 0x30, 0x60, 0xF1, 0xB2, 0x7C, 0xCF, 0x2D, 0xBC, 0xF3,
  0x6C, 0xB3, 0xCC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0xCF, 0x3F,
  0x6D, 0xB6, 0x18, 0x61, 0x84, 0xCF, 0xBA, 0xEB, 0xBE, 0x79, 0x67, 0x8C,
  0x33, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCD, 0xE0, 0xFF, 0x3C, 0x73, 0xFB,
  0x0C, 0x30, 0xC0, 0x33, 0xEC, 0xE3, 0x8E, 0x38, 0xE3, 0xCD, 0xE1, 0x83,
  0xFB, 0x3C, 0x73, 0xFB, 0x6D, 0xB2, 0xCC, 0x33, 0xEC, 0xF0, 0xE0, 0xE0,
  0xE3, 0xCD, 0xE0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x78, 0xC2, 0xCD, 0x99, 0x22, 0x45, 0x8F,
  0x0C, 0x18, 0xDB, 0xDA, 0x5A, 0x5A, 0x5A, 0x6A, 0x6A, 0x66, 0x66, 0x66,
  0x48, 0xF0, 0xC1, 0x87, 0x8B, 0x33, 0xC6, 0xC6, 0xCC, 0x91, 0xE1, 0x83,
  0x06, 0x0C, 0x18, 0xFC, 0x21, 0x8C, 0x31, 0x84, 0x30, 0xFC, 0xFF, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCF, 0xC3, 0x04, 0x18, 0x60, 0x83, 0x04, 0x18, 0x60,
  0x83, 0xFC, 0x92, 0x49, 0x24, 0xF0, 0x31, 0xE4, 0xB2, 0x8C, 0xFF, 0xF0,
  0xC4, 0x7B, 0x30, 0xFF, 0x8E, 0x3F, 0xC0, 0xC3, 0x0F, 0xB3, 0xCF, 0x3C,
  0xF3, 0xF8, 0x7B, 0x38, 0x20, 0x83, 0x37, 0x80, 0x0C, 0x37, 0xF3, 0x8E,
  0x38, 0xF3, 0x7C, 0x7B, 0x38, 0xFF, 0x83, 0x37, 0x80, 0x3C, 0x82, 0x3F,
  0x20, 0x82, 0x08, 0x20, 0x7F, 0x3C, 0xF3, 0xCF, 0xF2, 0xC3, 0x78, 0xC3,
  0x0F, 0xB3, 0xCF, 0x3C, 0xF3, 0xCC, 0x30, 0x40, 0x3C, 0x10, 0x41, 0x04,
  0x13, 0xF0, 0x18, 0xC1, 0xF1, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0xC3, 0x0C,
  0xF2, 0xDB, 0xCD, 0xB2, 0xCC, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C,
  0x1E, 0xEE, 0xDA, 0x69, 0xA6, 0x9A, 0x40, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C,
  0xC0, 0x7B, 0x38, 0xE3, 0x8F, 0x37, 0x80, 0xFB, 0x3C, 0xF3, 0xCF, 0x3F,
  0xB0, 0xC0, 0x7F, 0x3C, 0xF3, 0xCF, 0x37, 0xC3, 0x0C, 0xFF, 0x3C, 0x70,
  0xC3, 0x0C, 0x00, 0x7B, 0x3C, 0x1E, 0x0F, 0x37, 0x80, 0x20, 0x8F, 0xC8,
  0x20, 0x82, 0x08, 0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0x37, 0x80, 0x8F, 0x3C,
  0x92, 0x79, 0xC3, 0x00, 0xDA, 0xB5, 0x6A, 0xD6, 0xAC, 0xD9, 0x00, 0x66,
  0x58, 0xE0, 0xC3, 0xC4, 0xB9, 0x80, 0x8F, 0x34, 0x9E, 0x78, 0xC3, 0x08,
  0x60, 0xFC, 0x21, 0x8C, 0x63, 0x0F, 0xC0, 0x0C, 0x71, 0x04, 0x10, 0xCE,
  0x04, 0x10, 0x41, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0x82, 0x08, 0x20, 0xC3,
  0xC8, 0x20, 0x82, 0x38, 0xE6, 0xD9, 0x80,
};

const GFXglyph JetBrainsMono_SemiBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 2, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 13, 8, 1, -11 },
  { 24, 8, 10, 8, 0, -10 },
  { 34, 6, 10, 8, 1, -10 },
  { 42, 2, 3, 8, 3, -9 },
  { 43, 4, 13, 8, 2, -11 },
  { 50, 5, 13, 8, 1, -11 },
  { 59, 7, 7, 8, 0, -8 },
  { 66, 6, 6, 8, 1, -7 },
  { 71, 3, 4, 8, 2, -2 },
  { 73, 4, 1, 8, 2, -5 },
  { 74, 2, 2, 8, 3, -2 },
  { 75, 6, 12, 8, 1, -11 },
  { 84, 6, 10, 8, 1, -10 },
  { 92, 6, 9, 8, 1, -9 },
  { 99, 6, 10, 8, 1, -10 },
  { 107, 6, 9, 8, 1, -9 },
  { 114, 6, 9, 8, 1, -9 },
  { 121, 6, 9, 8, 1, -9 },
  { 128, 6, 9, 8, 1, -9 },
  { 135, 6, 9, 8, 1, -9 },
  { 142, 6, 10, 8, 1, -10 },
  { 150, 6, 10, 8, 1, -10 },
  { 158, 2, 7, 8, 3, -7 },
  { 160, 3, 9, 8, 2, -7 },
  { 164, 6, 7, 8, 1, -8 },
  { 170, 6, 5, 8, 1, -7 },
  { 174, 6, 7, 8, 1, -8 },
  { 180, 5, 9, 8, 2, -9 },
  { 186, 7, 12, 8, 0, -10 },
  { 197, 7, 9, 8, 0, -9 },
  { 205, 6, 9, 8, 1, -9 },
  { 212, 6, 10, 8, 1, -10 },
  { 220, 6, 9, 8, 1, -9 },
  { 227, 6, 9, 8, 1, -9 },
  { 234, 6, 10, 8, 1, -10 },
  { 242, 6, 10, 8, 1, -10 },
  { 250, 6, 9, 8, 1, -9 },
  { 257, 6, 9, 8, 1, -9 },
  { 264, 7, 9, 8, 0, -9 },
  { 272, 6, 9, 8, 1, -9 },
  { 279, 6, 9, 8, 1, -9 },
  { 286, 6, 9, 8, 1, -9 },
  { 293, 6, 9, 8, 1, -9 },
  { 300, 6, 10, 8, 1, -10 },
  { 308, 6, 9, 8, 1, -9 },
  { 315, 6, 12, 8, 1, -10 },
  { 324, 6, 9, 8, 1, -9 },
  { 331, 6, 10, 8, 1, -10 },
  { 339, 6, 10, 8, 1, -10 },
  { 347, 6, 9, 8, 1, -9 },
  { 354, 7, 9, 8, 0, -9 },
  { 362, 8, 9, 8, 0, -9 },
  { 371, 7, 9, 8, 0, -9 },
  { 379, 7, 9, 8, 0, -9 },
  { 387, 6, 9, 8, 1, -9 },
  { 394, 4, 12, 8, 2, -11 },
  { 400, 6, 12, 8, 1, -11 },
  { 409, 3, 12, 8, 2, -11 },
  { 414, 6, 5, 8, 1, -9 },
  { 418, 6, 2, 8, 1, 0 },
  { 420, 3, 2, 8, 2, -10 },
  { 421, 6, 7, 8, 1, -7 },
  { 427, 6, 9, 8, 1, -9 },
  { 434, 6, 7, 8, 1, -7 },
  { 440, 6, 9, 8, 1, -9 },
  { 447, 6, 7, 8, 1, -7 },
  { 453, 6, 9, 8, 1, -9 },
  { 460, 6, 9, 8, 1, -7 },
  { 467, 6, 9, 8, 1, -9 },
  { 474, 6, 10, 8, 1, -10 },
  { 482, 5, 12, 8, 1, -10 },
  { 490, 6, 9, 8, 1, -9 },
  { 497, 7, 9, 8, 0, -9 },
  { 505, 6, 7, 8, 1, -7 },
  { 511, 6, 7, 8, 1, -7 },
  { 517, 6, 7, 8, 1, -7 },
  { 523, 6, 9, 8, 1, -7 },
  { 530, 6, 9, 8, 1, -7 },
  { 537, 6, 7, 8, 1, -7 },
  { 543, 6, 7, 8, 1, -7 },
  { 549, 6, 9, 8, 1, -9 },
  { 556, 6, 7, 8, 1, -7 },
  { 562, 6, 7, 8, 1, -7 },
  { 568, 7, 7, 8, 0, -7 },
  { 575, 7, 7, 8, 0, -7 },
  { 582, 6, 9, 8, 1, -7 },
  { 589, 6, 7, 8, 1, -7 },
  { 595, 6, 12, 8, 1, -11 },
  { 604, 2, 12, 8, 3, -11 },
  { 607, 6, 12, 8, 1, -11 },
  { 616, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_SemiBold13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_SEMIBOLD13PT7B_H_
