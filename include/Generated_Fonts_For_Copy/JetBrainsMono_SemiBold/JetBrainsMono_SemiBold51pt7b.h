#ifndef _JETBRAINSMONO_SEMIBOLD51PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7C, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x78, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x01,
  0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0x9C, 0xFE, 0x7F,
  0x1C, 0x7F, 0x7E, 0x1C, 0x3F, 0x7E, 0x1C, 0x3F, 0x7E, 0x1C, 0x00, 0x7E,
  0x1C, 0x00, 0x7E, 0x1C, 0x00, 0x7F, 0x1C, 0x00, 0x3F, 0x9C, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1C, 0xFF, 0x00, 0x1C, 0x7F, 0x00, 0x1C, 0x3F, 0x00, 0x1C, 0x3F, 0x00,
  0x1C, 0x1F, 0xFC, 0x1C, 0x1F, 0xFC, 0x1C, 0x3F, 0xFE, 0x1C, 0x3F, 0x7E,
  0x1C, 0x7F, 0x7F, 0x9C, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x3F, 0xF0, 0x00,
  0xF0, 0xFF, 0xF0, 0x03, 0xE3, 0xF3, 0xF0, 0x0F, 0x87, 0x81, 0xE0, 0x1E,
  0x0F, 0x03, 0xC0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x3E, 0x01, 0xE0, 0x78, 0x78, 0x03,
  0xC0, 0xF1, 0xE0, 0x07, 0xC3, 0xE7, 0xC0, 0x07, 0xFF, 0x9F, 0x00, 0x0F,
  0xFF, 0x3C, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC7, 0xFC, 0x00, 0x0F, 0x9F, 0xFC, 0x00, 0x3E,
  0x7F, 0xFC, 0x00, 0x78, 0xF8, 0xFC, 0x01, 0xF3, 0xE0, 0xF8, 0x07, 0xC7,
  0xC0, 0xF0, 0x0F, 0x0F, 0x81, 0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E,
  0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x07, 0x80, 0xF8, 0x3E, 0x1F, 0x00, 0xF0,
  0x7C, 0x7C, 0x01, 0xFF, 0xF0, 0xF0, 0x03, 0xFF, 0xE3, 0xE0, 0x03, 0xFF,
  0x8F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xC7,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0xFC, 0x1F, 0xBF, 0x0F, 0xC3, 0xE7, 0xE0,
  0xFC, 0xFC, 0xFC, 0x1F, 0xFF, 0x1F, 0x81, 0xFF, 0xE3, 0xF0, 0x1F, 0xF8,
  0x7E, 0x01, 0xFF, 0x0F, 0xC0, 0x3F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00,
  0x7F, 0x03, 0xF0, 0x1F, 0xF0, 0x7E, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xCF, 0xC1, 0xFF, 0xF0, 0xFC, 0x0F, 0xFC,
  0x0F, 0xC0, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7D, 0xF7, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x80, 0xF8, 0x0C,
  0x7C, 0x1E, 0x0F, 0xDF, 0xE1, 0xC7, 0xFB, 0xFF, 0x39, 0xFF, 0xFF, 0xF6,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x03,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x04,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0x9F, 0x80, 0x7F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x78, 0x7F, 0xF1, 0xF8, 0xFF, 0xE3, 0xF1, 0xFF, 0xC7, 0xF3, 0xFF, 0x8F,
  0xC7, 0xFF, 0x0F, 0x8F, 0xFE, 0x04, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7E, 0x7F, 0x01, 0xFC,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xBF, 0x00,
  0xFF, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF0, 0x3F, 0x00,
  0xE0, 0x3F, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x7F, 0x81, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7F, 0x01, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xF8, 0x1F, 0x3F, 0xF8, 0x3E, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x3F, 0x80, 0xFE, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x7F, 0xE0, 0x3F, 0x7F, 0xF8, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x07, 0xF7, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFC, 0x1F, 0xC3, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x1F, 0xF7, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F,
  0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xBF, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x7F, 0xC7, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF3, 0xF0, 0x03, 0xE3, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x3F, 0xBF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xE0, 0x40, 0x03, 0x00, 0xFE, 0x1F, 0xE1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x07, 0xC7, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0xFF,
  0xCF, 0xF8, 0x1F, 0xFD, 0xFF, 0x07, 0xE0, 0xFF, 0xE0, 0xF8, 0x0F, 0xFC,
  0x1F, 0x01, 0xFF, 0x83, 0xE0, 0x3F, 0xF0, 0x7C, 0x07, 0xFE, 0x0F, 0x80,
  0xFF, 0xC1, 0xF0, 0x1F, 0xF8, 0x3E, 0x03, 0xFF, 0x07, 0xC0, 0x7F, 0xE0,
  0xF8, 0x0F, 0xFC, 0x1F, 0x01, 0xFF, 0x83, 0xE0, 0x3F, 0xF0, 0x7C, 0x07,
  0xFE, 0x0F, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF, 0x01,
  0xFF, 0x3F, 0xE0, 0x1F, 0xCF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x01,
  0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFE, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x03, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE,
  0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0xC0, 0x7F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7E, 0x7F, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0x81, 0xFF, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xBF, 0x00, 0x7F, 0x7E, 0x0F, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0x7F,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7E, 0x7F,
  0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC,
  0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80,
  0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xF7, 0x80, 0xFF, 0xF7, 0x80, 0xFF, 0xFF, 0x81, 0xEF, 0xFB, 0xC1, 0xEF,
  0xFB, 0xC1, 0xEF, 0xFB, 0xC3, 0xEF, 0xFB, 0xE3, 0xCF, 0xF9, 0xE3, 0xCF,
  0xF9, 0xE3, 0xDF, 0xF9, 0xF7, 0x9F, 0xF8, 0xF7, 0x9F, 0xF8, 0xF7, 0x9F,
  0xF8, 0xF7, 0x1F, 0xF8, 0x7F, 0x1F, 0xFC, 0x7F, 0x1F, 0xFC, 0x7F, 0x1F,
  0xFC, 0x7E, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xF7, 0xC0, 0xFF, 0xEF, 0x81, 0xFF, 0xDF,
  0x03, 0xFF, 0x9F, 0x07, 0xFF, 0x3E, 0x0F, 0xFE, 0x3C, 0x1F, 0xFC, 0x7C,
  0x3F, 0xF8, 0xF8, 0x7F, 0xF0, 0xF0, 0xFF, 0xE1, 0xF1, 0xFF, 0xC3, 0xE3,
  0xFF, 0x83, 0xC7, 0xFF, 0x07, 0xCF, 0xFE, 0x0F, 0x9F, 0xFC, 0x0F, 0xBF,
  0xF8, 0x1F, 0x7F, 0xF0, 0x3E, 0xFF, 0xE0, 0x3E, 0xFF, 0xC0, 0x7D, 0xFF,
  0x80, 0xFB, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x7F, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x7E, 0x7F, 0x03,
  0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0,
  0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x01, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0x7F,
  0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x7F,
  0x03, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x03,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x07, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xF7, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x80,
  0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x80,
  0x3F, 0x3F, 0x81, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0xF8, 0x0F, 0x81, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x07,
  0xE0, 0x7D, 0xF8, 0x3F, 0x03, 0xEF, 0xC1, 0xFC, 0x1F, 0x3E, 0x0E, 0xE0,
  0xF9, 0xF0, 0x77, 0x07, 0xCF, 0x83, 0xB8, 0x3E, 0x7C, 0x1D, 0xC1, 0xF3,
  0xE0, 0xEE, 0x0F, 0x9F, 0x0F, 0x70, 0x7C, 0xF8, 0x7B, 0x87, 0xC7, 0xC3,
  0xDC, 0x3E, 0x3E, 0x1C, 0xF1, 0xF1, 0xF8, 0xE7, 0x8F, 0x87, 0xC7, 0x1C,
  0x7C, 0x3E, 0x38, 0xE3, 0xE1, 0xF1, 0xC7, 0x1F, 0x0F, 0x8E, 0x38, 0xF8,
  0x7C, 0xF1, 0xC7, 0xC3, 0xE7, 0x8E, 0x3C, 0x1F, 0x38, 0x71, 0xE0, 0xF9,
  0xC3, 0xDF, 0x07, 0xCE, 0x1E, 0xF8, 0x1E, 0x70, 0xF7, 0xC0, 0xFB, 0x83,
  0xBE, 0x07, 0xDC, 0x1D, 0xF0, 0x3F, 0xE0, 0xEF, 0x81, 0xFF, 0x07, 0x7C,
  0x0F, 0xF8, 0x3B, 0xC0, 0x7F, 0x81, 0xDE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x07, 0xE1, 0xFC,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x1F,
  0xBF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xC7,
  0xE0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x80,
  0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0, 0x03,
  0xE7, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0xFC,
  0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7E, 0x3F, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xF7,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0x03, 0xFF, 0x7F, 0xFF,
  0xBF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x0F, 0xFC, 0x3F, 0x00, 0xC0,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x0C, 0x01, 0xF8, 0xFF, 0x83, 0xF3, 0xFF, 0x87, 0xEF, 0xFF, 0x8F,
  0xDF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0x7E, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x7F, 0x80, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFB, 0xFF, 0xF3, 0xF7, 0xFF, 0xC7, 0xE7, 0xFF, 0x0F, 0xC7, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0x7F,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0xFE,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xC0, 0x7E, 0x0F, 0xF0, 0xFC, 0x7F,
  0xF9, 0xF9, 0xFF, 0xFB, 0xF7, 0xFF, 0xF7, 0xEF, 0xFF, 0xEF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFF, 0x7F, 0xFF, 0x7E, 0xFF, 0xFE, 0xFC, 0xFF, 0xFD, 0xF8, 0xFF,
  0xF3, 0xF0, 0x7F, 0x87, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0,
  0x7F, 0x1F, 0x80, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x7F, 0xC3, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF1,
  0xF1, 0xFF, 0xE7, 0xCF, 0xFF, 0xDF, 0x3F, 0xFF, 0x7D, 0xFF, 0xFD, 0xF7,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xFF, 0xF7, 0xCF, 0xFF,
  0xDF, 0x3F, 0xFE, 0x7C, 0x7F, 0xF9, 0xF0, 0x7F, 0x87, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x04, 0x01, 0xF8, 0xFF, 0x83, 0xF3, 0xFF, 0x87,
  0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F,
  0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0,
  0x0F, 0xE3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E,
  0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7E, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0,
  0x03, 0xF8, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x40, 0x30, 0x7C, 0xFC,
  0x7E, 0x3E, 0xFE, 0x7F, 0x9F, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0xF7, 0xE3,
  0xF0, 0xFF, 0xE0, 0xF8, 0x7F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC,
  0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF,
  0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F,
  0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0,
  0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E,
  0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83,
  0xE0, 0xF8, 0x00, 0x04, 0x01, 0xF8, 0xFF, 0x83, 0xF3, 0xFF, 0x87, 0xEF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F, 0x00,
  0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x7F, 0x00,
  0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x3F, 0x81, 0xFE, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0C, 0x01, 0xF8, 0xFF, 0x83, 0xF3, 0xFF, 0x87, 0xEF,
  0xFF, 0x8F, 0xDF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F, 0x00,
  0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x7F, 0x80, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFB, 0xFF, 0xF3, 0xF7, 0xFF, 0xC7, 0xE7, 0xFF, 0x0F, 0xC7,
  0xFC, 0x1F, 0x80, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0xFC, 0x7F, 0xF9,
  0xF9, 0xFF, 0xFB, 0xF3, 0xFF, 0xF7, 0xEF, 0xFF, 0xEF, 0xDF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xBF, 0x81,
  0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFE, 0xFC, 0xFF, 0xFD, 0xF8, 0xFF, 0xF3,
  0xF0, 0x7F, 0x87, 0xE0, 0x08, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x04, 0x01, 0xF8, 0xFF, 0x83,
  0xF3, 0xFF, 0xC7, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFD, 0xFF, 0xBF,
  0xC0, 0x7F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0x9F,
  0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC7, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x00, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8,
  0x1F, 0x7C, 0x1F, 0x81, 0xF7, 0xC1, 0xF8, 0x1F, 0x7C, 0x1F, 0x81, 0xF7,
  0xC1, 0xFC, 0x1F, 0x7C, 0x1D, 0xC1, 0xE7, 0xC1, 0xDC, 0x3E, 0x3C, 0x1D,
  0xC3, 0xE3, 0xE3, 0xDC, 0x3E, 0x3E, 0x39, 0xC3, 0xE3, 0xE3, 0x9C, 0x3E,
  0x3E, 0x39, 0xE3, 0xC3, 0xE3, 0x8E, 0x3C, 0x3E, 0x38, 0xE7, 0xC1, 0xE7,
  0x8E, 0x7C, 0x1E, 0x78, 0xE7, 0xC1, 0xF7, 0x0E, 0x7C, 0x1F, 0x70, 0xF7,
  0x81, 0xF7, 0x0F, 0x78, 0x1F, 0x70, 0x77, 0x80, 0xF7, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC7,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xDF, 0xFE, 0x03, 0xEF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xE7, 0xF0, 0x7F, 0xE0, 0xFC, 0x7F, 0xF0,
  0x7F, 0xFE, 0xF8, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x3E, 0x01, 0xFF, 0x00,
  0x00, 0x3E, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 37, 31, 11, -37 },
  { 38, 17, 15, 31, 7, -37 },
  { 70, 28, 37, 31, 1, -37 },
  { 200, 24, 51, 31, 3, -44 },
  { 353, 31, 37, 31, 0, -37 },
  { 497, 27, 39, 31, 2, -38 },
  { 629, 6, 15, 31, 12, -37 },
  { 641, 16, 49, 31, 9, -43 },
  { 739, 16, 49, 31, 6, -43 },
  { 837, 27, 26, 31, 2, -31 },
  { 925, 24, 24, 31, 3, -29 },
  { 997, 12, 16, 31, 8, -8 },
  { 1021, 16, 6, 31, 7, -20 },
  { 1033, 9, 10, 31, 11, -9 },
  { 1045, 24, 48, 31, 3, -42 },
  { 1189, 23, 39, 31, 4, -38 },
  { 1302, 24, 37, 31, 4, -37 },
  { 1413, 24, 38, 31, 3, -38 },
  { 1527, 24, 38, 31, 3, -37 },
  { 1641, 22, 37, 31, 4, -37 },
  { 1743, 23, 38, 31, 4, -37 },
  { 1853, 25, 38, 31, 3, -37 },
  { 1972, 25, 37, 31, 3, -37 },
  { 2088, 24, 39, 31, 3, -38 },
  { 2205, 25, 38, 31, 3, -38 },
  { 2324, 9, 30, 31, 11, -29 },
  { 2358, 12, 37, 31, 8, -29 },
  { 2414, 23, 28, 31, 4, -31 },
  { 2495, 22, 18, 31, 4, -26 },
  { 2545, 23, 28, 31, 4, -31 },
  { 2626, 20, 37, 31, 6, -37 },
  { 2719, 27, 47, 31, 2, -38 },
  { 2878, 27, 37, 31, 2, -37 },
  { 3003, 24, 37, 31, 4, -37 },
  { 3114, 23, 39, 31, 4, -38 },
  { 3227, 23, 37, 31, 4, -37 },
  { 3334, 22, 37, 31, 5, -37 },
  { 3436, 23, 37, 31, 4, -37 },
  { 3543, 23, 39, 31, 4, -38 },
  { 3656, 22, 37, 31, 4, -37 },
  { 3758, 21, 37, 31, 5, -37 },
  { 3856, 24, 38, 31, 2, -37 },
  { 3970, 25, 37, 31, 4, -37 },
  { 4086, 22, 37, 31, 5, -37 },
  { 4188, 24, 37, 31, 3, -37 },
  { 4299, 23, 37, 31, 4, -37 },
  { 4406, 23, 39, 31, 4, -38 },
  { 4519, 25, 37, 31, 4, -37 },
  { 4635, 23, 47, 31, 4, -38 },
  { 4771, 24, 37, 31, 4, -37 },
  { 4882, 24, 39, 31, 3, -38 },
  { 4999, 26, 37, 31, 2, -37 },
  { 5120, 23, 38, 31, 4, -37 },
  { 5230, 27, 37, 31, 2, -37 },
  { 5355, 29, 37, 31, 1, -37 },
  { 5490, 27, 37, 31, 2, -37 },
  { 5615, 28, 37, 31, 1, -37 },
  { 5745, 22, 37, 31, 4, -37 },
  { 5847, 14, 48, 31, 10, -42 },
  { 5931, 24, 48, 31, 3, -42 },
  { 6075, 14, 48, 31, 7, -42 },
  { 6159, 23, 20, 31, 4, -37 },
  { 6217, 25, 6, 31, 3, 1 },
  { 6236, 12, 7, 31, 9, -40 },
  { 6247, 24, 30, 31, 3, -29 },
  { 6337, 23, 38, 31, 4, -37 },
  { 6447, 23, 30, 31, 4, -29 },
  { 6534, 23, 38, 31, 4, -37 },
  { 6644, 23, 30, 31, 4, -29 },
  { 6731, 25, 37, 31, 3, -37 },
  { 6847, 22, 38, 31, 4, -29 },
  { 6952, 23, 37, 31, 4, -37 },
  { 7059, 24, 40, 31, 4, -40 },
  { 7179, 20, 49, 31, 4, -40 },
  { 7302, 25, 37, 31, 4, -37 },
  { 7418, 27, 37, 31, 1, -37 },
  { 7543, 25, 29, 31, 3, -29 },
  { 7634, 23, 29, 31, 4, -29 },
  { 7718, 23, 29, 31, 4, -29 },
  { 7802, 23, 38, 31, 4, -29 },
  { 7912, 23, 38, 31, 4, -29 },
  { 8022, 23, 29, 31, 5, -29 },
  { 8106, 23, 29, 31, 4, -29 },
  { 8190, 25, 36, 31, 2, -36 },
  { 8303, 23, 29, 31, 4, -28 },
  { 8387, 26, 28, 31, 2, -28 },
  { 8478, 28, 28, 31, 1, -28 },
  { 8576, 27, 28, 31, 2, -28 },
  { 8671, 26, 37, 31, 2, -28 },
  { 8792, 22, 28, 31, 4, -28 },
  { 8869, 22, 48, 31, 4, -42 },
  { 9001, 6, 48, 31, 12, -42 },
  { 9037, 22, 48, 31, 4, -42 },
  { 9169, 25, 12, 31, 3, -24 },
};

const GFXfont JetBrainsMono_SemiBold51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_SEMIBOLD51PT7B_H_
