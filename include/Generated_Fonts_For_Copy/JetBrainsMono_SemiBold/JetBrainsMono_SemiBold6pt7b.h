#ifndef _JETBRAINSMONO_SEMIBOLD6PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0xEF, 0xD0, 0x55, 0x1E, 0x80, 0xFA, 0x5A, 0xEA, 0xF0,
  0x80, 0x6A, 0x90, 0x95, 0xA0, 0x55, 0x80, 0x5C, 0xC0, 0xC0, 0x80, 0x25,
  0x25, 0x00, 0xFE, 0xB0, 0x97, 0xE5, 0x70, 0x6C, 0xF0, 0x6F, 0x90, 0xEC,
  0xF0, 0x6E, 0xB0, 0xE5, 0x20, 0xEE, 0xB0, 0xF5, 0xA0, 0xA0, 0xB0, 0x2B,
  0x10, 0xFC, 0x8D, 0xC0, 0xDA, 0xFF, 0xD4, 0x4D, 0xD0, 0xFE, 0xF0, 0xF2,
  0x30, 0xF6, 0xF0, 0xFB, 0xFE, 0x40, 0xF2, 0xB0, 0xBE, 0xD0, 0xEB, 0x64,
  0xF0, 0xBA, 0xD0, 0xAB, 0xBE, 0xD0, 0xFE, 0xD0, 0xF6, 0xB0, 0xFE, 0x40,
  0xF6, 0xB2, 0xFE, 0xD0, 0xE8, 0xF0, 0xE9, 0x20, 0xB6, 0xB0, 0xAD, 0xA0,
  0xFF, 0xD0, 0xE9, 0xD0, 0xAD, 0x20, 0x69, 0x70, 0xEA, 0xB0, 0x89, 0x12,
  0x40, 0xFC, 0x74, 0xE0, 0x80, 0xFF, 0x80, 0x9E, 0xF0, 0xF1, 0x80, 0x76,
  0xB0, 0xFD, 0x80, 0x7D, 0x20, 0xF5, 0xB0, 0x9E, 0xD0, 0x41, 0x2E, 0x21,
  0x93, 0xC0, 0x97, 0x50, 0xC9, 0x30, 0xFF, 0x80, 0xF6, 0x80, 0xF5, 0x80,
  0xF7, 0xC0, 0xF5, 0x90, 0xE8, 0xEF, 0x80, 0x5D, 0x30, 0xB5, 0x80, 0xAD,
  0x00, 0xFD, 0x80, 0xEA, 0x80, 0xAD, 0x20, 0x6B, 0x80, 0x27, 0x14, 0x40,
  0xFC, 0xC9, 0xA5, 0x80, 0xE4,
};

const GFXglyph JetBrainsMono_SemiBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 2, 6, 4, 1, -5 },
  { 17, 3, 3, 4, 0, -4 },
  { 19, 3, 2, 4, 0, -3 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 3, 6, 4, 0, -5 },
  { 26, 3, 4, 4, 0, -4 },
  { 28, 2, 4, 4, 1, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 1, 3, 4, 1, -3 },
  { 46, 1, 4, 4, 1, -3 },
  { 47, 3, 4, 4, 0, -4 },
  { 49, 3, 2, 4, 0, -3 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 3, 5, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 2, 4, 4, 1, -4 },
  { 71, 3, 4, 4, 0, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 2, 4, 4, 1, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 5, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 0, -4 },
  { 94, 3, 4, 4, 0, -4 },
  { 96, 3, 4, 4, 0, -4 },
  { 98, 3, 4, 4, 0, -4 },
  { 100, 3, 4, 4, 0, -4 },
  { 102, 3, 4, 4, 0, -4 },
  { 104, 2, 6, 4, 1, -5 },
  { 106, 3, 6, 4, 0, -5 },
  { 109, 1, 6, 4, 1, -5 },
  { 110, 3, 2, 4, 0, -4 },
  { 111, 3, 1, 4, 0, 0 },
  { 112, 1, 1, 4, 1, -5 },
  { 113, 3, 3, 4, 0, -3 },
  { 115, 3, 4, 4, 0, -4 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 3, 4, 4, 0, -4 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 4, 4, 0, -4 },
  { 125, 3, 4, 4, 0, -3 },
  { 127, 3, 4, 4, 0, -4 },
  { 129, 3, 5, 4, 0, -5 },
  { 131, 3, 6, 4, 0, -5 },
  { 134, 3, 4, 4, 0, -4 },
  { 136, 3, 4, 4, 0, -4 },
  { 138, 3, 3, 4, 0, -3 },
  { 140, 3, 3, 4, 0, -3 },
  { 142, 3, 3, 4, 0, -3 },
  { 144, 3, 4, 4, 0, -3 },
  { 146, 3, 4, 4, 0, -3 },
  { 148, 2, 3, 4, 1, -3 },
  { 149, 3, 3, 4, 0, -3 },
  { 151, 3, 4, 4, 0, -4 },
  { 153, 3, 3, 4, 0, -3 },
  { 155, 3, 3, 4, 0, -3 },
  { 157, 3, 3, 4, 0, -3 },
  { 159, 3, 3, 4, 0, -3 },
  { 161, 3, 4, 4, 0, -3 },
  { 163, 3, 3, 4, 0, -3 },
  { 165, 3, 6, 4, 0, -5 },
  { 168, 1, 6, 4, 1, -5 },
  { 169, 3, 6, 4, 0, -5 },
  { 172, 3, 2, 4, 0, -3 },
};

const GFXfont JetBrainsMono_SemiBold6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_SEMIBOLD6PT7B_H_
