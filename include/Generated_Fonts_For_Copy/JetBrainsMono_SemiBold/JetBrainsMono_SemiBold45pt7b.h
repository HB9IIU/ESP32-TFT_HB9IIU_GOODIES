#ifndef _JETBRAINSMONO_SEMIBOLD45PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x8E, 0x00, 0x00, 0x00,
  0x01, 0xCF, 0xFF, 0xFF, 0xFF, 0x7C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x07, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x78, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x1E, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x07, 0x81, 0xE0, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFC, 0xE7,
  0xE7, 0xC7, 0x1F, 0xBE, 0x38, 0xFF, 0xF1, 0xC3, 0xFF, 0x8E, 0x00, 0x7C,
  0x70, 0x03, 0xF3, 0x80, 0x1F, 0xDC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1C, 0xFE, 0x00, 0xE3, 0xF0, 0x07, 0x0F, 0x80, 0x38, 0x7F,
  0xE1, 0xC3, 0xFF, 0x0E, 0x1F, 0xFC, 0x70, 0xFF, 0xE3, 0x8F, 0xDF, 0xDD,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xE7, 0xFE, 0x00, 0x78, 0xFF,
  0xE0, 0x1E, 0x3E, 0x7C, 0x03, 0xC7, 0x87, 0x80, 0xF0, 0xE0, 0x78, 0x3C,
  0x1C, 0x0F, 0x07, 0x83, 0x81, 0xE1, 0xE0, 0x70, 0x3C, 0x78, 0x0E, 0x07,
  0x9E, 0x01, 0xE1, 0xE3, 0xC0, 0x3E, 0x7C, 0xF0, 0x03, 0xFF, 0xBC, 0x00,
  0x3F, 0xE7, 0x80, 0x03, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7F, 0x80,
  0x07, 0x9F, 0xF8, 0x01, 0xE7, 0xFF, 0x80, 0x78, 0xF0, 0xF0, 0x0F, 0x3C,
  0x0E, 0x03, 0xC7, 0x81, 0xC0, 0xF0, 0xF0, 0x38, 0x1E, 0x1E, 0x07, 0x07,
  0x83, 0xC0, 0xE1, 0xE0, 0x3C, 0x3C, 0x78, 0x07, 0x8F, 0x8F, 0x00, 0xFF,
  0xF3, 0xC0, 0x0F, 0xFC, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x87, 0xE0, 0x3F,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0x7F,
  0xF8, 0x3E, 0xFC, 0xF8, 0x7E, 0xF8, 0x7C, 0x7C, 0xF8, 0x7E, 0xFC, 0xF8,
  0x3F, 0xF8, 0xF8, 0x1F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xF0, 0x7E, 0x1F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFE, 0x7C, 0x3F, 0xFC, 0x7E, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0xF0,
  0x0F, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0,
  0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0x01, 0xF0, 0x10, 0xE0,
  0x70, 0x38, 0xFC, 0x38, 0x7E, 0x7F, 0x9C, 0xFF, 0x7F, 0xEE, 0xFF, 0xCF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0,
  0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x07,
  0x80, 0x04, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xF8,
  0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFB,
  0xF9, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07,
  0xDF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F,
  0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xE0, 0xFC, 0x06, 0x07, 0xE0, 0x20,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFD,
  0xFE, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBF,
  0x00, 0x7D, 0xF8, 0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF3, 0xF0, 0x1F, 0x3F, 0x01,
  0xF7, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x30,
  0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0x07, 0xF3, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0xFB, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF7, 0xF8, 0x3F, 0xBF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xF7, 0xF0, 0x7F,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xF8, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC, 0x07, 0xE3, 0xF0, 0x7E,
  0x0F, 0xC7, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xF7, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0x3F, 0x3E, 0x00, 0xFB,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x7F, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFE, 0xF8, 0x1F, 0xEF, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x3F, 0x9F, 0xDF,
  0xF7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0xE7, 0xF7, 0xFF, 0xFE, 0xFE, 0x3E,
  0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F, 0x83, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00,
  0x38, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x07,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x0F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x7F, 0xEF, 0xF0, 0x7E,
  0x7F, 0xF0, 0x78, 0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8,
  0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8,
  0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0x78, 0x1F, 0xF0, 0x7C,
  0x3F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF0, 0x1F, 0xCF, 0xF0, 0x02,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0xF8, 0x07, 0xEF, 0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFC, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFB, 0xE0,
  0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xF8, 0x7F, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x80, 0xFE, 0xF8,
  0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xEF, 0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFC, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0,
  0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xF8, 0x7F, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7D, 0xF8, 0x07, 0xE7,
  0xF0, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC,
  0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8,
  0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x7E,
  0x03, 0xE1, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xE0,
  0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F,
  0x0F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xCF,
  0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFE, 0xE0, 0xEF,
  0xF7, 0x8F, 0x7F, 0xBC, 0x7B, 0xFC, 0xE3, 0x9F, 0xE7, 0x9C, 0xFF, 0x3D,
  0xE7, 0xF9, 0xEF, 0x3F, 0xC7, 0x71, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0xFF,
  0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFB, 0xC0, 0xFF, 0xDE, 0x07, 0xFE, 0xF8, 0x3F, 0xF3,
  0xC1, 0xFF, 0x9E, 0x0F, 0xFC, 0xF8, 0x7F, 0xE3, 0xC3, 0xFF, 0x1E, 0x1F,
  0xF8, 0xF8, 0xFF, 0xC3, 0xC7, 0xFE, 0x1E, 0x3F, 0xF0, 0xF9, 0xFF, 0x83,
  0xCF, 0xFC, 0x1E, 0x7F, 0xE0, 0xFB, 0xFF, 0x03, 0xDF, 0xF8, 0x1E, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F, 0x01,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xF8,
  0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7C, 0x03, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xF8, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xDF,
  0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xF8, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7C, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x1F,
  0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x0F,
  0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07,
  0xEF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xF0, 0x7F,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07,
  0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xF0, 0x3E,
  0x07, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83,
  0x60, 0xFF, 0xC1, 0xB0, 0x7F, 0xE0, 0xDC, 0x3E, 0xF0, 0xEE, 0x1E, 0x78,
  0x77, 0x0F, 0x3C, 0x3B, 0x87, 0x9E, 0x1D, 0xC3, 0xCF, 0x0E, 0xE1, 0xE7,
  0xC7, 0x70, 0xF3, 0xE3, 0x98, 0xF9, 0xF1, 0x8E, 0x7C, 0xF9, 0xC7, 0x3E,
  0x3C, 0xE3, 0x9E, 0x1E, 0x71, 0xCF, 0x0F, 0x38, 0xE7, 0x87, 0x9C, 0x73,
  0xC3, 0xCE, 0x39, 0xE1, 0xE7, 0x1C, 0xF0, 0xF3, 0x8E, 0x78, 0x7F, 0x83,
  0xBC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9,
  0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xF0,
  0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xC7,
  0xC0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF1, 0xE0, 0x0F,
  0x8F, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xC0,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x87,
  0xF7, 0xE0, 0x3F, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x01, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xDF,
  0x1F, 0xF1, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0xFE, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x9F, 0xEF,
  0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0xC0,
  0x7E, 0xFF, 0x0F, 0xEF, 0xFF, 0xFC, 0xFB, 0xFF, 0xCF, 0xBF, 0xF8, 0xF8,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFD, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xF8, 0x7F, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x07, 0xF1, 0xF1, 0xFF, 0x9F, 0x3F, 0xFD, 0xF3,
  0xFF, 0xFF, 0x7F, 0x9F, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFD, 0xF1, 0xFF, 0xDF, 0x0F, 0xF1, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0,
  0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x02, 0xF8, 0x03, 0xE7,
  0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF1, 0xF1, 0xFF,
  0x9F, 0x3F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0x9F, 0xF7, 0xE0, 0x3F, 0x7C,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFD,
  0xF1, 0xFF, 0xDF, 0x0F, 0xF9, 0xF0, 0x08, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0xFE, 0x1F, 0x3F, 0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xF1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD, 0xF0,
  0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x07, 0xE3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x7C, 0x03,
  0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF9, 0xE1, 0xF1, 0xF7, 0xE7, 0xF3, 0xFF, 0xEF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xC7, 0xC7, 0xDF, 0x0F, 0x87, 0xFE, 0x0E, 0x0F, 0xFC, 0x1C, 0x1F, 0xF8,
  0x38, 0x3F, 0xF0, 0x70, 0x7F, 0xE0, 0xE0, 0xFF, 0xC1, 0xC1, 0xFF, 0x83,
  0x83, 0xFF, 0x07, 0x07, 0xFE, 0x0E, 0x0F, 0xFC, 0x1C, 0x1F, 0xF8, 0x38,
  0x3F, 0xF0, 0x70, 0x7F, 0xE0, 0xE0, 0xFF, 0xC1, 0xC1, 0xFF, 0x83, 0x83,
  0xFF, 0x07, 0x07, 0xFE, 0x0E, 0x0F, 0xFC, 0x1C, 0x1F, 0xF8, 0x38, 0x3E,
  0xF8, 0xFE, 0x1F, 0x3F, 0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF9, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFD,
  0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF,
  0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xF8, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xF8, 0xFE, 0x0F, 0x9F, 0xF8, 0xFB,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x9F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0xFF, 0x0F, 0xEF, 0xFF,
  0xFC, 0xFB, 0xFF, 0xCF, 0xBF, 0xF8, 0xF8, 0xFF, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF1, 0xF1, 0xFF, 0x9F, 0x3F, 0xFD,
  0xF3, 0xFF, 0xFF, 0x7F, 0x9F, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFD, 0xF1, 0xFF, 0xDF, 0x07, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x7F, 0x07, 0xCF, 0xFE, 0x3E, 0xFF, 0xF9,
  0xF7, 0xFF, 0xCF, 0xB8, 0xFF, 0x7F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xF0, 0x7F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE1, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x3E, 0x07, 0xFC,
  0x1F, 0x03, 0xFE, 0x0F, 0x83, 0xEF, 0x07, 0xC1, 0xE7, 0x83, 0x60, 0xF3,
  0xC1, 0xB0, 0x79, 0xE1, 0xDC, 0x3C, 0xF0, 0xEE, 0x1E, 0x7C, 0x77, 0x0F,
  0x3E, 0x3B, 0x8F, 0x0F, 0x1D, 0xC7, 0x87, 0x8C, 0x63, 0xC3, 0xCE, 0x31,
  0xE1, 0xE7, 0x1C, 0xF0, 0xF3, 0x8E, 0x78, 0x7D, 0xC7, 0x3C, 0x1E, 0xE3,
  0xBC, 0x0F, 0x71, 0xDE, 0x07, 0xB0, 0x6F, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0x81, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03,
  0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0x1F, 0x80, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3,
  0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F,
  0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7E,
  0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x7D, 0xFF, 0xC0, 0xFB, 0xFF, 0xC1,
  0xF7, 0xCF, 0xC3, 0xFF, 0x0F, 0xC7, 0xBE, 0x0F, 0xFF, 0x7C, 0x0F, 0xFE,
  0xF8, 0x0F, 0xF9, 0xF0, 0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_SemiBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 33, 27, 10, -33 },
  { 30, 15, 14, 27, 6, -33 },
  { 57, 25, 33, 27, 1, -33 },
  { 161, 21, 45, 27, 3, -39 },
  { 280, 27, 33, 27, 0, -33 },
  { 392, 24, 33, 27, 2, -33 },
  { 491, 5, 14, 27, 11, -33 },
  { 500, 14, 43, 27, 8, -38 },
  { 576, 14, 43, 27, 5, -38 },
  { 652, 25, 23, 27, 1, -27 },
  { 724, 21, 22, 27, 3, -26 },
  { 782, 10, 14, 27, 7, -7 },
  { 800, 15, 5, 27, 6, -17 },
  { 810, 9, 8, 27, 9, -8 },
  { 819, 21, 42, 27, 3, -37 },
  { 930, 21, 33, 27, 3, -33 },
  { 1017, 21, 33, 27, 4, -33 },
  { 1104, 21, 33, 27, 3, -33 },
  { 1191, 21, 33, 27, 3, -33 },
  { 1278, 20, 33, 27, 3, -33 },
  { 1361, 21, 33, 27, 3, -33 },
  { 1448, 21, 33, 27, 3, -33 },
  { 1535, 21, 33, 27, 3, -33 },
  { 1622, 21, 33, 27, 3, -33 },
  { 1709, 21, 33, 27, 3, -33 },
  { 1796, 9, 25, 27, 9, -25 },
  { 1825, 11, 32, 27, 7, -25 },
  { 1869, 19, 24, 27, 4, -27 },
  { 1926, 19, 16, 27, 4, -23 },
  { 1964, 19, 24, 27, 4, -27 },
  { 2021, 17, 33, 27, 6, -33 },
  { 2092, 24, 41, 27, 2, -33 },
  { 2215, 23, 33, 27, 2, -33 },
  { 2310, 20, 33, 27, 4, -33 },
  { 2393, 21, 33, 27, 3, -33 },
  { 2480, 20, 33, 27, 4, -33 },
  { 2563, 20, 33, 27, 4, -33 },
  { 2646, 20, 33, 27, 4, -33 },
  { 2729, 21, 33, 27, 3, -33 },
  { 2816, 19, 33, 27, 4, -33 },
  { 2895, 19, 33, 27, 4, -33 },
  { 2974, 21, 33, 27, 2, -33 },
  { 3061, 22, 33, 27, 4, -33 },
  { 3152, 19, 33, 27, 5, -33 },
  { 3231, 21, 33, 27, 3, -33 },
  { 3318, 21, 33, 27, 3, -33 },
  { 3405, 21, 33, 27, 3, -33 },
  { 3492, 21, 33, 27, 4, -33 },
  { 3579, 21, 41, 27, 3, -33 },
  { 3687, 21, 33, 27, 4, -33 },
  { 3774, 21, 33, 27, 3, -33 },
  { 3861, 23, 33, 27, 2, -33 },
  { 3956, 21, 33, 27, 3, -33 },
  { 4043, 23, 33, 27, 2, -33 },
  { 4138, 25, 33, 27, 1, -33 },
  { 4242, 25, 33, 27, 1, -33 },
  { 4346, 25, 33, 27, 1, -33 },
  { 4450, 19, 33, 27, 4, -33 },
  { 4529, 12, 42, 27, 9, -37 },
  { 4592, 21, 42, 27, 3, -37 },
  { 4703, 12, 42, 27, 6, -37 },
  { 4766, 21, 18, 27, 3, -33 },
  { 4814, 21, 5, 27, 3, 1 },
  { 4828, 10, 6, 27, 8, -35 },
  { 4836, 20, 25, 27, 3, -25 },
  { 4899, 20, 33, 27, 4, -33 },
  { 4982, 21, 25, 27, 3, -25 },
  { 5048, 20, 33, 27, 3, -33 },
  { 5131, 21, 25, 27, 3, -25 },
  { 5197, 22, 33, 27, 2, -33 },
  { 5288, 20, 33, 27, 3, -25 },
  { 5371, 19, 33, 27, 4, -33 },
  { 5450, 21, 35, 27, 4, -35 },
  { 5542, 17, 43, 27, 4, -35 },
  { 5634, 21, 33, 27, 4, -33 },
  { 5721, 24, 33, 27, 1, -33 },
  { 5820, 23, 25, 27, 2, -25 },
  { 5892, 19, 25, 27, 4, -25 },
  { 5952, 21, 25, 27, 3, -25 },
  { 6018, 20, 33, 27, 4, -25 },
  { 6101, 20, 33, 27, 3, -25 },
  { 6184, 21, 25, 27, 4, -25 },
  { 6250, 21, 25, 27, 3, -25 },
  { 6316, 22, 32, 27, 2, -32 },
  { 6404, 19, 25, 27, 4, -25 },
  { 6464, 23, 25, 27, 2, -25 },
  { 6536, 25, 25, 27, 1, -25 },
  { 6615, 23, 25, 27, 2, -25 },
  { 6687, 23, 33, 27, 2, -25 },
  { 6782, 19, 25, 27, 4, -25 },
  { 6842, 19, 42, 27, 4, -37 },
  { 6942, 5, 42, 27, 11, -37 },
  { 6969, 19, 42, 27, 4, -37 },
  { 7069, 23, 10, 27, 2, -21 },
};

const GFXfont JetBrainsMono_SemiBold45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_SEMIBOLD45PT7B_H_
