#ifndef _JETBRAINSMONO_SEMIBOLD49PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFE,
  0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F, 0xDF, 0x07,
  0xEF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x3C, 0x00, 0x78, 0x0F,
  0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x80, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x1E, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00,
  0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01,
  0xE0, 0x3E, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x1E,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x01, 0xE0,
  0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFB, 0x9F,
  0xCF, 0xC7, 0x1F, 0x9F, 0x8E, 0x1F, 0xBF, 0x1C, 0x3F, 0x7E, 0x38, 0x00,
  0xFC, 0x70, 0x01, 0xF8, 0xE0, 0x03, 0xF1, 0xC0, 0x07, 0xF3, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xBF, 0xC0, 0x07,
  0x1F, 0xC0, 0x0E, 0x1F, 0x80, 0x1C, 0x3F, 0x00, 0x38, 0x3F, 0xF8, 0x70,
  0x7F, 0xF0, 0xE0, 0xFF, 0xE1, 0xC3, 0xFF, 0xE3, 0x87, 0xEF, 0xE7, 0x1F,
  0xDF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x78, 0xFF, 0x80, 0x07, 0x8F, 0xFE, 0x00, 0x7C, 0xFF, 0xF8,
  0x03, 0xC7, 0x83, 0xC0, 0x3C, 0x3C, 0x1F, 0x03, 0xE1, 0xE0, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x1F, 0x03, 0xC0, 0xF0, 0xF0, 0x1E,
  0x07, 0x8F, 0x00, 0xF0, 0x7C, 0xF0, 0x07, 0xC7, 0xCF, 0x80, 0x1F, 0xFE,
  0x78, 0x00, 0xFF, 0xE7, 0x80, 0x01, 0xFE, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE3, 0xF8, 0x00, 0x1E, 0x3F, 0xF0, 0x01, 0xF3, 0xFF, 0xC0, 0x0F,
  0x3F, 0xFE, 0x00, 0xF1, 0xE0, 0xF8, 0x0F, 0x8F, 0x07, 0xC0, 0x78, 0x78,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C,
  0x3C, 0x07, 0x83, 0xE3, 0xC0, 0x3C, 0x1F, 0x3E, 0x01, 0xFF, 0xF1, 0xE0,
  0x07, 0xFF, 0x9E, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0xFD,
  0xFB, 0xF0, 0x3E, 0xFC, 0x7E, 0x1F, 0xBF, 0x0F, 0xC7, 0xCF, 0xC1, 0xF3,
  0xF3, 0xF0, 0x7F, 0xF8, 0xFC, 0x0F, 0xFE, 0x3F, 0x01, 0xFF, 0x0F, 0xC0,
  0x7F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x7F, 0xC1, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF,
  0xC1, 0xFF, 0xF1, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x00, 0x03, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x83,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0x78, 0x1C,
  0x7C, 0x1E, 0x1F, 0xBF, 0xC7, 0x1F, 0xEF, 0xFD, 0xCF, 0xFF, 0xFF, 0xBF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xE0, 0x03, 0x00, 0x70, 0x00, 0x40, 0x08, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7C, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x1E, 0x3F, 0xFC, 0x7E, 0x7F,
  0xF8, 0xFC, 0xFF, 0xF1, 0xF9, 0xFF, 0xE3, 0xF3, 0xFF, 0xC3, 0xC7, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0,
  0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0xF7, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xF7, 0xC0,
  0x3F, 0xCF, 0x80, 0x7F, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7C, 0x03,
  0x80, 0xF8, 0x04, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0x80, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xDF, 0xC0,
  0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0xF7, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xDF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x08, 0x03, 0xF3, 0xFE,
  0x0F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0xEF,
  0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x3F, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x3F, 0x7F,
  0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC, 0x7F, 0x01,
  0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x3F, 0xEF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3E,
  0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xF0, 0x3F, 0x07, 0xF0, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFC,
  0x7F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7C, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0xC0, 0x7F, 0x3F, 0xF7, 0xFE, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE,
  0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xF9, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xCF, 0xC0, 0x0F, 0xC3, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F,
  0xC7, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0x87, 0xF0,
  0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0xFC, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x07, 0xC7, 0xFE, 0x03,
  0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0xFE,
  0x1F, 0x81, 0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0x7C, 0x07,
  0xFE, 0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0x7C,
  0x07, 0xFE, 0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8,
  0x3E, 0x0F, 0xFE, 0x0F, 0xC7, 0xFF, 0x83, 0xFF, 0xBF, 0xE0, 0x7F, 0xCF,
  0xF8, 0x0F, 0xE3, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF8,
  0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7E,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF0,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x01, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xC0, 0x3F,
  0x9F, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF,
  0x80, 0x3F, 0xBF, 0x00, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFC, 0x0F,
  0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x3F, 0x9F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xF0, 0xFF, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFC, 0x0F,
  0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x3F, 0x9F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xFE, 0xF0, 0x3F, 0xFD, 0xE0, 0x7F, 0xFB, 0xC1, 0xEF, 0xF7, 0x83,
  0xDF, 0xF7, 0x87, 0xBF, 0xEF, 0x1E, 0x7F, 0xDE, 0x3C, 0xFF, 0x9E, 0x79,
  0xFF, 0x3C, 0xF3, 0xFE, 0x7B, 0xCF, 0xFC, 0x77, 0x9F, 0xF8, 0xFF, 0x3F,
  0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC3, 0xF1, 0xFF, 0x87, 0xC3, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFD, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xBC,
  0x0F, 0xFE, 0xF8, 0x3F, 0xFB, 0xE0, 0xFF, 0xE7, 0x83, 0xFF, 0x9F, 0x0F,
  0xFE, 0x7C, 0x3F, 0xF8, 0xF0, 0xFF, 0xE3, 0xE3, 0xFF, 0x87, 0x8F, 0xFE,
  0x1F, 0x3F, 0xF8, 0x7C, 0xFF, 0xE0, 0xF3, 0xFF, 0x83, 0xE7, 0xFE, 0x0F,
  0x9F, 0xF8, 0x1E, 0x7F, 0xE0, 0x7D, 0xFF, 0x81, 0xF7, 0xFE, 0x03, 0xDF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x9F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xF0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F,
  0xC0, 0x7F, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x81, 0xFF,
  0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFE,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF3, 0xF0,
  0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0,
  0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xF8,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xF3,
  0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x83, 0xEF, 0x81,
  0xF8, 0x3E, 0xF8, 0x1F, 0x83, 0xEF, 0x81, 0xF8, 0x3E, 0x7C, 0x1F, 0x83,
  0xE7, 0xC3, 0xB8, 0x3E, 0x7C, 0x3B, 0x83, 0xE7, 0xC3, 0xB8, 0x3E, 0x7C,
  0x3B, 0x83, 0xC7, 0xC3, 0xBC, 0x3C, 0x7C, 0x39, 0xC7, 0xC7, 0xC3, 0x9C,
  0x7C, 0x7C, 0x39, 0xC7, 0xC7, 0xC7, 0x9C, 0x7C, 0x3C, 0x71, 0xC7, 0xC3,
  0xE7, 0x1C, 0x7C, 0x3E, 0x71, 0xC7, 0xC3, 0xE7, 0x1C, 0x78, 0x3E, 0x71,
  0xE7, 0x83, 0xE7, 0x0E, 0x78, 0x3E, 0x70, 0xE7, 0x83, 0xEF, 0x0E, 0xF8,
  0x3E, 0xF0, 0xEF, 0x81, 0xEE, 0x0E, 0xF8, 0x1E, 0xE0, 0xEF, 0x81, 0xEE,
  0x0E, 0xF8, 0x1E, 0xE0, 0xEF, 0x01, 0xEE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xE7, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F,
  0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7F,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFC, 0x7F, 0xC7, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7E,
  0x7F, 0xFC, 0xFC, 0x3F, 0xF1, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF1, 0xFE, 0x0F, 0xDF, 0xFC,
  0x3F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xBF,
  0x80, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xF0, 0x3F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xF7, 0xFF, 0xCF, 0xDF, 0xFE, 0x3F, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFB, 0xF8,
  0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x7F, 0xC7, 0xC7, 0xFF, 0x3E, 0x7F, 0xFD, 0xF7, 0xFF, 0xEF, 0xBF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0xFB, 0xFF,
  0x7F, 0xFE, 0xF9, 0xFF, 0xF7, 0xC7, 0xFF, 0x3E, 0x1F, 0xF1, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x07,
  0xF3, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xE7,
  0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8,
  0xF8, 0xFF, 0xE7, 0xCF, 0xFF, 0xBE, 0xFF, 0xFD, 0xF7, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0x7C, 0xFF, 0xFB, 0xE3, 0xFF,
  0x9F, 0x0F, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF1, 0xFE,
  0x0F, 0xDF, 0xFC, 0x3F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0x80,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF3, 0xF1, 0xF8, 0xF7, 0xFB, 0xFC, 0xF7, 0xFB, 0xFE,
  0xF7, 0xFB, 0xFE, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3C, 0x1F,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F,
  0xFC, 0x7F, 0x83, 0xF7, 0xFF, 0x0F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF8, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFB, 0xF8, 0x0F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x7F, 0x83, 0xF7, 0xFF, 0x8F,
  0xDF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0,
  0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFB, 0xFC, 0x0F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFD, 0xFF, 0xF3, 0xF7, 0xFF, 0x8F, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0xF8,
  0xFF, 0xE7, 0xCF, 0xFF, 0xBE, 0xFF, 0xFD, 0xF7, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFD, 0xFF, 0x7F, 0xEF, 0xFF, 0xDF,
  0x3F, 0xFE, 0xF8, 0xFF, 0xE7, 0xC3, 0xFE, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0xFF, 0x83, 0xE7,
  0xFF, 0x8F, 0xBF, 0xFF, 0x3E, 0xFF, 0xFC, 0xFF, 0xCF, 0xFB, 0xF8, 0x0F,
  0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0x07,
  0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x3F, 0xDF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xE7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xCF,
  0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0xF8, 0x1F, 0x01, 0xFF, 0x03, 0xE0, 0x7D, 0xE0, 0x7C,
  0x0F, 0xBC, 0x0F, 0xC1, 0xF7, 0xC1, 0xF8, 0x3E, 0xF8, 0x3F, 0x07, 0x9F,
  0x0E, 0xE0, 0xF3, 0xE1, 0xDC, 0x1E, 0x7C, 0x3B, 0x87, 0xC7, 0x87, 0x70,
  0xF8, 0xF0, 0xE7, 0x1F, 0x1F, 0x1C, 0xE3, 0xC3, 0xE7, 0x9C, 0x78, 0x7C,
  0xE3, 0x8F, 0x0F, 0x9C, 0x71, 0xE0, 0xF3, 0x8E, 0x7C, 0x1E, 0x71, 0xEF,
  0x83, 0xCE, 0x1D, 0xE0, 0x7D, 0xC3, 0xBC, 0x0F, 0xF0, 0x77, 0x81, 0xFE,
  0x0E, 0xF0, 0x3F, 0xC1, 0xDE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8,
  0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xE0,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0x7F,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8,
  0x7F, 0x3F, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F, 0xFE, 0xF8, 0x0F, 0xFC, 0xF8,
  0x07, 0xF0,
};

const GFXglyph JetBrainsMono_SemiBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 36, 29, 11, -36 },
  { 37, 17, 15, 29, 6, -36 },
  { 69, 27, 36, 29, 1, -36 },
  { 191, 23, 50, 29, 3, -43 },
  { 335, 29, 36, 29, 0, -36 },
  { 466, 26, 36, 29, 2, -36 },
  { 583, 6, 15, 29, 12, -36 },
  { 595, 16, 47, 29, 8, -41 },
  { 689, 15, 47, 29, 6, -41 },
  { 778, 26, 26, 29, 2, -30 },
  { 863, 23, 23, 29, 3, -28 },
  { 930, 11, 15, 29, 8, -7 },
  { 951, 16, 5, 29, 7, -19 },
  { 961, 9, 8, 29, 10, -8 },
  { 970, 23, 46, 29, 3, -41 },
  { 1103, 23, 36, 29, 3, -36 },
  { 1207, 23, 36, 29, 4, -36 },
  { 1311, 23, 36, 29, 3, -36 },
  { 1415, 23, 36, 29, 3, -36 },
  { 1519, 22, 36, 29, 3, -36 },
  { 1618, 22, 36, 29, 4, -36 },
  { 1717, 24, 36, 29, 3, -36 },
  { 1825, 24, 36, 29, 3, -36 },
  { 1933, 23, 36, 29, 3, -36 },
  { 2037, 24, 36, 29, 3, -36 },
  { 2145, 9, 27, 29, 10, -27 },
  { 2176, 11, 35, 29, 8, -27 },
  { 2225, 22, 26, 29, 4, -29 },
  { 2297, 21, 17, 29, 4, -25 },
  { 2342, 22, 26, 29, 4, -29 },
  { 2414, 19, 36, 29, 6, -36 },
  { 2500, 26, 45, 29, 2, -36 },
  { 2647, 25, 36, 29, 2, -36 },
  { 2760, 23, 36, 29, 4, -36 },
  { 2864, 22, 36, 29, 4, -36 },
  { 2963, 22, 36, 29, 4, -36 },
  { 3062, 22, 36, 29, 4, -36 },
  { 3161, 22, 36, 29, 4, -36 },
  { 3260, 22, 36, 29, 4, -36 },
  { 3359, 21, 36, 29, 4, -36 },
  { 3454, 20, 36, 29, 5, -36 },
  { 3544, 23, 36, 29, 2, -36 },
  { 3648, 24, 36, 29, 4, -36 },
  { 3756, 21, 36, 29, 5, -36 },
  { 3851, 23, 36, 29, 3, -36 },
  { 3955, 22, 36, 29, 4, -36 },
  { 4054, 22, 36, 29, 4, -36 },
  { 4153, 23, 36, 29, 4, -36 },
  { 4257, 23, 45, 29, 3, -36 },
  { 4387, 23, 36, 29, 4, -36 },
  { 4491, 23, 36, 29, 3, -36 },
  { 4595, 25, 36, 29, 2, -36 },
  { 4708, 22, 36, 29, 4, -36 },
  { 4807, 25, 36, 29, 2, -36 },
  { 4920, 28, 36, 29, 1, -36 },
  { 5046, 26, 36, 29, 2, -36 },
  { 5163, 27, 36, 29, 1, -36 },
  { 5285, 21, 36, 29, 4, -36 },
  { 5380, 14, 46, 29, 9, -41 },
  { 5461, 23, 46, 29, 3, -41 },
  { 5594, 13, 46, 29, 7, -41 },
  { 5669, 23, 19, 29, 3, -36 },
  { 5724, 23, 5, 29, 3, 1 },
  { 5739, 12, 6, 29, 8, -38 },
  { 5748, 23, 27, 29, 3, -27 },
  { 5826, 22, 36, 29, 4, -36 },
  { 5925, 22, 27, 29, 4, -27 },
  { 6000, 21, 36, 29, 4, -36 },
  { 6095, 22, 27, 29, 4, -27 },
  { 6170, 23, 36, 29, 3, -36 },
  { 6274, 21, 36, 29, 4, -27 },
  { 6369, 22, 36, 29, 4, -36 },
  { 6468, 23, 38, 29, 4, -38 },
  { 6578, 19, 47, 29, 4, -38 },
  { 6690, 24, 36, 29, 4, -36 },
  { 6798, 26, 36, 29, 1, -36 },
  { 6915, 24, 27, 29, 3, -27 },
  { 6996, 22, 27, 29, 4, -27 },
  { 7071, 22, 27, 29, 4, -27 },
  { 7146, 22, 36, 29, 4, -27 },
  { 7245, 21, 36, 29, 4, -27 },
  { 7340, 22, 27, 29, 5, -27 },
  { 7415, 22, 27, 29, 4, -27 },
  { 7490, 24, 35, 29, 2, -35 },
  { 7595, 22, 27, 29, 4, -27 },
  { 7670, 25, 27, 29, 2, -27 },
  { 7755, 27, 27, 29, 1, -27 },
  { 7847, 25, 27, 29, 2, -27 },
  { 7932, 25, 36, 29, 2, -27 },
  { 8045, 21, 27, 29, 4, -27 },
  { 8116, 21, 46, 29, 4, -41 },
  { 8237, 6, 46, 29, 12, -41 },
  { 8272, 21, 46, 29, 4, -41 },
  { 8393, 24, 11, 29, 3, -23 },
};

const GFXfont JetBrainsMono_SemiBold49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_SEMIBOLD49PT7B_H_
