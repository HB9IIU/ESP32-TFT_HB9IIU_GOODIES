#ifndef _ROBOTOMONO_THIN50PT7B_H_
#define _ROBOTOMONO_THIN50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin50pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00,
  0x00, 0x0B, 0xF0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83, 0x82, 0x82,
  0x82, 0x82, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80, 0x20, 0x00, 0x18, 0x02,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x10, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x20, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x08, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x40,
  0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x20, 0x00, 0x08,
  0x02, 0x00, 0x01, 0x80, 0x20, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x60,
  0x00, 0x10, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x20, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20, 0x08,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x00,
  0x1E, 0x1E, 0x01, 0x80, 0x38, 0x18, 0x00, 0x61, 0x80, 0x01, 0x08, 0x00,
  0x0C, 0xC0, 0x00, 0x24, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x36, 0x00, 0x01, 0x18, 0x00, 0x18,
  0x60, 0x01, 0x81, 0xC0, 0x38, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x06, 0x00, 0x00, 0x40,
  0x20, 0x08, 0x0C, 0x03, 0x00, 0xC0, 0x80, 0x30, 0x08, 0x08, 0x03, 0x01,
  0x80, 0x80, 0x30, 0x10, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x30, 0x60, 0x0C,
  0x02, 0x04, 0x00, 0x40, 0x20, 0xC0, 0x06, 0x06, 0x08, 0x00, 0x30, 0xC1,
  0x80, 0x01, 0xF8, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x0F, 0x00, 0x01,
  0x83, 0x9C, 0x00, 0x10, 0x20, 0x40, 0x03, 0x04, 0x02, 0x00, 0x20, 0x40,
  0x20, 0x06, 0x0C, 0x03, 0x00, 0x40, 0xC0, 0x30, 0x0C, 0x08, 0x01, 0x00,
  0x80, 0x80, 0x10, 0x18, 0x0C, 0x03, 0x01, 0x00, 0xC0, 0x30, 0x20, 0x0C,
  0x03, 0x02, 0x00, 0x40, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xCF,
  0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x60, 0x00, 0x80, 0x10, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x02, 0x00, 0x18, 0x01, 0x00, 0x0C,
  0x01, 0x80, 0x02, 0x00, 0x80, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x31, 0x80, 0x00, 0x09, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x11, 0x80, 0x30, 0x08, 0x80, 0x08, 0x04, 0x40, 0x02,
  0x06, 0x60, 0x01, 0x83, 0x20, 0x00, 0x61, 0x10, 0x00, 0x19, 0x88, 0x00,
  0x06, 0xC6, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0x80, 0x00, 0x70, 0x60,
  0x00, 0x6C, 0x18, 0x00, 0x63, 0x07, 0x00, 0xC0, 0x80, 0xFF, 0x80, 0x30,
  0xFF, 0xFF, 0xA8, 0x00, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0,
  0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x06, 0x07, 0x7C, 0x30, 0xF0, 0x79,
  0xBC, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x80, 0x00, 0x66, 0x00,
  0x06, 0x18, 0x00, 0x60, 0x60, 0x06, 0x01, 0x00, 0x20, 0x0C, 0x03, 0x00,
  0x38, 0x30, 0x00, 0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x33, 0x33, 0x32, 0x26, 0x4C,
  0xFF, 0xFF, 0xC0, 0x5D, 0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0x0C,
  0x02, 0x00, 0x18, 0x10, 0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18,
  0x00, 0x06, 0x40, 0x00, 0x09, 0x00, 0x00, 0x64, 0x00, 0x03, 0xB0, 0x00,
  0x1B, 0xC0, 0x00, 0xCF, 0x00, 0x06, 0x1C, 0x00, 0x30, 0x70, 0x01, 0x81,
  0xC0, 0x0C, 0x07, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x70, 0x18, 0x01, 0xC0,
  0xC0, 0x07, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x71, 0x80, 0x01, 0xCC, 0x00,
  0x0D, 0x60, 0x00, 0x37, 0x00, 0x00, 0x98, 0x00, 0x02, 0x60, 0x00, 0x08,
  0x80, 0x00, 0x63, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30,
  0x03, 0x00, 0x70, 0x18, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x0C, 0x0E, 0x87,
  0x13, 0x83, 0xC0, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0xF8, 0x00,
  0x1C, 0x3C, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x61, 0x80,
  0x00, 0x84, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0x87, 0x00, 0x18, 0x01, 0x80, 0x40, 0x01, 0x81,
  0x00, 0x01, 0x06, 0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x24, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x98, 0x00, 0x03, 0x18, 0x00, 0x04, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x01, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x47, 0xFC, 0x05, 0xC0, 0x70, 0x70, 0x01, 0x84, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00, 0x06, 0x30, 0x00, 0xC1,
  0x80, 0x18, 0x0C, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0xFF, 0x03, 0x1C, 0x0E, 0x13, 0x00,
  0x18, 0xB0, 0x00, 0x65, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0,
  0x00, 0x0D, 0x80, 0x00, 0x46, 0x00, 0x06, 0x18, 0x00, 0x60, 0x60, 0x06,
  0x01, 0xC0, 0x60, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x87, 0x00, 0x38, 0x03, 0x80, 0xC0,
  0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x11, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x86, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x07, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x70, 0x07, 0x01,
  0x80, 0x03, 0x06, 0x00, 0x03, 0x18, 0x00, 0x03, 0x20, 0x00, 0x02, 0x40,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x10, 0x00, 0x06, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x38, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x1E, 0x1C, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20,
  0x80, 0x00, 0xC6, 0x00, 0x01, 0x10, 0x00, 0x06, 0x40, 0x00, 0x0B, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36,
  0x00, 0x01, 0xC8, 0x00, 0x0F, 0x30, 0x00, 0x6C, 0x60, 0x03, 0x20, 0xE0,
  0x38, 0x80, 0xFF, 0x82, 0x00, 0x20, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x01, 0xFC,
  0x00, 0x5F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xBE, 0x11, 0xCC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x10,
  0x84, 0x21, 0x08, 0xC4, 0x40, 0x00, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0x87, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x60, 0x00, 0x90, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x18,
  0x0F, 0xE0, 0x63, 0x01, 0x83, 0x02, 0x30, 0x30, 0x10, 0x22, 0x06, 0x01,
  0x02, 0x60, 0x40, 0x30, 0x24, 0x0C, 0x03, 0x03, 0x40, 0x80, 0x20, 0x34,
  0x08, 0x02, 0x03, 0x40, 0x80, 0x20, 0x3C, 0x18, 0x02, 0x03, 0xC1, 0x80,
  0x20, 0x3C, 0x18, 0x02, 0x02, 0xC1, 0x80, 0x20, 0x2C, 0x18, 0x06, 0x02,
  0xC1, 0x80, 0x60, 0x2C, 0x18, 0x0E, 0x06, 0x40, 0x80, 0xE0, 0x44, 0x08,
  0x1A, 0x04, 0x40, 0xC1, 0x20, 0xC6, 0x06, 0x63, 0x18, 0x60, 0x3C, 0x1F,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0x30, 0x00, 0x00, 0x88, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x43, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x40, 0x00,
  0x10, 0x30, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x03, 0x00,
  0x02, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01, 0x00, 0x30, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x03, 0x00, 0x20, 0x00, 0x80, 0x30, 0x00,
  0x40, 0x10, 0x00, 0x30, 0x0F, 0xFF, 0xF8, 0x0C, 0x00, 0x04, 0x04, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x08, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x03, 0x20, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x30, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0C,
  0x00, 0x38, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0x8C, 0x00,
  0x03, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x4C, 0x00, 0x01,
  0x30, 0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x30, 0xC0, 0x03, 0x03, 0xFF, 0xF0, 0x0C, 0x00, 0xF8, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x02,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00,
  0x23, 0x00, 0x03, 0x0C, 0x00, 0x78, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0x87, 0x80, 0x1C, 0x01, 0x80, 0x60, 0x01, 0x80, 0x80, 0x01, 0x83,
  0x00, 0x01, 0x84, 0x00, 0x01, 0x10, 0x00, 0x03, 0x20, 0x00, 0x06, 0xC0,
  0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x05,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x66, 0x00, 0x00, 0x84,
  0x00, 0x03, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0E,
  0x03, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x08, 0x00, 0x60, 0x20, 0x00, 0x60, 0x80, 0x00, 0xC2, 0x00, 0x01,
  0x88, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x12, 0x00, 0x00, 0x68,
  0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00,
  0x06, 0x80, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x20, 0x00, 0x30,
  0x80, 0x01, 0x82, 0x00, 0x0C, 0x08, 0x03, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC8, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x87, 0x80, 0x1C, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x80, 0x01, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x10, 0x00, 0x03, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x26, 0x00, 0x00, 0x44, 0x00, 0x00, 0x8C, 0x00, 0x01,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0xE0, 0x07, 0xFF, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x4C, 0x00, 0x06, 0x30, 0x00, 0x60,
  0xC0, 0x06, 0x03, 0x80, 0xE0, 0x07, 0xFC, 0x00, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x32, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x10, 0x00,
  0x30, 0x20, 0x00, 0xC0, 0x40, 0x03, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x04, 0x01, 0x00, 0x08, 0x06, 0x00, 0x10, 0x18, 0x00,
  0x20, 0x60, 0x00, 0x41, 0x80, 0x00, 0x86, 0x00, 0x01, 0x1E, 0x00, 0x02,
  0x66, 0x00, 0x05, 0x84, 0x00, 0x0E, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x20,
  0x0C, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x08, 0x02, 0x00,
  0x18, 0x04, 0x00, 0x18, 0x08, 0x00, 0x18, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x10, 0x40, 0x00, 0x30, 0x80, 0x00, 0x31, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x5A, 0x00, 0x06, 0xD0,
  0x00, 0x26, 0xC0, 0x01, 0x32, 0x00, 0x19, 0x98, 0x00, 0x8C, 0x40, 0x0C,
  0x62, 0x00, 0x43, 0x18, 0x02, 0x18, 0x40, 0x30, 0xC2, 0x01, 0x06, 0x18,
  0x18, 0x30, 0x40, 0x81, 0x83, 0x04, 0x0C, 0x08, 0x40, 0x60, 0x42, 0x03,
  0x03, 0x30, 0x18, 0x09, 0x00, 0xC0, 0x78, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xD0, 0x00, 0x0F, 0x40,
  0x00, 0x3C, 0x80, 0x00, 0xF3, 0x00, 0x03, 0xC4, 0x00, 0x0F, 0x18, 0x00,
  0x3C, 0x20, 0x00, 0xF0, 0x40, 0x03, 0xC1, 0x00, 0x0F, 0x02, 0x00, 0x3C,
  0x0C, 0x00, 0xF0, 0x10, 0x03, 0xC0, 0x60, 0x0F, 0x00, 0x80, 0x3C, 0x01,
  0x00, 0xF0, 0x04, 0x03, 0xC0, 0x08, 0x0F, 0x00, 0x30, 0x3C, 0x00, 0x40,
  0xF0, 0x01, 0x83, 0xC0, 0x02, 0x0F, 0x00, 0x0C, 0x3C, 0x00, 0x10, 0xF0,
  0x00, 0x23, 0xC0, 0x00, 0xCF, 0x00, 0x01, 0x3C, 0x00, 0x06, 0xF0, 0x00,
  0x0B, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x7E, 0x00, 0x01, 0xC3, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30,
  0x08, 0x00, 0x10, 0x10, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x20, 0x00, 0xE1, 0x00, 0x01, 0xC8, 0x00,
  0x02, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x34, 0x00, 0x03, 0x20,
  0x00, 0x71, 0x00, 0x1F, 0x0F, 0xFF, 0xC0, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xC3, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60,
  0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x30, 0x03, 0x80, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x20, 0x01,
  0xC1, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x22, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x05, 0x00, 0x00,
  0x28, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80,
  0x00, 0xC4, 0x00, 0x0C, 0x20, 0x00, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x40, 0x04, 0x02, 0x00, 0x30, 0x10, 0x00, 0x80, 0x80, 0x06, 0x04, 0x00,
  0x10, 0x20, 0x00, 0xC1, 0x00, 0x03, 0x08, 0x00, 0x08, 0x40, 0x00, 0x62,
  0x00, 0x01, 0x10, 0x00, 0x0C, 0x80, 0x00, 0x24, 0x00, 0x01, 0xA0, 0x00,
  0x07, 0x00, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x0F, 0x87, 0x80, 0x30, 0x03,
  0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x03,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x60, 0x38, 0x03, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x80, 0x00, 0x62, 0x00,
  0x01, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0x70, 0x38,
  0x00, 0x7F, 0xC0, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x10, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x20, 0x04, 0x00, 0x20, 0x04, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x02, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x01, 0x00, 0x80,
  0x01, 0x01, 0x80, 0x01, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0x83, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x42, 0x00, 0x00, 0x46, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x68, 0x00, 0x80, 0x09, 0x00, 0x18,
  0x01, 0x20, 0x07, 0x00, 0x24, 0x00, 0xA0, 0x04, 0x80, 0x14, 0x00, 0x98,
  0x02, 0x80, 0x13, 0x00, 0x58, 0x06, 0x20, 0x1B, 0x00, 0x84, 0x02, 0x20,
  0x10, 0x80, 0x44, 0x02, 0x10, 0x08, 0x80, 0x43, 0x01, 0x18, 0x08, 0x60,
  0x63, 0x03, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x18, 0x20, 0x61, 0x83, 0x04, 0x0C, 0x30, 0x21, 0x80, 0x84,
  0x04, 0x20, 0x10, 0x80, 0x84, 0x02, 0x10, 0x18, 0x80, 0x46, 0x03, 0x10,
  0x08, 0xC0, 0x22, 0x01, 0x90, 0x04, 0xC0, 0x12, 0x00, 0x90, 0x02, 0x40,
  0x1A, 0x00, 0x58, 0x03, 0x40, 0x0B, 0x00, 0x68, 0x01, 0x40, 0x05, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x40, 0x00, 0x01, 0x30, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x40,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x80, 0x30,
  0x00, 0x40, 0x30, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x08,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x80, 0x00, 0x02, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x04, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x80, 0x20, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x04, 0x00, 0x40, 0x01, 0x00,
  0x60, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x20, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x10, 0x00, 0x01, 0x18, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x20, 0x60, 0x00, 0x30, 0x10, 0x00, 0x10, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x00,
  0x10, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x80, 0x00, 0x06, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F,
  0xFE, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFC, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0x20, 0x00, 0xCC, 0x00, 0x21, 0x00, 0x18, 0x60, 0x04, 0x08, 0x01, 0x02,
  0x00, 0xC0, 0xC0, 0x20, 0x10, 0x18, 0x06, 0x04, 0x00, 0x81, 0x00, 0x20,
  0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x64, 0x00, 0x0B, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x00, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0xC0, 0x0C, 0x06, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00, 0x46,
  0x00, 0x01, 0x98, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0xE0, 0x00,
  0x8E, 0x00, 0x02, 0x20, 0x00, 0x09, 0x80, 0x00, 0x24, 0x00, 0x00, 0x90,
  0x00, 0x02, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x64, 0x00, 0x02, 0x98, 0x00,
  0x1A, 0x30, 0x01, 0xC8, 0x70, 0x1C, 0x20, 0xFF, 0xC0, 0xC0, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x81, 0xF0, 0x0C, 0x7D, 0xE0, 0x66, 0x01, 0xC3, 0x60,
  0x03, 0x1E, 0x00, 0x08, 0xE0, 0x00, 0x66, 0x00, 0x01, 0x30, 0x00, 0x0D,
  0x80, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x06, 0xC0, 0x00,
  0x27, 0x00, 0x03, 0x3C, 0x00, 0x31, 0xB0, 0x03, 0x0C, 0xE0, 0x30, 0x61,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x7C, 0x01, 0x80, 0x30, 0x18, 0x00,
  0xC1, 0x00, 0x03, 0x18, 0x00, 0x08, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x90, 0x00, 0x0C,
  0xC0, 0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x38, 0x0E, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xF0, 0x30, 0x3D, 0xF1, 0x86,
  0x00, 0xCC, 0x60, 0x03, 0x62, 0x00, 0x0F, 0x30, 0x00, 0x39, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x6C, 0x00,
  0x03, 0x20, 0x00, 0x19, 0x80, 0x01, 0xC6, 0x00, 0x1E, 0x18, 0x01, 0xB0,
  0x60, 0x39, 0x81, 0xFF, 0x0C, 0x00, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x62, 0x00, 0x00,
  0x98, 0x00, 0x02, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x06, 0x0E,
  0x00, 0x30, 0x0C, 0x03, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x7C, 0x10, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0xF8, 0xC3, 0x80,
  0x66, 0x30, 0x01, 0xB1, 0x00, 0x07, 0x98, 0x00, 0x1C, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0x90, 0x00, 0x0C, 0xC0, 0x00, 0xE3, 0x00, 0x0F, 0x0C, 0x00, 0xD8, 0x30,
  0x1C, 0xC0, 0xFF, 0x86, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x20, 0x00, 0x21, 0x80, 0x03, 0x06, 0x00,
  0x30, 0x1C, 0x07, 0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x07, 0xC0, 0xC3, 0xC7, 0x8C, 0x60, 0x0C, 0xCC, 0x00, 0x6D, 0x00,
  0x02, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x0F,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x70, 0xFF, 0xC0, 0x3E, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x2C, 0x00, 0x06, 0x60, 0x00,
  0x43, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00,
  0x19, 0xC0, 0x00, 0xD9, 0x00, 0x07, 0x8C, 0x00, 0x30, 0x30, 0x01, 0x80,
  0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0xC0, 0x03, 0x06, 0x00, 0x08, 0x30, 0x00, 0x21, 0x80, 0x01, 0x8C, 0x00,
  0x06, 0x60, 0x00, 0x1C, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x7C, 0x27, 0x9C, 0x79, 0xCB, 0x01, 0xB0,
  0x1A, 0x80, 0x28, 0x02, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x7C, 0x0C, 0x3C, 0x70,
  0xC6, 0x00, 0xCC, 0xC0, 0x04, 0xD0, 0x00, 0x2F, 0x00, 0x02, 0xE0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x10, 0x00, 0x7E, 0x00, 0x01, 0xE7, 0x80, 0x07, 0x00, 0xE0,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C,
  0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x08,
  0x08, 0x00, 0x10, 0x0E, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xF8, 0x06, 0x3E, 0xF0, 0x33, 0x00, 0xE1, 0xB0, 0x01, 0x8F, 0x00,
  0x04, 0x70, 0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x16,
  0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xB0,
  0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x13, 0x80, 0x01,
  0x9E, 0x00, 0x18, 0xD8, 0x01, 0x86, 0x70, 0x18, 0x30, 0xFF, 0x81, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0xC3, 0x80, 0x66, 0x30, 0x01,
  0xB1, 0x00, 0x07, 0x98, 0x00, 0x1C, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x40,
  0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00,
  0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x36, 0x00, 0x01, 0x90, 0x00, 0x0C,
  0xC0, 0x00, 0xE3, 0x00, 0x0F, 0x0C, 0x00, 0xD8, 0x30, 0x1C, 0xC0, 0xFF,
  0x86, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x83, 0xF1, 0x8E, 0x00, 0x98, 0x00,
  0xB0, 0x00, 0xA0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x7E, 0xFC, 0x06, 0x00, 0x30, 0x60, 0x00, 0xC6, 0x00, 0x03, 0x20,
  0x00, 0x09, 0x00, 0x00, 0x68, 0x00, 0x03, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x4C, 0x00,
  0x06, 0x30, 0x00, 0x60, 0xE0, 0x0E, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x03,
  0x40, 0x00, 0x36, 0x00, 0x05, 0x20, 0x00, 0xD3, 0x00, 0x19, 0x1C, 0x07,
  0x10, 0x7F, 0xC1, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x10, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0,
  0x01, 0x00, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x46, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x78, 0x01, 0x80, 0x09, 0x00, 0x38, 0x03, 0x20, 0x05, 0x00, 0x64, 0x01,
  0xA0, 0x08, 0xC0, 0x24, 0x01, 0x18, 0x04, 0xC0, 0x21, 0x00, 0x98, 0x0C,
  0x20, 0x31, 0x01, 0x06, 0x04, 0x20, 0x20, 0xC0, 0x86, 0x04, 0x08, 0x10,
  0xC1, 0x81, 0x06, 0x08, 0x30, 0x20, 0x81, 0x04, 0x06, 0x10, 0x30, 0x80,
  0x42, 0x02, 0x10, 0x08, 0xC0, 0x46, 0x01, 0x10, 0x08, 0x80, 0x32, 0x01,
  0x90, 0x06, 0x40, 0x12, 0x00, 0x58, 0x02, 0xC0, 0x0A, 0x00, 0x50, 0x01,
  0x40, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x40, 0x00, 0xC0, 0xC0, 0x01,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80,
  0x01, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x63, 0x00, 0x01,
  0x82, 0x00, 0x06, 0x06, 0x00, 0x08, 0x06, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x60, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x02,
  0x00, 0x60, 0x01, 0x80, 0x08, 0x00, 0x40, 0x03, 0x00, 0x30, 0x00, 0x40,
  0x0C, 0x00, 0x18, 0x02, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x16, 0x03, 0x00, 0x05, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0xA0, 0x00,
  0xC0, 0x68, 0x00, 0x1C, 0x32, 0x00, 0x01, 0xF8,
};

const GFXglyph RobotoMono_Thin50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 3, 36, 30, 13, -36 },
  { 15, 8, 11, 30, 11, -38 },
  { 26, 28, 36, 30, 1, -36 },
  { 152, 21, 46, 30, 5, -41 },
  { 273, 28, 37, 30, 1, -36 },
  { 403, 25, 36, 30, 4, -36 },
  { 516, 2, 11, 30, 13, -38 },
  { 519, 10, 51, 30, 10, -40 },
  { 583, 10, 51, 30, 9, -40 },
  { 647, 21, 20, 30, 5, -36 },
  { 700, 24, 25, 30, 3, -29 },
  { 775, 4, 10, 30, 10, -4 },
  { 780, 18, 1, 30, 6, -17 },
  { 783, 3, 3, 30, 14, -3 },
  { 785, 17, 39, 30, 7, -36 },
  { 868, 22, 36, 30, 4, -36 },
  { 967, 11, 36, 30, 6, -36 },
  { 1017, 22, 36, 30, 3, -36 },
  { 1116, 23, 36, 30, 2, -36 },
  { 1220, 25, 36, 30, 2, -36 },
  { 1333, 20, 36, 30, 6, -36 },
  { 1423, 21, 36, 30, 4, -36 },
  { 1518, 23, 36, 30, 3, -36 },
  { 1622, 23, 36, 30, 4, -36 },
  { 1726, 22, 36, 30, 4, -36 },
  { 1825, 3, 24, 30, 16, -24 },
  { 1834, 5, 30, 30, 14, -24 },
  { 1853, 21, 20, 30, 4, -26 },
  { 1906, 22, 11, 30, 4, -22 },
  { 1937, 21, 20, 30, 5, -26 },
  { 1990, 18, 36, 30, 6, -36 },
  { 2071, 28, 36, 30, 1, -36 },
  { 2197, 25, 36, 30, 3, -36 },
  { 2310, 22, 36, 30, 5, -36 },
  { 2409, 23, 37, 30, 3, -36 },
  { 2516, 22, 36, 30, 5, -36 },
  { 2615, 21, 36, 30, 5, -36 },
  { 2710, 20, 36, 30, 6, -36 },
  { 2800, 23, 36, 30, 3, -36 },
  { 2904, 22, 36, 30, 4, -36 },
  { 3003, 20, 36, 30, 5, -36 },
  { 3093, 21, 36, 30, 3, -36 },
  { 3188, 23, 36, 30, 6, -36 },
  { 3292, 20, 36, 30, 6, -36 },
  { 3382, 21, 36, 30, 5, -36 },
  { 3477, 22, 36, 30, 4, -36 },
  { 3576, 24, 36, 30, 3, -36 },
  { 3684, 21, 36, 30, 6, -36 },
  { 3779, 24, 42, 30, 3, -36 },
  { 3905, 21, 36, 30, 6, -36 },
  { 4000, 23, 36, 30, 4, -36 },
  { 4104, 24, 36, 30, 3, -36 },
  { 4212, 22, 36, 30, 4, -36 },
  { 4311, 24, 36, 30, 3, -36 },
  { 4419, 27, 36, 30, 2, -36 },
  { 4541, 25, 36, 30, 3, -36 },
  { 4654, 25, 36, 30, 2, -36 },
  { 4767, 22, 36, 30, 3, -36 },
  { 4866, 7, 49, 30, 12, -41 },
  { 4909, 16, 39, 30, 7, -36 },
  { 4987, 7, 49, 30, 11, -41 },
  { 5030, 18, 20, 30, 6, -36 },
  { 5075, 20, 1, 30, 5, 0 },
  { 5078, 6, 6, 30, 12, -37 },
  { 5083, 22, 27, 30, 4, -27 },
  { 5158, 21, 38, 30, 5, -38 },
  { 5258, 21, 27, 30, 4, -27 },
  { 5329, 21, 38, 30, 4, -38 },
  { 5429, 22, 27, 30, 4, -27 },
  { 5504, 22, 38, 30, 5, -38 },
  { 5609, 21, 38, 30, 4, -27 },
  { 5709, 20, 38, 30, 5, -38 },
  { 5804, 20, 36, 30, 6, -36 },
  { 5894, 16, 47, 30, 4, -36 },
  { 5988, 21, 38, 30, 6, -38 },
  { 6088, 20, 38, 30, 6, -38 },
  { 6183, 26, 27, 30, 2, -27 },
  { 6271, 20, 27, 30, 5, -27 },
  { 6339, 24, 27, 30, 3, -27 },
  { 6420, 21, 37, 30, 5, -27 },
  { 6518, 21, 37, 30, 4, -27 },
  { 6616, 16, 27, 30, 10, -27 },
  { 6670, 21, 27, 30, 5, -27 },
  { 6741, 20, 34, 30, 5, -34 },
  { 6826, 20, 26, 30, 5, -26 },
  { 6891, 24, 26, 30, 3, -26 },
  { 6969, 27, 26, 30, 2, -26 },
  { 7057, 23, 26, 30, 4, -26 },
  { 7132, 26, 37, 30, 2, -26 },
  { 7253, 24, 26, 30, 3, -26 },
  { 7331, 16, 50, 30, 8, -39 },
  { 7431, 2, 43, 30, 14, -36 },
  { 7442, 16, 50, 30, 8, -39 },
  { 7542, 26, 8, 30, 2, -19 },
};

const GFXfont RobotoMono_Thin50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin50pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_THIN50PT7B_H_
