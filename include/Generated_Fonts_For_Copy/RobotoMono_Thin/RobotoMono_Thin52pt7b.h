#ifndef _ROBOTOMONO_THIN52PT7B_H_
#define _ROBOTOMONO_THIN52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin52pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00,
  0x00, 0x01, 0x7C, 0x41, 0x41, 0x41, 0x41, 0x41, 0x41, 0x41, 0x41, 0xC1,
  0xC1, 0xC1, 0x00, 0x18, 0x02, 0x00, 0x01, 0x00, 0x20, 0x00, 0x10, 0x06,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x20, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x60, 0x08, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x08, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x10,
  0x02, 0x00, 0x01, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x08,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x40, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x98, 0x00, 0x02, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x50, 0x00, 0x03, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x63, 0x00, 0x01, 0x06,
  0x00, 0x1C, 0x0E, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x20, 0x18, 0x03, 0x03, 0x00, 0x40, 0x10, 0x18,
  0x02, 0x01, 0x80, 0xC0, 0x10, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x30, 0x04,
  0x04, 0x01, 0x80, 0x20, 0x60, 0x0C, 0x01, 0x02, 0x00, 0x20, 0x18, 0x30,
  0x01, 0x80, 0x81, 0x00, 0x06, 0x0C, 0x18, 0x00, 0x1F, 0xC1, 0x80, 0x00,
  0x38, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x03, 0x80, 0x00, 0x30, 0x3F, 0x00, 0x01, 0x02,
  0x0C, 0x00, 0x18, 0x30, 0x30, 0x00, 0x83, 0x00, 0x80, 0x0C, 0x18, 0x06,
  0x00, 0xC0, 0x80, 0x30, 0x04, 0x04, 0x00, 0x80, 0x60, 0x20, 0x04, 0x02,
  0x01, 0x00, 0x20, 0x30, 0x08, 0x01, 0x01, 0x00, 0x40, 0x18, 0x18, 0x03,
  0x00, 0xC0, 0x80, 0x08, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x30, 0x70, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x01, 0x80,
  0x02, 0x00, 0x20, 0x00, 0x80, 0x08, 0x00, 0x20, 0x02, 0x00, 0x08, 0x00,
  0x80, 0x02, 0x00, 0x60, 0x00, 0x80, 0x10, 0x00, 0x20, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0xC0, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0x20, 0x00, 0x06, 0x04, 0x00, 0x01, 0x01, 0x80, 0x10, 0x80,
  0x30, 0x04, 0x60, 0x06, 0x01, 0x10, 0x00, 0xC0, 0x44, 0x00, 0x10, 0x33,
  0x00, 0x02, 0x0C, 0xC0, 0x00, 0xC2, 0x30, 0x00, 0x19, 0x8C, 0x00, 0x03,
  0x63, 0x00, 0x00, 0x70, 0x40, 0x00, 0x08, 0x18, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x60, 0x60, 0x03, 0x0C, 0x0E, 0x03, 0x81, 0x81, 0xFF, 0x80, 0x30,
  0x02, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x78, 0x04, 0x07, 0x3C, 0x10, 0xF0, 0x1E, 0x4F, 0x00, 0x0F,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x60, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x02,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x24, 0x92, 0x5A, 0xD0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x5F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x0C, 0x07, 0x00,
  0x60, 0x03, 0x00, 0x80, 0x03, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x32, 0x00,
  0x00, 0xF4, 0x00, 0x03, 0x78, 0x00, 0x0C, 0xF0, 0x00, 0x30, 0xE0, 0x00,
  0xC1, 0xC0, 0x03, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x30, 0x0E, 0x00, 0xC0,
  0x1C, 0x03, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x30, 0x00, 0xE0, 0xC0, 0x01,
  0xC3, 0x00, 0x03, 0x8C, 0x00, 0x0D, 0x30, 0x00, 0x1A, 0xC0, 0x00, 0x37,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x88, 0x00, 0x03, 0x10, 0x00, 0x04, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x70, 0x03, 0x00, 0x30,
  0x1C, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x03,
  0x90, 0xE1, 0x38, 0x1E, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0xFE, 0x00, 0x1C, 0x07, 0x00, 0x60, 0x03,
  0x01, 0x80, 0x03, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x01, 0x81,
  0x80, 0x01, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x10, 0x00, 0x02, 0x20,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x50, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x20, 0x00, 0x06, 0x60,
  0x00, 0x08, 0x60, 0x00, 0x20, 0x60, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x02,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF8, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x8F, 0xF8, 0x0D, 0xC0, 0xE0,
  0x70, 0x01, 0xC3, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x0D, 0x00, 0x00, 0x4C, 0x00, 0x02, 0x20, 0x00, 0x31, 0x80, 0x03, 0x06,
  0x00, 0x30, 0x1C, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x07, 0xFC,
  0x04, 0x78, 0x3C, 0x33, 0x00, 0x18, 0xD8, 0x00, 0x32, 0xC0, 0x00, 0x6E,
  0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x36, 0x00, 0x00, 0x88,
  0x00, 0x06, 0x30, 0x00, 0x10, 0x60, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0xC0,
  0x70, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x18, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00,
  0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x07, 0x00, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x30, 0x01,
  0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00, 0x03, 0x18, 0x00, 0x02,
  0x30, 0x00, 0x06, 0x40, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x39, 0x00,
  0x00, 0xF3, 0x00, 0x01, 0x63, 0x00, 0x0C, 0xC3, 0x00, 0x31, 0x03, 0xC3,
  0xC2, 0x01, 0xFE, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x60, 0x19, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x42, 0x10, 0x8C, 0x62, 0x33, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xC0, 0xE0, 0x60, 0x06, 0x18, 0x00, 0x66, 0x00,
  0x04, 0x80, 0x00, 0xD0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xE0, 0x70,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x83, 0x00, 0x30, 0x06, 0x18, 0x0F,
  0xE0, 0x31, 0x80, 0xC1, 0xC0, 0x8C, 0x0C, 0x06, 0x04, 0x40, 0x40, 0x30,
  0x26, 0x06, 0x01, 0x01, 0xB0, 0x20, 0x08, 0x0D, 0x01, 0x00, 0x40, 0x68,
  0x18, 0x02, 0x03, 0x40, 0x80, 0x10, 0x1A, 0x04, 0x00, 0x80, 0xF0, 0x20,
  0x04, 0x07, 0x81, 0x00, 0x60, 0x3C, 0x08, 0x03, 0x01, 0x60, 0x40, 0x18,
  0x0B, 0x02, 0x00, 0x80, 0x58, 0x10, 0x0C, 0x02, 0x40, 0x80, 0x60, 0x32,
  0x04, 0x07, 0x81, 0x10, 0x30, 0x2C, 0x18, 0xC0, 0x82, 0x20, 0x86, 0x07,
  0x71, 0xFC, 0x10, 0x0E, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x00, 0x20, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x40, 0x00, 0x80, 0x10,
  0x00, 0x20, 0x0C, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x40,
  0x60, 0x00, 0x18, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x18, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xF0, 0x02,
  0x01, 0xF8, 0x08, 0x00, 0x38, 0x20, 0x00, 0x30, 0x80, 0x00, 0x62, 0x00,
  0x00, 0x88, 0x00, 0x03, 0x20, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x00, 0x88,
  0x00, 0x06, 0x20, 0x00, 0x30, 0x80, 0x03, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x20, 0x00, 0x70, 0x80, 0x00, 0x62, 0x00, 0x00, 0xC8, 0x00, 0x01,
  0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00,
  0x06, 0x80, 0x00, 0x32, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x20, 0x03, 0xE0,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0C, 0x07, 0x00,
  0x70, 0x03, 0x01, 0x80, 0x03, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x10,
  0x00, 0x02, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x28, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x90, 0x00, 0x02, 0x30,
  0x00, 0x0C, 0x20, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x70,
  0x1C, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0x00,
  0x7C, 0x02, 0x00, 0x0E, 0x04, 0x00, 0x06, 0x08, 0x00, 0x06, 0x10, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x68, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00,
  0x04, 0x40, 0x00, 0x18, 0x80, 0x00, 0x61, 0x00, 0x01, 0x82, 0x00, 0x0E,
  0x04, 0x00, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0x80, 0xE0, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x08,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x30, 0x00, 0x02, 0x20, 0x00, 0x03, 0x20,
  0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x30, 0x00, 0x01, 0x10, 0x00, 0x01, 0x18, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x04, 0x00, 0x03, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x00,
  0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0xFF,
  0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x34,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC1, 0x80,
  0x06, 0x03, 0x80, 0x70, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x0E, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x60, 0x80, 0x00, 0xC0, 0x80, 0x01, 0x80, 0x80, 0x03, 0x00, 0x80, 0x06,
  0x00, 0x80, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x80, 0x30, 0x00, 0x80, 0x60,
  0x00, 0x80, 0xC0, 0x00, 0x80, 0x80, 0x00, 0x81, 0x80, 0x00, 0x83, 0x00,
  0x00, 0x87, 0x00, 0x00, 0x8D, 0x80, 0x00, 0x98, 0xC0, 0x00, 0xB0, 0x60,
  0x00, 0xE0, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x80, 0x06, 0x00, 0x80, 0x02, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01,
  0x80, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x10, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xE8,
  0x00, 0x05, 0xA0, 0x00, 0x36, 0xC0, 0x00, 0x99, 0x00, 0x06, 0x66, 0x00,
  0x11, 0x88, 0x00, 0x46, 0x20, 0x03, 0x18, 0xC0, 0x08, 0x61, 0x00, 0x61,
  0x84, 0x01, 0x06, 0x18, 0x04, 0x18, 0x20, 0x30, 0x60, 0xC0, 0x81, 0x81,
  0x06, 0x06, 0x04, 0x10, 0x18, 0x18, 0x40, 0x60, 0x23, 0x01, 0x80, 0xC8,
  0x06, 0x01, 0x60, 0x18, 0x05, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x20, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xA0, 0x00, 0x0E, 0x40,
  0x00, 0x39, 0x80, 0x00, 0xE2, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x10, 0x00,
  0x38, 0x60, 0x00, 0xE0, 0x80, 0x03, 0x81, 0x00, 0x0E, 0x04, 0x00, 0x38,
  0x08, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x40, 0x0E, 0x01, 0x80, 0x38, 0x02,
  0x00, 0xE0, 0x0C, 0x03, 0x80, 0x10, 0x0E, 0x00, 0x20, 0x38, 0x00, 0xC0,
  0xE0, 0x01, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x08, 0x38, 0x00, 0x30, 0xE0,
  0x00, 0x43, 0x80, 0x00, 0x8E, 0x00, 0x03, 0x38, 0x00, 0x04, 0xE0, 0x00,
  0x1B, 0x80, 0x00, 0x2E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x01, 0xFF, 0x00, 0x07, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x10, 0x00, 0x10, 0x30, 0x00, 0x08, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x04, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0x40, 0x00, 0x04, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C,
  0x30, 0x00, 0x08, 0x10, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x07, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x01,
  0x80, 0x1F, 0x03, 0x00, 0x03, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98,
  0x00, 0x01, 0x30, 0x00, 0x03, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80,
  0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x58, 0x00,
  0x00, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x63, 0x00, 0x01, 0x86, 0x00, 0x0E, 0x0F, 0xFF, 0xF0, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xC0, 0x70, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x06, 0x60, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x68, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x1C,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0xFF, 0xF8, 0x02, 0x00, 0x78, 0x08, 0x00, 0x38, 0x20, 0x00,
  0x30, 0x80, 0x00, 0x62, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00,
  0x22, 0x00, 0x01, 0x08, 0x00, 0x18, 0x20, 0x01, 0xC0, 0xFF, 0xFC, 0x02,
  0x00, 0x30, 0x08, 0x00, 0x40, 0x20, 0x01, 0x80, 0x80, 0x02, 0x02, 0x00,
  0x0C, 0x08, 0x00, 0x18, 0x20, 0x00, 0x20, 0x80, 0x00, 0xC2, 0x00, 0x01,
  0x08, 0x00, 0x06, 0x20, 0x00, 0x08, 0x80, 0x00, 0x32, 0x00, 0x00, 0x68,
  0x00, 0x01, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x01, 0xFF, 0x80, 0x07,
  0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x30, 0x00, 0x06, 0x38,
  0x00, 0x0C, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x70, 0x01, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x88, 0x00, 0x03, 0x18, 0x00, 0x04, 0x10,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x30, 0x01, 0x80, 0x38, 0x0E, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x08, 0x00, 0x02,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x40, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x08, 0x00, 0x20, 0x04, 0x00, 0x10, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x30, 0x06, 0x00, 0x08,
  0x02, 0x00, 0x04, 0x01, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x80, 0x00,
  0x40, 0x40, 0x00, 0x30, 0x60, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x06, 0x00, 0x34, 0x00, 0x60, 0x03, 0x40, 0x06, 0x00, 0x24,
  0x00, 0x70, 0x02, 0x40, 0x07, 0x00, 0x26, 0x00, 0xD0, 0x02, 0x60, 0x0D,
  0x00, 0x22, 0x00, 0x90, 0x06, 0x20, 0x09, 0x00, 0x42, 0x00, 0x98, 0x04,
  0x20, 0x19, 0x80, 0x43, 0x01, 0x88, 0x04, 0x30, 0x10, 0x80, 0x41, 0x01,
  0x08, 0x0C, 0x10, 0x10, 0xC0, 0x81, 0x03, 0x0C, 0x08, 0x10, 0x30, 0x40,
  0x81, 0x82, 0x04, 0x08, 0x18, 0x20, 0x40, 0x80, 0x82, 0x06, 0x18, 0x08,
  0x60, 0x61, 0x80, 0x86, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0xC4, 0x02,
  0x10, 0x0C, 0x40, 0x31, 0x00, 0x4C, 0x03, 0x30, 0x04, 0xC0, 0x13, 0x00,
  0x4C, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x68, 0x01, 0xA0, 0x06, 0x80,
  0x1A, 0x00, 0x78, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x60, 0x00, 0x08,
  0x08, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0x80, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x00, 0x40, 0x08, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x18, 0x00,
  0x10, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x01, 0x80, 0x02,
  0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x04, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x10, 0x04, 0x00, 0x0C, 0x01, 0x80, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x60, 0x18, 0x00, 0x08, 0x04,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x60, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFE, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x70, 0x00, 0x14,
  0x00, 0x05, 0x80, 0x03, 0x20, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x10, 0x40,
  0x0C, 0x18, 0x03, 0x02, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x04, 0x0C,
  0x01, 0x82, 0x00, 0x20, 0x80, 0x0C, 0x60, 0x01, 0x10, 0x00, 0x6C, 0x00,
  0x1A, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xC0, 0xC0, 0xC0, 0x81, 0x81, 0x81,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0x3E, 0x01, 0xC0, 0x0C, 0x0C, 0x00, 0x18,
  0x20, 0x00, 0x31, 0x00, 0x00, 0x44, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x0F, 0xFF, 0xE0, 0xF0, 0x00, 0x8E, 0x00, 0x02, 0x60, 0x00, 0x09,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x68, 0x00, 0x03, 0xB0, 0x00, 0x0A, 0x40, 0x00, 0xC9, 0x80, 0x06,
  0x23, 0x80, 0x70, 0x83, 0xFF, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x03, 0xF0, 0x08, 0x79, 0xE0, 0x4E, 0x01, 0xC2, 0xC0, 0x03,
  0x14, 0x00, 0x08, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x20, 0x00, 0x0D, 0x00,
  0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80, 0x00, 0x26,
  0x00, 0x01, 0x30, 0x00, 0x19, 0xC0, 0x01, 0x8B, 0x00, 0x18, 0x46, 0x03,
  0x82, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x7C, 0x03,
  0x00, 0x70, 0x30, 0x00, 0xC3, 0x00, 0x03, 0x10, 0x00, 0x09, 0x80, 0x00,
  0x68, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xA0, 0x00, 0x05, 0x80, 0x00, 0x66, 0x00, 0x02, 0x10, 0x00, 0x30,
  0xE0, 0x03, 0x01, 0x80, 0x70, 0x07, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x3F, 0x03, 0x03, 0xCF, 0x8C, 0x18,
  0x03, 0x30, 0xC0, 0x06, 0xC6, 0x00, 0x0F, 0x30, 0x00, 0x1C, 0x80, 0x00,
  0x32, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x34,
  0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x00, 0x01, 0xC6,
  0x00, 0x0F, 0x0C, 0x00, 0x6C, 0x1C, 0x07, 0x30, 0x1F, 0xF0, 0xC0, 0x04,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xCF, 0x80, 0x1C, 0x01, 0x80, 0x60, 0x01,
  0x81, 0x80, 0x01, 0x82, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0xF8, 0x00, 0x3C,
  0x78, 0xC3, 0x00, 0x66, 0x30, 0x01, 0xB3, 0x00, 0x07, 0xB0, 0x00, 0x1D,
  0x00, 0x00, 0xE8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x64, 0x00, 0x07, 0x30,
  0x00, 0x78, 0xC0, 0x06, 0xC3, 0x80, 0xE6, 0x07, 0xFC, 0x30, 0x02, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x18, 0x00, 0x18, 0x60, 0x01, 0x81, 0xC0, 0x18, 0x03, 0xC7, 0x80,
  0x07, 0xF0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0xFC, 0x0C, 0x1E,
  0x38, 0x63, 0x80, 0x73, 0x30, 0x00, 0x9B, 0x00, 0x06, 0xD0, 0x00, 0x17,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x70, 0x81, 0xC0, 0xFF, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x28, 0x00, 0x06, 0x40, 0x00,
  0xC2, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0x80, 0x0C, 0x04, 0x00, 0xC0, 0x20,
  0x0C, 0x01, 0x00, 0xC0, 0x08, 0x18, 0x00, 0x41, 0x80, 0x02, 0x18, 0x00,
  0x11, 0xC0, 0x00, 0x9B, 0x00, 0x05, 0x88, 0x00, 0x30, 0x60, 0x01, 0x01,
  0x80, 0x08, 0x06, 0x00, 0x40, 0x18, 0x02, 0x00, 0x60, 0x10, 0x01, 0x80,
  0x80, 0x06, 0x04, 0x00, 0x18, 0x20, 0x00, 0x61, 0x00, 0x01, 0x08, 0x00,
  0x0C, 0x40, 0x00, 0x32, 0x00, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0x13, 0xCE, 0x1E, 0x72, 0xC0, 0x66, 0x03,
  0x50, 0x07, 0x80, 0x2E, 0x00, 0x60, 0x07, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x00, 0x0E, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x7E, 0x06, 0x0F, 0x1C, 0x31, 0xC0, 0x39, 0x98, 0x00, 0x4D,
  0x80, 0x03, 0x68, 0x00, 0x0B, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x03, 0xE7, 0x80, 0x0E, 0x00, 0xE0,
  0x1C, 0x00, 0x30, 0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x60, 0x00, 0x0C,
  0x40, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x07, 0x01, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF8, 0x04, 0x3C, 0xF0, 0x26,
  0x00, 0xC1, 0x60, 0x03, 0x0E, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00,
  0x90, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00,
  0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00,
  0x03, 0x40, 0x00, 0x12, 0x00, 0x01, 0x98, 0x00, 0x08, 0xE0, 0x00, 0xC5,
  0x80, 0x0C, 0x27, 0x01, 0xC1, 0x0F, 0xF8, 0x08, 0x04, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0x3E, 0x30, 0x60, 0x0C, 0xC3, 0x00, 0x1B,
  0x18, 0x00, 0x3C, 0xC0, 0x00, 0x72, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D,
  0x00, 0x00, 0x34, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0C, 0x80,
  0x00, 0x33, 0x00, 0x00, 0xC4, 0x00, 0x07, 0x18, 0x00, 0x3C, 0x30, 0x01,
  0xB0, 0x70, 0x1C, 0xC0, 0x7F, 0xC3, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x7F, 0xC0, 0xFC, 0x61, 0xC0, 0x11, 0x80, 0x09, 0x80, 0x05,
  0x80, 0x02, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0x3F, 0x01, 0xC0, 0x0E, 0x0C, 0x00, 0x0C,
  0x20, 0x00, 0x19, 0x80, 0x00, 0x26, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0xC1, 0xE0, 0x0E, 0x01, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00,
  0x34, 0x00, 0x01, 0xB0, 0x00, 0x1C, 0x80, 0x00, 0xE6, 0x00, 0x0F, 0x18,
  0x00, 0xD8, 0x60, 0x1C, 0xC1, 0xFF, 0x86, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x30, 0x60, 0x00, 0x10, 0x30, 0x00, 0x18, 0x08,
  0x00, 0x08, 0x06, 0x00, 0x0C, 0x01, 0x00, 0x04, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x02, 0x00, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x30, 0x60, 0x00, 0x08, 0x20,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x88, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x02, 0x40, 0x0E, 0x00, 0x24, 0x00, 0xA0,
  0x06, 0x60, 0x0B, 0x00, 0x66, 0x00, 0x90, 0x04, 0x20, 0x19, 0x00, 0x42,
  0x01, 0x90, 0x0C, 0x20, 0x11, 0x80, 0xC3, 0x01, 0x08, 0x08, 0x30, 0x30,
  0x80, 0x81, 0x03, 0x08, 0x18, 0x10, 0x20, 0xC1, 0x81, 0x82, 0x04, 0x10,
  0x18, 0x60, 0x41, 0x00, 0x84, 0x04, 0x10, 0x08, 0x40, 0x63, 0x00, 0xC4,
  0x02, 0x30, 0x0C, 0xC0, 0x22, 0x00, 0x48, 0x02, 0x20, 0x04, 0x80, 0x36,
  0x00, 0x48, 0x01, 0x60, 0x07, 0x80, 0x14, 0x00, 0x70, 0x01, 0x40, 0x03,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0xE0, 0x00,
  0x07, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x08, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x00, 0x81,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3,
  0x00, 0x01, 0x81, 0x00, 0x01, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x10, 0x10, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x80, 0x18, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x04, 0x01,
  0x80, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x04, 0xC0, 0xC0,
  0x00, 0xB0, 0x0C, 0x00, 0x14, 0x00, 0xE0, 0x07, 0x80, 0x06, 0x00, 0xA0,
  0x00, 0x60, 0x64, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoMono_Thin52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 3, 37, 31, 14, -37 },
  { 15, 8, 11, 31, 11, -39 },
  { 26, 28, 37, 31, 2, -37 },
  { 156, 22, 47, 31, 5, -42 },
  { 286, 29, 39, 31, 1, -38 },
  { 428, 26, 39, 31, 4, -38 },
  { 555, 1, 11, 31, 14, -39 },
  { 557, 11, 53, 31, 10, -41 },
  { 630, 11, 53, 31, 9, -41 },
  { 703, 22, 20, 31, 5, -37 },
  { 758, 25, 27, 31, 3, -31 },
  { 843, 3, 10, 31, 11, -4 },
  { 847, 19, 2, 31, 6, -18 },
  { 852, 3, 3, 31, 15, -3 },
  { 854, 17, 40, 31, 8, -37 },
  { 939, 23, 39, 31, 4, -38 },
  { 1052, 12, 37, 31, 6, -37 },
  { 1108, 23, 37, 31, 3, -37 },
  { 1215, 23, 38, 31, 3, -37 },
  { 1325, 26, 37, 31, 2, -37 },
  { 1446, 21, 38, 31, 6, -37 },
  { 1546, 22, 38, 31, 4, -37 },
  { 1651, 24, 37, 31, 3, -37 },
  { 1762, 24, 38, 31, 4, -37 },
  { 1876, 23, 38, 31, 4, -37 },
  { 1986, 3, 25, 31, 16, -25 },
  { 1996, 5, 31, 31, 14, -25 },
  { 2016, 22, 20, 31, 4, -27 },
  { 2071, 23, 12, 31, 4, -23 },
  { 2106, 22, 20, 31, 5, -27 },
  { 2161, 19, 37, 31, 6, -37 },
  { 2249, 29, 37, 31, 1, -37 },
  { 2384, 26, 37, 31, 3, -37 },
  { 2505, 22, 37, 31, 6, -37 },
  { 2607, 23, 39, 31, 4, -38 },
  { 2720, 23, 37, 31, 5, -37 },
  { 2827, 21, 37, 31, 6, -37 },
  { 2925, 21, 37, 31, 6, -37 },
  { 3023, 24, 38, 31, 3, -37 },
  { 3137, 22, 37, 31, 5, -37 },
  { 3239, 21, 37, 31, 5, -37 },
  { 3337, 22, 38, 31, 3, -37 },
  { 3442, 24, 37, 31, 6, -37 },
  { 3553, 21, 37, 31, 6, -37 },
  { 3651, 22, 37, 31, 5, -37 },
  { 3753, 22, 37, 31, 5, -37 },
  { 3855, 24, 38, 31, 4, -37 },
  { 3969, 23, 37, 31, 6, -37 },
  { 4076, 25, 44, 31, 3, -37 },
  { 4214, 22, 37, 31, 6, -37 },
  { 4316, 24, 38, 31, 4, -37 },
  { 4430, 26, 37, 31, 3, -37 },
  { 4551, 23, 38, 31, 4, -37 },
  { 4661, 25, 37, 31, 3, -37 },
  { 4777, 28, 37, 31, 2, -37 },
  { 4907, 26, 37, 31, 3, -37 },
  { 5028, 26, 37, 31, 2, -37 },
  { 5149, 22, 37, 31, 4, -37 },
  { 5251, 8, 50, 31, 12, -42 },
  { 5301, 17, 40, 31, 7, -37 },
  { 5386, 7, 50, 31, 12, -42 },
  { 5430, 18, 20, 31, 7, -37 },
  { 5475, 21, 1, 31, 5, 0 },
  { 5478, 7, 7, 31, 12, -39 },
  { 5485, 22, 29, 31, 5, -28 },
  { 5565, 21, 40, 31, 6, -39 },
  { 5670, 21, 29, 31, 5, -28 },
  { 5747, 22, 40, 31, 4, -39 },
  { 5857, 23, 29, 31, 4, -28 },
  { 5941, 23, 40, 31, 5, -40 },
  { 6056, 21, 39, 31, 5, -28 },
  { 6159, 21, 39, 31, 5, -39 },
  { 6262, 21, 37, 31, 6, -37 },
  { 6360, 16, 48, 31, 5, -37 },
  { 6456, 21, 39, 31, 7, -39 },
  { 6559, 21, 39, 31, 6, -39 },
  { 6662, 27, 28, 31, 2, -28 },
  { 6757, 21, 28, 31, 5, -28 },
  { 6831, 24, 29, 31, 4, -28 },
  { 6918, 21, 39, 31, 6, -28 },
  { 7021, 22, 39, 31, 4, -28 },
  { 7129, 17, 28, 31, 10, -28 },
  { 7189, 22, 29, 31, 5, -28 },
  { 7269, 21, 36, 31, 5, -35 },
  { 7364, 21, 28, 31, 5, -27 },
  { 7438, 25, 27, 31, 3, -27 },
  { 7523, 28, 27, 31, 2, -27 },
  { 7618, 24, 27, 31, 4, -27 },
  { 7699, 27, 38, 31, 2, -27 },
  { 7828, 25, 27, 31, 3, -27 },
  { 7913, 16, 52, 31, 9, -41 },
  { 8017, 1, 44, 31, 15, -37 },
  { 8023, 16, 52, 31, 9, -41 },
  { 8127, 27, 9, 31, 2, -20 },
};

const GFXfont RobotoMono_Thin52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin52pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_THIN52PT7B_H_
