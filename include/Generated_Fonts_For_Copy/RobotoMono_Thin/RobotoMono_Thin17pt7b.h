#ifndef _ROBOTOMONO_THIN17PT7B_H_
#define _ROBOTOMONO_THIN17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xFF, 0x09, 0x02, 0x40, 0x91, 0xFF, 0x11, 0x04, 0x41,
  0x20, 0x48, 0xFF, 0x88, 0x82, 0x20, 0x90, 0x10, 0x21, 0xB4, 0x18, 0x30,
  0x20, 0x38, 0x0C, 0x04, 0x0C, 0x18, 0x2D, 0x84, 0x08, 0x70, 0x22, 0x48,
  0xA2, 0x28, 0x54, 0x09, 0x00, 0x98, 0x29, 0x12, 0x44, 0x92, 0x24, 0x0E,
  0x3C, 0x22, 0x11, 0x08, 0x83, 0x81, 0x01, 0x40, 0x91, 0x85, 0x41, 0xA0,
  0xCF, 0x90, 0xF0, 0x32, 0x44, 0x48, 0x88, 0x88, 0x88, 0x44, 0x42, 0x10,
  0xC4, 0x22, 0x21, 0x11, 0x11, 0x11, 0x22, 0x24, 0x80, 0x10, 0x23, 0x59,
  0xC2, 0x88, 0x90, 0x00, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08,
  0x08, 0x58, 0xFC, 0x80, 0x08, 0x44, 0x21, 0x10, 0x88, 0x42, 0x21, 0x08,
  0x00, 0x3C, 0x42, 0x81, 0x83, 0x85, 0x89, 0x91, 0xA1, 0x41, 0x41, 0x42,
  0x3C, 0x3D, 0x11, 0x11, 0x11, 0x11, 0x11, 0x7D, 0x06, 0x08, 0x10, 0x20,
  0x82, 0x04, 0x10, 0x41, 0x07, 0xF0, 0x7D, 0x06, 0x08, 0x10, 0x27, 0x81,
  0x01, 0x03, 0x06, 0x0B, 0xE0, 0x04, 0x0C, 0x0C, 0x14, 0x24, 0x24, 0x44,
  0x84, 0xFF, 0x04, 0x04, 0x04, 0x7F, 0x02, 0x04, 0x0B, 0x98, 0x80, 0x81,
  0x03, 0x06, 0x0B, 0xE0, 0x1C, 0x20, 0x40, 0x40, 0xBC, 0xC2, 0x81, 0x81,
  0x81, 0x81, 0x42, 0x3C, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x3E, 0x22, 0x41,
  0x81, 0x81, 0x41, 0x3E, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D,
  0x01, 0x02, 0x04, 0x38, 0x81, 0x81, 0xC0, 0x03, 0x0C, 0x30, 0xC0, 0x30,
  0x0C, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xC0, 0x60, 0x31, 0x8C, 0x20, 0x00,
  0x7A, 0x18, 0x41, 0x04, 0x21, 0x04, 0x20, 0x00, 0x08, 0x1F, 0x08, 0x24,
  0xC5, 0x49, 0x92, 0x64, 0x99, 0x26, 0x49, 0x96, 0x92, 0x44, 0x00, 0xFC,
  0x08, 0x18, 0x14, 0x14, 0x24, 0x22, 0x22, 0x42, 0x7D, 0x41, 0x81, 0x81,
  0xF9, 0x0A, 0x0C, 0x18, 0x5F, 0x21, 0x41, 0x83, 0x06, 0x0F, 0xE0, 0x3E,
  0x41, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x81, 0x42, 0x3C, 0xF9,
  0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x17, 0xC0, 0xFF, 0x02,
  0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04,
  0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3E, 0x41, 0x81, 0x80,
  0x80, 0x80, 0x8E, 0x81, 0x81, 0x81, 0x41, 0x3E, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFC, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x06, 0x0B, 0xE0, 0x82, 0x84, 0x88, 0x90, 0xA0, 0xE0, 0x90, 0x90,
  0x88, 0x84, 0x82, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x07, 0xF0, 0x83, 0x06, 0x1E, 0x5C, 0xB5, 0x6C, 0xC9, 0x83, 0x06,
  0x0C, 0x10, 0x81, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x83,
  0x83, 0x81, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0x40, 0x81, 0x02, 0x04,
  0x00, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0x02, 0x01, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x44, 0x85, 0x0A,
  0x0C, 0x10, 0x3E, 0x41, 0x81, 0x80, 0x40, 0x38, 0x06, 0x01, 0x01, 0x81,
  0x41, 0x3E, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0x81, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18,
  0x18, 0x08, 0x88, 0xC4, 0x66, 0x33, 0x29, 0x54, 0xA9, 0x94, 0xCA, 0x65,
  0x31, 0x10, 0x88, 0x40, 0x81, 0x41, 0x22, 0x24, 0x14, 0x08, 0x08, 0x14,
  0x24, 0x42, 0x41, 0x81, 0x81, 0x81, 0x42, 0x42, 0x24, 0x28, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0x40, 0xFF, 0xEA, 0xAA, 0xAA, 0xAA, 0xC0, 0x81, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0xD5, 0x55, 0x55, 0x55, 0xC0,
  0x10, 0xC2, 0x92, 0x4A, 0x18, 0x40, 0xFE, 0x94, 0x79, 0x08, 0x08, 0x17,
  0xF0, 0x60, 0xC2, 0xFA, 0x81, 0x02, 0x04, 0x0F, 0x90, 0xA0, 0xC1, 0x83,
  0x06, 0x0C, 0x2F, 0x80, 0x3C, 0x42, 0x41, 0x80, 0x80, 0x80, 0x81, 0x41,
  0x3E, 0x02, 0x04, 0x08, 0x13, 0xE8, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x13,
  0xE0, 0x3C, 0x42, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x41, 0x3E, 0x1E, 0x40,
  0x81, 0x0F, 0xC4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x3E, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xA1, 0x3E, 0x04, 0x0A, 0x13, 0xC0, 0x81, 0x02,
  0x04, 0x0F, 0xD0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x10, 0x00,
  0x07, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x04, 0x00, 0x0F,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0xBC, 0x81, 0x02, 0x04,
  0x08, 0x71, 0x24, 0x50, 0xE1, 0x22, 0x24, 0x28, 0x20, 0xF0, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0xF7, 0x44, 0x62,
  0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0x80, 0xFD, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x82, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0xF9, 0x02, 0x04, 0x00,
  0x3E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xA1, 0x3E, 0x04, 0x08, 0x10, 0xBF,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x7D, 0x06, 0x06, 0x03, 0x80, 0x80,
  0xC1, 0x7C, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20, 0x81, 0xC0, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x81, 0x81, 0x42, 0x42, 0x24, 0x24,
  0x14, 0x18, 0x08, 0x88, 0xC4, 0x66, 0x52, 0xA9, 0x53, 0x29, 0x98, 0x84,
  0x42, 0x00, 0xC1, 0x42, 0x24, 0x18, 0x08, 0x14, 0x24, 0x42, 0x81, 0x81,
  0x81, 0x41, 0x42, 0x22, 0x24, 0x14, 0x18, 0x08, 0x10, 0x10, 0x20, 0xC0,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFF, 0x19, 0x08, 0x42,
  0x10, 0x88, 0xC1, 0x08, 0x42, 0x10, 0x82, 0x08, 0xFF, 0xFC, 0xC1, 0x08,
  0x42, 0x10, 0x82, 0x19, 0x08, 0x42, 0x10, 0x88, 0x80, 0xF0, 0xC7, 0x80,
};

const GFXglyph RobotoMono_Thin17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 1, 12, 10, 4, -12 },
  { 3, 2, 4, 10, 4, -13 },
  { 4, 10, 12, 10, 0, -12 },
  { 19, 7, 16, 10, 2, -14 },
  { 33, 10, 12, 10, 0, -12 },
  { 48, 9, 12, 10, 1, -12 },
  { 62, 1, 4, 10, 4, -13 },
  { 63, 4, 17, 10, 3, -13 },
  { 72, 4, 17, 10, 3, -13 },
  { 81, 7, 7, 10, 2, -12 },
  { 88, 8, 9, 10, 1, -10 },
  { 97, 2, 3, 10, 3, -1 },
  { 98, 6, 1, 10, 2, -6 },
  { 99, 1, 1, 10, 5, -1 },
  { 100, 5, 13, 10, 3, -12 },
  { 109, 8, 12, 10, 1, -12 },
  { 121, 4, 12, 10, 2, -12 },
  { 127, 7, 12, 10, 1, -12 },
  { 138, 7, 12, 10, 1, -12 },
  { 149, 8, 12, 10, 1, -12 },
  { 161, 7, 12, 10, 2, -12 },
  { 172, 8, 12, 10, 1, -12 },
  { 184, 8, 12, 10, 1, -12 },
  { 196, 8, 12, 10, 1, -12 },
  { 208, 8, 12, 10, 1, -12 },
  { 220, 1, 8, 10, 5, -8 },
  { 221, 1, 10, 10, 5, -8 },
  { 223, 8, 7, 10, 1, -9 },
  { 230, 8, 3, 10, 1, -7 },
  { 233, 7, 7, 10, 2, -9 },
  { 240, 6, 12, 10, 2, -12 },
  { 249, 10, 12, 10, 0, -12 },
  { 264, 8, 12, 10, 1, -12 },
  { 276, 7, 12, 10, 2, -12 },
  { 287, 8, 12, 10, 1, -12 },
  { 299, 7, 12, 10, 2, -12 },
  { 310, 7, 12, 10, 2, -12 },
  { 321, 7, 12, 10, 2, -12 },
  { 332, 8, 12, 10, 1, -12 },
  { 344, 8, 12, 10, 1, -12 },
  { 356, 6, 12, 10, 2, -12 },
  { 365, 7, 12, 10, 1, -12 },
  { 376, 8, 12, 10, 2, -12 },
  { 388, 7, 12, 10, 2, -12 },
  { 399, 7, 12, 10, 2, -12 },
  { 410, 8, 12, 10, 1, -12 },
  { 422, 8, 12, 10, 1, -12 },
  { 434, 7, 12, 10, 2, -12 },
  { 445, 8, 14, 10, 1, -12 },
  { 459, 7, 12, 10, 2, -12 },
  { 470, 8, 12, 10, 1, -12 },
  { 482, 8, 12, 10, 1, -12 },
  { 494, 8, 12, 10, 1, -12 },
  { 506, 8, 12, 10, 1, -12 },
  { 518, 9, 12, 10, 1, -12 },
  { 532, 8, 12, 10, 1, -12 },
  { 544, 8, 12, 10, 1, -12 },
  { 556, 8, 12, 10, 1, -12 },
  { 568, 2, 17, 10, 4, -14 },
  { 573, 6, 13, 10, 2, -12 },
  { 583, 2, 17, 10, 4, -14 },
  { 588, 6, 7, 10, 2, -12 },
  { 594, 7, 1, 10, 2, 0 },
  { 595, 2, 3, 10, 4, -13 },
  { 596, 7, 9, 10, 2, -9 },
  { 604, 7, 13, 10, 2, -13 },
  { 616, 8, 9, 10, 1, -9 },
  { 625, 7, 13, 10, 1, -13 },
  { 637, 8, 9, 10, 1, -9 },
  { 646, 7, 13, 10, 2, -13 },
  { 658, 7, 13, 10, 1, -9 },
  { 670, 7, 13, 10, 2, -13 },
  { 682, 7, 12, 10, 2, -12 },
  { 693, 6, 16, 10, 1, -12 },
  { 705, 7, 13, 10, 2, -13 },
  { 717, 7, 13, 10, 2, -13 },
  { 729, 9, 9, 10, 1, -9 },
  { 740, 7, 9, 10, 2, -9 },
  { 748, 8, 9, 10, 1, -9 },
  { 757, 7, 12, 10, 2, -9 },
  { 768, 7, 12, 10, 1, -9 },
  { 779, 6, 9, 10, 3, -9 },
  { 786, 7, 9, 10, 2, -9 },
  { 794, 6, 11, 10, 2, -11 },
  { 803, 6, 9, 10, 2, -9 },
  { 810, 8, 9, 10, 1, -9 },
  { 819, 9, 9, 10, 1, -9 },
  { 830, 8, 9, 10, 1, -9 },
  { 839, 8, 13, 10, 1, -9 },
  { 852, 8, 9, 10, 1, -9 },
  { 861, 5, 17, 10, 3, -13 },
  { 872, 1, 14, 10, 5, -12 },
  { 874, 5, 17, 10, 3, -13 },
  { 885, 9, 2, 10, 1, -6 },
};

const GFXfont RobotoMono_Thin17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin17pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_THIN17PT7B_H_
