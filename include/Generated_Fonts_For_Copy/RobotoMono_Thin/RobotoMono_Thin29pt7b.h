#ifndef _ROBOTOMONO_THIN29PT7B_H_
#define _ROBOTOMONO_THIN29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x08, 0x8C, 0x63, 0x18, 0xC4, 0x02, 0x08, 0x02, 0x08,
  0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x04, 0x10, 0x7F, 0xFF, 0x04, 0x10,
  0x04, 0x10, 0x04, 0x10, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20,
  0xFF, 0xFE, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0xF8, 0x30, 0x44, 0x02, 0x40,
  0x18, 0x01, 0x80, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x60,
  0x21, 0xDC, 0x02, 0x00, 0x20, 0x02, 0x00, 0x78, 0x00, 0x84, 0x00, 0x84,
  0x00, 0x84, 0x10, 0x82, 0x10, 0x82, 0x20, 0x84, 0x40, 0x84, 0x40, 0x48,
  0x80, 0x30, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x3C, 0x02, 0x42, 0x04,
  0x41, 0x04, 0x41, 0x08, 0x41, 0x10, 0x41, 0x10, 0x41, 0x00, 0x22, 0x00,
  0x3C, 0x0F, 0x00, 0x21, 0x00, 0x41, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x20, 0x08, 0x80, 0x12, 0x00, 0x18, 0x00, 0x50, 0x01, 0x10, 0x02,
  0x10, 0x48, 0x10, 0xA0, 0x21, 0x40, 0x24, 0x80, 0x29, 0x00, 0x21, 0x00,
  0x61, 0x03, 0x41, 0xF8, 0x60, 0xFC, 0x04, 0x21, 0x08, 0x21, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x81, 0x02, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x41, 0x08, 0x42, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xC2, 0x33,
  0xAC, 0x07, 0x00, 0x50, 0x09, 0x01, 0x08, 0x20, 0x42, 0x02, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x55, 0xA0, 0xFF, 0xC0, 0x70, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x00, 0x0F,
  0x80, 0x83, 0x08, 0x08, 0x80, 0x24, 0x01, 0x20, 0x06, 0x00, 0x70, 0x05,
  0x80, 0x4C, 0x04, 0x60, 0x43, 0x04, 0x18, 0x40, 0xC4, 0x06, 0x40, 0x2C,
  0x01, 0x40, 0x0A, 0x00, 0x88, 0x04, 0x20, 0x40, 0xFC, 0x00, 0x02, 0x1C,
  0xCE, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x1F, 0x02, 0x0C, 0x40, 0x48, 0x02, 0x80,
  0x28, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xFF,
  0xF0, 0x0F, 0x80, 0x83, 0x08, 0x04, 0x80, 0x24, 0x00, 0xA0, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x03, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x60, 0x60, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00,
  0x88, 0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81, 0x02, 0x02,
  0x08, 0x04, 0x1F, 0xFF, 0xC0, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x3F, 0xF2, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x5F, 0x86, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x14, 0x01, 0x40, 0x22, 0x06, 0x1F, 0x80,
  0x01, 0xC0, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08,
  0xE0, 0x98, 0xC5, 0x01, 0x30, 0x05, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x40, 0x0A, 0x00, 0x88, 0x04, 0x60, 0x40, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x00, 0x07, 0xC0,
  0x60, 0x82, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02,
  0x20, 0x10, 0x40, 0x80, 0xFC, 0x04, 0x08, 0x20, 0x11, 0x00, 0x24, 0x00,
  0x60, 0x01, 0x80, 0x05, 0x00, 0x24, 0x00, 0x88, 0x04, 0x1F, 0xE0, 0x0F,
  0x80, 0x82, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x50, 0x02, 0x80, 0x32, 0x02, 0x8F, 0xE4, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x01, 0xF0, 0x00, 0xB0, 0x00,
  0x00, 0xB0, 0x4C, 0x00, 0x00, 0x00, 0x04, 0x92, 0x90, 0x00, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x06, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x00, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1E, 0x18, 0x68, 0x0A,
  0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x40, 0x30, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xE0, 0x0C, 0x18, 0x10, 0x04, 0x20, 0x02, 0x20, 0x82, 0x43, 0x62, 0x44,
  0x22, 0x84, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88,
  0x22, 0x88, 0x42, 0x88, 0x42, 0x88, 0xA4, 0x87, 0x1C, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x10, 0x0F, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x40,
  0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01, 0x02,
  0x04, 0x08, 0x20, 0x20, 0x80, 0x43, 0xFF, 0x10, 0x04, 0x40, 0x09, 0x00,
  0x28, 0x00, 0xA0, 0x01, 0x80, 0x04, 0xFE, 0x08, 0x18, 0x80, 0x48, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x0C, 0xFF, 0x88, 0x06,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x06,
  0xFF, 0x80, 0x0F, 0x80, 0x83, 0x08, 0x04, 0x80, 0x24, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x04, 0x20, 0x40, 0xFC,
  0x00, 0xFE, 0x04, 0x0C, 0x20, 0x11, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x20, 0x11, 0x01, 0x0F, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0xC8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF,
  0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x83, 0x08, 0x04, 0x80, 0x24, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x1F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x02, 0x20,
  0x30, 0xFE, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x0F, 0xFE, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x26, 0x04, 0x1F, 0x80,
  0x80, 0x0A, 0x00, 0x48, 0x02, 0x20, 0x10, 0x80, 0x82, 0x04, 0x08, 0x20,
  0x21, 0x00, 0x8C, 0x02, 0x20, 0x09, 0x80, 0x29, 0x00, 0xC2, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x80, 0x42, 0x00, 0x88, 0x01, 0x20, 0x04, 0x80,
  0x0C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0x80, 0x18, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x5A, 0x05, 0xA0, 0x99, 0x09, 0x90, 0x99, 0x11,
  0x89, 0x18, 0xA1, 0x8A, 0x18, 0x41, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xA0,
  0x1A, 0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0x41, 0x84, 0x18, 0x21, 0x82,
  0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x98, 0x05, 0x80, 0x38, 0x03, 0x80,
  0x10, 0x0F, 0x80, 0x82, 0x08, 0x08, 0x80, 0x24, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x88, 0x04, 0x20, 0x40, 0xFC, 0x00,
  0xFE, 0x04, 0x06, 0x20, 0x0D, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xA0, 0x09, 0xFF, 0x88, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0x80, 0x41, 0x82, 0x01, 0x10, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x09, 0x00, 0x22, 0x01, 0x0C, 0x08, 0x0F, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0xFC, 0x04, 0x0E, 0x20, 0x09,
  0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x20,
  0x11, 0xFF, 0x08, 0x10, 0x40, 0x42, 0x02, 0x10, 0x08, 0x80, 0x44, 0x01,
  0x20, 0x05, 0x00, 0x28, 0x00, 0x80, 0x0F, 0xC0, 0x40, 0x82, 0x01, 0x10,
  0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0xA0, 0x01, 0x80, 0x05,
  0x00, 0x24, 0x00, 0x88, 0x04, 0x1F, 0xE0, 0xFF, 0xFC, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x0A,
  0x00, 0x88, 0x04, 0x60, 0x40, 0xFC, 0x00, 0x80, 0x02, 0x80, 0x05, 0x00,
  0x12, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x08, 0x04, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x41, 0x00, 0x82, 0x00, 0x84, 0x01, 0x10, 0x02,
  0x20, 0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x80,
  0x81, 0x81, 0x81, 0x41, 0x82, 0x41, 0x82, 0x41, 0x82, 0x41, 0x42, 0x42,
  0x42, 0x42, 0x42, 0x22, 0x44, 0x22, 0x44, 0x22, 0x44, 0x24, 0x24, 0x24,
  0x24, 0x24, 0x24, 0x24, 0x24, 0x14, 0x28, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x08, 0x10, 0x80, 0x05, 0x00, 0x24, 0x00, 0x88, 0x04,
  0x10, 0x20, 0x40, 0x80, 0x84, 0x01, 0x20, 0x04, 0x80, 0x0C, 0x00, 0x20,
  0x00, 0xC0, 0x04, 0x80, 0x22, 0x00, 0x84, 0x04, 0x08, 0x10, 0x20, 0x80,
  0x44, 0x00, 0x90, 0x02, 0x80, 0x04, 0x80, 0x02, 0x80, 0x09, 0x00, 0x11,
  0x00, 0x42, 0x00, 0x82, 0x02, 0x04, 0x08, 0x04, 0x10, 0x08, 0x40, 0x08,
  0x80, 0x0A, 0x00, 0x14, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x7F, 0xF0,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04,
  0x02, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xF0, 0x08, 0x03, 0x01, 0x40, 0x50,
  0x12, 0x08, 0x82, 0x11, 0x04, 0x41, 0x20, 0x28, 0x0A, 0x01, 0xFF, 0xF0,
  0xC8, 0x80, 0x0F, 0x03, 0x0C, 0x40, 0x28, 0x02, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x7E, 0x38, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x03, 0xC0,
  0xD3, 0xF1, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x8E,
  0x09, 0x18, 0xE0, 0x4C, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x2C, 0x02, 0xA0, 0x49, 0xF8, 0x0E,
  0x03, 0x18, 0x40, 0x44, 0x02, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x14, 0x02, 0x20, 0x41, 0xF8, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x03, 0x11, 0x8D, 0x20,
  0x34, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x12, 0x01, 0x30, 0x30, 0xF9, 0x07, 0x80, 0xC3, 0x08,
  0x0C, 0x40, 0x24, 0x00, 0xA0, 0x06, 0x00, 0x3F, 0xFF, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x04, 0x40, 0x41, 0xFC, 0x01, 0xF8,
  0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x1F, 0xFC, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x06, 0x06,
  0x35, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x80, 0x58, 0x18, 0xFD, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x26, 0x0C, 0x3E, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x82, 0x09, 0x8C, 0xA0, 0x2C, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x02, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x01, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x03, 0x3E, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x02, 0x80, 0x90, 0x22, 0x18, 0x44, 0x09, 0x01, 0x60,
  0x32, 0x04, 0x60, 0x84, 0x10, 0x42, 0x04, 0x40, 0x48, 0x05, 0x00, 0x40,
  0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x1C, 0x31, 0x44,
  0x8B, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81,
  0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0x40, 0xC0, 0x81, 0x02, 0x09, 0x8C, 0xA0, 0x2C, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x07, 0x00, 0xC6, 0x08, 0x08, 0x80, 0x24, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x14, 0x00,
  0xA0, 0x08, 0xC0, 0x81, 0xF8, 0x0E, 0x0B, 0x18, 0xC0, 0x4C, 0x02, 0x80,
  0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x2C, 0x02, 0xE0, 0x49, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x07, 0x01, 0x8D, 0x20, 0x34, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x40, 0x12, 0x01, 0x30,
  0x30, 0xFD, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x07,
  0xCC, 0x28, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x0F, 0x03, 0x0C, 0x40, 0x28, 0x01, 0x80,
  0x14, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x23, 0xFC, 0x08, 0x01, 0x00, 0x20, 0x04, 0x0F, 0xFE,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x0F, 0x80, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x14, 0x02, 0x80, 0xCF, 0xE8, 0x80, 0x0E, 0x00, 0x24, 0x00, 0x90, 0x04,
  0x20, 0x10, 0x80, 0x81, 0x02, 0x04, 0x10, 0x10, 0x40, 0x22, 0x00, 0x88,
  0x01, 0x20, 0x05, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x81, 0x03, 0x81, 0x82,
  0x41, 0x82, 0x42, 0x82, 0x42, 0x82, 0x42, 0x44, 0x22, 0x44, 0x24, 0x44,
  0x24, 0x44, 0x24, 0x28, 0x24, 0x28, 0x18, 0x28, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x10, 0xC0, 0x08, 0x80, 0x41, 0x02, 0x04, 0x10, 0x08, 0x80, 0x12,
  0x00, 0x30, 0x00, 0xC0, 0x05, 0x00, 0x32, 0x00, 0x84, 0x04, 0x08, 0x20,
  0x11, 0x00, 0x4C, 0x00, 0xC0, 0xC0, 0x02, 0x80, 0x09, 0x00, 0x11, 0x00,
  0x42, 0x00, 0x82, 0x01, 0x04, 0x04, 0x04, 0x08, 0x08, 0x20, 0x08, 0x40,
  0x11, 0x00, 0x12, 0x00, 0x28, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x81, 0x81, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x01, 0x03, 0x00, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x40, 0x18, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x0E, 0x06, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x04, 0x0C, 0x00, 0x3C, 0x02,
  0x84, 0x06, 0x04, 0x0C, 0x06, 0x20, 0x03, 0x80,
};

const GFXglyph RobotoMono_Thin29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 1, 21, 17, 8, -21 },
  { 4, 5, 6, 17, 6, -22 },
  { 8, 16, 21, 17, 1, -21 },
  { 50, 12, 27, 17, 3, -24 },
  { 91, 16, 21, 17, 1, -21 },
  { 133, 15, 21, 17, 2, -21 },
  { 173, 1, 6, 17, 8, -22 },
  { 174, 6, 30, 17, 6, -23 },
  { 197, 6, 30, 17, 5, -23 },
  { 220, 12, 12, 17, 3, -21 },
  { 238, 14, 15, 17, 2, -17 },
  { 265, 2, 6, 17, 6, -2 },
  { 267, 10, 1, 17, 4, -10 },
  { 269, 2, 2, 17, 8, -2 },
  { 270, 10, 23, 17, 4, -21 },
  { 299, 13, 21, 17, 2, -21 },
  { 334, 7, 21, 17, 3, -21 },
  { 353, 12, 21, 17, 2, -21 },
  { 385, 13, 21, 17, 1, -21 },
  { 420, 15, 21, 17, 1, -21 },
  { 460, 12, 21, 17, 3, -21 },
  { 492, 13, 21, 17, 2, -21 },
  { 527, 13, 21, 17, 2, -21 },
  { 562, 14, 21, 17, 2, -21 },
  { 599, 13, 21, 17, 2, -21 },
  { 634, 2, 14, 17, 9, -14 },
  { 638, 3, 18, 17, 8, -14 },
  { 645, 13, 11, 17, 2, -15 },
  { 663, 13, 7, 17, 2, -13 },
  { 675, 12, 11, 17, 3, -15 },
  { 692, 10, 21, 17, 4, -21 },
  { 719, 16, 21, 17, 1, -21 },
  { 761, 14, 21, 17, 2, -21 },
  { 798, 12, 21, 17, 3, -21 },
  { 830, 13, 21, 17, 2, -21 },
  { 865, 13, 21, 17, 3, -21 },
  { 900, 12, 21, 17, 3, -21 },
  { 932, 12, 21, 17, 3, -21 },
  { 964, 13, 21, 17, 2, -21 },
  { 999, 12, 21, 17, 3, -21 },
  { 1031, 11, 21, 17, 3, -21 },
  { 1060, 12, 21, 17, 2, -21 },
  { 1092, 14, 21, 17, 3, -21 },
  { 1129, 12, 21, 17, 3, -21 },
  { 1161, 12, 21, 17, 3, -21 },
  { 1193, 12, 21, 17, 3, -21 },
  { 1225, 13, 21, 17, 2, -21 },
  { 1260, 13, 21, 17, 3, -21 },
  { 1295, 14, 25, 17, 2, -21 },
  { 1339, 13, 21, 17, 3, -21 },
  { 1374, 14, 21, 17, 2, -21 },
  { 1411, 14, 21, 17, 2, -21 },
  { 1448, 13, 21, 17, 2, -21 },
  { 1483, 15, 21, 17, 1, -21 },
  { 1523, 16, 21, 17, 1, -21 },
  { 1565, 14, 21, 17, 2, -21 },
  { 1602, 15, 21, 17, 1, -21 },
  { 1642, 13, 21, 17, 2, -21 },
  { 1677, 4, 28, 17, 7, -24 },
  { 1691, 9, 23, 17, 4, -21 },
  { 1717, 5, 28, 17, 6, -24 },
  { 1735, 10, 12, 17, 4, -21 },
  { 1750, 12, 1, 17, 3, 0 },
  { 1752, 3, 3, 17, 7, -21 },
  { 1754, 12, 16, 17, 3, -16 },
  { 1778, 12, 22, 17, 3, -22 },
  { 1811, 12, 16, 17, 3, -16 },
  { 1835, 12, 22, 17, 2, -22 },
  { 1868, 13, 16, 17, 2, -16 },
  { 1894, 13, 22, 17, 3, -22 },
  { 1930, 11, 22, 17, 3, -16 },
  { 1961, 12, 22, 17, 3, -22 },
  { 1994, 12, 21, 17, 3, -21 },
  { 2026, 9, 27, 17, 3, -21 },
  { 2057, 11, 22, 17, 4, -22 },
  { 2088, 12, 22, 17, 3, -22 },
  { 2121, 15, 16, 17, 1, -16 },
  { 2151, 12, 16, 17, 3, -16 },
  { 2175, 13, 16, 17, 2, -16 },
  { 2201, 12, 22, 17, 3, -16 },
  { 2234, 12, 22, 17, 2, -16 },
  { 2267, 9, 16, 17, 6, -16 },
  { 2285, 12, 16, 17, 3, -16 },
  { 2309, 11, 19, 17, 3, -19 },
  { 2336, 11, 15, 17, 3, -15 },
  { 2357, 14, 15, 17, 2, -15 },
  { 2384, 16, 15, 17, 1, -15 },
  { 2414, 14, 15, 17, 2, -15 },
  { 2441, 15, 21, 17, 1, -15 },
  { 2481, 14, 15, 17, 2, -15 },
  { 2508, 9, 29, 17, 5, -23 },
  { 2541, 1, 25, 17, 8, -21 },
  { 2545, 9, 29, 17, 5, -23 },
  { 2578, 15, 5, 17, 1, -11 },
};

const GFXfont RobotoMono_Thin29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin29pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_THIN29PT7B_H_
