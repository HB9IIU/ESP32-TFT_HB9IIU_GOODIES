#ifndef _ROBOTOMONO_THIN27PT7B_H_
#define _ROBOTOMONO_THIN27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin27pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0x0C, 0x99, 0x99, 0x90, 0x02, 0x10, 0x08,
  0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x0F, 0xFF, 0xC1, 0x08, 0x04, 0x10,
  0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x01, 0x04, 0x1F, 0xFF, 0x84,
  0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x82, 0x00, 0x04, 0x00, 0x80,
  0x38, 0x18, 0xC4, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x08, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x14, 0x04, 0x77, 0x01, 0x00, 0x20, 0x04, 0x00, 0x78, 0x01, 0x08, 0x02,
  0x10, 0x84, 0x21, 0x08, 0x44, 0x10, 0x88, 0x21, 0x20, 0x2C, 0x40, 0x21,
  0x00, 0x02, 0x00, 0x08, 0xE0, 0x22, 0x20, 0x48, 0x41, 0x10, 0x42, 0x20,
  0x88, 0x41, 0x10, 0x82, 0x00, 0x88, 0x00, 0xE0, 0x1F, 0x01, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x10, 0x80, 0x48, 0x02, 0x80, 0x08, 0x00, 0xA0,
  0x08, 0x80, 0x84, 0x18, 0x10, 0xC0, 0x4A, 0x01, 0x50, 0x06, 0x40, 0x22,
  0x02, 0x8F, 0xE2, 0xF8, 0x04, 0x21, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x82, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x40, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x08, 0x21, 0x08, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x42, 0x17, 0x5C, 0x1C, 0x02, 0x80, 0x88, 0x10, 0x8C, 0x18,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F,
  0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x55,
  0xC0, 0xFF, 0xC0, 0x80, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x00, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x18,
  0x03, 0x80, 0x58, 0x09, 0x81, 0x18, 0x21, 0x84, 0x18, 0x81, 0x90, 0x1A,
  0x01, 0x40, 0x14, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x0C, 0xDC, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40,
  0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x7F, 0xF0, 0x1F, 0xC2, 0x02, 0x40, 0x24, 0x01, 0x40,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0xC0, 0xF8, 0x00, 0x60, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x02, 0x1F, 0xC0, 0x00, 0x40,
  0x03, 0x00, 0x14, 0x00, 0x50, 0x02, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10,
  0x10, 0x40, 0x41, 0x02, 0x04, 0x10, 0x10, 0x40, 0x43, 0xFF, 0xF0, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x3F, 0xE8, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xF8, 0x40, 0x80, 0x08, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x44, 0x08, 0x7E, 0x00, 0x07,
  0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x8F, 0x0B, 0x0C, 0xC0,
  0x48, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x40,
  0x22, 0x04, 0x1F, 0x80, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x00, 0x1F, 0xC1, 0x01,
  0x10, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x44, 0x04, 0x18, 0xC0,
  0xFE, 0x08, 0x08, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x02, 0x40,
  0x11, 0x01, 0x07, 0xF0, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x40, 0x33, 0x0D, 0x0F, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x18, 0x1E, 0x00, 0x80, 0x08, 0x40,
  0x00, 0x01, 0x6A, 0x00, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x00, 0x80, 0x00, 0x3F, 0x10,
  0x24, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xF0,
  0x40, 0x62, 0x00, 0x90, 0x01, 0x43, 0xC6, 0x11, 0x18, 0x84, 0x62, 0x11,
  0x88, 0x46, 0x41, 0x19, 0x04, 0x64, 0x11, 0x90, 0xC6, 0x23, 0x18, 0xF3,
  0x90, 0x00, 0x40, 0x00, 0x80, 0x81, 0xFC, 0x00, 0x02, 0x00, 0x30, 0x01,
  0x40, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x22, 0x02, 0x10, 0x10, 0x40, 0x82,
  0x08, 0x10, 0x40, 0x43, 0xFE, 0x20, 0x11, 0x00, 0x48, 0x02, 0x80, 0x14,
  0x00, 0x60, 0x02, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x14, 0x02, 0x81, 0x9F, 0xF2, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x1B, 0xFC, 0x00, 0x1F, 0x82, 0x06, 0x40, 0x24, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x14, 0x01, 0x40, 0x22, 0x04, 0x1F, 0x80, 0xFE,
  0x08, 0x18, 0x80, 0x48, 0x04, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x48, 0x18, 0xFE, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0xC2,
  0x02, 0x40, 0x24, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x83, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12,
  0x03, 0x1F, 0xC0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF, 0xC1, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x48, 0x18, 0xFC, 0x00, 0x80,
  0x38, 0x04, 0x80, 0x88, 0x18, 0x81, 0x08, 0x20, 0x84, 0x08, 0x80, 0x90,
  0x0A, 0x80, 0xC4, 0x08, 0x20, 0x82, 0x08, 0x10, 0x80, 0x88, 0x04, 0x80,
  0x28, 0x02, 0x80, 0x10, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x80, 0xC0, 0x1C, 0x03, 0xA0, 0x3A,
  0x05, 0xA0, 0x59, 0x05, 0x90, 0x98, 0x89, 0x89, 0x18, 0x91, 0x86, 0x18,
  0x61, 0x82, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x80, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0x41,
  0x84, 0x18, 0x21, 0x82, 0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x58, 0x05,
  0x80, 0x38, 0x03, 0x80, 0x10, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0xFF, 0x88,
  0x04, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28,
  0x04, 0xFF, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x1F, 0x81, 0x03, 0x10, 0x09, 0x00, 0x28, 0x01, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x50, 0x02, 0x40, 0x21, 0x02, 0x07, 0xE0, 0x00, 0x80,
  0x02, 0x00, 0x08, 0xFF, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x08, 0xFF, 0x08, 0x10, 0x81, 0x08, 0x08,
  0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x10, 0x1F, 0xC2, 0x02, 0x40,
  0x14, 0x01, 0x80, 0x14, 0x00, 0x40, 0x02, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x40, 0x12, 0x02, 0x1F,
  0xC0, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40,
  0x22, 0x04, 0x1F, 0x80, 0x80, 0x05, 0x00, 0x24, 0x00, 0x90, 0x02, 0x20,
  0x10, 0x80, 0x42, 0x01, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x84, 0x02,
  0x10, 0x08, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x81, 0x06, 0x04, 0x14, 0x30, 0x50, 0xA1, 0x42, 0x85, 0x0A,
  0x14, 0x28, 0x51, 0x22, 0x44, 0x48, 0x91, 0x22, 0x44, 0x89, 0x12, 0x28,
  0x48, 0xA0, 0xC2, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xC1, 0x01, 0x00,
  0x80, 0x1A, 0x00, 0x88, 0x08, 0x40, 0x41, 0x04, 0x08, 0x40, 0x22, 0x00,
  0xA0, 0x06, 0x00, 0x10, 0x01, 0x40, 0x12, 0x00, 0x88, 0x08, 0x20, 0x81,
  0x04, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x02, 0x80, 0x0D, 0x00, 0x22, 0x01,
  0x08, 0x04, 0x10, 0x20, 0x40, 0x80, 0x84, 0x02, 0x10, 0x04, 0x80, 0x12,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xE0, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xF0, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F,
  0x0C, 0x03, 0x00, 0xA0, 0x48, 0x11, 0x08, 0x42, 0x11, 0x02, 0x40, 0xB0,
  0x10, 0xFF, 0xE0, 0xC4, 0x21, 0x07, 0x01, 0x8C, 0x20, 0x24, 0x02, 0x40,
  0x10, 0x01, 0x00, 0x11, 0xFE, 0x20, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x24, 0x05, 0x3F, 0x90, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x1C,
  0x2C, 0x46, 0x04, 0x80, 0x50, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x50, 0x0B, 0x02, 0x5F, 0x80, 0x07, 0x01, 0x8C, 0x20,
  0x24, 0x02, 0x40, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x01, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x0C, 0x46, 0x69, 0x03, 0x40, 0x28, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x28, 0x04, 0x81, 0x8F, 0xD0, 0x07,
  0x01, 0x8C, 0x20, 0x24, 0x02, 0x40, 0x18, 0x01, 0x80, 0x1F, 0xFE, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x13, 0x02, 0x0F, 0xC0, 0x01, 0xE0,
  0x61, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xFC, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x06, 0x03, 0x34, 0x81, 0xA0, 0x14,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x40, 0xC7, 0xE8, 0x01, 0x00, 0x20, 0x05, 0x01, 0x18, 0x40, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x0C, 0x26, 0x65, 0x02, 0xC0, 0x50,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x83, 0xFF, 0x80, 0x01, 0x80, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x0C, 0xF0, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x14, 0x04, 0x81, 0x10,
  0xC2, 0x20, 0x48, 0x0A, 0x81, 0x90, 0x21, 0x04, 0x10, 0x81, 0x10, 0x12,
  0x01, 0x40, 0x10, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x7F, 0xF0, 0x18, 0x32, 0x9B, 0x2C, 0x30,
  0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04,
  0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x40, 0x06, 0x13,
  0x33, 0x81, 0x60, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x06, 0x01, 0x98, 0x20, 0x64,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x0E, 0x16, 0x23, 0x02, 0x40, 0x28,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x05,
  0x81, 0x2F, 0xC4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x06, 0x03,
  0x34, 0x81, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xA0, 0x14, 0x02, 0x40, 0xC7, 0xE8, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x03, 0xCE, 0x28, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x0E, 0x06, 0x31, 0x01, 0x40,
  0x18, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x18,
  0x02, 0x80, 0x8F, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x01, 0xF0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0xCF, 0xD0, 0x80, 0x1C, 0x00,
  0x90, 0x04, 0x80, 0x44, 0x02, 0x10, 0x20, 0x81, 0x02, 0x10, 0x10, 0x80,
  0x48, 0x02, 0x40, 0x0A, 0x00, 0x60, 0x03, 0x00, 0x81, 0x06, 0x0C, 0x14,
  0x30, 0x50, 0xA1, 0x42, 0x89, 0x12, 0x24, 0x48, 0x89, 0x12, 0x24, 0x48,
  0xA1, 0x42, 0x85, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x80, 0xC0, 0x11, 0x01,
  0x08, 0x10, 0x21, 0x00, 0x88, 0x02, 0x80, 0x08, 0x00, 0xC0, 0x09, 0x00,
  0x44, 0x04, 0x10, 0x40, 0x44, 0x02, 0x40, 0x0C, 0x80, 0x05, 0x00, 0x24,
  0x00, 0x88, 0x04, 0x20, 0x10, 0x40, 0x41, 0x02, 0x02, 0x08, 0x08, 0x40,
  0x11, 0x00, 0x48, 0x00, 0xA0, 0x03, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x1C, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x7F, 0xFC, 0x01, 0x81, 0x01, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x03, 0x06, 0x00, 0xC0, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x80,
  0x20, 0xFF, 0xFF, 0xFE, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x0C, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x10, 0x30, 0x00, 0x7C,
  0x06, 0x08, 0x18, 0x10, 0x60, 0x3E,
};

const GFXglyph RobotoMono_Thin27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 19, 16, 7, -19 },
  { 6, 4, 5, 16, 6, -20 },
  { 9, 15, 19, 16, 1, -19 },
  { 45, 11, 25, 16, 3, -22 },
  { 80, 15, 19, 16, 1, -19 },
  { 116, 13, 19, 16, 2, -19 },
  { 147, 1, 5, 16, 7, -20 },
  { 148, 6, 27, 16, 5, -21 },
  { 169, 6, 27, 16, 5, -21 },
  { 190, 11, 10, 16, 3, -19 },
  { 204, 13, 14, 16, 2, -16 },
  { 227, 2, 5, 16, 5, -2 },
  { 229, 10, 1, 16, 3, -9 },
  { 231, 1, 1, 16, 8, -1 },
  { 232, 9, 21, 16, 4, -19 },
  { 256, 12, 19, 16, 2, -19 },
  { 285, 6, 19, 16, 3, -19 },
  { 300, 12, 19, 16, 1, -19 },
  { 329, 12, 19, 16, 1, -19 },
  { 358, 14, 19, 16, 1, -19 },
  { 392, 11, 19, 16, 3, -19 },
  { 419, 12, 19, 16, 2, -19 },
  { 448, 12, 19, 16, 2, -19 },
  { 477, 13, 19, 16, 2, -19 },
  { 508, 12, 19, 16, 2, -19 },
  { 537, 1, 13, 16, 9, -13 },
  { 539, 2, 16, 16, 8, -13 },
  { 543, 12, 11, 16, 2, -14 },
  { 560, 12, 6, 16, 2, -12 },
  { 569, 12, 11, 16, 2, -14 },
  { 586, 10, 19, 16, 3, -19 },
  { 610, 14, 19, 16, 1, -19 },
  { 644, 13, 19, 16, 2, -19 },
  { 675, 11, 19, 16, 3, -19 },
  { 702, 12, 19, 16, 2, -19 },
  { 731, 12, 19, 16, 3, -19 },
  { 760, 11, 19, 16, 3, -19 },
  { 787, 11, 19, 16, 3, -19 },
  { 814, 12, 19, 16, 2, -19 },
  { 843, 12, 19, 16, 2, -19 },
  { 872, 10, 19, 16, 3, -19 },
  { 896, 11, 19, 16, 2, -19 },
  { 923, 12, 19, 16, 3, -19 },
  { 952, 11, 19, 16, 3, -19 },
  { 979, 12, 19, 16, 2, -19 },
  { 1008, 12, 19, 16, 2, -19 },
  { 1037, 12, 19, 16, 2, -19 },
  { 1066, 12, 19, 16, 3, -19 },
  { 1095, 13, 22, 16, 2, -19 },
  { 1131, 12, 19, 16, 3, -19 },
  { 1160, 12, 19, 16, 2, -19 },
  { 1189, 14, 19, 16, 1, -19 },
  { 1223, 12, 19, 16, 2, -19 },
  { 1252, 14, 19, 16, 1, -19 },
  { 1286, 14, 19, 16, 1, -19 },
  { 1320, 13, 19, 16, 2, -19 },
  { 1351, 14, 19, 16, 1, -19 },
  { 1385, 12, 19, 16, 2, -19 },
  { 1414, 4, 26, 16, 6, -22 },
  { 1427, 9, 21, 16, 4, -19 },
  { 1451, 4, 26, 16, 6, -22 },
  { 1464, 10, 10, 16, 3, -19 },
  { 1477, 11, 1, 16, 3, 0 },
  { 1479, 4, 4, 16, 6, -20 },
  { 1481, 12, 15, 16, 2, -15 },
  { 1504, 11, 20, 16, 3, -20 },
  { 1532, 12, 15, 16, 2, -15 },
  { 1555, 11, 20, 16, 2, -20 },
  { 1583, 12, 15, 16, 2, -15 },
  { 1606, 12, 21, 16, 3, -21 },
  { 1638, 11, 21, 16, 2, -15 },
  { 1667, 11, 20, 16, 3, -20 },
  { 1695, 11, 19, 16, 3, -19 },
  { 1722, 9, 25, 16, 2, -19 },
  { 1751, 11, 20, 16, 3, -20 },
  { 1779, 11, 20, 16, 3, -20 },
  { 1807, 14, 15, 16, 1, -15 },
  { 1834, 11, 15, 16, 3, -15 },
  { 1855, 12, 15, 16, 2, -15 },
  { 1878, 11, 20, 16, 3, -15 },
  { 1906, 11, 20, 16, 2, -15 },
  { 1934, 9, 15, 16, 5, -15 },
  { 1951, 11, 15, 16, 3, -15 },
  { 1972, 10, 18, 16, 3, -18 },
  { 1995, 10, 14, 16, 3, -14 },
  { 2013, 13, 14, 16, 2, -14 },
  { 2036, 14, 14, 16, 1, -14 },
  { 2061, 13, 14, 16, 2, -14 },
  { 2084, 14, 20, 16, 1, -14 },
  { 2119, 13, 14, 16, 2, -14 },
  { 2142, 9, 27, 16, 4, -21 },
  { 2173, 1, 23, 16, 8, -19 },
  { 2176, 9, 27, 16, 4, -21 },
  { 2207, 14, 4, 16, 1, -10 },
};

const GFXfont RobotoMono_Thin27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin27pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_THIN27PT7B_H_
