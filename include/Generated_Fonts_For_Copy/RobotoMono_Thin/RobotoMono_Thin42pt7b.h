#ifndef _ROBOTOMONO_THIN42PT7B_H_
#define _ROBOTOMONO_THIN42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin42pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x50, 0x00, 0xF0, 0xC7, 0x8F, 0x1E,
  0x18, 0x70, 0xE1, 0xC2, 0x84, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x40, 0x01,
  0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x10,
  0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40, 0x7F, 0xFF, 0xFC, 0x02, 0x03,
  0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20,
  0x00, 0x80, 0x40, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x04, 0x00,
  0x10, 0x08, 0x00, 0x20, 0x10, 0x1F, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x03,
  0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20,
  0x20, 0x00, 0x40, 0x40, 0x01, 0x80, 0x80, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x03, 0x01, 0x81, 0x00, 0x30,
  0x80, 0x04, 0x60, 0x00, 0x90, 0x00, 0x24, 0x00, 0x0D, 0x00, 0x01, 0x40,
  0x00, 0x50, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x50, 0x00, 0x26, 0x00, 0x08, 0xC0, 0x04, 0x18, 0x06, 0x01, 0xFF,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x3E, 0x00,
  0x00, 0xC2, 0x00, 0x01, 0x02, 0x00, 0x04, 0x04, 0x02, 0x08, 0x0C, 0x04,
  0x10, 0x08, 0x10, 0x20, 0x10, 0x20, 0x40, 0x20, 0x80, 0x80, 0x41, 0x01,
  0x01, 0x04, 0x01, 0x02, 0x18, 0x03, 0x0C, 0x20, 0x03, 0xF0, 0xC0, 0x01,
  0x81, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x41, 0xF0, 0x01, 0x04, 0x10, 0x02, 0x10, 0x30, 0x08, 0x20, 0x20, 0x30,
  0xC0, 0x40, 0x41, 0x80, 0x81, 0x83, 0x01, 0x02, 0x06, 0x02, 0x08, 0x0C,
  0x04, 0x10, 0x08, 0x08, 0x00, 0x10, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x30, 0xC0, 0x02, 0x03, 0x00, 0x10, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x01, 0x80, 0x18, 0x08,
  0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x08, 0x80, 0x00, 0x78, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0x90, 0x00, 0x18, 0x40, 0x01, 0x83, 0x00,
  0x88, 0x0C, 0x04, 0x80, 0x20, 0x24, 0x00, 0x83, 0x60, 0x02, 0x12, 0x00,
  0x08, 0x98, 0x00, 0x6C, 0x40, 0x01, 0xC2, 0x00, 0x06, 0x18, 0x00, 0x70,
  0x60, 0x06, 0x41, 0x80, 0xC1, 0x07, 0xFC, 0x0C, 0xFF, 0x80, 0x00, 0x80,
  0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0xC0,
  0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x20, 0x20, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x20,
  0x10, 0x1F, 0x04, 0x3C, 0x79, 0x38, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x1A,
  0x00, 0x0C, 0x40, 0x02, 0x08, 0x01, 0x03, 0x00, 0x80, 0x60, 0x60, 0x0C,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x55, 0x5A,
  0xFF, 0xFE, 0xF8, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x07, 0xF0, 0x06, 0x03, 0x03, 0x00, 0x60, 0x80, 0x0C, 0x40, 0x01,
  0x10, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0xA0, 0x00, 0xB8,
  0x00, 0x46, 0x00, 0x21, 0x80, 0x10, 0x60, 0x08, 0x18, 0x04, 0x06, 0x02,
  0x01, 0x81, 0x00, 0x60, 0x80, 0x18, 0x40, 0x06, 0x20, 0x01, 0x90, 0x00,
  0xE8, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0x40, 0x01, 0x90, 0x00, 0x42,
  0x00, 0x30, 0xC0, 0x18, 0x18, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0xF0,
  0xEC, 0xC3, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x07,
  0xF8, 0x01, 0x81, 0x80, 0x40, 0x0C, 0x10, 0x00, 0x86, 0x00, 0x18, 0x80,
  0x01, 0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xF8, 0x01, 0x80, 0xC0, 0x40, 0x0C, 0x10, 0x00, 0xC6, 0x00, 0x08, 0x80,
  0x01, 0x90, 0x00, 0x12, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x08, 0x80, 0x02, 0x18, 0x00, 0xC0, 0xC0, 0x30, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xB0,
  0x00, 0x09, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x43, 0x00, 0x04,
  0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x30, 0x02, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x10, 0x03, 0x01, 0x80, 0x18, 0x08, 0x00,
  0xC0, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x7F, 0xFF, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0x90, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x7C, 0x05, 0xC3, 0x83, 0x00, 0x61,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x20,
  0x00, 0x98, 0x00, 0xC4, 0x00, 0xC1, 0x80, 0xC0, 0x7F, 0xC0, 0x00, 0x3E,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x06, 0x01, 0x1F,
  0xF0, 0x48, 0x06, 0x2C, 0x00, 0x4A, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0xC8, 0x00, 0x23, 0x00, 0x18, 0x60,
  0x0C, 0x0C, 0x06, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x03, 0x81, 0xC0, 0xC0,
  0x0C, 0x10, 0x00, 0xC4, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x16, 0x00,
  0x02, 0xC0, 0x00, 0x48, 0x00, 0x19, 0x00, 0x02, 0x10, 0x00, 0xC3, 0x00,
  0x30, 0x18, 0x1C, 0x01, 0xFE, 0x00, 0x78, 0xE0, 0x30, 0x03, 0x0C, 0x00,
  0x31, 0x00, 0x03, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x58, 0x00, 0x09, 0x00, 0x02, 0x10, 0x00,
  0xC1, 0x80, 0x70, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0x80, 0xC0, 0x60,
  0x0C, 0x18, 0x00, 0x82, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x12, 0x00,
  0x02, 0xC0, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x06, 0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x07, 0x20, 0x01, 0xE2, 0x00,
  0x68, 0x30, 0x19, 0x03, 0xFC, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x22,
  0x64, 0x4C, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x30, 0x30, 0x80, 0x32,
  0x00, 0x34, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x03, 0x81, 0xC0, 0x0C, 0x00, 0xC0,
  0x20, 0x00, 0xC0, 0x80, 0x00, 0x83, 0x00, 0x01, 0x8C, 0x07, 0x81, 0x10,
  0x31, 0x82, 0x20, 0xC1, 0x86, 0x81, 0x02, 0x05, 0x04, 0x04, 0x0A, 0x08,
  0x08, 0x1C, 0x10, 0x10, 0x30, 0x40, 0x20, 0x60, 0x80, 0x40, 0xC1, 0x00,
  0x81, 0x82, 0x01, 0x03, 0x04, 0x06, 0x06, 0x08, 0x0C, 0x1C, 0x10, 0x18,
  0x28, 0x20, 0x50, 0x48, 0x21, 0xA1, 0x90, 0x42, 0x42, 0x20, 0x78, 0x78,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x02, 0x30,
  0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x08, 0x30, 0x00, 0x40, 0x80, 0x02,
  0x04, 0x00, 0x20, 0x30, 0x01, 0x00, 0x80, 0x08, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x30, 0x10, 0x00, 0x80, 0xFF,
  0xFC, 0x08, 0x00, 0x30, 0x40, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x31,
  0x00, 0x00, 0x88, 0x00, 0x04, 0x80, 0x00, 0x34, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0xFF, 0xC0, 0x30, 0x0E, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01,
  0x30, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C,
  0x00, 0x1B, 0x00, 0x04, 0xC0, 0x02, 0x30, 0x03, 0x0F, 0xFF, 0x03, 0x00,
  0x38, 0xC0, 0x03, 0x30, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0B, 0x00, 0x0C, 0xC0, 0x0E, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x01,
  0xC0, 0xC0, 0x60, 0x04, 0x08, 0x00, 0x42, 0x00, 0x0C, 0xC0, 0x00, 0x90,
  0x00, 0x1A, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x50, 0x00, 0x0A, 0x00, 0x03, 0x60, 0x00, 0x44, 0x00, 0x18, 0x40,
  0x02, 0x0C, 0x00, 0x80, 0xC0, 0x60, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x10,
  0x0F, 0x02, 0x00, 0x30, 0x40, 0x03, 0x08, 0x00, 0x31, 0x00, 0x03, 0x20,
  0x00, 0x24, 0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00,
  0x00, 0xA0, 0x00, 0x34, 0x00, 0x04, 0x80, 0x01, 0x90, 0x00, 0x22, 0x00,
  0x08, 0x40, 0x06, 0x08, 0x03, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFC, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0xFF, 0xF9, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xC0, 0xC0, 0x60, 0x04, 0x18, 0x00, 0x42, 0x00,
  0x0C, 0xC0, 0x00, 0x90, 0x00, 0x1A, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x60, 0x00,
  0x24, 0x00, 0x04, 0x40, 0x00, 0x8C, 0x00, 0x30, 0xE0, 0x18, 0x07, 0xFC,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0x80,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xB0, 0x00, 0x44,
  0x00, 0x30, 0x80, 0x18, 0x18, 0x0C, 0x03, 0xFC, 0x00, 0x80, 0x00, 0xD0,
  0x00, 0x32, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x10, 0x20,
  0x04, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x18, 0x02, 0x06, 0x00, 0x41,
  0x80, 0x08, 0x60, 0x01, 0x18, 0x00, 0x27, 0x80, 0x05, 0x90, 0x00, 0xA1,
  0x00, 0x18, 0x10, 0x02, 0x03, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00,
  0x20, 0x20, 0x02, 0x04, 0x00, 0x60, 0x80, 0x06, 0x10, 0x00, 0x42, 0x00,
  0x04, 0x40, 0x00, 0x48, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFF,
  0xFC, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x16, 0x80, 0x05, 0xA0, 0x03,
  0x68, 0x00, 0x99, 0x00, 0x26, 0x40, 0x11, 0x98, 0x04, 0x62, 0x03, 0x18,
  0x80, 0x86, 0x10, 0x21, 0x84, 0x10, 0x61, 0x84, 0x18, 0x23, 0x06, 0x08,
  0x81, 0x81, 0x20, 0x60, 0x50, 0x18, 0x14, 0x06, 0x02, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x80, 0x03, 0xA0, 0x00, 0xE4, 0x00, 0x39, 0x00,
  0x0E, 0x20, 0x03, 0x88, 0x00, 0xE1, 0x00, 0x38, 0x60, 0x0E, 0x08, 0x03,
  0x81, 0x00, 0xE0, 0x40, 0x38, 0x08, 0x0E, 0x02, 0x03, 0x80, 0x40, 0xE0,
  0x18, 0x38, 0x02, 0x0E, 0x00, 0x41, 0x80, 0x10, 0x60, 0x02, 0x18, 0x00,
  0x86, 0x00, 0x11, 0x80, 0x06, 0x60, 0x00, 0x98, 0x00, 0x16, 0x00, 0x05,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x0C,
  0x08, 0x00, 0xC2, 0x00, 0x08, 0xC0, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x1A,
  0x00, 0x02, 0x60, 0x00, 0x44, 0x00, 0x10, 0x40, 0x06, 0x0C, 0x01, 0x80,
  0xC0, 0x60, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x20, 0x07, 0x08, 0x00, 0x22,
  0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xA0, 0x00,
  0x68, 0x00, 0x32, 0x00, 0x18, 0xFF, 0xF8, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x30, 0x18, 0x03, 0x00, 0x20, 0x30, 0x00, 0x81,
  0x00, 0x06, 0x10, 0x00, 0x10, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00,
  0x12, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00,
  0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x20, 0x80, 0x01, 0x06, 0x00, 0x10,
  0x18, 0x01, 0x00, 0x60, 0x30, 0x00, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0xFF, 0xC0, 0x20,
  0x0E, 0x08, 0x00, 0xC2, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00, 0x48, 0x00,
  0x12, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x60, 0xFF, 0xE0, 0x20,
  0x08, 0x08, 0x02, 0x02, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00,
  0xC2, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x12, 0x00, 0x06,
  0x80, 0x00, 0xA0, 0x00, 0x30, 0x03, 0xFC, 0x00, 0xE0, 0x70, 0x18, 0x01,
  0x82, 0x00, 0x0C, 0x20, 0x00, 0x44, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x80, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00,
  0x61, 0x00, 0x0C, 0x0C, 0x03, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x02, 0xC0, 0x00, 0x90,
  0x00, 0x46, 0x00, 0x30, 0xC0, 0x18, 0x18, 0x0C, 0x01, 0xFE, 0x00, 0x80,
  0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x22, 0x00, 0x02,
  0x10, 0x00, 0x10, 0x80, 0x00, 0x82, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80,
  0x02, 0x02, 0x00, 0x20, 0x10, 0x01, 0x00, 0x80, 0x08, 0x06, 0x00, 0xC0,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x06, 0x03, 0x00, 0x10, 0x10, 0x00, 0x80,
  0x80, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x06, 0x30, 0x00,
  0x11, 0x00, 0x00, 0x88, 0x00, 0x06, 0xC0, 0x00, 0x14, 0x00, 0x00, 0xA0,
  0x00, 0x05, 0x00, 0x00, 0x10, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x50, 0x0C, 0x01, 0x40, 0x30, 0x09, 0x01, 0xA0, 0x24, 0x04,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x81, 0x20, 0x22, 0x0C, 0xC1,
  0x08, 0x21, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x0C,
  0x61, 0x84, 0x11, 0x02, 0x20, 0x44, 0x08, 0x81, 0x10, 0x22, 0x04, 0x40,
  0x88, 0x13, 0x03, 0x20, 0x48, 0x04, 0x80, 0xA0, 0x16, 0x02, 0x80, 0x50,
  0x0A, 0x01, 0x40, 0x28, 0x07, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x04,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00,
  0x62, 0x00, 0x04, 0x10, 0x00, 0x81, 0x80, 0x18, 0x08, 0x01, 0x00, 0x40,
  0x20, 0x06, 0x06, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00, 0x11, 0x80, 0x00,
  0x90, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x90, 0x00,
  0x09, 0x00, 0x01, 0x08, 0x00, 0x30, 0xC0, 0x02, 0x04, 0x00, 0x40, 0x20,
  0x0C, 0x03, 0x00, 0x80, 0x10, 0x10, 0x00, 0x83, 0x00, 0x0C, 0x20, 0x00,
  0x44, 0x00, 0x06, 0x40, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x90, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x04, 0x08, 0x00, 0x20,
  0x60, 0x02, 0x01, 0x00, 0x10, 0x0C, 0x01, 0x00, 0x20, 0x18, 0x01, 0x80,
  0x80, 0x04, 0x0C, 0x00, 0x30, 0x40, 0x00, 0x86, 0x00, 0x06, 0x20, 0x00,
  0x12, 0x00, 0x00, 0x50, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0xFC,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x7F, 0x01, 0x00, 0x03, 0x00, 0x0A, 0x00, 0x16,
  0x00, 0x44, 0x00, 0x88, 0x03, 0x08, 0x04, 0x10, 0x08, 0x30, 0x20, 0x20,
  0x40, 0x41, 0x80, 0x42, 0x00, 0x84, 0x01, 0x90, 0x01, 0x60, 0x03, 0xFF,
  0xFF, 0x80, 0xC3, 0x08, 0x21, 0x80, 0x01, 0xC0, 0x03, 0xFF, 0x01, 0x80,
  0x60, 0x80, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x6C, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x3F, 0xFE, 0x38, 0x00, 0x98,
  0x00, 0x2C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x1A, 0x00, 0x0A, 0x40, 0x06, 0x88, 0x06, 0x21, 0xFE, 0x0C, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x80, 0x23, 0xFC, 0x16, 0x01, 0x0E,
  0x00, 0x46, 0x00, 0x12, 0x00, 0x09, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x4C, 0x00, 0x67,
  0x00, 0x22, 0xC0, 0x61, 0x1F, 0xE0, 0x00, 0xC0, 0x03, 0xFC, 0x06, 0x01,
  0x86, 0x00, 0x66, 0x00, 0x12, 0x00, 0x05, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x24, 0x00,
  0x23, 0x00, 0x30, 0xC0, 0x30, 0x1F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x60, 0xC3, 0xFC, 0x63, 0x01, 0xB2, 0x00, 0x7B, 0x00,
  0x1D, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x36, 0x00, 0x39, 0x80, 0x3C, 0x60,
  0x36, 0x0F, 0xE3, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x30, 0x0C, 0x0C, 0x00,
  0xC3, 0x00, 0x08, 0x40, 0x00, 0x98, 0x00, 0x12, 0x00, 0x03, 0x40, 0x00,
  0x28, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x20, 0x80, 0x0C, 0x0C, 0x03, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xFE,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x07, 0xF8, 0x46, 0x03, 0x26, 0x00, 0xD6, 0x00,
  0x2A, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x73, 0x00, 0x68, 0xC0,
  0x64, 0x1F, 0xC2, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x48,
  0x00, 0x66, 0x00, 0x21, 0x80, 0x20, 0x70, 0xE0, 0x0F, 0xC0, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x70, 0x30, 0xFF, 0x19, 0x80, 0xCD,
  0x80, 0x17, 0x80, 0x0B, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x07, 0xFF, 0xFC, 0x00, 0x30,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x01, 0xC3,
  0xF8, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0xD0, 0x00, 0xC8, 0x00, 0xC4, 0x00, 0x82, 0x00, 0x81, 0x01, 0x80,
  0x81, 0x80, 0x41, 0x80, 0x21, 0x80, 0x11, 0x80, 0x09, 0x60, 0x05, 0x18,
  0x03, 0x06, 0x01, 0x01, 0x80, 0x80, 0x60, 0x40, 0x10, 0x20, 0x04, 0x10,
  0x01, 0x08, 0x00, 0x44, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x01, 0xFF, 0xFF, 0x06, 0x00, 0xC4, 0xFC, 0x3B, 0xA8,
  0x12, 0x07, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x00, 0xE0, 0x41, 0xFE, 0x23,
  0x01, 0x93, 0x00, 0x2B, 0x00, 0x15, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x40, 0x00, 0xFF,
  0x80, 0x30, 0x18, 0x08, 0x00, 0xC2, 0x00, 0x08, 0xC0, 0x00, 0x90, 0x00,
  0x12, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x40, 0x00,
  0x68, 0x00, 0x09, 0x80, 0x03, 0x18, 0x00, 0x41, 0x80, 0x10, 0x18, 0x0C,
  0x00, 0xFF, 0x00, 0x01, 0x80, 0x47, 0xF8, 0x2C, 0x06, 0x1C, 0x00, 0x8C,
  0x00, 0x64, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0x98, 0x00, 0xCE, 0x00, 0xC5,
  0x80, 0xC2, 0x3F, 0xC1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x07, 0xF8, 0x46, 0x03, 0x26, 0x00, 0xD6, 0x00, 0x3A, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x50, 0x00, 0x6C, 0x00, 0x73, 0x00, 0x68, 0xC0, 0x64, 0x1F, 0xC2,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x7A, 0x0F, 0xF8, 0xC0,
  0x24, 0x00, 0xA0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0x01, 0x00, 0x30, 0x80, 0x06, 0x40, 0x00, 0x90,
  0x00, 0x24, 0x00, 0x0D, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x02, 0x60, 0x01, 0x8E,
  0x01, 0xC0, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x03, 0xFF, 0xFC, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0xF0, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02,
  0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0xE4, 0x00, 0xD1, 0x80,
  0xC8, 0x7F, 0x84, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x40,
  0x00, 0x43, 0x00, 0x06, 0x08, 0x00, 0x20, 0x60, 0x01, 0x01, 0x00, 0x10,
  0x08, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x20,
  0x20, 0x01, 0x81, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x00, 0x88, 0x00,
  0x04, 0x40, 0x00, 0x36, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0x00, 0x80, 0x20, 0x06, 0x00, 0xC0, 0x38, 0x03, 0x00, 0xB0, 0x14, 0x02,
  0x40, 0x50, 0x09, 0x01, 0x20, 0x24, 0x04, 0x81, 0x18, 0x22, 0x04, 0x20,
  0x88, 0x10, 0x82, 0x10, 0x42, 0x08, 0x43, 0x08, 0x41, 0x08, 0x31, 0x04,
  0x20, 0x44, 0x08, 0x81, 0x10, 0x26, 0x04, 0x80, 0x90, 0x1A, 0x02, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x00, 0x62, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x80, 0x10,
  0x0C, 0x02, 0x00, 0x60, 0x60, 0x02, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x90,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x90, 0x00, 0x11,
  0x80, 0x03, 0x0C, 0x00, 0x60, 0x40, 0x0C, 0x02, 0x00, 0x80, 0x10, 0x10,
  0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0x4C, 0x00, 0x03, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0xD0, 0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x18, 0x00,
  0x30, 0x40, 0x01, 0x03, 0x00, 0x08, 0x08, 0x00, 0x80, 0x60, 0x04, 0x01,
  0x00, 0x60, 0x0C, 0x02, 0x00, 0x20, 0x30, 0x01, 0x01, 0x00, 0x04, 0x18,
  0x00, 0x20, 0x80, 0x00, 0x84, 0x00, 0x04, 0x40, 0x00, 0x12, 0x00, 0x00,
  0xB0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x30, 0x0F, 0x00,
  0x70, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x80, 0x1C, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x71, 0x80, 0x0C, 0x81, 0x80, 0x12, 0x00, 0x80,
  0x24, 0x00, 0xC0, 0xC8, 0x00, 0xC3, 0x30, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoMono_Thin42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 2, 30, 25, 11, -30 },
  { 9, 7, 9, 25, 9, -32 },
  { 17, 23, 30, 25, 1, -30 },
  { 104, 18, 38, 25, 4, -34 },
  { 190, 23, 30, 25, 1, -30 },
  { 277, 21, 30, 25, 3, -30 },
  { 356, 1, 9, 25, 11, -32 },
  { 358, 9, 43, 25, 8, -33 },
  { 407, 9, 43, 25, 7, -33 },
  { 456, 18, 16, 25, 4, -30 },
  { 492, 21, 22, 25, 2, -25 },
  { 550, 2, 8, 25, 9, -3 },
  { 552, 15, 1, 25, 5, -14 },
  { 554, 3, 2, 25, 12, -2 },
  { 555, 14, 33, 25, 6, -30 },
  { 613, 18, 30, 25, 4, -30 },
  { 681, 10, 30, 25, 5, -30 },
  { 719, 19, 30, 25, 2, -30 },
  { 791, 19, 30, 25, 2, -30 },
  { 863, 21, 30, 25, 2, -30 },
  { 942, 17, 30, 25, 5, -30 },
  { 1006, 18, 30, 25, 3, -30 },
  { 1074, 19, 30, 25, 3, -30 },
  { 1146, 19, 30, 25, 4, -30 },
  { 1218, 19, 30, 25, 3, -30 },
  { 1290, 3, 20, 25, 13, -20 },
  { 1298, 4, 25, 25, 12, -20 },
  { 1311, 18, 17, 25, 3, -22 },
  { 1350, 18, 9, 25, 4, -18 },
  { 1371, 18, 17, 25, 4, -22 },
  { 1410, 15, 30, 25, 5, -30 },
  { 1467, 23, 30, 25, 1, -30 },
  { 1554, 21, 30, 25, 2, -30 },
  { 1633, 18, 30, 25, 4, -30 },
  { 1701, 19, 30, 25, 3, -30 },
  { 1773, 19, 30, 25, 4, -30 },
  { 1845, 16, 30, 25, 5, -30 },
  { 1905, 17, 30, 25, 5, -30 },
  { 1969, 19, 30, 25, 3, -30 },
  { 2041, 18, 30, 25, 4, -30 },
  { 2109, 17, 30, 25, 4, -30 },
  { 2173, 18, 30, 25, 3, -30 },
  { 2241, 19, 30, 25, 5, -30 },
  { 2313, 17, 30, 25, 5, -30 },
  { 2377, 18, 30, 25, 4, -30 },
  { 2445, 18, 30, 25, 4, -30 },
  { 2513, 19, 30, 25, 3, -30 },
  { 2585, 18, 30, 25, 5, -30 },
  { 2653, 21, 35, 25, 2, -30 },
  { 2745, 18, 30, 25, 5, -30 },
  { 2813, 20, 30, 25, 3, -30 },
  { 2888, 21, 30, 25, 2, -30 },
  { 2967, 18, 30, 25, 4, -30 },
  { 3035, 21, 30, 25, 2, -30 },
  { 3114, 22, 30, 25, 2, -30 },
  { 3197, 20, 30, 25, 3, -30 },
  { 3272, 21, 30, 25, 2, -30 },
  { 3351, 18, 30, 25, 3, -30 },
  { 3419, 6, 40, 25, 10, -34 },
  { 3449, 13, 33, 25, 6, -30 },
  { 3503, 6, 40, 25, 9, -34 },
  { 3533, 15, 16, 25, 5, -30 },
  { 3563, 17, 1, 25, 4, 0 },
  { 3566, 5, 5, 25, 10, -31 },
  { 3570, 18, 23, 25, 4, -23 },
  { 3622, 17, 32, 25, 5, -32 },
  { 3690, 17, 23, 25, 4, -23 },
  { 3739, 17, 32, 25, 4, -32 },
  { 3807, 19, 23, 25, 3, -23 },
  { 3862, 19, 32, 25, 4, -32 },
  { 3938, 17, 32, 25, 4, -23 },
  { 4006, 17, 32, 25, 4, -32 },
  { 4074, 17, 30, 25, 5, -30 },
  { 4138, 13, 39, 25, 4, -30 },
  { 4202, 17, 32, 25, 5, -32 },
  { 4270, 17, 32, 25, 5, -32 },
  { 4338, 21, 23, 25, 2, -23 },
  { 4399, 17, 23, 25, 4, -23 },
  { 4448, 19, 23, 25, 3, -23 },
  { 4503, 17, 32, 25, 5, -23 },
  { 4571, 17, 32, 25, 4, -23 },
  { 4639, 14, 23, 25, 8, -23 },
  { 4680, 18, 23, 25, 4, -23 },
  { 4732, 17, 28, 25, 4, -28 },
  { 4792, 17, 22, 25, 4, -22 },
  { 4839, 21, 22, 25, 2, -22 },
  { 4897, 22, 22, 25, 2, -22 },
  { 4958, 20, 22, 25, 3, -22 },
  { 5013, 21, 31, 25, 2, -22 },
  { 5095, 20, 22, 25, 3, -22 },
  { 5150, 13, 42, 25, 7, -33 },
  { 5219, 1, 36, 25, 12, -30 },
  { 5224, 13, 42, 25, 7, -33 },
  { 5293, 23, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_Thin42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin42pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_THIN42PT7B_H_
