#ifndef _ROBOTOMONO_THIN55PT7B_H_
#define _ROBOTOMONO_THIN55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin55pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60,
  0x00, 0x00, 0x0D, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x2C, 0x16, 0x0B, 0x05,
  0x82, 0xC1, 0x60, 0xB0, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x30, 0x02, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x10, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x08, 0x01, 0x80, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x03, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x30, 0x02,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x80, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x20,
  0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x04, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x38, 0x07, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x08, 0x03, 0x00, 0x20, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x04, 0x01, 0x00,
  0xC0, 0x08, 0x06, 0x01, 0x80, 0x10, 0x08, 0x03, 0x00, 0x20, 0x30, 0x06,
  0x00, 0x40, 0x40, 0x0C, 0x01, 0x81, 0x80, 0x08, 0x03, 0x06, 0x00, 0x18,
  0x04, 0x0C, 0x00, 0x10, 0x18, 0x30, 0x00, 0x38, 0x60, 0x40, 0x00, 0x3F,
  0x81, 0x80, 0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03,
  0x03, 0xF8, 0x00, 0x0C, 0x0C, 0x18, 0x00, 0x10, 0x30, 0x10, 0x00, 0x60,
  0x40, 0x30, 0x00, 0x81, 0x80, 0x20, 0x03, 0x03, 0x00, 0x60, 0x04, 0x04,
  0x00, 0xC0, 0x18, 0x08, 0x01, 0x80, 0x20, 0x10, 0x03, 0x00, 0xC0, 0x20,
  0x06, 0x03, 0x00, 0x40, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x01, 0x80,
  0x20, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x08, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x04, 0x30, 0x06, 0x00, 0x42,
  0x00, 0x30, 0x0C, 0x60, 0x01, 0x00, 0xC4, 0x00, 0x18, 0x0C, 0x40, 0x00,
  0xC0, 0x8C, 0x00, 0x06, 0x18, 0xC0, 0x00, 0x31, 0x8C, 0x00, 0x01, 0x90,
  0x40, 0x00, 0x0B, 0x04, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x02, 0x00,
  0x00, 0xF0, 0x30, 0x00, 0x19, 0x81, 0xC0, 0x07, 0x0C, 0x0F, 0x01, 0xC0,
  0x40, 0x3F, 0xF0, 0x07, 0x00, 0x10, 0x00, 0x00, 0x55, 0x55, 0x5C, 0x00,
  0x20, 0x03, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x20, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x60, 0x08, 0x07, 0xF8, 0x10, 0x7C, 0x3E, 0x23,
  0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x80,
  0x00, 0x31, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x03, 0x01, 0x80, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x11, 0x11, 0x33, 0x32,
  0x6C, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x20, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x80, 0x00, 0x1A, 0x80,
  0x00, 0x32, 0x80, 0x00, 0x62, 0x80, 0x00, 0xC3, 0x80, 0x01, 0x83, 0x80,
  0x03, 0x03, 0x80, 0x06, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x60, 0x03, 0x80, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x83,
  0x00, 0x03, 0x86, 0x00, 0x02, 0x8C, 0x00, 0x02, 0x98, 0x00, 0x02, 0xF0,
  0x00, 0x02, 0xE0, 0x00, 0x06, 0x40, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x07, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x03, 0xC0, 0x72, 0x0E, 0x13, 0xC0, 0xF8, 0x07, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x80, 0x07, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x18, 0x00, 0x30, 0x30, 0x00, 0x18, 0x60, 0x00, 0x08,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x00, 0xE0,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x07, 0x00, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x10, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x04,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0x00, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x10, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xFF, 0xFC, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x11, 0xFF, 0x80, 0x2E, 0x01, 0xC0,
  0x70, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x60, 0x00, 0x0C, 0x40, 0x00,
  0x10, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x06, 0x00, 0xE0, 0x38,
  0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x3E, 0x00, 0x41, 0xFF, 0xC0, 0x47, 0x00, 0xE0, 0x4C, 0x00, 0x30,
  0xD8, 0x00, 0x18, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x30,
  0x03, 0x80, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x01, 0x81, 0x80, 0x00, 0x60, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x23, 0x00, 0x00, 0x10, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x38, 0x03, 0x80, 0x70, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x3C, 0x03,
  0xC0, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60,
  0x00, 0x02, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x07, 0x30,
  0x00, 0x05, 0x18, 0x00, 0x0D, 0x18, 0x00, 0x19, 0x0E, 0x00, 0x71, 0x03,
  0x81, 0xC3, 0x01, 0xFF, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x6F,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F,
  0x60, 0x18, 0xF1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x10, 0x41, 0x04, 0x30, 0xC2,
  0x18, 0xC1, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1C, 0x03, 0x03, 0x00, 0x18, 0x20,
  0x00, 0xC6, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x03, 0xF0, 0x08, 0x30, 0x1C, 0x30, 0x18, 0xC0, 0x60, 0x30, 0x31,
  0x80, 0x80, 0x20, 0x22, 0x03, 0x00, 0xC0, 0x4C, 0x04, 0x01, 0x80, 0x98,
  0x18, 0x03, 0x01, 0x30, 0x30, 0x04, 0x02, 0x40, 0x40, 0x08, 0x04, 0x80,
  0x80, 0x10, 0x09, 0x03, 0x00, 0x20, 0x12, 0x06, 0x00, 0x40, 0x2C, 0x0C,
  0x00, 0x80, 0x58, 0x18, 0x03, 0x00, 0xB0, 0x30, 0x06, 0x01, 0x60, 0x60,
  0x0C, 0x06, 0x40, 0xC0, 0x38, 0x0C, 0x81, 0x80, 0x70, 0x11, 0x03, 0x01,
  0xE0, 0x22, 0x02, 0x02, 0xC0, 0xC6, 0x06, 0x0C, 0x81, 0x0C, 0x04, 0x31,
  0x8E, 0x08, 0x0F, 0xC1, 0xF8, 0x18, 0x02, 0x00, 0x80, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x04,
  0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x18, 0x01, 0x80, 0x01, 0x00, 0x18, 0x00, 0x10, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x00, 0x40, 0x00, 0x20, 0x0F, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x30, 0x08, 0x00, 0x01, 0x01, 0x80, 0x00, 0x10, 0x18, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFC, 0x01, 0x00, 0x1F, 0x02,
  0x00, 0x07, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x03, 0x20,
  0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00,
  0x06, 0x40, 0x00, 0x18, 0x80, 0x00, 0x61, 0x00, 0x03, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x08, 0x00, 0x0E, 0x10, 0x00, 0x06, 0x20, 0x00, 0x06,
  0x40, 0x00, 0x06, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x64, 0x00,
  0x01, 0xC8, 0x00, 0x06, 0x10, 0x01, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x20, 0x00, 0x03, 0x30, 0x00, 0x00, 0x90, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0x20, 0x00, 0x03, 0x18, 0x00, 0x01, 0x84, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x60,
  0x0F, 0x80, 0x30, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x13, 0x00, 0x00, 0x19, 0x80, 0x00, 0x08,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x30, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x44, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x30, 0x0F, 0x00, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x78, 0x00, 0x03, 0x33, 0x00, 0x00,
  0xD8, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xA0, 0x00, 0x0F, 0xA0, 0x00, 0x0F, 0xB0, 0x00, 0x0B, 0x90, 0x00,
  0x1B, 0x98, 0x00, 0x13, 0x98, 0x00, 0x33, 0x88, 0x00, 0x33, 0x8C, 0x00,
  0x23, 0x84, 0x00, 0x63, 0x86, 0x00, 0x43, 0x86, 0x00, 0xC3, 0x82, 0x00,
  0x83, 0x83, 0x00, 0x83, 0x81, 0x01, 0x83, 0x81, 0x01, 0x03, 0x81, 0x83,
  0x03, 0x80, 0x82, 0x03, 0x80, 0xC6, 0x03, 0x80, 0x46, 0x03, 0x80, 0x44,
  0x03, 0x80, 0x6C, 0x03, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0D, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x32, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xC4, 0x00, 0x01, 0x84, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x30, 0x30, 0x00, 0x60, 0x20, 0x00, 0xC0,
  0x20, 0x01, 0x80, 0x60, 0x03, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x01, 0x00, 0x60, 0x01, 0x00, 0xC0, 0x03,
  0x01, 0x80, 0x02, 0x03, 0x00, 0x06, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x08, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x11,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x26, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x58,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x20, 0x00,
  0x02, 0x30, 0x00, 0x01, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x06, 0x20, 0x00, 0x02, 0x18, 0x00, 0x03, 0x04, 0x00, 0x01, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x03, 0xE0,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x04, 0x06,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x38, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFC, 0x00, 0xC0, 0x0F, 0x80,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0xC0, 0x03, 0x80, 0xFF, 0xFE, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x20, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x38, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x04, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x03, 0x80, 0x03, 0x00, 0x78, 0x03, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00,
  0x02, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x60, 0xC0, 0x01,
  0x80, 0xC0, 0x06, 0x00, 0xE0, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x08, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x80, 0x05, 0x80,
  0x0E, 0x00, 0x2C, 0x00, 0x70, 0x03, 0x60, 0x07, 0x80, 0x19, 0x00, 0x34,
  0x00, 0x88, 0x01, 0x20, 0x04, 0x40, 0x09, 0x80, 0x23, 0x00, 0x4C, 0x01,
  0x18, 0x06, 0x60, 0x08, 0xC0, 0x31, 0x00, 0xC2, 0x01, 0x08, 0x06, 0x10,
  0x08, 0x40, 0x20, 0x80, 0x43, 0x01, 0x04, 0x06, 0x18, 0x08, 0x30, 0x30,
  0x40, 0x41, 0x81, 0x02, 0x06, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0xC1,
  0x01, 0x06, 0x06, 0x08, 0x08, 0x30, 0x10, 0x40, 0x61, 0x00, 0x82, 0x03,
  0x08, 0x04, 0x30, 0x08, 0x40, 0x31, 0x80, 0x46, 0x01, 0x88, 0x02, 0x30,
  0x0C, 0x40, 0x11, 0x00, 0x22, 0x00, 0xC8, 0x01, 0x10, 0x06, 0x40, 0x0D,
  0x80, 0x36, 0x00, 0x6C, 0x00, 0xB0, 0x03, 0x40, 0x05, 0x00, 0x0A, 0x00,
  0x28, 0x00, 0x50, 0x01, 0xC0, 0x02, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x00, 0x03, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0x80, 0x10,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x01, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x40, 0x00,
  0x1C, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00, 0x11, 0x00, 0x02, 0x30, 0x00,
  0xC6, 0x00, 0x10, 0x40, 0x06, 0x0C, 0x00, 0x80, 0x80, 0x30, 0x18, 0x06,
  0x03, 0x00, 0x80, 0x20, 0x30, 0x06, 0x04, 0x00, 0x41, 0x80, 0x0C, 0x30,
  0x01, 0x84, 0x00, 0x11, 0x80, 0x03, 0x20, 0x00, 0x2C, 0x00, 0x06, 0xFF,
  0xFF, 0xFE, 0xC0, 0xC0, 0x81, 0x81, 0x81, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0xE0, 0x01, 0x83, 0x00, 0x01, 0x84,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x7F, 0xFF, 0x03, 0xF0, 0x02, 0x1C, 0x00, 0x04, 0x60, 0x00,
  0x09, 0x80, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x50, 0x00, 0x00,
  0xA0, 0x00, 0x01, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x2D,
  0x80, 0x01, 0x99, 0x80, 0x06, 0x31, 0xC0, 0x38, 0x61, 0xFF, 0xC0, 0xC0,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x1C, 0x00,
  0x83, 0xFF, 0x02, 0x38, 0x0E, 0x09, 0x80, 0x0C, 0x2C, 0x00, 0x18, 0xA0,
  0x00, 0x33, 0x80, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0A, 0x00, 0x00,
  0x2C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xE0, 0x00, 0x32, 0xC0, 0x01, 0x89,
  0x80, 0x0C, 0x23, 0x80, 0xE0, 0x83, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x03, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x03, 0x81, 0x80,
  0x01, 0x86, 0x00, 0x01, 0x08, 0x00, 0x03, 0x30, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xD0, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x60, 0x60, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x3F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x0E, 0x01, 0x03, 0xFF, 0x04, 0x1C, 0x06, 0x10, 0xC0, 0x06, 0x46, 0x00,
  0x0D, 0x30, 0x00, 0x14, 0x80, 0x00, 0x76, 0x00, 0x00, 0xD0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x05,
  0x00, 0x00, 0x16, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x30, 0x00, 0x1C, 0x60,
  0x00, 0xD0, 0xC0, 0x06, 0x41, 0xC0, 0x71, 0x03, 0xFF, 0x04, 0x00, 0x40,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x20, 0x00, 0x03, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x01, 0x83, 0x80,
  0x01, 0x80, 0xE0, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x0F,
  0xFC, 0x10, 0x70, 0x18, 0x43, 0x00, 0x19, 0x18, 0x00, 0x34, 0xC0, 0x00,
  0x52, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x58,
  0x00, 0x03, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x71, 0x80, 0x03, 0x43, 0x00,
  0x19, 0x07, 0x01, 0xC4, 0x0F, 0xFC, 0x10, 0x01, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x20,
  0x00, 0x10, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x80, 0x70, 0x03, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x07,
  0x00, 0x81, 0xFF, 0x82, 0x1E, 0x03, 0x08, 0xE0, 0x06, 0x26, 0x00, 0x0C,
  0x90, 0x00, 0x1A, 0x80, 0x00, 0x6E, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x7F, 0xF0,
  0x1F, 0xC0, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x3A, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x20, 0x00, 0x60, 0x80,
  0x03, 0x02, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x20, 0x0E, 0x00, 0x80, 0x60,
  0x02, 0x03, 0x00, 0x08, 0x18, 0x00, 0x20, 0xC0, 0x00, 0x86, 0x00, 0x02,
  0x3C, 0x00, 0x0B, 0x18, 0x00, 0x38, 0x30, 0x00, 0xC0, 0x60, 0x02, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x20, 0x03, 0x00, 0x80, 0x06, 0x02, 0x00, 0x18,
  0x08, 0x00, 0x30, 0x20, 0x00, 0x60, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x88,
  0x00, 0x03, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0C, 0xFF, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x80, 0x06, 0x06, 0x7F, 0xC1,
  0xFE, 0x37, 0x07, 0x18, 0x19, 0xE0, 0x09, 0x00, 0x6E, 0x00, 0x78, 0x01,
  0x70, 0x03, 0x80, 0x0B, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x40, 0x03, 0xC0,
  0x02, 0x00, 0x1E, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x80, 0x07, 0x80, 0x04,
  0x00, 0x3C, 0x00, 0x20, 0x01, 0xE0, 0x01, 0x00, 0x0F, 0x00, 0x08, 0x00,
  0x78, 0x00, 0x40, 0x03, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0x10, 0x00, 0xF0,
  0x00, 0x80, 0x07, 0x80, 0x04, 0x00, 0x3C, 0x00, 0x20, 0x01, 0xE0, 0x01,
  0x00, 0x0F, 0x00, 0x08, 0x00, 0x78, 0x00, 0x40, 0x03, 0xC0, 0x02, 0x00,
  0x1E, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x80, 0x07, 0x80, 0x04, 0x00, 0x3C,
  0x00, 0x20, 0x01, 0xE0, 0x01, 0x00, 0x0C, 0x00, 0x3C, 0x02, 0x07, 0xFE,
  0x08, 0x70, 0x0C, 0x23, 0x80, 0x18, 0x98, 0x00, 0x32, 0xC0, 0x00, 0x6A,
  0x00, 0x01, 0xB8, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x20, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x02, 0x0F, 0xFC,
  0x08, 0xE0, 0x38, 0x26, 0x00, 0x30, 0xB0, 0x00, 0x62, 0x80, 0x00, 0xCC,
  0x00, 0x01, 0x30, 0x00, 0x06, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00,
  0x06, 0xC0, 0x00, 0x13, 0x80, 0x00, 0xCB, 0x00, 0x06, 0x26, 0x00, 0x30,
  0x8E, 0x03, 0x82, 0x0F, 0xFC, 0x08, 0x02, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x0F, 0xFC, 0x10, 0x70, 0x1C, 0x43, 0x00, 0x39, 0x18,
  0x00, 0x34, 0xC0, 0x00, 0x52, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x40, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x58, 0x00, 0x03, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x71,
  0x80, 0x03, 0x43, 0x00, 0x19, 0x07, 0x01, 0xC4, 0x0F, 0xFC, 0x10, 0x01,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x07, 0x98, 0x0F, 0xFF, 0x07, 0x00,
  0x63, 0x80, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x34, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x80, 0x3C,
  0x03, 0xC0, 0xE0, 0x00, 0xC3, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xA0,
  0x00, 0x01, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0xC0, 0xF0, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x68, 0x00, 0x03, 0x60,
  0x00, 0x39, 0x00, 0x03, 0x4C, 0x00, 0x32, 0x38, 0x0F, 0x10, 0x7F, 0xE0,
  0x80, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x20, 0x00, 0x02, 0x06,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x10, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x10, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x20, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x28, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x50, 0x01, 0xC0, 0x06, 0x80, 0x0E, 0x00, 0x36, 0x00, 0x58, 0x01, 0x30,
  0x02, 0xC0, 0x08, 0x80, 0x32, 0x00, 0xC4, 0x01, 0x90, 0x06, 0x30, 0x08,
  0xC0, 0x21, 0x80, 0x46, 0x01, 0x0C, 0x06, 0x10, 0x18, 0x20, 0x30, 0x80,
  0xC1, 0x01, 0x06, 0x06, 0x0C, 0x08, 0x30, 0x20, 0x60, 0xC0, 0x81, 0x01,
  0x06, 0x04, 0x18, 0x08, 0x20, 0x30, 0xC0, 0x61, 0x01, 0x84, 0x03, 0x18,
  0x04, 0x20, 0x08, 0xC0, 0x23, 0x00, 0x44, 0x01, 0x98, 0x03, 0x20, 0x0C,
  0x80, 0x1B, 0x00, 0x24, 0x00, 0xD0, 0x01, 0x20, 0x02, 0x80, 0x0F, 0x00,
  0x14, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x20, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0xC0, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x08, 0x01, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x10, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x03, 0x80, 0x07, 0x80, 0x03, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x4C, 0x0E, 0x00, 0x06, 0xC0, 0x18, 0x00, 0x34, 0x00,
  0x60, 0x01, 0x60, 0x01, 0xC0, 0x1B, 0x00, 0x03, 0x01, 0x90, 0x00, 0x0F,
  0x38, 0x80, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_Thin55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 3, 39, 33, 15, -39 },
  { 16, 9, 11, 33, 12, -41 },
  { 29, 30, 39, 33, 2, -39 },
  { 176, 24, 51, 33, 5, -45 },
  { 329, 31, 41, 33, 1, -40 },
  { 488, 28, 41, 33, 4, -40 },
  { 632, 2, 11, 33, 14, -41 },
  { 635, 12, 57, 33, 11, -44 },
  { 721, 11, 57, 33, 10, -44 },
  { 800, 23, 21, 33, 6, -39 },
  { 861, 27, 28, 33, 3, -32 },
  { 956, 4, 11, 33, 11, -4 },
  { 962, 19, 2, 33, 7, -19 },
  { 967, 3, 3, 33, 16, -3 },
  { 969, 18, 42, 33, 8, -39 },
  { 1064, 24, 41, 33, 5, -40 },
  { 1187, 13, 39, 33, 6, -39 },
  { 1251, 24, 40, 33, 3, -40 },
  { 1371, 24, 41, 33, 3, -40 },
  { 1494, 28, 39, 33, 2, -39 },
  { 1631, 23, 40, 33, 6, -39 },
  { 1746, 24, 41, 33, 4, -40 },
  { 1869, 25, 39, 33, 4, -39 },
  { 1991, 25, 41, 33, 5, -40 },
  { 2120, 24, 41, 33, 4, -40 },
  { 2243, 4, 27, 33, 17, -27 },
  { 2257, 6, 34, 33, 15, -27 },
  { 2283, 24, 22, 33, 4, -29 },
  { 2349, 24, 12, 33, 5, -24 },
  { 2385, 23, 22, 33, 5, -29 },
  { 2449, 20, 40, 33, 7, -40 },
  { 2549, 31, 39, 33, 1, -39 },
  { 2701, 28, 39, 33, 3, -39 },
  { 2838, 23, 39, 33, 6, -39 },
  { 2951, 25, 41, 33, 4, -40 },
  { 3080, 25, 39, 33, 5, -39 },
  { 3202, 22, 39, 33, 6, -39 },
  { 3310, 22, 39, 33, 6, -39 },
  { 3418, 25, 41, 33, 4, -40 },
  { 3547, 23, 39, 33, 5, -39 },
  { 3660, 21, 39, 33, 6, -39 },
  { 3763, 24, 40, 33, 3, -39 },
  { 3883, 26, 39, 33, 6, -39 },
  { 4010, 23, 39, 33, 6, -39 },
  { 4123, 24, 39, 33, 5, -39 },
  { 4240, 23, 39, 33, 5, -39 },
  { 4353, 25, 41, 33, 4, -40 },
  { 4482, 24, 39, 33, 6, -39 },
  { 4599, 27, 47, 33, 3, -40 },
  { 4758, 24, 39, 33, 6, -39 },
  { 4875, 26, 41, 33, 4, -40 },
  { 5009, 27, 39, 33, 3, -39 },
  { 5141, 23, 40, 33, 5, -39 },
  { 5256, 27, 39, 33, 3, -39 },
  { 5388, 29, 39, 33, 3, -39 },
  { 5530, 28, 39, 33, 3, -39 },
  { 5667, 28, 39, 33, 2, -39 },
  { 5804, 24, 39, 33, 4, -39 },
  { 5921, 8, 53, 33, 13, -45 },
  { 5974, 17, 42, 33, 8, -39 },
  { 6064, 8, 53, 33, 12, -45 },
  { 6117, 19, 21, 33, 7, -39 },
  { 6167, 23, 1, 33, 5, 0 },
  { 6170, 7, 7, 33, 13, -41 },
  { 6177, 23, 31, 33, 5, -30 },
  { 6267, 22, 42, 33, 6, -41 },
  { 6383, 23, 31, 33, 5, -30 },
  { 6473, 22, 42, 33, 5, -41 },
  { 6589, 25, 31, 33, 4, -30 },
  { 6686, 24, 42, 33, 6, -42 },
  { 6812, 22, 42, 33, 5, -30 },
  { 6928, 22, 41, 33, 6, -41 },
  { 7041, 23, 39, 33, 6, -39 },
  { 7154, 17, 51, 33, 5, -39 },
  { 7263, 22, 41, 33, 7, -41 },
  { 7376, 23, 41, 33, 6, -41 },
  { 7494, 29, 30, 33, 2, -30 },
  { 7603, 22, 30, 33, 6, -30 },
  { 7686, 25, 31, 33, 4, -30 },
  { 7783, 22, 41, 33, 6, -30 },
  { 7896, 22, 41, 33, 5, -30 },
  { 8009, 19, 30, 33, 10, -30 },
  { 8081, 23, 31, 33, 5, -30 },
  { 8171, 22, 38, 33, 5, -37 },
  { 8276, 21, 30, 33, 6, -29 },
  { 8355, 27, 29, 33, 3, -29 },
  { 8453, 29, 29, 33, 2, -29 },
  { 8559, 26, 29, 33, 4, -29 },
  { 8654, 29, 41, 33, 2, -29 },
  { 8803, 26, 29, 33, 4, -29 },
  { 8898, 18, 55, 33, 9, -43 },
  { 9022, 1, 46, 33, 16, -39 },
  { 9028, 18, 55, 33, 9, -43 },
  { 9152, 29, 9, 33, 2, -21 },
};

const GFXfont RobotoMono_Thin55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin55pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_THIN55PT7B_H_
