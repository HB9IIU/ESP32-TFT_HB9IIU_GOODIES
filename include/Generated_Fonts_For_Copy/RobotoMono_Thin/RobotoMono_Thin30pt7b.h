#ifndef _ROBOTOMONO_THIN30PT7B_H_
#define _ROBOTOMONO_THIN30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin30pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA8, 0x02, 0xC0, 0x99, 0x99, 0x99, 0x90, 0x02,
  0x04, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x7F,
  0xFF, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10, 0x08,
  0x20, 0x08, 0x20, 0xFF, 0xFE, 0x08, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x31, 0x82,
  0x02, 0x20, 0x09, 0x00, 0x50, 0x01, 0x80, 0x0A, 0x00, 0x10, 0x00, 0x40,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xA0, 0x08, 0x80, 0x83, 0xB8, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x10, 0x00, 0x4C, 0x00, 0x84, 0x00, 0x82, 0x08, 0x82, 0x10, 0x82,
  0x10, 0x82, 0x20, 0x84, 0x20, 0x84, 0x40, 0x78, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x08, 0x02, 0x32, 0x02, 0x21, 0x04, 0x41, 0x04, 0x41, 0x08,
  0x41, 0x08, 0x41, 0x10, 0x41, 0x00, 0x21, 0x00, 0x1E, 0x02, 0x00, 0x11,
  0x00, 0x41, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x08, 0x40,
  0x11, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x90, 0x02, 0x20, 0x08, 0x20, 0x90,
  0x21, 0x40, 0x22, 0x80, 0x25, 0x00, 0x31, 0x00, 0x62, 0x00, 0xC2, 0x02,
  0x43, 0xF8, 0x40, 0xFE, 0x04, 0x20, 0x84, 0x20, 0x84, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x40, 0x80, 0x80, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x81, 0x04, 0x17, 0x27, 0x07, 0xC0, 0x08, 0x00, 0xA0, 0x08, 0x80, 0x82,
  0x08, 0x08, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x55, 0x60, 0xFF, 0xC0, 0xC0, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x0C, 0x00, 0x0F, 0x00, 0x86, 0x18, 0x08, 0x80, 0x48, 0x01,
  0x40, 0x0A, 0x00, 0xD0, 0x0D, 0x80, 0xCC, 0x0C, 0x60, 0x83, 0x0C, 0x18,
  0xC0, 0xCC, 0x06, 0xC0, 0x34, 0x02, 0xC0, 0x14, 0x00, 0xA0, 0x04, 0x80,
  0x42, 0x04, 0x0F, 0xC0, 0x06, 0x35, 0x8C, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x0E,
  0x01, 0x8E, 0x10, 0x09, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xFC, 0x01,
  0x80, 0x71, 0x82, 0x01, 0x08, 0x02, 0x40, 0x09, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x0C, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x88, 0x02, 0x30, 0x10,
  0x3F, 0x80, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x84, 0x02, 0x08, 0x04, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80,
  0x82, 0x01, 0x08, 0x02, 0x3F, 0xFF, 0x80, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x3F, 0xF9, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x40, 0x5D, 0xC3, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x90,
  0x04, 0x40, 0x41, 0xFC, 0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x4F, 0xC4, 0x81, 0x28, 0x05, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x50, 0x02,
  0x40, 0x21, 0x02, 0x07, 0xE0, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x02, 0x01, 0xC6, 0x18, 0x08, 0x80,
  0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x02, 0x40, 0x11, 0x01, 0x06, 0x30,
  0x3F, 0x86, 0x02, 0x20, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x26, 0x02, 0x0F, 0xE0, 0x07, 0x00, 0xC6, 0x08, 0x0C, 0x40,
  0x24, 0x00, 0xA0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x50, 0x02,
  0x80, 0x12, 0x01, 0x88, 0x14, 0x3F, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x0C, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x2C, 0x00,
  0x00, 0x00, 0x00, 0x4A, 0x4A, 0x00, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x08, 0x00, 0x06, 0x06, 0x31, 0x01,
  0x40, 0x28, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x01,
  0x80, 0x40, 0x08, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x00, 0xC0, 0x07, 0x38, 0x08, 0x04, 0x10, 0x02, 0x20,
  0x02, 0x41, 0xE1, 0x42, 0x11, 0x84, 0x11, 0x84, 0x21, 0x88, 0x21, 0x88,
  0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x61, 0x88, 0x62, 0x84,
  0xA2, 0x87, 0x1C, 0x40, 0x00, 0x20, 0x00, 0x10, 0x08, 0x0F, 0xF0, 0x01,
  0x00, 0x06, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x88, 0x02, 0x10,
  0x04, 0x20, 0x08, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x82, 0x01, 0x04,
  0x02, 0x0F, 0xFE, 0x20, 0x04, 0x40, 0x08, 0x80, 0x09, 0x00, 0x14, 0x00,
  0x28, 0x00, 0x20, 0xFF, 0x84, 0x03, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x02, 0x80, 0x24, 0x0E, 0x3F, 0xF1, 0x00, 0x48, 0x01,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0xCF,
  0xF8, 0x00, 0x07, 0x80, 0x21, 0x83, 0x01, 0x08, 0x02, 0x40, 0x09, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00, 0x88,
  0x04, 0x10, 0x30, 0x3F, 0x00, 0xFF, 0x84, 0x02, 0x20, 0x09, 0x00, 0x28,
  0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x14, 0x00, 0xA0, 0x09,
  0x01, 0x8F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xE8, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x03, 0x80, 0x71, 0x83,
  0x01, 0x08, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x05, 0x00, 0x14, 0x00, 0x48, 0x01, 0x10, 0x08, 0x3F, 0xC0, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x14, 0x00, 0x90, 0x08, 0x40, 0xC1,
  0xF8, 0x00, 0x80, 0x0E, 0x00, 0x48, 0x02, 0x20, 0x10, 0x80, 0x82, 0x04,
  0x08, 0x20, 0x21, 0x00, 0x88, 0x02, 0x60, 0x0B, 0x40, 0x28, 0x80, 0xC2,
  0x02, 0x04, 0x08, 0x08, 0x20, 0x10, 0x80, 0x22, 0x00, 0x88, 0x01, 0x20,
  0x02, 0x80, 0x04, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0x80,
  0x1E, 0x00, 0xF0, 0x0B, 0x80, 0x5A, 0x04, 0xD0, 0x26, 0x41, 0x32, 0x11,
  0x90, 0x8C, 0x48, 0x62, 0x43, 0x12, 0x18, 0x60, 0xC3, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x80, 0x18,
  0x01, 0xC0, 0x1A, 0x01, 0xA0, 0x19, 0x01, 0x90, 0x18, 0x81, 0x88, 0x18,
  0x41, 0x82, 0x18, 0x21, 0x81, 0x18, 0x11, 0x80, 0x98, 0x09, 0x80, 0x58,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x10, 0x07, 0x80, 0x61, 0x03, 0x03, 0x08,
  0x04, 0x40, 0x09, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05,
  0x00, 0x24, 0x00, 0x88, 0x04, 0x10, 0x20, 0x3F, 0x00, 0xFF, 0x88, 0x06,
  0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02,
  0x80, 0x4F, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0x80, 0x61, 0x82, 0x01, 0x10, 0x02,
  0x40, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00,
  0x14, 0x00, 0x88, 0x04, 0x10, 0x30, 0x3F, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0xFF, 0x84, 0x03, 0x20, 0x05, 0x00, 0x28, 0x01, 0x40,
  0x06, 0x00, 0x30, 0x02, 0x80, 0x14, 0x01, 0x20, 0x11, 0xFF, 0x08, 0x08,
  0x40, 0x42, 0x01, 0x10, 0x08, 0x80, 0x24, 0x01, 0x20, 0x05, 0x00, 0x18,
  0x00, 0x80, 0x01, 0x00, 0x71, 0x82, 0x01, 0x10, 0x02, 0x40, 0x05, 0x00,
  0x14, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50,
  0x02, 0x30, 0x18, 0x3F, 0x80, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x22, 0x04,
  0x1F, 0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00,
  0x22, 0x01, 0x08, 0x04, 0x20, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08,
  0x40, 0x21, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x80, 0x81, 0x40, 0x81, 0x41, 0x81, 0x41, 0x41, 0x41,
  0x41, 0x41, 0x42, 0x42, 0x42, 0x22, 0x42, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x24, 0x24, 0x24, 0x24, 0x14, 0x14, 0x14, 0x14, 0x14, 0x14,
  0x14, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0xC0, 0x04, 0x80,
  0x10, 0x80, 0x20, 0x80, 0x81, 0x02, 0x01, 0x04, 0x02, 0x10, 0x02, 0x40,
  0x02, 0x80, 0x06, 0x00, 0x04, 0x00, 0x14, 0x00, 0x48, 0x00, 0x88, 0x02,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x40, 0x11, 0x00, 0x22, 0x00, 0x28, 0x00,
  0x60, 0xC0, 0x02, 0x80, 0x08, 0x80, 0x11, 0x00, 0x41, 0x00, 0x82, 0x02,
  0x02, 0x04, 0x04, 0x10, 0x04, 0x20, 0x08, 0x80, 0x09, 0x00, 0x14, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x0F, 0xFF, 0x80, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0xF0, 0x0C, 0x03, 0x01, 0x20, 0x48, 0x12, 0x08, 0x42, 0x11,
  0x02, 0x40, 0xA0, 0x18, 0x04, 0xFF, 0xF0, 0xC4, 0x21, 0x1F, 0x82, 0x06,
  0x40, 0x28, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0xFF, 0x30, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40, 0x53, 0xF9, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x09, 0xF8, 0xA0, 0x4C, 0x02,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0x2A, 0x04, 0x9F, 0x80, 0x1F, 0x82, 0x06, 0x40,
  0x28, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x14, 0x01, 0x20, 0x21, 0xFC, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x11, 0xF9, 0x20, 0x54, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x32, 0x05, 0x1F, 0x90, 0x0F, 0xC0, 0x40, 0xC2, 0x01,
  0x10, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x21, 0x01, 0x03, 0xF8, 0x00,
  0xF8, 0x18, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x1F, 0xFE,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x1F, 0x92, 0x05, 0x40, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x20, 0x51,
  0xF9, 0x00, 0x10, 0x01, 0x00, 0x24, 0x02, 0x60, 0x41, 0xF8, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0xFC, 0x90, 0x2A,
  0x02, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x0F, 0xFF, 0x80, 0x01, 0x80, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x3F, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x02, 0x80, 0x48, 0x08, 0x83, 0x08, 0x40, 0x88, 0x09, 0x00,
  0xB0, 0x0C, 0x80, 0x84, 0x08, 0x20, 0x81, 0x08, 0x08, 0x80, 0x48, 0x06,
  0x80, 0x30, 0xFE, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x03, 0xFF, 0xE0, 0xBE, 0x3C, 0xC1, 0x42, 0xC1, 0x81, 0x81, 0x01,
  0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01,
  0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01,
  0x8F, 0xC9, 0x02, 0xA0, 0x2C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x0F, 0xC0, 0x40, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x02, 0x40, 0x08, 0x80,
  0x43, 0x03, 0x03, 0xF0, 0x9F, 0x8A, 0x04, 0xC0, 0x28, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C,
  0x02, 0xA0, 0x49, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x1F, 0x92, 0x05, 0x40, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x20, 0x51,
  0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x8F, 0xEC,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1F, 0xC2, 0x02, 0x40, 0x18, 0x01,
  0x40, 0x04, 0x00, 0x20, 0x01, 0xE0, 0x01, 0xC0, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x01, 0x40, 0x33, 0xFC, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0xFF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x3F,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x60, 0x51, 0xF9,
  0x80, 0x06, 0x00, 0x14, 0x00, 0x90, 0x02, 0x20, 0x10, 0x80, 0x42, 0x01,
  0x04, 0x08, 0x10, 0x20, 0x21, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80, 0x14,
  0x00, 0x30, 0x00, 0xC0, 0x80, 0x81, 0x81, 0x81, 0x41, 0x81, 0x41, 0x82,
  0x41, 0x42, 0x42, 0x42, 0x42, 0x42, 0x22, 0x42, 0x22, 0x24, 0x24, 0x24,
  0x24, 0x24, 0x14, 0x24, 0x14, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08,
  0x40, 0x04, 0x80, 0x22, 0x01, 0x04, 0x08, 0x08, 0x40, 0x11, 0x00, 0x28,
  0x00, 0xC0, 0x03, 0x00, 0x12, 0x00, 0x44, 0x02, 0x08, 0x10, 0x20, 0x80,
  0x44, 0x00, 0xB0, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04,
  0x20, 0x04, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x10,
  0x04, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x78, 0x00,
  0x7F, 0xF8, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x3F, 0xFF, 0x01, 0x80, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x08, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x18, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x06, 0x06, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x06, 0x0C, 0x00, 0x3E, 0x01, 0x41, 0x01, 0x80, 0x82,
  0x80, 0x66, 0x00, 0x18,
};

const GFXglyph RobotoMono_Thin30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 2, 21, 18, 8, -21 },
  { 7, 4, 7, 18, 7, -23 },
  { 11, 16, 21, 18, 1, -21 },
  { 53, 13, 27, 18, 3, -24 },
  { 97, 16, 22, 18, 1, -22 },
  { 141, 15, 22, 18, 2, -22 },
  { 183, 1, 7, 18, 8, -23 },
  { 184, 6, 31, 18, 6, -24 },
  { 208, 7, 31, 18, 5, -24 },
  { 236, 13, 11, 18, 3, -21 },
  { 254, 14, 16, 18, 2, -18 },
  { 282, 2, 6, 18, 6, -2 },
  { 284, 10, 1, 18, 4, -10 },
  { 286, 1, 2, 18, 9, -2 },
  { 287, 10, 23, 18, 4, -21 },
  { 316, 13, 22, 18, 3, -22 },
  { 352, 7, 21, 18, 3, -21 },
  { 371, 13, 22, 18, 2, -22 },
  { 407, 14, 22, 18, 1, -22 },
  { 446, 15, 21, 18, 1, -21 },
  { 486, 13, 21, 18, 3, -21 },
  { 521, 13, 22, 18, 2, -22 },
  { 557, 14, 21, 18, 2, -21 },
  { 594, 13, 22, 18, 3, -22 },
  { 630, 13, 22, 18, 2, -22 },
  { 666, 2, 15, 18, 9, -15 },
  { 670, 3, 19, 18, 8, -15 },
  { 678, 13, 12, 18, 2, -16 },
  { 698, 13, 7, 18, 3, -13 },
  { 710, 12, 12, 18, 3, -16 },
  { 728, 11, 22, 18, 4, -22 },
  { 759, 16, 22, 18, 1, -22 },
  { 803, 15, 21, 18, 2, -21 },
  { 843, 13, 21, 18, 3, -21 },
  { 878, 14, 22, 18, 2, -22 },
  { 917, 13, 21, 18, 3, -21 },
  { 952, 12, 21, 18, 3, -21 },
  { 984, 12, 21, 18, 3, -21 },
  { 1016, 14, 22, 18, 2, -22 },
  { 1055, 12, 21, 18, 3, -21 },
  { 1087, 12, 21, 18, 3, -21 },
  { 1119, 13, 21, 18, 2, -21 },
  { 1154, 14, 21, 18, 3, -21 },
  { 1191, 12, 21, 18, 4, -21 },
  { 1223, 13, 21, 18, 3, -21 },
  { 1258, 12, 21, 18, 3, -21 },
  { 1290, 14, 22, 18, 2, -22 },
  { 1329, 12, 21, 18, 4, -21 },
  { 1361, 14, 26, 18, 2, -22 },
  { 1407, 13, 21, 18, 3, -21 },
  { 1442, 14, 22, 18, 2, -22 },
  { 1481, 14, 21, 18, 2, -21 },
  { 1518, 12, 21, 18, 3, -21 },
  { 1550, 14, 21, 18, 2, -21 },
  { 1587, 16, 21, 18, 1, -21 },
  { 1629, 15, 21, 18, 2, -21 },
  { 1669, 15, 21, 18, 1, -21 },
  { 1709, 13, 21, 18, 2, -21 },
  { 1744, 4, 29, 18, 7, -24 },
  { 1759, 10, 23, 18, 4, -21 },
  { 1788, 4, 29, 18, 7, -24 },
  { 1803, 10, 11, 18, 4, -21 },
  { 1817, 12, 1, 18, 3, 0 },
  { 1819, 4, 4, 18, 7, -22 },
  { 1821, 12, 16, 18, 3, -16 },
  { 1845, 12, 23, 18, 3, -23 },
  { 1880, 12, 16, 18, 3, -16 },
  { 1904, 12, 23, 18, 3, -23 },
  { 1939, 14, 16, 18, 2, -16 },
  { 1967, 13, 23, 18, 3, -23 },
  { 2005, 12, 22, 18, 3, -16 },
  { 2038, 12, 23, 18, 3, -23 },
  { 2073, 13, 21, 18, 3, -21 },
  { 2108, 9, 27, 18, 3, -21 },
  { 2139, 12, 23, 18, 4, -23 },
  { 2174, 13, 23, 18, 3, -23 },
  { 2212, 16, 16, 18, 1, -16 },
  { 2244, 12, 16, 18, 3, -16 },
  { 2268, 14, 16, 18, 2, -16 },
  { 2296, 12, 22, 18, 3, -16 },
  { 2329, 12, 22, 18, 3, -16 },
  { 2362, 10, 16, 18, 6, -16 },
  { 2382, 12, 16, 18, 3, -16 },
  { 2406, 12, 20, 18, 3, -20 },
  { 2436, 12, 16, 18, 3, -16 },
  { 2460, 14, 16, 18, 2, -16 },
  { 2488, 16, 16, 18, 1, -16 },
  { 2520, 14, 16, 18, 2, -16 },
  { 2548, 16, 22, 18, 1, -16 },
  { 2592, 14, 16, 18, 2, -16 },
  { 2620, 10, 29, 18, 5, -23 },
  { 2657, 1, 25, 18, 9, -21 },
  { 2661, 9, 29, 18, 5, -23 },
  { 2694, 16, 5, 18, 1, -11 },
};

const GFXfont RobotoMono_Thin30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin30pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_THIN30PT7B_H_
