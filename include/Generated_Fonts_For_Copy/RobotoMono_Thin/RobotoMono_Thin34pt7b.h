#ifndef _ROBOTOMONO_THIN34PT7B_H_
#define _ROBOTOMONO_THIN34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin34pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x0F, 0x45, 0x14, 0x51, 0x46, 0x18,
  0x40, 0x00, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10,
  0x20, 0x02, 0x04, 0x00, 0x81, 0x03, 0xFF, 0xFF, 0x02, 0x04, 0x00, 0x40,
  0x80, 0x08, 0x10, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x02,
  0x00, 0x20, 0x40, 0xFF, 0xFF, 0x81, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08,
  0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x08, 0x00, 0x81, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0xE7, 0x02, 0x03, 0x08, 0x03, 0x20,
  0x02, 0x40, 0x04, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x40, 0x08, 0xC0,
  0x60, 0x7F, 0x80, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0D,
  0x80, 0x03, 0x08, 0x00, 0x41, 0x03, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20,
  0x42, 0x04, 0x08, 0x40, 0x82, 0x10, 0x10, 0x42, 0x01, 0x90, 0x80, 0x0C,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x21, 0xC0, 0x08, 0x44, 0x01,
  0x10, 0x40, 0x42, 0x08, 0x08, 0x40, 0x82, 0x08, 0x10, 0x41, 0x02, 0x10,
  0x20, 0x42, 0x04, 0x10, 0x00, 0x42, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x06,
  0xE0, 0x04, 0x10, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x80, 0x10, 0x80, 0x08, 0x80, 0x02, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x01, 0x90, 0x00, 0x84, 0x04, 0x81, 0x02, 0x80, 0xC2, 0x40, 0x21, 0x20,
  0x08, 0x90, 0x02, 0x48, 0x00, 0xC4, 0x00, 0x61, 0x00, 0x70, 0xC0, 0x64,
  0x1F, 0xC1, 0x80, 0xFE, 0x02, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x80,
  0x80, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x81, 0x04, 0x08, 0x20, 0x82, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x04, 0x10, 0x77, 0x27, 0x01, 0xF0, 0x00, 0xC0, 0x02, 0xC0, 0x08,
  0xC0, 0x20, 0x80, 0xC0, 0x81, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x55, 0x58,
  0xFF, 0xF0, 0xB0, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x00, 0x03, 0x00, 0x19, 0xC0, 0xC0, 0x41, 0x00, 0x44, 0x00,
  0x88, 0x00, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x13, 0x00, 0x46, 0x01, 0x0C,
  0x04, 0x18, 0x10, 0x30, 0x40, 0x61, 0x00, 0xC4, 0x01, 0x90, 0x03, 0x40,
  0x07, 0x00, 0x14, 0x00, 0x24, 0x00, 0x48, 0x01, 0x08, 0x02, 0x08, 0x18,
  0x0F, 0xE0, 0x03, 0x0D, 0x31, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x00, 0x3B, 0xC0, 0x80, 0x42, 0x00, 0x44, 0x00, 0x90,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF,
  0xFE, 0x01, 0x00, 0x3D, 0xC0, 0xC0, 0x42, 0x00, 0x44, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80,
  0x7C, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x58, 0x00, 0x90, 0x02, 0x18, 0x0C, 0x0F, 0xE0,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x50, 0x00, 0x50, 0x00, 0x90, 0x01, 0x10,
  0x01, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0xC0, 0x10, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x3F, 0xFC, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x7F, 0x06, 0x02, 0x10, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x02, 0x40,
  0x09, 0x00, 0x42, 0x03, 0x07, 0xF0, 0x00, 0x30, 0x0F, 0x00, 0x40, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x1F, 0x09,
  0x82, 0x28, 0x06, 0xC0, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x26, 0x00, 0x8C, 0x0C,
  0x0F, 0xE0, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x1D, 0xE0, 0xC0, 0x61, 0x00, 0x64, 0x00, 0x48,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x08, 0x80, 0x20, 0xC0,
  0x80, 0x7E, 0x03, 0x06, 0x08, 0x02, 0x20, 0x02, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00, 0x50, 0x01, 0x18, 0x04, 0x0F,
  0xF0, 0x03, 0x00, 0x73, 0x83, 0x01, 0x18, 0x02, 0x40, 0x0A, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05,
  0x00, 0x36, 0x01, 0xCC, 0x0D, 0x0F, 0xC4, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x1F, 0x00, 0xB0, 0x00, 0x00,
  0x02, 0xC0, 0x23, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x22, 0x24,
  0xC0, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x10, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x02, 0x00, 0xEE, 0x08, 0x08, 0x80,
  0x28, 0x01, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x03,
  0xFC, 0x00, 0xC0, 0x60, 0x20, 0x06, 0x08, 0x00, 0x42, 0x00, 0x04, 0xC1,
  0xF0, 0x90, 0x42, 0x12, 0x10, 0x42, 0x84, 0x08, 0x50, 0x81, 0x0A, 0x10,
  0x21, 0x42, 0x04, 0x28, 0x40, 0x85, 0x08, 0x10, 0xA1, 0x04, 0x14, 0x20,
  0x82, 0x84, 0x28, 0x50, 0x85, 0x11, 0x0F, 0x3C, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x01, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08,
  0x20, 0x04, 0x10, 0x02, 0x08, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x10, 0x20, 0x08, 0x3F, 0xFC, 0x10, 0x01, 0x08, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0xFF,
  0x82, 0x01, 0x88, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x02, 0x80, 0x0A, 0x00, 0x48, 0x06, 0x3F, 0xE0, 0x80, 0x62, 0x00, 0x68,
  0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A,
  0x00, 0x68, 0x03, 0x3F, 0xF0, 0x00, 0x80, 0x07, 0x70, 0x18, 0x08, 0x10,
  0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x01, 0x40, 0x01, 0x20, 0x02, 0x20,
  0x02, 0x10, 0x04, 0x08, 0x08, 0x07, 0xF0, 0xFF, 0xC1, 0x00, 0x42, 0x00,
  0x44, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90, 0x02,
  0x20, 0x18, 0x7F, 0xC0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xE8,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x3F, 0xFC, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x07, 0x70, 0x18, 0x0C, 0x10, 0x04, 0x20, 0x02, 0x40,
  0x02, 0x40, 0x01, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08,
  0x06, 0x07, 0xF8, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xF8, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x14,
  0x00, 0x24, 0x00, 0x4C, 0x01, 0x0C, 0x04, 0x07, 0xF0, 0x80, 0x06, 0x80,
  0x08, 0x80, 0x10, 0x80, 0x20, 0x80, 0x40, 0x80, 0xC0, 0x81, 0x80, 0x81,
  0x00, 0x82, 0x00, 0x84, 0x00, 0x88, 0x00, 0x98, 0x00, 0xA4, 0x00, 0xC2,
  0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80,
  0x10, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x03, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x2D, 0x00, 0x5A, 0x01,
  0x32, 0x02, 0x64, 0x04, 0xC8, 0x11, 0x88, 0x23, 0x10, 0x86, 0x11, 0x0C,
  0x22, 0x18, 0x48, 0x30, 0x50, 0x60, 0xC0, 0xC1, 0x81, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x68, 0x01, 0x90, 0x06, 0x40, 0x18, 0x80,
  0x62, 0x01, 0x84, 0x06, 0x10, 0x18, 0x20, 0x60, 0x81, 0x81, 0x06, 0x02,
  0x18, 0x08, 0x60, 0x11, 0x80, 0x46, 0x00, 0x98, 0x02, 0x60, 0x05, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x00, 0x80, 0x07, 0x70, 0x18, 0x08,
  0x10, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x20, 0x02,
  0x20, 0x04, 0x10, 0x04, 0x08, 0x18, 0x07, 0xF0, 0xFF, 0xE1, 0x00, 0x22,
  0x00, 0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x03, 0x1F, 0xF0, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x80, 0x03, 0xB8, 0x06, 0x02, 0x04,
  0x00, 0x82, 0x00, 0x22, 0x00, 0x11, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x21, 0x00, 0x10, 0xC0, 0x10, 0x30, 0x10, 0x07, 0xF0, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0xFF, 0x81, 0x00, 0xC2, 0x00,
  0x44, 0x00, 0x48, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x64, 0x01, 0x88, 0x04, 0x1F, 0xF0, 0x20, 0x20, 0x40,
  0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0xC4, 0x00, 0x88, 0x00, 0x90, 0x01,
  0x20, 0x01, 0x40, 0x03, 0x01, 0x00, 0x3D, 0xE0, 0xC0, 0x62, 0x00, 0x24,
  0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x50, 0x01, 0x18,
  0x04, 0x0F, 0xF0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x24, 0x00, 0x84, 0x01, 0x0C,
  0x0C, 0x07, 0xF0, 0x80, 0x01, 0xC0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44,
  0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x10, 0x04, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x08,
  0x40, 0x04, 0x20, 0x02, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x30,
  0x30, 0x28, 0x18, 0x14, 0x0C, 0x0A, 0x05, 0x05, 0x02, 0x82, 0x42, 0x42,
  0x21, 0x21, 0x10, 0x90, 0x88, 0x48, 0x44, 0x22, 0x21, 0x11, 0x20, 0x90,
  0x90, 0x48, 0x48, 0x24, 0x24, 0x12, 0x12, 0x05, 0x06, 0x02, 0x83, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x20, 0x08, 0xC0, 0x01, 0xB0,
  0x01, 0x88, 0x00, 0x82, 0x00, 0x81, 0x00, 0x40, 0x40, 0x40, 0x10, 0x40,
  0x08, 0x20, 0x02, 0x20, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x10, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x08, 0x80, 0x04, 0x60, 0x04, 0x10, 0x04, 0x04, 0x02,
  0x02, 0x02, 0x00, 0x82, 0x00, 0x21, 0x00, 0x11, 0x00, 0x05, 0x00, 0x01,
  0xC0, 0x00, 0xA0, 0x00, 0x88, 0x00, 0x46, 0x00, 0x41, 0x00, 0x20, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x10, 0x04, 0x08, 0x01, 0x08, 0x00, 0x84, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x7F, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x7F, 0xFF,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x06, 0x00, 0x60, 0x05, 0x00, 0x90, 0x08, 0x81, 0x08, 0x10,
  0x81, 0x04, 0x20, 0x42, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x10, 0xFF, 0xFC,
  0xC4, 0x21, 0x0F, 0xE0, 0xC0, 0x46, 0x00, 0x90, 0x01, 0x40, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x0F, 0xFC, 0xC0, 0x14, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xF0, 0x05, 0x60, 0x24, 0xFF, 0x10, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x9F,
  0xC5, 0x01, 0x30, 0x05, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x58,
  0x02, 0xA0, 0x24, 0xFE, 0x00, 0x0F, 0xE0, 0x40, 0x42, 0x00, 0x90, 0x01,
  0x40, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x14, 0x00, 0x48, 0x02, 0x10, 0x10, 0x3F,
  0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x0F, 0xC4, 0xC0, 0x92, 0x01, 0x50, 0x03, 0x40, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x05, 0x00, 0x14, 0x00, 0xC8, 0x03, 0x30, 0x34, 0x3F, 0x10, 0x0F,
  0xE0, 0x20, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x02, 0x10, 0x08, 0x1F, 0xE0, 0x00, 0x7E, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0xFF, 0xFC, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x0F, 0xC4,
  0x40, 0x92, 0x01, 0x50, 0x03, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00,
  0xC8, 0x03, 0x30, 0x34, 0x3F, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x24, 0x01, 0x0C, 0x0C, 0x0F, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x8F, 0xC5, 0x81, 0xA8, 0x05,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xFF, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x4F, 0xE0, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x0A, 0x00, 0xC8, 0x06, 0x20, 0x30, 0x81, 0x02, 0x08, 0x08, 0x40,
  0x22, 0x00, 0xB8, 0x03, 0x90, 0x08, 0x20, 0x20, 0x40, 0x80, 0x82, 0x01,
  0x08, 0x02, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x30, 0xFF, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0, 0x9F, 0x1F, 0xA8, 0x28, 0x2C, 0x0C,
  0x07, 0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01,
  0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60,
  0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x10, 0x8F,
  0xC5, 0x81, 0xA8, 0x05, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x07, 0xF0, 0x18, 0x18, 0x30, 0x04, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x20, 0x02, 0x30,
  0x04, 0x18, 0x08, 0x07, 0xF0, 0x9F, 0xC5, 0x03, 0x30, 0x05, 0x00, 0x28,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x58, 0x02, 0xE0, 0x64, 0xFE, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x0F, 0xC4,
  0xC0, 0xD2, 0x01, 0x50, 0x03, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00,
  0xC8, 0x03, 0x30, 0x34, 0x3F, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x87, 0xF8, 0x80, 0x90, 0x0A, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xE0, 0x60,
  0x31, 0x00, 0x12, 0x00, 0x24, 0x00, 0x28, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x20, 0x00, 0x50, 0x00, 0x50,
  0x01, 0x20, 0x02, 0x20, 0x08, 0x1F, 0xE0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x03, 0xFF, 0xE0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x1F, 0xC0,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x68, 0x03, 0x60, 0x69, 0xFC, 0x40, 0x80, 0x01, 0x40, 0x01, 0x40, 0x02,
  0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10, 0x04, 0x10, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x02, 0x20, 0x02, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x80, 0x40, 0x50, 0x10, 0x14, 0x0C,
  0x05, 0x02, 0x81, 0x40, 0xA0, 0x88, 0x48, 0x22, 0x12, 0x08, 0x84, 0x42,
  0x21, 0x11, 0x08, 0x84, 0x41, 0x21, 0x10, 0x48, 0x24, 0x12, 0x09, 0x05,
  0x02, 0x80, 0xC0, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x40,
  0x03, 0x20, 0x02, 0x10, 0x04, 0x08, 0x08, 0x0C, 0x10, 0x04, 0x30, 0x02,
  0x20, 0x01, 0x40, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x20, 0x04,
  0x10, 0x08, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x02, 0xC0, 0x01, 0xC0,
  0x00, 0x50, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x30, 0x01, 0x04, 0x00,
  0x81, 0x80, 0x20, 0x20, 0x08, 0x08, 0x04, 0x01, 0x01, 0x00, 0x40, 0x80,
  0x08, 0x20, 0x02, 0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00,
  0xE0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x00, 0x40, 0x30, 0x30,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x30, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x30, 0x03, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x10, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x30, 0x00, 0x1C, 0x00, 0x48, 0xC0, 0x14, 0x08, 0x06, 0x01, 0x82, 0x80,
  0x31, 0x80, 0x03, 0x00,
};

const GFXglyph RobotoMono_Thin34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 2, 24, 20, 9, -24 },
  { 7, 6, 7, 20, 7, -26 },
  { 13, 19, 24, 20, 1, -24 },
  { 70, 15, 31, 20, 3, -28 },
  { 129, 19, 25, 20, 1, -25 },
  { 189, 17, 25, 20, 3, -25 },
  { 243, 1, 7, 20, 9, -26 },
  { 244, 7, 35, 20, 7, -27 },
  { 275, 7, 35, 20, 6, -27 },
  { 306, 15, 13, 20, 3, -24 },
  { 331, 17, 18, 20, 2, -20 },
  { 370, 2, 7, 20, 7, -3 },
  { 372, 12, 1, 20, 4, -12 },
  { 374, 2, 2, 20, 10, -2 },
  { 375, 11, 26, 20, 5, -24 },
  { 411, 15, 25, 20, 3, -25 },
  { 458, 8, 24, 20, 4, -24 },
  { 482, 15, 25, 20, 2, -25 },
  { 529, 15, 25, 20, 2, -25 },
  { 576, 16, 24, 20, 2, -24 },
  { 624, 14, 24, 20, 4, -24 },
  { 666, 14, 25, 20, 3, -25 },
  { 710, 16, 24, 20, 2, -24 },
  { 758, 15, 25, 20, 3, -25 },
  { 805, 14, 25, 20, 3, -25 },
  { 849, 2, 17, 20, 11, -17 },
  { 854, 4, 21, 20, 9, -17 },
  { 865, 14, 14, 20, 3, -18 },
  { 890, 15, 8, 20, 3, -15 },
  { 905, 14, 14, 20, 3, -18 },
  { 930, 13, 25, 20, 4, -25 },
  { 971, 19, 24, 20, 1, -24 },
  { 1028, 17, 24, 20, 2, -24 },
  { 1079, 14, 24, 20, 4, -24 },
  { 1121, 16, 25, 20, 2, -25 },
  { 1171, 15, 24, 20, 3, -24 },
  { 1216, 13, 24, 20, 4, -24 },
  { 1255, 14, 24, 20, 4, -24 },
  { 1297, 16, 25, 20, 2, -25 },
  { 1347, 14, 24, 20, 3, -24 },
  { 1389, 13, 24, 20, 4, -24 },
  { 1428, 15, 24, 20, 2, -24 },
  { 1473, 16, 24, 20, 4, -24 },
  { 1521, 14, 24, 20, 4, -24 },
  { 1563, 15, 24, 20, 3, -24 },
  { 1608, 14, 24, 20, 3, -24 },
  { 1650, 16, 25, 20, 2, -25 },
  { 1700, 15, 24, 20, 4, -24 },
  { 1745, 17, 29, 20, 2, -25 },
  { 1807, 15, 24, 20, 4, -24 },
  { 1852, 15, 25, 20, 3, -25 },
  { 1899, 17, 24, 20, 2, -24 },
  { 1950, 15, 24, 20, 3, -24 },
  { 1995, 17, 24, 20, 2, -24 },
  { 2046, 17, 24, 20, 2, -24 },
  { 2097, 17, 24, 20, 2, -24 },
  { 2148, 17, 24, 20, 1, -24 },
  { 2199, 15, 24, 20, 2, -24 },
  { 2244, 5, 33, 20, 8, -28 },
  { 2265, 11, 26, 20, 5, -24 },
  { 2301, 4, 33, 20, 8, -28 },
  { 2318, 12, 13, 20, 4, -24 },
  { 2338, 14, 1, 20, 3, 0 },
  { 2340, 4, 4, 20, 8, -25 },
  { 2342, 14, 18, 20, 3, -18 },
  { 2374, 13, 26, 20, 4, -26 },
  { 2417, 14, 18, 20, 3, -18 },
  { 2449, 14, 26, 20, 3, -26 },
  { 2495, 15, 18, 20, 3, -18 },
  { 2529, 15, 26, 20, 3, -26 },
  { 2578, 14, 25, 20, 3, -18 },
  { 2622, 13, 26, 20, 4, -26 },
  { 2665, 14, 24, 20, 4, -24 },
  { 2707, 10, 31, 20, 3, -24 },
  { 2746, 14, 26, 20, 4, -26 },
  { 2792, 14, 26, 20, 4, -26 },
  { 2838, 18, 18, 20, 1, -18 },
  { 2879, 13, 18, 20, 4, -18 },
  { 2909, 16, 18, 20, 2, -18 },
  { 2945, 13, 25, 20, 4, -18 },
  { 2986, 14, 25, 20, 3, -18 },
  { 3030, 12, 18, 20, 6, -18 },
  { 3057, 15, 18, 20, 3, -18 },
  { 3091, 14, 23, 20, 3, -23 },
  { 3132, 13, 18, 20, 4, -18 },
  { 3162, 16, 18, 20, 2, -18 },
  { 3198, 18, 18, 20, 1, -18 },
  { 3239, 16, 18, 20, 2, -18 },
  { 3275, 18, 25, 20, 1, -18 },
  { 3332, 16, 18, 20, 2, -18 },
  { 3368, 10, 34, 20, 6, -27 },
  { 3411, 1, 28, 20, 10, -24 },
  { 3415, 10, 34, 20, 6, -27 },
  { 3458, 18, 6, 20, 1, -13 },
};

const GFXfont RobotoMono_Thin34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin34pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_THIN34PT7B_H_
