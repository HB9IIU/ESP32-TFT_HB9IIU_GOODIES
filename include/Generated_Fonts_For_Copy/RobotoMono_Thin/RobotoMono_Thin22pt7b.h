#ifndef _ROBOTOMONO_THIN22PT7B_H_
#define _ROBOTOMONO_THIN22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0xB6, 0xDA, 0x08, 0x40, 0x84, 0x08, 0x40, 0x88, 0x08,
  0x8F, 0x7F, 0x10, 0x81, 0x08, 0x11, 0x01, 0x10, 0x11, 0x0F, 0xFE, 0x21,
  0x02, 0x10, 0x22, 0x02, 0x20, 0x04, 0x02, 0x07, 0x84, 0x24, 0x0C, 0x06,
  0x02, 0x80, 0x40, 0x1C, 0x01, 0x80, 0x20, 0x08, 0x06, 0x03, 0x01, 0x40,
  0x9D, 0x81, 0x00, 0x80, 0x30, 0x02, 0x40, 0x21, 0x11, 0x08, 0x88, 0x48,
  0x22, 0x41, 0x24, 0x06, 0x40, 0x02, 0x00, 0x23, 0x81, 0x22, 0x12, 0x10,
  0x90, 0x88, 0x84, 0x42, 0x20, 0x1E, 0x1C, 0x04, 0x41, 0x08, 0x21, 0x04,
  0x20, 0x88, 0x0A, 0x00, 0x80, 0x68, 0x09, 0x0A, 0x11, 0x41, 0x28, 0x15,
  0x01, 0x20, 0x53, 0xF3, 0xF8, 0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x08, 0x42, 0x08, 0x41, 0x04, 0x82, 0x08, 0x41, 0x08, 0x41,
  0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x44, 0x40, 0x04, 0x01, 0x00,
  0x83, 0x23, 0x3B, 0x03, 0x01, 0x20, 0x84, 0x21, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x00, 0x55, 0x80, 0xFE, 0xC0, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x80, 0x1E, 0x30, 0x90, 0x30,
  0x18, 0x0C, 0x0E, 0x0B, 0x09, 0x88, 0xC8, 0x68, 0x38, 0x18, 0x0C, 0x05,
  0x04, 0x7C, 0x04, 0x7E, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x1E, 0x18, 0x44, 0x0A, 0x02, 0x80, 0x80, 0x20, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0xFF, 0x1E, 0x08,
  0x44, 0x0A, 0x01, 0x00, 0x40, 0x20, 0x08, 0x0C, 0x1F, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x60, 0x14, 0x08, 0xFC, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x80,
  0x50, 0x12, 0x04, 0x41, 0x08, 0x21, 0x08, 0x22, 0x04, 0x7F, 0xF0, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x3F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07,
  0xE1, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x50, 0x24, 0x08, 0xFC,
  0x0E, 0x08, 0x08, 0x08, 0x08, 0x04, 0x02, 0xF9, 0x82, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0xFF, 0xC0, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x1E, 0x18, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x24, 0x08, 0xFC,
  0x23, 0x10, 0x28, 0x06, 0x01, 0x80, 0x60, 0x14, 0x08, 0xFC, 0x3E, 0x20,
  0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0xCF, 0xA0, 0x10,
  0x08, 0x08, 0x08, 0x78, 0x80, 0x40, 0x40, 0x00, 0x56, 0x80, 0x03, 0x86,
  0x0C, 0x18, 0x04, 0x01, 0xC0, 0x18, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x08, 0x38, 0x60, 0xC0, 0x00,
  0x3C, 0x42, 0x81, 0x81, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x62, 0x89, 0x19,
  0x11, 0x91, 0x19, 0x11, 0xA1, 0x1A, 0x11, 0xA1, 0x29, 0x32, 0x9C, 0xC8,
  0x00, 0x40, 0x03, 0xF8, 0x04, 0x00, 0x80, 0x18, 0x05, 0x00, 0x90, 0x12,
  0x04, 0x40, 0x84, 0x10, 0x84, 0x10, 0x81, 0x1F, 0xE4, 0x04, 0x80, 0x50,
  0x0C, 0x01, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0B, 0xFC,
  0x81, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B, 0xFC, 0x1E, 0x18,
  0x44, 0x0A, 0x02, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x24, 0x10, 0xF8, 0xFC, 0x20, 0x88, 0x12, 0x02, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28,
  0x13, 0xF8, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x0F, 0x06, 0x11, 0x01, 0x20, 0x24, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x7E, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x48, 0x18, 0xFC,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x80, 0x50, 0x24, 0x08, 0xFC, 0x80, 0x50, 0x12, 0x04,
  0x41, 0x08, 0x41, 0x08, 0x22, 0x04, 0x80, 0xA8, 0x18, 0x82, 0x10, 0x41,
  0x08, 0x11, 0x01, 0x20, 0x14, 0x03, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0xC0,
  0x70, 0x38, 0x3A, 0x1D, 0x16, 0x8B, 0x29, 0x94, 0xC4, 0x62, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1A, 0x0C, 0x86, 0x43,
  0x11, 0x88, 0xC2, 0x61, 0x30, 0x58, 0x1C, 0x0E, 0x03, 0x01, 0x1E, 0x18,
  0x44, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xA0, 0x24, 0x10, 0xF8, 0xFC, 0x41, 0xA0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x02, 0x86, 0x7C, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x88, 0x20, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x0A,
  0x02, 0x83, 0x3F, 0x88, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0A, 0x01, 0x3E,
  0x10, 0x48, 0x0A, 0x01, 0x80, 0x60, 0x04, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x04, 0x01, 0x80, 0x60, 0x14, 0x08, 0xFC, 0xFF, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0x80,
  0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x41, 0x08, 0x21, 0x04, 0x10, 0x82,
  0x20, 0x44, 0x04, 0x80, 0xA0, 0x14, 0x01, 0x00, 0x20, 0x84, 0x18, 0x41,
  0x86, 0x28, 0x62, 0x86, 0x24, 0xA2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x94,
  0x51, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0x80, 0x28, 0x08,
  0x81, 0x10, 0x41, 0x08, 0x12, 0x02, 0x80, 0x30, 0x04, 0x01, 0x40, 0x24,
  0x08, 0x42, 0x08, 0x40, 0x90, 0x16, 0x01, 0x80, 0x30, 0x09, 0x01, 0x20,
  0x42, 0x08, 0x22, 0x04, 0x40, 0x50, 0x0A, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0xFF, 0xF2,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4E, 0x81, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x81, 0x01, 0x02, 0xE4, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x9E, 0x10, 0x20, 0xA1, 0x44, 0x48, 0x90,
  0xC1, 0x82, 0xFF, 0x80, 0xC8, 0x80, 0x3E, 0x20, 0xA0, 0x30, 0x10, 0x08,
  0xFD, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x6F, 0xD0, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0xF2, 0x85, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x82, 0xBE, 0x00, 0x1E, 0x30, 0x90, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x50, 0x27, 0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x09,
  0xE5, 0x0E, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83,
  0x3E, 0x80, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x27, 0xE0, 0x03, 0xC3, 0x00, 0x80, 0x40, 0x10, 0x3F, 0xE1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x00, 0x3C, 0xA1, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x50, 0x67, 0xD0, 0x08, 0x05, 0x04, 0xC4, 0x1C, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0xF2, 0x85, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x18, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF,
  0x06, 0x0C, 0x00, 0x07, 0xC0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x4F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x0A, 0x09, 0x08, 0x88, 0x48, 0x38, 0x12, 0x08, 0x84, 0x22, 0x09,
  0x04, 0x81, 0x80, 0xF0, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0xFF, 0x80, 0xB9,
  0xD8, 0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30,
  0x86, 0x10, 0xC2, 0x10, 0x9E, 0x50, 0xB0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x3E, 0x10, 0x48, 0x0A, 0x02, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x24, 0x10, 0xF8, 0x9E, 0x70, 0xA0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x57, 0xC8, 0x04,
  0x02, 0x01, 0x00, 0x3C, 0xA1, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x50, 0x67, 0xD0, 0x08, 0x04, 0x02, 0x01, 0x9F, 0xA0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x20, 0xE0,
  0x30, 0x04, 0x01, 0xC0, 0x1C, 0x01, 0x00, 0xC0, 0x50, 0x27, 0xE0, 0x10,
  0x08, 0x04, 0x1F, 0xE1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x1E, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x50, 0x67, 0xD0, 0x80, 0x28, 0x05, 0x01, 0x20, 0x22,
  0x08, 0x41, 0x04, 0x40, 0x88, 0x09, 0x01, 0x40, 0x28, 0x02, 0x00, 0x84,
  0x18, 0x42, 0x84, 0x28, 0xA2, 0x4A, 0x24, 0xA2, 0x49, 0x45, 0x14, 0x51,
  0x43, 0x14, 0x20, 0x82, 0x08, 0x80, 0x50, 0x24, 0x10, 0x88, 0x14, 0x03,
  0x00, 0x80, 0x50, 0x22, 0x10, 0x44, 0x0A, 0x01, 0x80, 0x30, 0x05, 0x01,
  0x20, 0x22, 0x04, 0x41, 0x04, 0x20, 0x88, 0x09, 0x01, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x60, 0x00, 0x7F, 0xC0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7F,
  0xF0, 0x06, 0x10, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x43, 0x02, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0xC0, 0xFF, 0xFF, 0xE0,
  0xC0, 0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x38, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x04, 0x10, 0x00, 0x78, 0x30, 0x86, 0x0F,
  0x00,
};

const GFXglyph RobotoMono_Thin22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 1, 16, 13, 6, -16 },
  { 3, 3, 5, 13, 5, -17 },
  { 5, 12, 16, 13, 1, -16 },
  { 29, 9, 20, 13, 2, -18 },
  { 52, 13, 16, 13, 0, -16 },
  { 78, 11, 16, 13, 2, -16 },
  { 100, 1, 5, 13, 6, -17 },
  { 101, 5, 22, 13, 4, -17 },
  { 115, 5, 22, 13, 4, -17 },
  { 129, 10, 9, 13, 2, -16 },
  { 141, 11, 11, 13, 1, -13 },
  { 157, 2, 5, 13, 4, -2 },
  { 159, 7, 1, 13, 3, -8 },
  { 160, 2, 1, 13, 6, -1 },
  { 161, 7, 17, 13, 3, -16 },
  { 176, 9, 16, 13, 2, -16 },
  { 194, 6, 16, 13, 2, -16 },
  { 206, 10, 16, 13, 1, -16 },
  { 226, 10, 16, 13, 1, -16 },
  { 246, 11, 16, 13, 1, -16 },
  { 268, 10, 16, 13, 2, -16 },
  { 288, 9, 16, 13, 2, -16 },
  { 306, 10, 16, 13, 1, -16 },
  { 326, 10, 16, 13, 2, -16 },
  { 346, 9, 16, 13, 2, -16 },
  { 364, 1, 10, 13, 7, -10 },
  { 366, 2, 13, 13, 6, -10 },
  { 370, 9, 8, 13, 2, -11 },
  { 379, 9, 5, 13, 2, -10 },
  { 385, 9, 9, 13, 2, -12 },
  { 396, 8, 16, 13, 3, -16 },
  { 412, 12, 16, 13, 1, -16 },
  { 436, 11, 16, 13, 1, -16 },
  { 458, 10, 16, 13, 2, -16 },
  { 478, 10, 16, 13, 2, -16 },
  { 498, 10, 16, 13, 2, -16 },
  { 518, 9, 16, 13, 2, -16 },
  { 536, 9, 16, 13, 2, -16 },
  { 554, 11, 16, 13, 1, -16 },
  { 576, 9, 16, 13, 2, -16 },
  { 594, 9, 16, 13, 2, -16 },
  { 612, 10, 16, 13, 1, -16 },
  { 632, 11, 16, 13, 2, -16 },
  { 654, 8, 16, 13, 3, -16 },
  { 670, 9, 16, 13, 2, -16 },
  { 688, 9, 16, 13, 2, -16 },
  { 706, 10, 16, 13, 2, -16 },
  { 726, 9, 16, 13, 3, -16 },
  { 744, 11, 19, 13, 1, -16 },
  { 771, 10, 16, 13, 2, -16 },
  { 791, 10, 16, 13, 2, -16 },
  { 811, 11, 16, 13, 1, -16 },
  { 833, 9, 16, 13, 2, -16 },
  { 851, 11, 16, 13, 1, -16 },
  { 873, 12, 16, 13, 1, -16 },
  { 897, 11, 16, 13, 1, -16 },
  { 919, 11, 16, 13, 1, -16 },
  { 941, 9, 16, 13, 2, -16 },
  { 959, 3, 21, 13, 5, -18 },
  { 967, 7, 17, 13, 3, -16 },
  { 982, 3, 21, 13, 5, -18 },
  { 990, 7, 9, 13, 3, -16 },
  { 998, 9, 1, 13, 2, 0 },
  { 1000, 3, 3, 13, 5, -16 },
  { 1002, 9, 12, 13, 2, -12 },
  { 1016, 9, 17, 13, 2, -17 },
  { 1036, 9, 12, 13, 2, -12 },
  { 1050, 9, 17, 13, 2, -17 },
  { 1070, 9, 12, 13, 2, -12 },
  { 1084, 10, 17, 13, 2, -17 },
  { 1106, 9, 17, 13, 2, -12 },
  { 1126, 9, 17, 13, 2, -17 },
  { 1146, 9, 16, 13, 3, -16 },
  { 1164, 7, 21, 13, 2, -16 },
  { 1183, 9, 17, 13, 3, -17 },
  { 1203, 9, 17, 13, 3, -17 },
  { 1223, 11, 12, 13, 1, -12 },
  { 1240, 9, 12, 13, 2, -12 },
  { 1254, 10, 12, 13, 2, -12 },
  { 1269, 9, 16, 13, 2, -12 },
  { 1287, 9, 16, 13, 2, -12 },
  { 1305, 8, 12, 13, 4, -12 },
  { 1317, 9, 12, 13, 2, -12 },
  { 1331, 9, 15, 13, 2, -15 },
  { 1348, 9, 12, 13, 2, -12 },
  { 1362, 11, 12, 13, 1, -12 },
  { 1379, 12, 12, 13, 1, -12 },
  { 1397, 10, 12, 13, 2, -12 },
  { 1412, 11, 17, 13, 1, -12 },
  { 1436, 11, 12, 13, 1, -12 },
  { 1453, 7, 22, 13, 4, -17 },
  { 1473, 1, 19, 13, 6, -16 },
  { 1476, 7, 22, 13, 4, -17 },
  { 1496, 11, 3, 13, 1, -8 },
};

const GFXfont RobotoMono_Thin22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin22pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_THIN22PT7B_H_
