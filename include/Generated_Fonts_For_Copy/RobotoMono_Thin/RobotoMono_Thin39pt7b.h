#ifndef _ROBOTOMONO_THIN39PT7B_H_
#define _ROBOTOMONO_THIN39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin39pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x00, 0x01, 0x70,
  0x8E, 0x38, 0xA2, 0x8A, 0x28, 0xA2, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00,
  0x10, 0x10, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02,
  0x00, 0x10, 0x10, 0x3F, 0xFF, 0xF8, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02,
  0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x40, 0x40,
  0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x81, 0xFF, 0xFF, 0xE0, 0x40,
  0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x07, 0xF0, 0x18, 0x18, 0x30, 0x04, 0x60, 0x02,
  0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x40, 0x03, 0x20, 0x02, 0x10, 0x0C, 0x0F, 0xF8,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x3E, 0x00, 0x01, 0x8C,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x20, 0x20, 0x80, 0x81, 0x02, 0x02, 0x04,
  0x08, 0x08, 0x20, 0x20, 0x20, 0x80, 0x80, 0x84, 0x02, 0x06, 0x10, 0x04,
  0x10, 0x80, 0x1D, 0x82, 0x00, 0x1C, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x43, 0xF0, 0x02, 0x18, 0x40, 0x08, 0x40,
  0x80, 0x41, 0x02, 0x01, 0x08, 0x08, 0x08, 0x20, 0x30, 0x20, 0x80, 0xC1,
  0x02, 0x02, 0x0C, 0x04, 0x08, 0x10, 0x10, 0x20, 0x00, 0x21, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x01, 0x86, 0x00, 0x60, 0x40, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x80, 0x10, 0x30, 0x01, 0x0C,
  0x00, 0x23, 0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02, 0x40,
  0x00, 0x84, 0x00, 0x20, 0x40, 0x48, 0x0C, 0x09, 0x00, 0xC1, 0x40, 0x08,
  0x28, 0x00, 0x8D, 0x00, 0x09, 0x20, 0x00, 0xA6, 0x00, 0x18, 0x40, 0x03,
  0x8C, 0x00, 0xD0, 0xC0, 0x21, 0x07, 0xF8, 0x10, 0xFF, 0x01, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02,
  0x01, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x08,
  0x10, 0x10, 0x20, 0x40, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x04, 0x04, 0x09, 0xC2, 0x3A, 0x1D, 0x70, 0x01, 0xC0,
  0x00, 0xA0, 0x00, 0x98, 0x00, 0x86, 0x00, 0xC1, 0x00, 0x40, 0x40, 0xC0,
  0x10, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x03, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x24, 0x94, 0xB4, 0xFF, 0xFC, 0xF0, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x06, 0x06,
  0x04, 0x01, 0x86, 0x00, 0x42, 0x00, 0x12, 0x00, 0x09, 0x00, 0x06, 0x80,
  0x03, 0x40, 0x02, 0xC0, 0x02, 0x60, 0x02, 0x30, 0x02, 0x18, 0x02, 0x0C,
  0x02, 0x06, 0x02, 0x03, 0x02, 0x01, 0x82, 0x00, 0xC2, 0x00, 0x62, 0x00,
  0x32, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x40, 0x02, 0x20,
  0x02, 0x08, 0x03, 0x02, 0x03, 0x00, 0xFE, 0x00, 0x00, 0x40, 0xF0, 0xEC,
  0xC3, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xE0, 0x0C, 0x0C, 0x0C,
  0x01, 0x04, 0x00, 0x44, 0x00, 0x22, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0x06, 0x06, 0x0C,
  0x01, 0x84, 0x00, 0x64, 0x00, 0x12, 0x00, 0x09, 0x00, 0x05, 0x80, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01,
  0x18, 0x01, 0x06, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x00,
  0x04, 0x20, 0x01, 0x84, 0x00, 0x20, 0x80, 0x08, 0x10, 0x03, 0x02, 0x00,
  0x40, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x20, 0x04, 0x0C,
  0x00, 0x81, 0x00, 0x10, 0x7F, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x1F, 0xFF, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x2F, 0xF0, 0x70, 0x0C, 0x40, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x20, 0x02, 0x30, 0x06, 0x18, 0x0C, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x11, 0xFC, 0x13, 0x01, 0x8B,
  0x00, 0x67, 0x00, 0x13, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0D, 0x00, 0x04, 0x80,
  0x02, 0x20, 0x02, 0x18, 0x03, 0x02, 0x03, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0x03, 0x01, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x90, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x98, 0x00, 0x22, 0x00, 0x10, 0x40,
  0x0C, 0x0C, 0x06, 0x01, 0xFE, 0x00, 0x73, 0xC0, 0x60, 0x08, 0x20, 0x01,
  0x10, 0x00, 0x24, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x03, 0x60, 0x00, 0x8C, 0x00, 0x41, 0x80, 0x60, 0x1F,
  0xF0, 0x07, 0xF0, 0x06, 0x0C, 0x04, 0x01, 0x04, 0x00, 0x46, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x06, 0x40, 0x05, 0x30,
  0x04, 0x84, 0x0C, 0x41, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xF0,
  0x00, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x67, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x24, 0x44, 0xC8, 0x00, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x06, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xC0, 0xC6, 0x01,
  0x90, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x1E,
  0x0C, 0x01, 0x80, 0x18, 0x18, 0x00, 0x41, 0x80, 0x01, 0x08, 0x00, 0x08,
  0x81, 0xF0, 0x64, 0x18, 0x41, 0x41, 0x82, 0x0A, 0x08, 0x10, 0x50, 0x80,
  0x83, 0x04, 0x04, 0x18, 0x20, 0x20, 0xC1, 0x01, 0x06, 0x08, 0x08, 0x30,
  0x80, 0xC1, 0x84, 0x04, 0x0C, 0x20, 0x20, 0x60, 0x83, 0x03, 0x04, 0x18,
  0x2C, 0x21, 0x21, 0x20, 0x99, 0xB1, 0x03, 0x02, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x09,
  0x00, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20, 0x40, 0x02,
  0x04, 0x00, 0x20, 0x40, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00,
  0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x10, 0x01, 0x81, 0xFF, 0xF8,
  0x10, 0x00, 0x83, 0x00, 0x0C, 0x20, 0x00, 0x42, 0x00, 0x04, 0x40, 0x00,
  0x64, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x03, 0xFF, 0x80, 0x40, 0x38,
  0x20, 0x03, 0x10, 0x00, 0x88, 0x00, 0x24, 0x00, 0x12, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x03, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x01, 0x87,
  0xFF, 0x02, 0x00, 0xE1, 0x00, 0x0C, 0x80, 0x03, 0x40, 0x00, 0xA0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x02, 0x80,
  0x03, 0x40, 0x03, 0x20, 0x07, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0x03,
  0x01, 0x00, 0x60, 0x80, 0x0C, 0x20, 0x01, 0x10, 0x00, 0x24, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09,
  0x80, 0x04, 0x20, 0x01, 0x04, 0x00, 0x80, 0x80, 0xC0, 0x1F, 0xE0, 0xFF,
  0x80, 0x40, 0x70, 0x20, 0x06, 0x10, 0x01, 0x88, 0x00, 0x64, 0x00, 0x12,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x04, 0x40, 0x0C, 0x20, 0x1C, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFC, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x60, 0x80, 0x0C,
  0x60, 0x01, 0x10, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x14, 0x00, 0x05, 0x80, 0x01, 0x20, 0x00, 0x44,
  0x00, 0x20, 0xC0, 0x30, 0x1F, 0xF0, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x02, 0x20, 0x03, 0x18, 0x01, 0x06, 0x03, 0x00, 0xFF, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x48, 0x00, 0x22, 0x00, 0x18, 0x80, 0x0C, 0x20, 0x06,
  0x08, 0x03, 0x02, 0x01, 0x80, 0x80, 0x40, 0x20, 0x20, 0x08, 0x10, 0x02,
  0x08, 0x00, 0x84, 0x00, 0x23, 0x80, 0x09, 0x30, 0x02, 0x84, 0x00, 0xC0,
  0x80, 0x20, 0x10, 0x08, 0x06, 0x02, 0x00, 0xC0, 0x80, 0x10, 0x20, 0x02,
  0x08, 0x00, 0x42, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00, 0x48, 0x00, 0x0A,
  0x00, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x07, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xA0, 0x05, 0xA0, 0x05, 0xA0, 0x09, 0x90, 0x09, 0x90,
  0x11, 0x98, 0x11, 0x88, 0x11, 0x88, 0x21, 0x84, 0x21, 0x84, 0x41, 0x84,
  0x41, 0x82, 0x41, 0x82, 0x81, 0x81, 0x81, 0x81, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x34, 0x00, 0x19,
  0x00, 0x0C, 0x80, 0x06, 0x20, 0x03, 0x10, 0x01, 0x84, 0x00, 0xC1, 0x00,
  0x60, 0x80, 0x30, 0x20, 0x18, 0x10, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x00,
  0x81, 0x80, 0x20, 0xC0, 0x10, 0x60, 0x04, 0x30, 0x02, 0x18, 0x00, 0x8C,
  0x00, 0x46, 0x00, 0x13, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x10, 0x03, 0xF0, 0x03, 0x06, 0x01, 0x00, 0x60, 0x80, 0x08,
  0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0x90, 0x00, 0x24, 0x00, 0x11, 0x80, 0x04, 0x20, 0x02, 0x04,
  0x01, 0x80, 0x80, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0x80, 0x38, 0x80, 0x0C,
  0x80, 0x06, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x06, 0x80, 0x1C,
  0xFF, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0xC0, 0x20, 0x0C, 0x08, 0x00, 0xC2,
  0x00, 0x08, 0x40, 0x00, 0x90, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x88, 0x00, 0x11, 0x00, 0x06, 0x10,
  0x00, 0x83, 0x00, 0x20, 0x30, 0x18, 0x01, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0xFF, 0xC0, 0x40,
  0x38, 0x20, 0x03, 0x10, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x22, 0x00, 0x61, 0xFF, 0xC0, 0x80, 0x20, 0x40, 0x10, 0x20,
  0x04, 0x10, 0x03, 0x08, 0x00, 0x84, 0x00, 0x62, 0x00, 0x11, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x10, 0x03, 0xF8, 0x03,
  0x03, 0x03, 0x00, 0x30, 0x80, 0x04, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00,
  0x0D, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x05, 0x00, 0x03, 0x60, 0x00, 0x8C, 0x00, 0x41, 0x80, 0x60, 0x1F, 0xF0,
  0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x02, 0x20, 0x03,
  0x08, 0x03, 0x02, 0x03, 0x00, 0xFE, 0x00, 0x80, 0x00, 0x30, 0x00, 0x05,
  0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x04, 0x40, 0x01, 0x88, 0x00, 0x21,
  0x00, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0x40, 0x04, 0x04, 0x01, 0x80,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x20, 0x04, 0x04, 0x00,
  0x40, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x60, 0x14, 0x05, 0x01, 0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x90,
  0x24, 0x09, 0x02, 0x40, 0x88, 0x22, 0x10, 0x82, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x44, 0x22, 0x04, 0x41, 0x20, 0x44, 0x12,
  0x04, 0x81, 0x20, 0x48, 0x12, 0x02, 0x81, 0x40, 0x28, 0x14, 0x02, 0x80,
  0xC0, 0x28, 0x0C, 0x02, 0x80, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x80, 0x10,
  0x40, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x41, 0x00, 0x08, 0x18, 0x01,
  0x80, 0x80, 0x10, 0x04, 0x02, 0x00, 0x60, 0x20, 0x02, 0x04, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x09, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0D, 0x00, 0x00, 0x90, 0x00, 0x10, 0x80, 0x03, 0x0C, 0x00,
  0x20, 0x40, 0x04, 0x02, 0x00, 0x40, 0x30, 0x08, 0x01, 0x01, 0x00, 0x08,
  0x10, 0x00, 0x82, 0x00, 0x04, 0x60, 0x00, 0x2C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x09, 0x00, 0x01, 0x30, 0x00, 0x42, 0x00, 0x08, 0x60, 0x02,
  0x04, 0x00, 0x40, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x80, 0x10, 0x10,
  0x01, 0x04, 0x00, 0x21, 0x80, 0x02, 0x20, 0x00, 0x48, 0x00, 0x05, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x1F, 0xFF, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0xF8,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x02,
  0x00, 0x18, 0x01, 0x40, 0x0B, 0x00, 0xC8, 0x04, 0x40, 0x21, 0x02, 0x08,
  0x10, 0x61, 0x81, 0x08, 0x08, 0x40, 0x24, 0x01, 0x20, 0x0E, 0x00, 0x20,
  0xFF, 0xFF, 0xC3, 0x08, 0x21, 0x80, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x00,
  0x84, 0x00, 0x64, 0x00, 0x12, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x1F, 0x83, 0xFF, 0xC3, 0x00, 0x22, 0x00, 0x12, 0x00, 0x09,
  0x00, 0x05, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x98, 0x01, 0x66, 0x03,
  0x11, 0xFE, 0x08, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xE0, 0x9C, 0x38, 0xB0,
  0x0C, 0xA0, 0x04, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x04, 0xA0, 0x0C, 0x90, 0x18, 0x8F,
  0xF0, 0x03, 0xF0, 0x06, 0x06, 0x06, 0x01, 0x86, 0x00, 0x62, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x02, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x01, 0x20,
  0x01, 0x10, 0x00, 0x84, 0x00, 0x81, 0x80, 0x80, 0x7F, 0x80, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x03, 0xE1, 0x0C, 0x19, 0x10, 0x05, 0x20, 0x03, 0x20, 0x03,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x60, 0x01,
  0x20, 0x03, 0x10, 0x07, 0x18, 0x0D, 0x07, 0xF1, 0x03, 0xF0, 0x07, 0x06,
  0x06, 0x01, 0x86, 0x00, 0x62, 0x00, 0x12, 0x00, 0x05, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x61, 0x80, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x38, 0x40, 0x60, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x7F, 0xFF, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x03, 0xE1, 0x0C,
  0x19, 0x10, 0x05, 0x20, 0x03, 0x20, 0x03, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x60, 0x01, 0x20, 0x03, 0x10, 0x07, 0x08,
  0x0D, 0x07, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x20,
  0x02, 0x30, 0x04, 0x18, 0x08, 0x07, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x83,
  0xF0, 0x8C, 0x18, 0x90, 0x04, 0xA0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x07, 0xFF, 0xF0, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x8F, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x06, 0x80, 0x0C,
  0x80, 0x18, 0x80, 0x20, 0x80, 0x40, 0x80, 0x80, 0x83, 0x00, 0x86, 0x00,
  0x8C, 0x00, 0x98, 0x00, 0xA4, 0x00, 0xC2, 0x00, 0x81, 0x00, 0x81, 0x80,
  0x80, 0xC0, 0x80, 0x60, 0x80, 0x30, 0x80, 0x18, 0x80, 0x08, 0x80, 0x04,
  0x80, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x0F, 0xFF, 0xE0, 0x9F, 0x07, 0x8A,
  0x19, 0x86, 0xC0, 0x60, 0x28, 0x06, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01,
  0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40,
  0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04,
  0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x10, 0x83, 0xF0, 0x8C, 0x18, 0x90, 0x04, 0xA0, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x03, 0xF0, 0x03, 0x07,
  0x01, 0x00, 0x60, 0x80, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x28, 0x00, 0x0B, 0x00, 0x02, 0x40, 0x01, 0x08, 0x00,
  0x43, 0x00, 0x20, 0x60, 0x30, 0x07, 0xF8, 0x00, 0x87, 0xE0, 0x98, 0x30,
  0xB0, 0x08, 0xE0, 0x04, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x04, 0xA0, 0x0C, 0x90, 0x18,
  0x8F, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xE1, 0x0C, 0x19, 0x10, 0x05,
  0x20, 0x03, 0x20, 0x03, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x60, 0x01, 0x20, 0x03, 0x10, 0x07, 0x08, 0x0D, 0x07, 0xF1,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x81, 0xFC, 0x30, 0x32, 0x01, 0xA0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x07, 0xF0, 0x18, 0x1C, 0x20, 0x06, 0x40, 0x02, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x02, 0x30, 0x0C, 0x0F, 0xF8, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x1F, 0xFF, 0x80, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFC, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x02, 0x80, 0x0D, 0x80, 0x39, 0x80, 0xD1,
  0xFE, 0x20, 0x80, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0x10, 0x00, 0x22,
  0x00, 0x08, 0x60, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08, 0x08, 0x03, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x02, 0x00, 0x60, 0x40, 0x04, 0x10, 0x00,
  0xC2, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00,
  0x70, 0x00, 0x04, 0x00, 0xC0, 0x20, 0x0A, 0x01, 0x80, 0x50, 0x0C, 0x02,
  0x80, 0x60, 0x36, 0x05, 0x01, 0x10, 0x24, 0x08, 0x81, 0x20, 0x44, 0x09,
  0x02, 0x20, 0x88, 0x20, 0x84, 0x21, 0x04, 0x21, 0x08, 0x21, 0x08, 0x41,
  0x10, 0x44, 0x0C, 0x81, 0x20, 0x24, 0x09, 0x01, 0x20, 0x48, 0x0A, 0x02,
  0x40, 0x50, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x00,
  0xC0, 0x00, 0xD8, 0x00, 0x62, 0x00, 0x10, 0x40, 0x08, 0x08, 0x04, 0x03,
  0x03, 0x00, 0x61, 0x80, 0x08, 0x40, 0x01, 0x20, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x20, 0x00, 0x84, 0x00, 0x41, 0x80, 0x30, 0x30,
  0x18, 0x04, 0x04, 0x00, 0x82, 0x00, 0x11, 0x00, 0x06, 0xC0, 0x00, 0xC0,
  0x80, 0x00, 0x38, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x04, 0x20, 0x00,
  0x42, 0x00, 0x08, 0x30, 0x00, 0x81, 0x00, 0x18, 0x18, 0x01, 0x00, 0x80,
  0x30, 0x0C, 0x02, 0x00, 0x40, 0x60, 0x06, 0x04, 0x00, 0x20, 0x40, 0x02,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x38, 0x03, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x3C, 0x01, 0xE0, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x8C, 0x00, 0x58, 0x10, 0x02, 0x80, 0x60, 0x24, 0x01, 0x81, 0x40,
  0x03, 0xF0, 0x00, 0x04, 0x00,
};

const GFXglyph RobotoMono_Thin39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 3, 28, 23, 10, -28 },
  { 12, 6, 8, 23, 9, -29 },
  { 18, 21, 28, 23, 1, -28 },
  { 92, 16, 36, 23, 4, -32 },
  { 164, 22, 28, 23, 1, -28 },
  { 241, 19, 28, 23, 3, -28 },
  { 308, 1, 8, 23, 10, -29 },
  { 309, 8, 40, 23, 8, -31 },
  { 349, 8, 40, 23, 7, -31 },
  { 389, 17, 15, 23, 4, -28 },
  { 421, 19, 20, 23, 2, -23 },
  { 469, 3, 8, 23, 8, -3 },
  { 472, 14, 1, 23, 5, -13 },
  { 474, 2, 2, 23, 11, -2 },
  { 475, 13, 30, 23, 6, -28 },
  { 524, 17, 28, 23, 3, -28 },
  { 584, 10, 28, 23, 4, -28 },
  { 619, 17, 28, 23, 2, -28 },
  { 679, 17, 28, 23, 2, -28 },
  { 739, 19, 28, 23, 2, -28 },
  { 806, 16, 28, 23, 4, -28 },
  { 862, 17, 28, 23, 3, -28 },
  { 922, 17, 28, 23, 3, -28 },
  { 982, 18, 28, 23, 3, -28 },
  { 1045, 17, 28, 23, 3, -28 },
  { 1105, 3, 19, 23, 12, -19 },
  { 1113, 4, 24, 23, 11, -19 },
  { 1125, 17, 15, 23, 3, -20 },
  { 1157, 17, 9, 23, 3, -17 },
  { 1177, 16, 15, 23, 4, -20 },
  { 1207, 14, 28, 23, 5, -28 },
  { 1256, 21, 28, 23, 1, -28 },
  { 1330, 20, 28, 23, 2, -28 },
  { 1400, 17, 28, 23, 4, -28 },
  { 1460, 18, 28, 23, 3, -28 },
  { 1523, 17, 28, 23, 4, -28 },
  { 1583, 16, 28, 23, 4, -28 },
  { 1639, 16, 28, 23, 4, -28 },
  { 1695, 18, 28, 23, 3, -28 },
  { 1758, 17, 28, 23, 3, -28 },
  { 1818, 15, 28, 23, 4, -28 },
  { 1871, 17, 28, 23, 2, -28 },
  { 1931, 18, 28, 23, 4, -28 },
  { 1994, 15, 28, 23, 5, -28 },
  { 2047, 16, 28, 23, 4, -28 },
  { 2103, 17, 28, 23, 3, -28 },
  { 2163, 18, 28, 23, 3, -28 },
  { 2226, 16, 28, 23, 5, -28 },
  { 2282, 19, 33, 23, 2, -28 },
  { 2361, 17, 28, 23, 4, -28 },
  { 2421, 18, 28, 23, 3, -28 },
  { 2484, 19, 28, 23, 2, -28 },
  { 2551, 17, 28, 23, 3, -28 },
  { 2611, 19, 28, 23, 2, -28 },
  { 2678, 20, 28, 23, 2, -28 },
  { 2748, 20, 28, 23, 2, -28 },
  { 2818, 19, 28, 23, 2, -28 },
  { 2885, 17, 28, 23, 3, -28 },
  { 2945, 6, 38, 23, 9, -32 },
  { 2974, 13, 30, 23, 5, -28 },
  { 3023, 5, 38, 23, 9, -32 },
  { 3047, 13, 15, 23, 5, -28 },
  { 3072, 16, 1, 23, 4, 0 },
  { 3074, 5, 5, 23, 9, -29 },
  { 3078, 17, 21, 23, 3, -21 },
  { 3123, 16, 29, 23, 4, -29 },
  { 3181, 17, 21, 23, 3, -21 },
  { 3226, 16, 29, 23, 3, -29 },
  { 3284, 17, 21, 23, 3, -21 },
  { 3329, 17, 30, 23, 4, -30 },
  { 3393, 16, 29, 23, 3, -21 },
  { 3451, 16, 29, 23, 4, -29 },
  { 3509, 15, 28, 23, 5, -28 },
  { 3562, 12, 36, 23, 3, -28 },
  { 3616, 16, 29, 23, 5, -29 },
  { 3674, 15, 29, 23, 5, -29 },
  { 3729, 20, 21, 23, 2, -21 },
  { 3782, 16, 21, 23, 4, -21 },
  { 3824, 18, 21, 23, 3, -21 },
  { 3872, 16, 29, 23, 4, -21 },
  { 3930, 16, 29, 23, 3, -21 },
  { 3988, 13, 21, 23, 7, -21 },
  { 4023, 16, 21, 23, 4, -21 },
  { 4065, 15, 26, 23, 4, -26 },
  { 4114, 15, 21, 23, 4, -21 },
  { 4154, 19, 21, 23, 2, -21 },
  { 4204, 21, 21, 23, 1, -21 },
  { 4260, 18, 21, 23, 3, -21 },
  { 4308, 20, 29, 23, 2, -21 },
  { 4381, 18, 21, 23, 3, -21 },
  { 4429, 13, 38, 23, 6, -30 },
  { 4491, 1, 33, 23, 11, -28 },
  { 4496, 13, 38, 23, 6, -30 },
  { 4558, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_Thin39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin39pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_THIN39PT7B_H_
