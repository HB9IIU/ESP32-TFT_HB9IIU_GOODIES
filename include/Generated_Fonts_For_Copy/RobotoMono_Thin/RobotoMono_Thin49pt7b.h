#ifndef _ROBOTOMONO_THIN49PT7B_H_
#define _ROBOTOMONO_THIN49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin49pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x00,
  0x00, 0x5F, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x08,
  0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x20, 0x00,
  0x10, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x18, 0x06,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x08, 0x02, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x20, 0x00, 0x10, 0x04, 0x00,
  0x02, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x01, 0xFF, 0x00, 0x38, 0x0E, 0x03, 0x00, 0x18, 0x30, 0x00, 0x41, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00, 0x01, 0x20, 0x00, 0x09,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x06,
  0x0C, 0x00, 0x60, 0x38, 0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x30, 0x00, 0x0C,
  0x02, 0x00, 0x81, 0x00, 0x40, 0x10, 0x20, 0x08, 0x04, 0x04, 0x01, 0x81,
  0x80, 0x80, 0x30, 0x20, 0x10, 0x04, 0x0C, 0x03, 0x00, 0x81, 0x00, 0x20,
  0x10, 0x60, 0x04, 0x06, 0x08, 0x00, 0xC1, 0x83, 0x00, 0x0E, 0xE0, 0x40,
  0x00, 0x78, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x07, 0x00, 0x01, 0x83, 0xF8, 0x00, 0x20, 0xC1,
  0x80, 0x0C, 0x10, 0x10, 0x01, 0x06, 0x03, 0x00, 0x60, 0x80, 0x20, 0x08,
  0x10, 0x04, 0x02, 0x02, 0x00, 0x80, 0x40, 0x40, 0x10, 0x10, 0x08, 0x02,
  0x06, 0x01, 0x00, 0x40, 0x80, 0x20, 0x08, 0x10, 0x06, 0x03, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x04, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x02, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x03, 0x00,
  0x18, 0x01, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x02, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x06, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x20, 0x00,
  0x30, 0x10, 0x06, 0x60, 0x18, 0x06, 0x40, 0x0C, 0x06, 0xC0, 0x06, 0x04,
  0xC0, 0x03, 0x04, 0x80, 0x01, 0x0C, 0x80, 0x00, 0x8C, 0x80, 0x00, 0xC8,
  0x80, 0x00, 0x78, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x30, 0x60, 0x00, 0x48,
  0x30, 0x01, 0x8C, 0x1C, 0x07, 0x06, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0x40, 0x30, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x10, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x02, 0x00, 0x80, 0x5E,
  0x04, 0x0F, 0x1E, 0x23, 0xC0, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0xA0,
  0x00, 0x0D, 0x80, 0x00, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0x40, 0x60, 0x04,
  0x01, 0x80, 0x60, 0x04, 0x06, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x24, 0x92, 0x4B, 0x50, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x5F, 0x80,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x18, 0x03, 0x00, 0x30,
  0x30, 0x00, 0x83, 0x00, 0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0x48, 0x00,
  0x02, 0x40, 0x00, 0x1A, 0x00, 0x01, 0xF0, 0x00, 0x1B, 0x80, 0x01, 0x98,
  0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x18,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC1,
  0x80, 0x06, 0x18, 0x00, 0x39, 0x80, 0x01, 0xD8, 0x00, 0x0B, 0x80, 0x00,
  0x58, 0x00, 0x06, 0x80, 0x00, 0x26, 0x00, 0x01, 0x10, 0x00, 0x18, 0xC0,
  0x00, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0xFF, 0x80,
  0x00, 0x10, 0x07, 0x03, 0x90, 0xE1, 0x38, 0x1E, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x70, 0x38, 0x06, 0x00,
  0x60, 0x60, 0x01, 0x86, 0x00, 0x04, 0x20, 0x00, 0x33, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x34, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C,
  0x30, 0x00, 0x10, 0x80, 0x00, 0x62, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x23,
  0x00, 0x01, 0x84, 0x00, 0x04, 0x0C, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x20, 0x40, 0x00,
  0x60, 0x40, 0x00, 0x40, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80, 0x40, 0x03,
  0x00, 0x40, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x08,
  0x00, 0x40, 0x18, 0x00, 0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x60,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x3F,
  0xFF, 0xE3, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x3F, 0x00, 0x5F, 0x1E,
  0x07, 0x00, 0x30, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x2C,
  0x00, 0x06, 0x40, 0x00, 0x42, 0x00, 0x0C, 0x30, 0x01, 0x80, 0xC0, 0x70,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x0F,
  0xC0, 0x63, 0xC7, 0x82, 0x30, 0x06, 0x12, 0x00, 0x18, 0xA0, 0x00, 0x66,
  0x00, 0x01, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x24, 0x00, 0x01, 0x30, 0x00, 0x18, 0x80, 0x00,
  0x82, 0x00, 0x0C, 0x1C, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x0E,
  0x06, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x80, 0x00, 0x66, 0x00, 0x00, 0x98,
  0x00, 0x02, 0x60, 0x00, 0x09, 0x80, 0x00, 0x26, 0x00, 0x00, 0x88, 0x00,
  0x02, 0x20, 0x00, 0x18, 0x40, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x80, 0x30,
  0x03, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x1C, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x11, 0x80, 0x00, 0x24, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00, 0x05,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x70, 0x38,
  0x07, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x30, 0x38, 0x07, 0x00,
  0x60, 0x20, 0x00, 0x83, 0x00, 0x06, 0x30, 0x00, 0x19, 0x00, 0x00, 0x48,
  0x00, 0x02, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40,
  0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00, 0x0A, 0x60, 0x00, 0xD1, 0x80, 0x0C,
  0x86, 0x01, 0xC4, 0x1F, 0xF8, 0x60, 0x3E, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xF8,
  0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0x27, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x22, 0x26, 0x64,
  0xC8, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x07, 0x03, 0x83, 0x00,
  0x31, 0x80, 0x06, 0x40, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x00, 0x18, 0x01,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x30, 0xC0, 0x3C, 0x02, 0x10, 0x1C, 0xE0, 0x46, 0x06, 0x06, 0x0C, 0x81,
  0x80, 0x81, 0xB0, 0x20, 0x10, 0x36, 0x0C, 0x02, 0x02, 0x81, 0x00, 0x40,
  0x50, 0x20, 0x08, 0x0A, 0x04, 0x01, 0x01, 0xC1, 0x80, 0x20, 0x38, 0x30,
  0x0C, 0x07, 0x04, 0x01, 0x80, 0xE0, 0x80, 0x20, 0x3C, 0x10, 0x04, 0x07,
  0x82, 0x00, 0x80, 0xB0, 0x40, 0x30, 0x12, 0x0C, 0x06, 0x02, 0x40, 0x81,
  0x60, 0xC8, 0x10, 0x6C, 0x11, 0x83, 0x18, 0xC4, 0x30, 0x3E, 0x0F, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x26, 0x00, 0x00, 0x62, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x43, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x81, 0x00, 0x00, 0x81, 0x80,
  0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x03, 0x00, 0x40,
  0x02, 0x00, 0x40, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x20,
  0x04, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x10, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x04,
  0x03, 0xF0, 0x20, 0x00, 0xE1, 0x00, 0x01, 0x88, 0x00, 0x04, 0x40, 0x00,
  0x32, 0x00, 0x00, 0x90, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0,
  0x00, 0x0D, 0x00, 0x00, 0x48, 0x00, 0x06, 0x40, 0x00, 0x22, 0x00, 0x03,
  0x10, 0x00, 0x60, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x20, 0x00, 0x61, 0x00,
  0x00, 0xC8, 0x00, 0x03, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0xD0, 0x00, 0x0C, 0x80, 0x00, 0xC4,
  0x00, 0x3C, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01, 0x82, 0x00, 0x01, 0x0C, 0x00,
  0x03, 0x10, 0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x11, 0x00,
  0x00, 0x23, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0xE0, 0x02, 0x01, 0xF0, 0x08, 0x00, 0x70, 0x20, 0x00, 0x60,
  0x80, 0x00, 0xC2, 0x00, 0x01, 0x08, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00,
  0x68, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88,
  0x00, 0x0C, 0x20, 0x00, 0x60, 0x80, 0x07, 0x02, 0x00, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0x03, 0x80, 0x18, 0x01, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01,
  0x82, 0x00, 0x01, 0x08, 0x00, 0x03, 0x10, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00,
  0x05, 0x80, 0x00, 0x09, 0x00, 0x00, 0x13, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x86, 0x00, 0x03, 0x06, 0x00, 0x1C, 0x07, 0x00, 0xE0,
  0x03, 0xFF, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x34, 0x00, 0x01, 0x20, 0x00, 0x19, 0x80, 0x00, 0x86, 0x00, 0x0C, 0x18,
  0x00, 0xC0, 0x70, 0x1C, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x33, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x60, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x9B, 0x00, 0x03, 0x63,
  0x00, 0x07, 0x83, 0x00, 0x0E, 0x03, 0x00, 0x18, 0x02, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x04,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x08, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xD0, 0x00, 0x2F, 0x40, 0x01, 0xBD, 0x80, 0x04, 0xF2,
  0x00, 0x13, 0xCC, 0x00, 0xCF, 0x10, 0x02, 0x3C, 0x40, 0x18, 0xF1, 0x80,
  0x43, 0xC2, 0x01, 0x0F, 0x08, 0x0C, 0x3C, 0x30, 0x20, 0xF0, 0x41, 0x83,
  0xC1, 0x84, 0x0F, 0x02, 0x10, 0x3C, 0x08, 0x80, 0xF0, 0x32, 0x03, 0xC0,
  0x58, 0x0F, 0x01, 0x40, 0x3C, 0x03, 0x00, 0xF0, 0x08, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1D, 0x00, 0x00, 0xEC, 0x00, 0x07, 0x20, 0x00, 0x39,
  0x80, 0x01, 0xC4, 0x00, 0x0E, 0x10, 0x00, 0x70, 0x80, 0x03, 0x82, 0x00,
  0x1C, 0x18, 0x00, 0xE0, 0x40, 0x07, 0x03, 0x00, 0x38, 0x08, 0x01, 0xC0,
  0x60, 0x0E, 0x01, 0x00, 0x70, 0x04, 0x03, 0x80, 0x20, 0x1C, 0x00, 0x80,
  0xE0, 0x06, 0x07, 0x00, 0x10, 0x38, 0x00, 0xC1, 0xC0, 0x02, 0x0E, 0x00,
  0x08, 0x70, 0x00, 0x43, 0x80, 0x01, 0x1C, 0x00, 0x0C, 0xE0, 0x00, 0x27,
  0x00, 0x01, 0xB8, 0x00, 0x05, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0x00, 0xFF, 0x00, 0x07, 0x03, 0x00, 0x18, 0x01, 0x80, 0x60, 0x01,
  0x01, 0x80, 0x01, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x40, 0x00,
  0x06, 0x80, 0x00, 0x09, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x82, 0x00, 0x03, 0x06, 0x00, 0x04, 0x06, 0x00, 0x18, 0x06, 0x00, 0x60,
  0x06, 0x03, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0xF8, 0x20,
  0x00, 0x61, 0x00, 0x01, 0x88, 0x00, 0x06, 0x40, 0x00, 0x1A, 0x00, 0x00,
  0x50, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x06,
  0x80, 0x00, 0x64, 0x00, 0x06, 0x20, 0x01, 0xE1, 0xFF, 0xFC, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x81, 0xC0, 0x06, 0x00, 0x60, 0x08,
  0x00, 0x30, 0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x60,
  0x00, 0x04, 0x40, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x08, 0x10, 0x00, 0x18, 0x08,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x03, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x03, 0x00, 0xF8, 0x0C, 0x00,
  0x38, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0x8C, 0x00, 0x03,
  0x30, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x30,
  0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x70, 0x3F, 0xFF, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x80, 0xC0,
  0x03, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x43, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x13,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0x1C, 0x0F, 0x01,
  0x80, 0x06, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x11, 0x80, 0x00, 0x64, 0x00,
  0x00, 0x90, 0x00, 0x03, 0x40, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x05, 0x00, 0x00, 0x36, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x38, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x02, 0x80, 0x00, 0x34, 0x00, 0x01, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x82, 0x00, 0x0C, 0x08, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0xFF, 0x80,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06,
  0x40, 0x00, 0x04, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08,
  0x30, 0x00, 0x08, 0x10, 0x00, 0x18, 0x10, 0x00, 0x10, 0x18, 0x00, 0x10,
  0x08, 0x00, 0x30, 0x08, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x02, 0x00, 0x80,
  0x02, 0x00, 0x80, 0x03, 0x01, 0x80, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x82, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x44, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x50, 0x03, 0x00, 0x14, 0x00, 0xC0, 0x05, 0x00, 0x38, 0x03, 0x40, 0x0E,
  0x00, 0x90, 0x02, 0x80, 0x26, 0x01, 0xA0, 0x09, 0x80, 0x48, 0x02, 0x20,
  0x13, 0x00, 0x88, 0x04, 0xC0, 0x62, 0x01, 0x10, 0x10, 0x80, 0xC4, 0x04,
  0x30, 0x21, 0x01, 0x0C, 0x08, 0x40, 0x41, 0x02, 0x18, 0x10, 0x40, 0x82,
  0x0C, 0x10, 0x60, 0x82, 0x04, 0x18, 0x20, 0x81, 0x84, 0x08, 0x20, 0x61,
  0x03, 0x08, 0x08, 0x40, 0x42, 0x02, 0x30, 0x11, 0x80, 0x8C, 0x04, 0x60,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x64, 0x03, 0x20, 0x19, 0x00, 0x58, 0x02,
  0x40, 0x16, 0x00, 0x90, 0x05, 0x00, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x50,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00,
  0x20, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30, 0x00, 0x04,
  0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x08, 0x00, 0x10, 0x04, 0x00, 0x30,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x80,
  0x00, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x42, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x62, 0x00, 0x00, 0x43, 0x00, 0x00, 0x81, 0x00,
  0x01, 0x81, 0x80, 0x01, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x08, 0x00, 0x18, 0x10, 0x00, 0x08,
  0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x18,
  0x04, 0x00, 0x10, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x40,
  0x01, 0x00, 0x40, 0x01, 0x80, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x62, 0x00, 0x00, 0x26, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x50, 0x00, 0x2C, 0x00, 0x32, 0x00, 0x11, 0x80, 0x18, 0x40, 0x08, 0x20,
  0x04, 0x18, 0x06, 0x04, 0x02, 0x03, 0x03, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x30, 0xC0, 0x08, 0x40, 0x06, 0x60, 0x01, 0x20, 0x00, 0xF0, 0x00, 0x60,
  0xFF, 0xFF, 0xF0, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x03, 0xFF, 0x00, 0x70,
  0x0C, 0x06, 0x00, 0x10, 0x60, 0x00, 0x42, 0x00, 0x03, 0x30, 0x00, 0x09,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0x07, 0x00, 0x08, 0xE0, 0x00, 0x44,
  0x00, 0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00,
  0x2C, 0x00, 0x03, 0x20, 0x00, 0x39, 0x80, 0x03, 0x66, 0x00, 0x33, 0x18,
  0x07, 0x18, 0x7F, 0xE0, 0x40, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x3F, 0xC0, 0xCE,
  0x07, 0x0D, 0x80, 0x18, 0xF0, 0x00, 0xCE, 0x00, 0x04, 0xC0, 0x00, 0x6C,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x06, 0xE0, 0x00, 0x4E, 0x00, 0x0C, 0xD8, 0x01, 0x8C, 0xC0, 0x70, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x30, 0x30, 0x00,
  0xC3, 0x00, 0x03, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x03, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x02, 0xC0, 0x00, 0x32, 0x00, 0x01, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x81, 0x80, 0x0C, 0x06, 0x01, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x3F, 0xC1, 0x06, 0x07, 0x10, 0xC0, 0x19, 0x10, 0x00,
  0x53, 0x00, 0x07, 0x20, 0x00, 0x36, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x60, 0x00, 0x12, 0x00, 0x03, 0x30, 0x00, 0x31, 0x00, 0x05,
  0x08, 0x00, 0xD0, 0x60, 0x39, 0x03, 0xFE, 0x10, 0x01, 0xFE, 0x00, 0x38,
  0x1C, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC3, 0x00, 0x03, 0x10, 0x00, 0x09,
  0x80, 0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x61, 0x80, 0x06, 0x07,
  0x00, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xFC, 0x10, 0x60, 0x71, 0x0C, 0x01, 0x91, 0x80, 0x05, 0x30, 0x00, 0x72,
  0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x16, 0x00,
  0x01, 0x20, 0x00, 0x33, 0x00, 0x03, 0x10, 0x00, 0x70, 0x80, 0x0D, 0x06,
  0x03, 0x90, 0x3F, 0xE1, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0x41, 0x80, 0x18,
  0x0E, 0x03, 0x00, 0x3F, 0xE0, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x1F, 0xE0, 0x87,
  0x03, 0x88, 0xC0, 0x0C, 0x98, 0x00, 0x4B, 0x00, 0x06, 0xA0, 0x00, 0x2C,
  0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x0F, 0xFC, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x06, 0x80, 0x00, 0xC8, 0x00, 0x10, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80,
  0x18, 0x08, 0x03, 0x00, 0x80, 0x60, 0x08, 0x0C, 0x00, 0x83, 0x00, 0x08,
  0x60, 0x00, 0x8E, 0x00, 0x09, 0xB0, 0x00, 0xB1, 0x80, 0x0C, 0x0C, 0x00,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x10, 0x08, 0x01, 0x80, 0x80, 0x0C,
  0x08, 0x00, 0x60, 0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00,
  0x06, 0x80, 0x00, 0x30, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xF0, 0x8F, 0xE0, 0xFE, 0x4C, 0x18, 0xC1, 0xA8, 0x06, 0x80, 0x7C, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x81,
  0xFE, 0x08, 0x70, 0x38, 0x8C, 0x00, 0xC9, 0x80, 0x04, 0xB0, 0x00, 0x6A,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x01, 0xFF, 0x00, 0x06, 0x03, 0x80, 0x38, 0x01,
  0x80, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x01, 0x08, 0x00, 0x03,
  0x30, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x11, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x82, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x30, 0x07, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0xC3, 0xFC, 0x0C, 0xE0, 0x70,
  0xD8, 0x01, 0x8F, 0x00, 0x0C, 0xE0, 0x00, 0x4C, 0x00, 0x06, 0xC0, 0x00,
  0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C,
  0x00, 0x04, 0xE0, 0x00, 0xCD, 0x00, 0x18, 0xCC, 0x07, 0x0C, 0x7F, 0xC0,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFC, 0x10, 0x60, 0x71, 0x0C, 0x01, 0x91, 0x80, 0x0D, 0x30,
  0x00, 0x72, 0x00, 0x03, 0x60, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00,
  0x16, 0x00, 0x01, 0x20, 0x00, 0x13, 0x00, 0x03, 0x10, 0x00, 0x70, 0x80,
  0x0D, 0x06, 0x03, 0x90, 0x3F, 0xE1, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xC0, 0xFF, 0xE1, 0xC0, 0x33,
  0x80, 0x19, 0x00, 0x0D, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xC0, 0x38, 0x30, 0x00, 0xC6, 0x00,
  0x06, 0x40, 0x00, 0x34, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x60, 0x00,
  0x33, 0x00, 0x06, 0x1C, 0x01, 0xC0, 0x7F, 0xF0, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x07, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xE0, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x14, 0x00, 0x06, 0xC0, 0x00, 0xC8, 0x00, 0x29, 0x80, 0x0D,
  0x1C, 0x07, 0x20, 0xFF, 0x84, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x40,
  0x00, 0x04, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x10,
  0x00, 0x18, 0x10, 0x00, 0x10, 0x18, 0x00, 0x30, 0x08, 0x00, 0x20, 0x0C,
  0x00, 0x20, 0x04, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x02,
  0x00, 0x80, 0x03, 0x01, 0x80, 0x01, 0x01, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x83, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x46, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x09, 0x00, 0x70, 0x02,
  0x40, 0x16, 0x00, 0x90, 0x04, 0x80, 0x66, 0x01, 0x20, 0x18, 0x80, 0xC8,
  0x04, 0x20, 0x33, 0x01, 0x08, 0x08, 0x40, 0xC3, 0x02, 0x10, 0x30, 0xC1,
  0x84, 0x08, 0x10, 0x41, 0x82, 0x04, 0x10, 0x20, 0x81, 0x84, 0x08, 0x60,
  0x63, 0x02, 0x10, 0x08, 0x80, 0xC4, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04,
  0xC0, 0x36, 0x01, 0x30, 0x05, 0x00, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x02, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x18, 0x08,
  0x00, 0x40, 0x30, 0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0xC0, 0x01, 0x86,
  0x00, 0x02, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x33, 0x00, 0x01, 0x86, 0x00, 0x0C,
  0x0C, 0x00, 0x20, 0x10, 0x01, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x60, 0x01,
  0x83, 0x00, 0x03, 0x08, 0x00, 0x04, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x60, 0x00, 0x10, 0x30, 0x00,
  0x18, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x01, 0x00, 0x06, 0x00, 0xC0,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x00, 0x04, 0x01, 0x80, 0x03,
  0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x10, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x02, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x32, 0x06, 0x00, 0x0D, 0x00, 0x60, 0x02, 0xC0, 0x0C,
  0x00, 0xA0, 0x01, 0x80, 0x48, 0x00, 0x38, 0x32, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_Thin49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 3, 35, 29, 13, -35 },
  { 15, 7, 10, 29, 11, -37 },
  { 24, 27, 35, 29, 1, -35 },
  { 143, 21, 45, 29, 5, -40 },
  { 262, 27, 36, 29, 1, -35 },
  { 384, 24, 35, 29, 4, -35 },
  { 489, 1, 10, 29, 13, -37 },
  { 491, 10, 50, 29, 10, -39 },
  { 554, 10, 50, 29, 9, -39 },
  { 617, 21, 19, 29, 5, -35 },
  { 667, 24, 26, 29, 3, -29 },
  { 745, 3, 10, 29, 10, -4 },
  { 749, 17, 2, 29, 6, -17 },
  { 754, 3, 3, 29, 14, -3 },
  { 756, 16, 38, 29, 7, -35 },
  { 832, 21, 35, 29, 4, -35 },
  { 924, 12, 35, 29, 5, -35 },
  { 977, 21, 35, 29, 3, -35 },
  { 1069, 22, 35, 29, 2, -35 },
  { 1166, 24, 35, 29, 2, -35 },
  { 1271, 20, 35, 29, 6, -35 },
  { 1359, 21, 35, 29, 4, -35 },
  { 1451, 23, 35, 29, 3, -35 },
  { 1552, 22, 35, 29, 4, -35 },
  { 1649, 21, 35, 29, 4, -35 },
  { 1741, 3, 24, 29, 15, -24 },
  { 1750, 4, 30, 29, 14, -24 },
  { 1765, 21, 20, 29, 4, -26 },
  { 1818, 22, 11, 29, 4, -21 },
  { 1849, 21, 20, 29, 4, -26 },
  { 1902, 18, 35, 29, 6, -35 },
  { 1981, 27, 35, 29, 1, -35 },
  { 2100, 24, 35, 29, 3, -35 },
  { 2205, 21, 35, 29, 5, -35 },
  { 2297, 23, 36, 29, 3, -35 },
  { 2401, 22, 35, 29, 5, -35 },
  { 2498, 20, 35, 29, 5, -35 },
  { 2586, 20, 35, 29, 5, -35 },
  { 2674, 23, 35, 29, 3, -35 },
  { 2775, 21, 35, 29, 4, -35 },
  { 2867, 19, 35, 29, 5, -35 },
  { 2951, 21, 35, 29, 3, -35 },
  { 3043, 23, 35, 29, 5, -35 },
  { 3144, 20, 35, 29, 6, -35 },
  { 3232, 22, 35, 29, 4, -35 },
  { 3329, 21, 35, 29, 4, -35 },
  { 3421, 23, 35, 29, 3, -35 },
  { 3522, 21, 35, 29, 6, -35 },
  { 3614, 24, 41, 29, 3, -35 },
  { 3737, 22, 35, 29, 5, -35 },
  { 3834, 22, 35, 29, 4, -35 },
  { 3931, 24, 35, 29, 3, -35 },
  { 4036, 21, 35, 29, 4, -35 },
  { 4128, 24, 35, 29, 3, -35 },
  { 4233, 26, 35, 29, 2, -35 },
  { 4347, 24, 35, 29, 3, -35 },
  { 4452, 24, 35, 29, 2, -35 },
  { 4557, 22, 35, 29, 3, -35 },
  { 4654, 8, 47, 29, 11, -40 },
  { 4701, 16, 38, 29, 7, -35 },
  { 4777, 7, 47, 29, 11, -40 },
  { 4819, 17, 19, 29, 6, -35 },
  { 4860, 20, 1, 29, 5, 0 },
  { 4863, 6, 6, 29, 12, -36 },
  { 4868, 21, 26, 29, 4, -26 },
  { 4937, 20, 37, 29, 5, -37 },
  { 5030, 21, 26, 29, 4, -26 },
  { 5099, 20, 37, 29, 4, -37 },
  { 5192, 21, 26, 29, 4, -26 },
  { 5261, 22, 37, 29, 5, -37 },
  { 5363, 20, 36, 29, 4, -26 },
  { 5453, 20, 37, 29, 5, -37 },
  { 5546, 20, 35, 29, 6, -35 },
  { 5634, 15, 45, 29, 4, -35 },
  { 5719, 20, 37, 29, 6, -37 },
  { 5812, 20, 37, 29, 6, -37 },
  { 5905, 25, 26, 29, 2, -26 },
  { 5987, 20, 26, 29, 5, -26 },
  { 6052, 23, 26, 29, 3, -26 },
  { 6127, 20, 36, 29, 5, -26 },
  { 6217, 20, 36, 29, 4, -26 },
  { 6307, 17, 26, 29, 9, -26 },
  { 6363, 20, 26, 29, 5, -26 },
  { 6428, 19, 33, 29, 5, -33 },
  { 6507, 19, 26, 29, 5, -26 },
  { 6569, 24, 26, 29, 3, -26 },
  { 6647, 26, 26, 29, 2, -26 },
  { 6732, 22, 26, 29, 4, -26 },
  { 6804, 25, 36, 29, 2, -26 },
  { 6917, 24, 26, 29, 3, -26 },
  { 6995, 16, 49, 29, 8, -38 },
  { 7093, 1, 41, 29, 14, -35 },
  { 7099, 16, 49, 29, 8, -38 },
  { 7197, 26, 8, 29, 2, -19 },
};

const GFXfont RobotoMono_Thin49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin49pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_THIN49PT7B_H_
