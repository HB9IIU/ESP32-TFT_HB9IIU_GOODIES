#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoMono_Thin6pt7b, 6, "RobotoMono_Thin6pt7b" },
  { &RobotoMono_Thin7pt7b, 7, "RobotoMono_Thin7pt7b" },
  { &RobotoMono_Thin8pt7b, 8, "RobotoMono_Thin8pt7b" },
  { &RobotoMono_Thin9pt7b, 9, "RobotoMono_Thin9pt7b" },
  { &RobotoMono_Thin10pt7b, 10, "RobotoMono_Thin10pt7b" },
  { &RobotoMono_Thin11pt7b, 11, "RobotoMono_Thin11pt7b" },
  { &RobotoMono_Thin12pt7b, 12, "RobotoMono_Thin12pt7b" },
  { &RobotoMono_Thin13pt7b, 13, "RobotoMono_Thin13pt7b" },
  { &RobotoMono_Thin14pt7b, 14, "RobotoMono_Thin14pt7b" },
  { &RobotoMono_Thin15pt7b, 15, "RobotoMono_Thin15pt7b" },
  { &RobotoMono_Thin16pt7b, 16, "RobotoMono_Thin16pt7b" },
  { &RobotoMono_Thin17pt7b, 17, "RobotoMono_Thin17pt7b" },
  { &RobotoMono_Thin18pt7b, 18, "RobotoMono_Thin18pt7b" },
  { &RobotoMono_Thin19pt7b, 19, "RobotoMono_Thin19pt7b" },
  { &RobotoMono_Thin20pt7b, 20, "RobotoMono_Thin20pt7b" },
  { &RobotoMono_Thin21pt7b, 21, "RobotoMono_Thin21pt7b" },
  { &RobotoMono_Thin22pt7b, 22, "RobotoMono_Thin22pt7b" },
  { &RobotoMono_Thin23pt7b, 23, "RobotoMono_Thin23pt7b" },
  { &RobotoMono_Thin24pt7b, 24, "RobotoMono_Thin24pt7b" },
  { &RobotoMono_Thin25pt7b, 25, "RobotoMono_Thin25pt7b" },
  { &RobotoMono_Thin26pt7b, 26, "RobotoMono_Thin26pt7b" },
  { &RobotoMono_Thin27pt7b, 27, "RobotoMono_Thin27pt7b" },
  { &RobotoMono_Thin28pt7b, 28, "RobotoMono_Thin28pt7b" },
  { &RobotoMono_Thin29pt7b, 29, "RobotoMono_Thin29pt7b" },
  { &RobotoMono_Thin30pt7b, 30, "RobotoMono_Thin30pt7b" },
  { &RobotoMono_Thin31pt7b, 31, "RobotoMono_Thin31pt7b" },
  { &RobotoMono_Thin32pt7b, 32, "RobotoMono_Thin32pt7b" },
  { &RobotoMono_Thin33pt7b, 33, "RobotoMono_Thin33pt7b" },
  { &RobotoMono_Thin34pt7b, 34, "RobotoMono_Thin34pt7b" },
  { &RobotoMono_Thin35pt7b, 35, "RobotoMono_Thin35pt7b" },
  { &RobotoMono_Thin36pt7b, 36, "RobotoMono_Thin36pt7b" },
  { &RobotoMono_Thin37pt7b, 37, "RobotoMono_Thin37pt7b" },
  { &RobotoMono_Thin38pt7b, 38, "RobotoMono_Thin38pt7b" },
  { &RobotoMono_Thin39pt7b, 39, "RobotoMono_Thin39pt7b" },
  { &RobotoMono_Thin40pt7b, 40, "RobotoMono_Thin40pt7b" },
  { &RobotoMono_Thin41pt7b, 41, "RobotoMono_Thin41pt7b" },
  { &RobotoMono_Thin42pt7b, 42, "RobotoMono_Thin42pt7b" },
  { &RobotoMono_Thin43pt7b, 43, "RobotoMono_Thin43pt7b" },
  { &RobotoMono_Thin44pt7b, 44, "RobotoMono_Thin44pt7b" },
  { &RobotoMono_Thin45pt7b, 45, "RobotoMono_Thin45pt7b" },
  { &RobotoMono_Thin46pt7b, 46, "RobotoMono_Thin46pt7b" },
  { &RobotoMono_Thin47pt7b, 47, "RobotoMono_Thin47pt7b" },
  { &RobotoMono_Thin48pt7b, 48, "RobotoMono_Thin48pt7b" },
  { &RobotoMono_Thin49pt7b, 49, "RobotoMono_Thin49pt7b" },
  { &RobotoMono_Thin50pt7b, 50, "RobotoMono_Thin50pt7b" },
  { &RobotoMono_Thin51pt7b, 51, "RobotoMono_Thin51pt7b" },
  { &RobotoMono_Thin52pt7b, 52, "RobotoMono_Thin52pt7b" },
  { &RobotoMono_Thin53pt7b, 53, "RobotoMono_Thin53pt7b" },
  { &RobotoMono_Thin54pt7b, 54, "RobotoMono_Thin54pt7b" },
  { &RobotoMono_Thin55pt7b, 55, "RobotoMono_Thin55pt7b" },
  { &RobotoMono_Thin56pt7b, 56, "RobotoMono_Thin56pt7b" },
  { &RobotoMono_Thin57pt7b, 57, "RobotoMono_Thin57pt7b" },
  { &RobotoMono_Thin58pt7b, 58, "RobotoMono_Thin58pt7b" },
  { &RobotoMono_Thin59pt7b, 59, "RobotoMono_Thin59pt7b" },
  { &RobotoMono_Thin60pt7b, 60, "RobotoMono_Thin60pt7b" },
  { &RobotoMono_Thin61pt7b, 61, "RobotoMono_Thin61pt7b" },
  { &RobotoMono_Thin62pt7b, 62, "RobotoMono_Thin62pt7b" },
  { &RobotoMono_Thin63pt7b, 63, "RobotoMono_Thin63pt7b" },
  { &RobotoMono_Thin64pt7b, 64, "RobotoMono_Thin64pt7b" },
  { &RobotoMono_Thin65pt7b, 65, "RobotoMono_Thin65pt7b" },
  { &RobotoMono_Thin66pt7b, 66, "RobotoMono_Thin66pt7b" },
  { &RobotoMono_Thin67pt7b, 67, "RobotoMono_Thin67pt7b" },
  { &RobotoMono_Thin68pt7b, 68, "RobotoMono_Thin68pt7b" },
  { &RobotoMono_Thin69pt7b, 69, "RobotoMono_Thin69pt7b" },
  { &RobotoMono_Thin70pt7b, 70, "RobotoMono_Thin70pt7b" },
  { &RobotoMono_Thin71pt7b, 71, "RobotoMono_Thin71pt7b" },
  { &RobotoMono_Thin72pt7b, 72, "RobotoMono_Thin72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
