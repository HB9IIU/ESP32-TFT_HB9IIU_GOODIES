#ifndef _ROBOTOMONO_THIN48PT7B_H_
#define _ROBOTOMONO_THIN48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x10, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20,
  0x08, 0x00, 0x04, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x08, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x40, 0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x40, 0x10,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x40, 0x00, 0x20, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0C, 0x03, 0x81, 0x80, 0x0C, 0x30, 0x00,
  0x46, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x34, 0x00,
  0x01, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00, 0x06, 0x30, 0x00, 0xC0, 0xC0,
  0x38, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x06, 0x00, 0x01, 0x80, 0x40, 0x30,
  0x20, 0x08, 0x04, 0x04, 0x01, 0x01, 0x80, 0x80, 0x20, 0x20, 0x10, 0x04,
  0x0C, 0x02, 0x00, 0x81, 0x00, 0x60, 0x10, 0x60, 0x04, 0x06, 0x08, 0x00,
  0xC0, 0x82, 0x00, 0x0C, 0x60, 0x40, 0x00, 0xF8, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x83, 0xF0, 0x00, 0x20, 0xC3, 0x00, 0x0C, 0x30, 0x30, 0x01, 0x04,
  0x02, 0x00, 0x40, 0x80, 0x40, 0x08, 0x10, 0x0C, 0x02, 0x06, 0x01, 0x80,
  0xC0, 0xC0, 0x30, 0x10, 0x18, 0x06, 0x06, 0x01, 0x00, 0xC0, 0x80, 0x20,
  0x10, 0x30, 0x04, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x02, 0x00, 0x18, 0x03, 0x00,
  0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00,
  0x18, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x30, 0x00,
  0x06, 0x40, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x30, 0x30, 0x04, 0x20, 0x10, 0x04,
  0x40, 0x08, 0x04, 0xC0, 0x04, 0x04, 0xC0, 0x06, 0x0C, 0x80, 0x03, 0x0C,
  0x80, 0x01, 0x88, 0x80, 0x00, 0x98, 0x80, 0x00, 0x50, 0xC0, 0x00, 0x70,
  0x40, 0x00, 0x70, 0x60, 0x00, 0xD8, 0x30, 0x01, 0x8C, 0x1C, 0x07, 0x04,
  0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0xC0, 0x20, 0x37, 0x82, 0x1E, 0x0F, 0x2F, 0x00, 0x1F, 0x80, 0x00, 0x60,
  0x00, 0x0D, 0x00, 0x01, 0x98, 0x00, 0x30, 0xC0, 0x02, 0x06, 0x00, 0x40,
  0x30, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x24, 0x92, 0x5A,
  0xD0, 0xFF, 0xFF, 0x80, 0x5F, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0xF0, 0x03, 0x80, 0xC0, 0x30, 0x01, 0x01, 0x00, 0x04, 0x18, 0x00, 0x30,
  0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x01, 0xB0, 0x00,
  0x1D, 0x80, 0x01, 0xB8, 0x00, 0x19, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30,
  0x01, 0x81, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0x80,
  0x18, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x31, 0x80, 0x03, 0xD8,
  0x00, 0x1F, 0x80, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00, 0x26, 0x00, 0x03,
  0x10, 0x00, 0x10, 0xC0, 0x01, 0x82, 0x00, 0x08, 0x08, 0x00, 0x80, 0x30,
  0x18, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x0F, 0x07, 0x31, 0xC3, 0x70, 0x3C,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x00, 0x3F, 0xE0,
  0x07, 0x01, 0xC0, 0x60, 0x03, 0x02, 0x00, 0x0C, 0x20, 0x00, 0x23, 0x00,
  0x01, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x1C, 0x02,
  0x00, 0x18, 0x10, 0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00,
  0x06, 0x40, 0x00, 0x19, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x80,
  0x00, 0x22, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x60, 0x18, 0x07,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C,
  0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x60,
  0x40, 0x00, 0x40, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x00,
  0x40, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x40, 0x18, 0x00, 0x40, 0x10, 0x00, 0x40, 0x20, 0x00, 0x40, 0x60, 0x00,
  0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x1F, 0xFF,
  0xF1, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x7F, 0xE0, 0x3C, 0x03, 0x03,
  0x00, 0x18, 0x20, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0x60, 0x00, 0x22, 0x00,
  0x06, 0x30, 0x00, 0x41, 0x80, 0x0C, 0x0E, 0x03, 0x80, 0x3F, 0xE0, 0x00,
  0x01, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x3F, 0xE0, 0x8E, 0x03,
  0x09, 0x80, 0x0C, 0xA0, 0x00, 0x4E, 0x00, 0x06, 0xC0, 0x00, 0x28, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x36,
  0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x30,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x18,
  0x10, 0x00, 0x20, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00, 0x06, 0x40,
  0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20, 0x00,
  0x10, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x30, 0x07, 0x03, 0x80,
  0x07, 0xF0, 0x00, 0x70, 0x38, 0x07, 0x00, 0x30, 0x30, 0x00, 0x30, 0x80,
  0x00, 0x44, 0x00, 0x00, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x26,
  0x00, 0x01, 0x8C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x38, 0x07, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0xC0, 0x30, 0x03,
  0x03, 0x00, 0x0C, 0x10, 0x00, 0x31, 0x80, 0x00, 0x88, 0x00, 0x06, 0xC0,
  0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00,
  0x01, 0xD8, 0x00, 0x0E, 0x40, 0x00, 0xB3, 0x00, 0x0D, 0x8C, 0x01, 0xC8,
  0x1C, 0x38, 0x40, 0x3F, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x5F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xBF, 0x11, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18, 0xC6, 0x31, 0x08,
  0xC4, 0x60, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xFC, 0x06, 0x01, 0x86, 0x00, 0x66, 0x00, 0x12, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x06, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x10, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20,
  0x80, 0x7E, 0x06, 0x30, 0x38, 0x60, 0xC4, 0x04, 0x04, 0x08, 0x81, 0x00,
  0x81, 0x30, 0x60, 0x10, 0x24, 0x08, 0x02, 0x04, 0x81, 0x00, 0xC0, 0x90,
  0x60, 0x18, 0x16, 0x0C, 0x02, 0x02, 0xC1, 0x00, 0x40, 0x58, 0x20, 0x08,
  0x0B, 0x04, 0x01, 0x01, 0x60, 0x80, 0x20, 0x2C, 0x10, 0x0C, 0x05, 0x82,
  0x01, 0x80, 0xB0, 0x40, 0x70, 0x32, 0x0C, 0x0A, 0x04, 0x40, 0x83, 0x41,
  0x88, 0x18, 0xCC, 0x61, 0x81, 0xF0, 0xF8, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x80,
  0x03, 0x80, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x81, 0x00, 0x01, 0x81, 0x00, 0x01, 0x01, 0x80, 0x01, 0x00,
  0x80, 0x03, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x04, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x08, 0x00,
  0x30, 0x08, 0x00, 0x10, 0x1F, 0xFF, 0xF0, 0x10, 0x00, 0x18, 0x10, 0x00,
  0x08, 0x30, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00,
  0x04, 0x40, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x04, 0x00, 0xF0, 0x20, 0x00, 0xE1, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00,
  0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0xC8, 0x00, 0x04, 0x40,
  0x00, 0x62, 0x00, 0x06, 0x10, 0x01, 0xC0, 0xFF, 0xFC, 0x04, 0x00, 0x38,
  0x20, 0x00, 0x31, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x40, 0x00, 0x0A, 0x00,
  0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x05,
  0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00,
  0x38, 0x80, 0x07, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC,
  0x00, 0x70, 0x1C, 0x03, 0x00, 0x18, 0x08, 0x00, 0x30, 0x40, 0x00, 0x63,
  0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x0D, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x16, 0x00, 0x00, 0x48, 0x00, 0x03,
  0x20, 0x00, 0x08, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x04,
  0x00, 0x60, 0x0C, 0x07, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x04, 0x00, 0xE0, 0x20, 0x01, 0xC1, 0x00, 0x03, 0x08, 0x00, 0x08, 0x40,
  0x00, 0x22, 0x00, 0x01, 0x90, 0x00, 0x04, 0x80, 0x00, 0x34, 0x00, 0x00,
  0xA0, 0x00, 0x05, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x02, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00, 0x00, 0xC8,
  0x00, 0x04, 0x40, 0x00, 0x42, 0x00, 0x04, 0x10, 0x00, 0xC0, 0x80, 0x3C,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x88, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xCC,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00,
  0x70, 0x1C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0x40, 0x00, 0x63, 0x00,
  0x00, 0x88, 0x00, 0x03, 0x60, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x40, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20,
  0x00, 0x04, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x42, 0x00, 0x03, 0x06, 0x00,
  0x18, 0x0C, 0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00,
  0x06, 0x20, 0x00, 0x41, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x3F, 0xE0, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xCD, 0x80, 0x01,
  0xB1, 0x00, 0x03, 0x43, 0x00, 0x07, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x04, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x09, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0B, 0xE0, 0x00, 0x5D, 0x00, 0x06, 0xE8,
  0x00, 0x27, 0x60, 0x03, 0x39, 0x00, 0x11, 0xCC, 0x00, 0x8E, 0x20, 0x0C,
  0x71, 0x00, 0x43, 0x8C, 0x06, 0x1C, 0x20, 0x20, 0xE1, 0x01, 0x07, 0x0C,
  0x10, 0x38, 0x20, 0x81, 0xC1, 0x8C, 0x0E, 0x04, 0x40, 0x70, 0x22, 0x03,
  0x81, 0xA0, 0x1C, 0x05, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE8, 0x00, 0x07,
  0x40, 0x00, 0x39, 0x00, 0x01, 0xCC, 0x00, 0x0E, 0x20, 0x00, 0x71, 0x80,
  0x03, 0x84, 0x00, 0x1C, 0x10, 0x00, 0xE0, 0x80, 0x07, 0x02, 0x00, 0x38,
  0x18, 0x01, 0xC0, 0x40, 0x0E, 0x03, 0x00, 0x70, 0x08, 0x03, 0x80, 0x20,
  0x1C, 0x01, 0x00, 0xE0, 0x04, 0x07, 0x00, 0x30, 0x38, 0x00, 0x81, 0xC0,
  0x06, 0x0E, 0x00, 0x10, 0x70, 0x00, 0x43, 0x80, 0x02, 0x1C, 0x00, 0x08,
  0xE0, 0x00, 0x47, 0x00, 0x01, 0x38, 0x00, 0x0D, 0xC0, 0x00, 0x2E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x07, 0xFC, 0x00, 0x70, 0x18, 0x03, 0x00, 0x10, 0x08, 0x00, 0x20,
  0x40, 0x00, 0xC3, 0x00, 0x01, 0x08, 0x00, 0x02, 0x20, 0x00, 0x09, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x16, 0x00, 0x00,
  0xC8, 0x00, 0x02, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x41, 0x00, 0x03, 0x02,
  0x00, 0x08, 0x04, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFC, 0x08, 0x00, 0x70, 0x80, 0x01, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x68,
  0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x28, 0x00, 0x06, 0x80, 0x00, 0xC8, 0x00, 0x38, 0xFF, 0xFE, 0x0F, 0xFE,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0x07, 0x00, 0x60, 0x03, 0x01,
  0x80, 0x03, 0x02, 0x00, 0x02, 0x08, 0x00, 0x02, 0x30, 0x00, 0x06, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0E,
  0x03, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0xFF, 0xF8,
  0x06, 0x00, 0x70, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x04, 0x60,
  0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00,
  0xB0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00,
  0x01, 0x98, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x3F, 0xFF, 0x01,
  0x80, 0x10, 0x0C, 0x00, 0xC0, 0x60, 0x02, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x40, 0xC0, 0x03, 0x06, 0x00, 0x08, 0x30, 0x00, 0x21, 0x80, 0x01, 0x8C,
  0x00, 0x04, 0x60, 0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00,
  0x16, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x1C,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0x44, 0x00, 0x01, 0x90,
  0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x26, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x18, 0x00, 0x60, 0x38,
  0x07, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x26, 0x00, 0x03, 0x10,
  0x00, 0x30, 0xC0, 0x01, 0x03, 0x00, 0x18, 0x0E, 0x03, 0x00, 0x1F, 0xF0,
  0x00, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00,
  0x0C, 0x18, 0x00, 0x08, 0x08, 0x00, 0x08, 0x08, 0x00, 0x18, 0x0C, 0x00,
  0x10, 0x04, 0x00, 0x10, 0x04, 0x00, 0x30, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00, 0x40, 0x01, 0x00,
  0xC0, 0x01, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x81, 0x80, 0x00, 0x81,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x43, 0x00, 0x00, 0x42, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x26, 0x00, 0x00, 0x34, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xD0, 0x03,
  0x00, 0x24, 0x00, 0xC0, 0x09, 0x00, 0x30, 0x02, 0x40, 0x1C, 0x00, 0x90,
  0x05, 0x80, 0x66, 0x01, 0x20, 0x11, 0x80, 0x48, 0x04, 0x20, 0x12, 0x01,
  0x08, 0x0C, 0x80, 0x42, 0x02, 0x30, 0x10, 0x80, 0x84, 0x04, 0x30, 0x21,
  0x03, 0x0C, 0x08, 0x40, 0x81, 0x06, 0x10, 0x20, 0x41, 0x86, 0x08, 0x10,
  0x41, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x60, 0x63, 0x02, 0x10,
  0x08, 0xC0, 0xC4, 0x02, 0x20, 0x31, 0x00, 0x88, 0x04, 0x40, 0x22, 0x01,
  0x10, 0x09, 0x80, 0x4C, 0x03, 0x60, 0x1A, 0x00, 0x50, 0x06, 0x80, 0x14,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x18, 0x00,
  0x10, 0x08, 0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x40, 0x02, 0x00,
  0xC0, 0x01, 0x00, 0x80, 0x01, 0x81, 0x80, 0x00, 0x83, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x83, 0x00, 0x01, 0x81, 0x00, 0x01, 0x00, 0x80, 0x02, 0x00,
  0xC0, 0x06, 0x00, 0x40, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x10, 0x10, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x40, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x04, 0x10, 0x00, 0x08, 0x18, 0x00, 0x08, 0x08, 0x00,
  0x10, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x40, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xC0, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0xFE, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC0,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x22, 0x00, 0x31,
  0x00, 0x10, 0xC0, 0x08, 0x20, 0x0C, 0x18, 0x04, 0x04, 0x06, 0x02, 0x02,
  0x01, 0x81, 0x00, 0x41, 0x80, 0x30, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x03,
  0x20, 0x00, 0xB0, 0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x86, 0x10, 0x43, 0x08,
  0x20, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x03, 0x00, 0x70, 0x20, 0x00, 0x82,
  0x00, 0x02, 0x30, 0x00, 0x19, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0x07,
  0x80, 0x08, 0x60, 0x00, 0x46, 0x00, 0x02, 0x60, 0x00, 0x12, 0x00, 0x00,
  0xB0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x20, 0x00, 0x39, 0x00,
  0x03, 0x44, 0x00, 0x32, 0x18, 0x06, 0x10, 0x7F, 0xE0, 0xC0, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC1,
  0xF0, 0x0C, 0x7B, 0xE0, 0xCC, 0x03, 0x0D, 0x00, 0x18, 0xE0, 0x00, 0xCC,
  0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xE0, 0x00, 0x8D, 0x00, 0x10, 0xCC,
  0x06, 0x0C, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0xF0, 0x0C, 0x01, 0x81,
  0x80, 0x0C, 0x10, 0x00, 0x62, 0x00, 0x02, 0x60, 0x00, 0x14, 0x00, 0x01,
  0x40, 0x00, 0x14, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x14, 0x00, 0x01, 0x20, 0x00, 0x13, 0x00, 0x02, 0x10,
  0x00, 0x60, 0x80, 0x0C, 0x06, 0x01, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x01, 0xF8,
  0x30, 0x7D, 0xE3, 0x0C, 0x03, 0x31, 0x80, 0x0B, 0x30, 0x00, 0x72, 0x00,
  0x07, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03,
  0x60, 0x00, 0x32, 0x00, 0x07, 0x10, 0x00, 0x71, 0x80, 0x1B, 0x0E, 0x03,
  0x30, 0x3F, 0xC3, 0x00, 0xFC, 0x00, 0x1E, 0x78, 0x03, 0x80, 0x60, 0x30,
  0x01, 0x81, 0x00, 0x06, 0x10, 0x00, 0x19, 0x80, 0x00, 0x48, 0x00, 0x02,
  0x40, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x41, 0x80, 0x0C, 0x07, 0x00, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x7D, 0xE3, 0x0C, 0x03, 0x31, 0x80, 0x0B,
  0x30, 0x00, 0x72, 0x00, 0x07, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x07, 0x10, 0x00, 0x71,
  0x80, 0x0B, 0x0E, 0x03, 0x30, 0x3F, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00,
  0xC1, 0x80, 0x18, 0x0E, 0x07, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x03, 0xE0, 0x41, 0xE7,
  0x88, 0xE0, 0x19, 0x30, 0x01, 0xA4, 0x00, 0x15, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x03, 0x87, 0xFC, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x68, 0x00,
  0x19, 0x00, 0x0C, 0x20, 0x03, 0x04, 0x00, 0xC0, 0x80, 0x30, 0x10, 0x0C,
  0x02, 0x03, 0x00, 0x40, 0xC0, 0x08, 0x60, 0x01, 0x18, 0x00, 0x26, 0x80,
  0x05, 0x98, 0x00, 0xE1, 0x80, 0x10, 0x18, 0x02, 0x01, 0x80, 0x40, 0x18,
  0x08, 0x01, 0x81, 0x00, 0x18, 0x20, 0x01, 0x84, 0x00, 0x10, 0x80, 0x01,
  0x10, 0x00, 0x32, 0x00, 0x03, 0x40, 0x00, 0x30, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0x80,
  0x78, 0x4E, 0x70, 0xE7, 0x2C, 0x0C, 0x80, 0xDC, 0x02, 0x80, 0x2C, 0x01,
  0xC0, 0x1E, 0x00, 0x40, 0x0E, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x00, 0xF8, 0x10, 0x79,
  0xE2, 0x38, 0x06, 0x4C, 0x00, 0x69, 0x00, 0x05, 0x40, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x18, 0x03, 0x00, 0x60, 0x03, 0x01, 0x80, 0x03,
  0x06, 0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x06, 0x40, 0x00, 0x0C,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x58,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80,
  0x00, 0x09, 0x00, 0x00, 0x33, 0x00, 0x00, 0x42, 0x00, 0x01, 0x86, 0x00,
  0x02, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x03, 0xFE,
  0x00, 0x01, 0xF0, 0x08, 0x7B, 0xC0, 0x9C, 0x03, 0x0B, 0x00, 0x18, 0xA0,
  0x00, 0x8C, 0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xA0, 0x00, 0x8B, 0x00,
  0x10, 0x8C, 0x06, 0x08, 0x7F, 0xC0, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7D, 0xE3,
  0x0C, 0x03, 0x31, 0x80, 0x0B, 0x30, 0x00, 0x72, 0x00, 0x07, 0x60, 0x00,
  0x34, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x32,
  0x00, 0x07, 0x10, 0x00, 0x71, 0x80, 0x1B, 0x0E, 0x03, 0x30, 0x3F, 0xC3,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x7F, 0x83, 0xF3, 0x86, 0x00, 0x88, 0x00, 0xD0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFB, 0xF0, 0x18, 0x01,
  0x82, 0x00, 0x0C, 0x40, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x34, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0x40, 0x00, 0x66, 0x00, 0x0C, 0x18, 0x03, 0x80, 0x7F, 0xE0, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x07, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xA0,
  0x00, 0x34, 0x00, 0x0E, 0xC0, 0x03, 0x4C, 0x00, 0xC8, 0xC0, 0x71, 0x0F,
  0xFC, 0x20, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x42, 0x00, 0x01, 0x86, 0x00, 0x02, 0x04, 0x00, 0x04, 0x0C, 0x00,
  0x18, 0x08, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x08, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x80,
  0x01, 0x03, 0x00, 0x03, 0x04, 0x00, 0x02, 0x18, 0x00, 0x06, 0x20, 0x00,
  0x04, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x80, 0x08, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x05, 0x00, 0x68,
  0x02, 0x80, 0x34, 0x01, 0x40, 0x13, 0x00, 0xB0, 0x09, 0x80, 0xC8, 0x0C,
  0x40, 0x44, 0x06, 0x20, 0x22, 0x02, 0x10, 0x11, 0x81, 0x0C, 0x18, 0x40,
  0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x40, 0x82, 0x0C, 0x20, 0x63, 0x02,
  0x10, 0x31, 0x01, 0x18, 0x08, 0x80, 0x8C, 0x04, 0x40, 0x64, 0x02, 0x40,
  0x12, 0x01, 0xA0, 0x09, 0x00, 0x50, 0x05, 0x80, 0x28, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18,
  0x80, 0x00, 0xC3, 0x00, 0x06, 0x06, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x20, 0x30, 0x00, 0xC1, 0x80, 0x01, 0x84, 0x00, 0x03, 0x30,
  0x00, 0x05, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x61, 0x00, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x30, 0x18, 0x00, 0x40, 0xC0, 0x01, 0x82, 0x00, 0x03,
  0x10, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x20, 0x60, 0x00, 0x30, 0x10, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x02, 0x00,
  0x08, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x04, 0x01, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x20, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x1E, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x98, 0x70, 0x00, 0x58, 0x0C, 0x00, 0x78, 0x03, 0x00, 0x38,
  0x00, 0xC0, 0x14, 0x00, 0x38, 0x12, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xE0,
};

const GFXglyph RobotoMono_Thin48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 2, 34, 29, 13, -34 },
  { 10, 7, 10, 29, 11, -36 },
  { 19, 27, 34, 29, 1, -34 },
  { 134, 20, 44, 29, 5, -39 },
  { 244, 27, 36, 29, 1, -35 },
  { 366, 24, 35, 29, 4, -35 },
  { 471, 1, 10, 29, 13, -36 },
  { 473, 10, 49, 29, 10, -38 },
  { 535, 10, 49, 29, 9, -38 },
  { 597, 20, 19, 29, 5, -34 },
  { 645, 23, 25, 29, 3, -28 },
  { 717, 3, 10, 29, 10, -4 },
  { 721, 17, 1, 29, 6, -16 },
  { 724, 3, 3, 29, 14, -3 },
  { 726, 16, 37, 29, 7, -34 },
  { 800, 21, 35, 29, 4, -35 },
  { 892, 12, 34, 29, 5, -34 },
  { 943, 21, 35, 29, 3, -35 },
  { 1035, 22, 35, 29, 2, -35 },
  { 1132, 24, 34, 29, 2, -34 },
  { 1234, 20, 34, 29, 5, -34 },
  { 1319, 20, 35, 29, 4, -35 },
  { 1407, 22, 34, 29, 3, -34 },
  { 1501, 22, 35, 29, 4, -35 },
  { 1598, 21, 35, 29, 4, -35 },
  { 1690, 3, 24, 29, 15, -24 },
  { 1699, 5, 30, 29, 13, -24 },
  { 1718, 20, 19, 29, 4, -25 },
  { 1766, 21, 11, 29, 4, -21 },
  { 1795, 21, 19, 29, 4, -25 },
  { 1845, 17, 35, 29, 6, -35 },
  { 1920, 27, 34, 29, 1, -34 },
  { 2035, 24, 34, 29, 3, -34 },
  { 2137, 21, 34, 29, 5, -34 },
  { 2227, 22, 36, 29, 3, -35 },
  { 2326, 21, 34, 29, 5, -34 },
  { 2416, 20, 34, 29, 5, -34 },
  { 2501, 20, 34, 29, 5, -34 },
  { 2586, 22, 35, 29, 3, -35 },
  { 2683, 21, 34, 29, 4, -34 },
  { 2773, 19, 34, 29, 5, -34 },
  { 2854, 20, 34, 29, 3, -34 },
  { 2939, 23, 34, 29, 5, -34 },
  { 3037, 19, 34, 29, 6, -34 },
  { 3118, 21, 34, 29, 4, -34 },
  { 3208, 21, 34, 29, 4, -34 },
  { 3298, 22, 35, 29, 3, -35 },
  { 3395, 20, 34, 29, 6, -34 },
  { 3480, 23, 41, 29, 3, -35 },
  { 3598, 21, 34, 29, 5, -34 },
  { 3688, 22, 35, 29, 4, -35 },
  { 3785, 23, 34, 29, 3, -34 },
  { 3883, 21, 34, 29, 4, -34 },
  { 3973, 24, 34, 29, 2, -34 },
  { 4075, 26, 34, 29, 2, -34 },
  { 4186, 24, 34, 29, 3, -34 },
  { 4288, 24, 34, 29, 2, -34 },
  { 4390, 21, 34, 29, 3, -34 },
  { 4480, 7, 46, 29, 11, -39 },
  { 4521, 15, 37, 29, 7, -34 },
  { 4591, 7, 46, 29, 11, -39 },
  { 4632, 17, 19, 29, 6, -34 },
  { 4673, 20, 1, 29, 4, 0 },
  { 4676, 5, 7, 29, 12, -36 },
  { 4681, 21, 26, 29, 4, -26 },
  { 4750, 20, 36, 29, 5, -36 },
  { 4840, 20, 26, 29, 4, -26 },
  { 4905, 20, 36, 29, 4, -36 },
  { 4995, 21, 26, 29, 4, -26 },
  { 5064, 21, 37, 29, 5, -37 },
  { 5162, 20, 36, 29, 4, -26 },
  { 5252, 19, 36, 29, 5, -36 },
  { 5338, 19, 34, 29, 6, -34 },
  { 5419, 15, 44, 29, 4, -34 },
  { 5502, 19, 36, 29, 6, -36 },
  { 5588, 19, 36, 29, 6, -36 },
  { 5674, 25, 26, 29, 2, -26 },
  { 5756, 19, 26, 29, 5, -26 },
  { 5818, 23, 26, 29, 3, -26 },
  { 5893, 20, 36, 29, 5, -26 },
  { 5983, 20, 36, 29, 4, -26 },
  { 6073, 16, 26, 29, 9, -26 },
  { 6125, 20, 26, 29, 5, -26 },
  { 6190, 19, 32, 29, 5, -32 },
  { 6266, 19, 25, 29, 5, -25 },
  { 6326, 23, 25, 29, 3, -25 },
  { 6398, 25, 25, 29, 2, -25 },
  { 6477, 22, 25, 29, 4, -25 },
  { 6546, 25, 35, 29, 2, -25 },
  { 6656, 23, 25, 29, 3, -25 },
  { 6728, 15, 47, 29, 8, -37 },
  { 6817, 1, 40, 29, 14, -34 },
  { 6822, 15, 47, 29, 8, -37 },
  { 6911, 25, 8, 29, 2, -18 },
};

const GFXfont RobotoMono_Thin48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin48pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_THIN48PT7B_H_
