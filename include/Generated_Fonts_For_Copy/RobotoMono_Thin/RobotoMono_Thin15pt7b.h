#ifndef _ROBOTOMONO_THIN15PT7B_H_
#define _ROBOTOMONO_THIN15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0x80, 0x11, 0x09, 0x04, 0x8F, 0xF1, 0x20, 0x90,
  0x91, 0xFE, 0x24, 0x12, 0x09, 0x00, 0x10, 0x79, 0x0C, 0x14, 0x08, 0x0E,
  0x02, 0x03, 0x05, 0x09, 0x61, 0x02, 0x00, 0x60, 0x49, 0x24, 0x92, 0x87,
  0x40, 0x40, 0x2C, 0x29, 0x24, 0x92, 0x41, 0xC0, 0x30, 0x48, 0x48, 0x48,
  0x30, 0x20, 0x51, 0x8A, 0x86, 0x82, 0x7F, 0xE0, 0x29, 0x49, 0x24, 0x92,
  0x48, 0x88, 0x91, 0x22, 0x49, 0x24, 0x94, 0xA0, 0x20, 0x8A, 0xDC, 0x53,
  0x20, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0xE0, 0xF8, 0x80, 0x08,
  0x42, 0x21, 0x10, 0x84, 0x42, 0x21, 0x00, 0x38, 0x8A, 0x0C, 0x38, 0xB2,
  0x68, 0xE1, 0x82, 0x88, 0xF0, 0x3C, 0x92, 0x49, 0x24, 0x80, 0x7A, 0x18,
  0x41, 0x04, 0x21, 0x04, 0x21, 0x0F, 0xC0, 0x7A, 0x18, 0x41, 0x04, 0xE0,
  0x41, 0x86, 0x17, 0x80, 0x08, 0x10, 0x51, 0x22, 0x48, 0xA1, 0x7F, 0x04,
  0x08, 0x10, 0x7E, 0x08, 0x20, 0xF2, 0x20, 0x41, 0x86, 0x17, 0x80, 0x18,
  0x41, 0x04, 0x0F, 0x90, 0xA0, 0xC1, 0x83, 0x09, 0xF0, 0xFE, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x80, 0x3C, 0x86, 0x0C, 0x14, 0x67,
  0x11, 0xC1, 0x83, 0x05, 0xF0, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x51, 0x9D,
  0x04, 0x08, 0xE0, 0x82, 0x40, 0x06, 0x80, 0x06, 0x31, 0x86, 0x03, 0x80,
  0xC0, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x60, 0x30, 0x33, 0x98, 0x00, 0x74,
  0x62, 0x10, 0x88, 0x84, 0x00, 0x08, 0x1E, 0x10, 0x93, 0x2A, 0x5A, 0x4D,
  0x26, 0x93, 0x49, 0x9B, 0x20, 0x0F, 0x80, 0x10, 0x20, 0xA1, 0x42, 0x88,
  0x91, 0x3E, 0x83, 0x06, 0x08, 0xF2, 0x28, 0x61, 0x8B, 0xE8, 0x61, 0x86,
  0x1F, 0x80, 0x38, 0x8A, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x82, 0x84, 0xF0,
  0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0B, 0xE0, 0xFE, 0x08,
  0x20, 0x83, 0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8,
  0x20, 0x82, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x08, 0x10, 0x23, 0xC1, 0x82,
  0x84, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x86, 0x17, 0x80, 0x85, 0x12, 0x24, 0x8A, 0x18, 0x28, 0x48, 0x89,
  0x0A, 0x18, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x83,
  0x07, 0x1E, 0x3A, 0xB5, 0x64, 0xC9, 0x83, 0x06, 0x08, 0x83, 0x07, 0x0D,
  0x1A, 0x32, 0x64, 0xC5, 0x87, 0x0E, 0x08, 0x38, 0x8A, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x82, 0x88, 0xE0, 0xFA, 0x18, 0x61, 0x86, 0x3F, 0x20, 0x82,
  0x08, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0xF0,
  0x20, 0x20, 0xF2, 0x28, 0x61, 0x86, 0x2F, 0x24, 0x8A, 0x18, 0x40, 0x3C,
  0x86, 0x0C, 0x04, 0x07, 0x01, 0x01, 0x83, 0x05, 0xF0, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x05, 0xF0, 0x83, 0x06, 0x0A, 0x24, 0x48, 0x92, 0x14,
  0x28, 0x60, 0x40, 0x91, 0x91, 0x91, 0x92, 0xAA, 0xAA, 0xAA, 0x44, 0x44,
  0x44, 0x44, 0x82, 0x85, 0x11, 0x42, 0x82, 0x04, 0x14, 0x44, 0x86, 0x08,
  0x83, 0x05, 0x12, 0x22, 0x85, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFC, 0x08,
  0x10, 0x41, 0x02, 0x08, 0x10, 0x41, 0x03, 0xF8, 0xF2, 0x49, 0x24, 0x92,
  0x49, 0xC0, 0x84, 0x10, 0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0xE4, 0x92,
  0x49, 0x24, 0x93, 0xC0, 0x21, 0x14, 0xA8, 0xC4, 0xFE, 0xC0, 0x7D, 0x04,
  0x09, 0xF4, 0x30, 0x61, 0xBD, 0x82, 0x08, 0x3C, 0x8A, 0x18, 0x61, 0x86,
  0x2F, 0x80, 0x3C, 0x86, 0x0C, 0x08, 0x10, 0x10, 0x9E, 0x04, 0x10, 0x4F,
  0x46, 0x18, 0x61, 0x85, 0x17, 0xC0, 0x3C, 0x86, 0x0F, 0xF8, 0x10, 0x10,
  0x9E, 0x3D, 0x04, 0x3E, 0x41, 0x04, 0x10, 0x41, 0x04, 0x00, 0x3D, 0x18,
  0x61, 0x86, 0x14, 0x5F, 0x04, 0x17, 0x80, 0x82, 0x08, 0x3E, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x40, 0x20, 0x00, 0x38, 0x20, 0x82, 0x08, 0x20, 0x8F,
  0xC0, 0x08, 0x00, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x82, 0x08,
  0x23, 0x92, 0x8C, 0x28, 0x92, 0x28, 0x40, 0xE0, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x8F, 0xC0, 0xEF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x7D, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xBE,
  0xF2, 0x28, 0x61, 0x86, 0x18, 0xBE, 0x82, 0x08, 0x00, 0x3D, 0x18, 0x61,
  0x86, 0x14, 0x5F, 0x04, 0x10, 0x40, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x3C,
  0x85, 0x01, 0x80, 0xC0, 0x60, 0xBE, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08,
  0x10, 0x70, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0x83, 0x05, 0x12, 0x24, 0x85,
  0x0A, 0x08, 0x91, 0x91, 0xAA, 0xAA, 0xAA, 0x4A, 0x44, 0x44, 0x82, 0x88,
  0xA0, 0x81, 0x05, 0x11, 0x41, 0x83, 0x06, 0x0A, 0x24, 0x45, 0x0A, 0x08,
  0x10, 0x43, 0x80, 0xFE, 0x08, 0x20, 0x82, 0x04, 0x10, 0x7F, 0x08, 0x88,
  0x42, 0x10, 0x98, 0x21, 0x08, 0x42, 0x08, 0x20, 0xFF, 0xF8, 0xC1, 0x08,
  0x42, 0x10, 0x41, 0x10, 0x88, 0x42, 0x13, 0x00, 0x63, 0x26, 0x30,
};

const GFXglyph RobotoMono_Thin15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 1, 11, 9, 4, -11 },
  { 3, 3, 3, 9, 3, -11 },
  { 5, 9, 11, 9, 0, -11 },
  { 18, 7, 14, 9, 1, -12 },
  { 31, 9, 11, 9, 0, -11 },
  { 44, 8, 11, 9, 1, -11 },
  { 55, 1, 3, 9, 4, -11 },
  { 56, 3, 15, 9, 3, -12 },
  { 62, 3, 15, 9, 3, -12 },
  { 68, 6, 6, 9, 2, -11 },
  { 73, 7, 8, 9, 1, -9 },
  { 80, 1, 3, 9, 3, -1 },
  { 81, 5, 1, 9, 2, -5 },
  { 82, 1, 1, 9, 4, -1 },
  { 83, 5, 12, 9, 2, -11 },
  { 91, 7, 11, 9, 1, -11 },
  { 101, 3, 11, 9, 2, -11 },
  { 106, 6, 11, 9, 1, -11 },
  { 115, 6, 11, 9, 1, -11 },
  { 124, 7, 11, 9, 1, -11 },
  { 134, 6, 11, 9, 2, -11 },
  { 143, 7, 11, 9, 1, -11 },
  { 153, 7, 11, 9, 1, -11 },
  { 163, 7, 11, 9, 1, -11 },
  { 173, 7, 11, 9, 1, -11 },
  { 183, 1, 7, 9, 5, -7 },
  { 184, 2, 9, 9, 4, -7 },
  { 187, 7, 6, 9, 1, -8 },
  { 193, 7, 4, 9, 1, -7 },
  { 197, 7, 6, 9, 1, -8 },
  { 203, 5, 11, 9, 2, -11 },
  { 210, 9, 11, 9, 0, -11 },
  { 223, 7, 11, 9, 1, -11 },
  { 233, 6, 11, 9, 2, -11 },
  { 242, 7, 11, 9, 1, -11 },
  { 252, 7, 11, 9, 1, -11 },
  { 262, 6, 11, 9, 2, -11 },
  { 271, 6, 11, 9, 2, -11 },
  { 280, 7, 11, 9, 1, -11 },
  { 290, 7, 11, 9, 1, -11 },
  { 300, 5, 11, 9, 2, -11 },
  { 307, 6, 11, 9, 1, -11 },
  { 316, 7, 11, 9, 2, -11 },
  { 326, 6, 11, 9, 2, -11 },
  { 335, 7, 11, 9, 1, -11 },
  { 345, 7, 11, 9, 1, -11 },
  { 355, 7, 11, 9, 1, -11 },
  { 365, 6, 11, 9, 2, -11 },
  { 374, 7, 13, 9, 1, -11 },
  { 386, 6, 11, 9, 2, -11 },
  { 395, 7, 11, 9, 1, -11 },
  { 405, 7, 11, 9, 1, -11 },
  { 415, 7, 11, 9, 1, -11 },
  { 425, 7, 11, 9, 1, -11 },
  { 435, 8, 11, 9, 1, -11 },
  { 446, 7, 11, 9, 1, -11 },
  { 456, 7, 11, 9, 1, -11 },
  { 466, 7, 11, 9, 1, -11 },
  { 476, 3, 14, 9, 3, -12 },
  { 482, 5, 12, 9, 2, -11 },
  { 490, 3, 14, 9, 3, -12 },
  { 496, 5, 6, 9, 2, -11 },
  { 500, 7, 1, 9, 1, 0 },
  { 501, 1, 2, 9, 4, -11 },
  { 502, 7, 8, 9, 1, -8 },
  { 509, 6, 11, 9, 2, -11 },
  { 518, 7, 8, 9, 1, -8 },
  { 525, 6, 11, 9, 1, -11 },
  { 534, 7, 8, 9, 1, -8 },
  { 541, 6, 11, 9, 2, -11 },
  { 550, 6, 11, 9, 1, -8 },
  { 559, 6, 11, 9, 2, -11 },
  { 568, 6, 11, 9, 2, -11 },
  { 577, 5, 14, 9, 1, -11 },
  { 586, 6, 11, 9, 2, -11 },
  { 595, 6, 11, 9, 2, -11 },
  { 604, 7, 8, 9, 1, -8 },
  { 611, 6, 8, 9, 2, -8 },
  { 617, 7, 8, 9, 1, -8 },
  { 624, 6, 11, 9, 2, -8 },
  { 633, 6, 11, 9, 1, -8 },
  { 642, 5, 8, 9, 3, -8 },
  { 647, 7, 8, 9, 1, -8 },
  { 654, 6, 10, 9, 1, -10 },
  { 662, 5, 8, 9, 2, -8 },
  { 667, 7, 8, 9, 1, -8 },
  { 674, 8, 8, 9, 1, -8 },
  { 682, 7, 8, 9, 1, -8 },
  { 689, 7, 11, 9, 1, -8 },
  { 699, 7, 8, 9, 1, -8 },
  { 706, 5, 15, 9, 2, -12 },
  { 716, 1, 13, 9, 4, -11 },
  { 718, 5, 15, 9, 2, -12 },
  { 728, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoMono_Thin15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin15pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_THIN15PT7B_H_
