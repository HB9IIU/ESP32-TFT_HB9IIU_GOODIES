#ifndef _ROBOTOMONO_THIN12PT7B_H_
#define _ROBOTOMONO_THIN12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xC0, 0x14, 0x28, 0x93, 0xF2, 0x85, 0x3F, 0x24, 0x48,
  0x23, 0xA3, 0x18, 0x38, 0x21, 0x8A, 0xC8, 0x41, 0x4A, 0xA5, 0x45, 0x03,
  0xCA, 0x95, 0x0E, 0x21, 0x49, 0x18, 0x42, 0x99, 0x62, 0xF4, 0xC0, 0x29,
  0x49, 0x24, 0x91, 0x22, 0x89, 0x12, 0x49, 0x25, 0x28, 0x21, 0x3A, 0x64,
  0x80, 0x20, 0x82, 0x3F, 0x20, 0x80, 0xE0, 0xF8, 0x80, 0x11, 0x22, 0x44,
  0x48, 0x88, 0x74, 0x63, 0x3A, 0xE6, 0x31, 0x70, 0x3C, 0x92, 0x49, 0x20,
  0x74, 0x62, 0x11, 0x11, 0x08, 0xF8, 0x74, 0x62, 0x17, 0x04, 0x31, 0xF0,
  0x10, 0x8C, 0xA5, 0x4B, 0xE2, 0x10, 0x7A, 0x21, 0x6C, 0x84, 0x31, 0x78,
  0x32, 0x21, 0xE8, 0xC6, 0x31, 0x70, 0xF8, 0x42, 0x21, 0x10, 0x84, 0x40,
  0x74, 0x63, 0x17, 0x46, 0x31, 0x78, 0x74, 0x63, 0x18, 0xEC, 0xA1, 0x70,
  0x84, 0x87, 0x1B, 0x30, 0x70, 0xFF, 0xC0, 0xE0, 0x87, 0xC0, 0x74, 0x42,
  0x11, 0x10, 0x80, 0x20, 0x3C, 0x85, 0x6D, 0x5A, 0xB5, 0x6A, 0xCA, 0x7C,
  0x20, 0x85, 0x14, 0x49, 0x2B, 0xA1, 0x84, 0xF4, 0x63, 0x1F, 0x46, 0x31,
  0xF8, 0x74, 0x63, 0x08, 0x42, 0x31, 0x78, 0xF2, 0x28, 0xA1, 0x86, 0x18,
  0x62, 0xF0, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0xF8, 0xFC, 0x21, 0x0F, 0xC2,
  0x10, 0x80, 0x74, 0x63, 0x08, 0x4E, 0x31, 0x78, 0x8C, 0x63, 0x1F, 0xC6,
  0x31, 0x88, 0xF9, 0x08, 0x42, 0x10, 0x84, 0xF8, 0x08, 0x42, 0x10, 0x84,
  0x31, 0xF0, 0x86, 0x29, 0x28, 0xC2, 0x89, 0x22, 0x84, 0x84, 0x21, 0x08,
  0x42, 0x10, 0xF8, 0x8C, 0x63, 0xBD, 0xD6, 0x31, 0x88, 0x8C, 0x63, 0x9A,
  0xCE, 0x71, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xF2, 0x28, 0x61,
  0x8B, 0xC8, 0x20, 0x80, 0x72, 0x28, 0x61, 0x86, 0x18, 0x62, 0x78, 0x20,
  0x40, 0xF2, 0x28, 0x62, 0x8B, 0xC9, 0x22, 0x84, 0x74, 0x63, 0x07, 0x04,
  0x31, 0x78, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x70, 0x86, 0x18, 0xA2, 0x49, 0x45, 0x08, 0x20, 0xA6, 0x9A,
  0x69, 0xD7, 0x65, 0x92, 0x48, 0x86, 0x24, 0x94, 0x20, 0x85, 0x22, 0x84,
  0x8C, 0x62, 0xA5, 0x10, 0x84, 0x20, 0xF8, 0x44, 0x22, 0x21, 0x10, 0xF8,
  0xEA, 0xAA, 0xAB, 0x88, 0x88, 0x44, 0x22, 0x21, 0xFF, 0xF0, 0x44, 0xAA,
  0x90, 0xF8, 0xC0, 0xF8, 0x5F, 0x18, 0xFC, 0x84, 0x2D, 0x98, 0xC6, 0x31,
  0xF0, 0xFC, 0x61, 0x08, 0xBC, 0x08, 0x5F, 0x18, 0xC6, 0x31, 0x78, 0xFC,
  0x7F, 0x08, 0x3C, 0x3C, 0x8F, 0x88, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x63,
  0x18, 0xBC, 0x31, 0x70, 0x84, 0x2D, 0x98, 0xC6, 0x31, 0x88, 0x20, 0x30,
  0x42, 0x10, 0x84, 0xF8, 0x10, 0x61, 0x11, 0x11, 0x11, 0x1E, 0x84, 0x21,
  0x3A, 0x62, 0x92, 0x88, 0xE1, 0x08, 0x42, 0x10, 0x84, 0xF8, 0xFF, 0x26,
  0x4C, 0x99, 0x32, 0x40, 0xFC, 0x63, 0x18, 0xC4, 0xFC, 0x63, 0x18, 0xBC,
  0xFC, 0x63, 0x18, 0xFA, 0x10, 0xFC, 0x63, 0x18, 0xBC, 0x21, 0xF8, 0x88,
  0x88, 0xFC, 0x1C, 0x18, 0xBC, 0x27, 0xC8, 0x42, 0x10, 0x87, 0x8C, 0x63,
  0x18, 0xBC, 0x8E, 0x24, 0x94, 0x50, 0x80, 0x92, 0xA5, 0xAB, 0x62, 0x44,
  0x80, 0x8A, 0x88, 0x64, 0xC4, 0xC2, 0x88, 0x91, 0x42, 0x82, 0x04, 0x10,
  0x40, 0xF8, 0x42, 0x10, 0x43, 0xF0, 0x34, 0x44, 0x48, 0x44, 0x44, 0x21,
  0xFF, 0xE0, 0xC4, 0x44, 0x21, 0x24, 0x44, 0x48, 0x61, 0x3C,
};

const GFXglyph RobotoMono_Thin12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 1, 2, 7, 3, -9 },
  { 4, 7, 9, 7, 0, -9 },
  { 12, 5, 11, 7, 1, -10 },
  { 19, 7, 9, 7, 0, -9 },
  { 27, 6, 9, 7, 1, -9 },
  { 34, 1, 2, 7, 3, -9 },
  { 35, 3, 13, 7, 2, -10 },
  { 40, 3, 13, 7, 2, -10 },
  { 45, 5, 5, 7, 1, -9 },
  { 49, 6, 6, 7, 1, -7 },
  { 54, 1, 3, 7, 2, -1 },
  { 55, 5, 1, 7, 1, -4 },
  { 56, 1, 1, 7, 3, -1 },
  { 57, 4, 10, 7, 2, -9 },
  { 62, 5, 9, 7, 1, -9 },
  { 68, 3, 9, 7, 1, -9 },
  { 72, 5, 9, 7, 1, -9 },
  { 78, 5, 9, 7, 1, -9 },
  { 84, 5, 9, 7, 1, -9 },
  { 90, 5, 9, 7, 1, -9 },
  { 96, 5, 9, 7, 1, -9 },
  { 102, 5, 9, 7, 1, -9 },
  { 108, 5, 9, 7, 1, -9 },
  { 114, 5, 9, 7, 1, -9 },
  { 120, 1, 6, 7, 4, -6 },
  { 121, 1, 8, 7, 3, -6 },
  { 122, 5, 4, 7, 1, -6 },
  { 125, 5, 2, 7, 1, -5 },
  { 127, 5, 4, 7, 1, -6 },
  { 130, 5, 9, 7, 1, -9 },
  { 136, 7, 9, 7, 0, -9 },
  { 144, 6, 9, 7, 1, -9 },
  { 151, 5, 9, 7, 1, -9 },
  { 157, 5, 9, 7, 1, -9 },
  { 163, 6, 9, 7, 1, -9 },
  { 170, 5, 9, 7, 1, -9 },
  { 176, 5, 9, 7, 1, -9 },
  { 182, 5, 9, 7, 1, -9 },
  { 188, 5, 9, 7, 1, -9 },
  { 194, 5, 9, 7, 1, -9 },
  { 200, 5, 9, 7, 1, -9 },
  { 206, 6, 9, 7, 1, -9 },
  { 213, 5, 9, 7, 1, -9 },
  { 219, 5, 9, 7, 1, -9 },
  { 225, 5, 9, 7, 1, -9 },
  { 231, 5, 9, 7, 1, -9 },
  { 237, 6, 9, 7, 1, -9 },
  { 244, 6, 11, 7, 1, -9 },
  { 253, 6, 9, 7, 1, -9 },
  { 260, 5, 9, 7, 1, -9 },
  { 266, 6, 9, 7, 1, -9 },
  { 273, 5, 9, 7, 1, -9 },
  { 279, 6, 9, 7, 1, -9 },
  { 286, 6, 9, 7, 1, -9 },
  { 293, 6, 9, 7, 1, -9 },
  { 300, 5, 9, 7, 1, -9 },
  { 306, 5, 9, 7, 1, -9 },
  { 312, 2, 12, 7, 3, -10 },
  { 315, 4, 10, 7, 2, -9 },
  { 320, 1, 12, 7, 3, -10 },
  { 322, 4, 5, 7, 2, -9 },
  { 325, 5, 1, 7, 1, 0 },
  { 326, 1, 2, 7, 3, -9 },
  { 327, 5, 6, 7, 1, -6 },
  { 331, 5, 9, 7, 1, -9 },
  { 337, 5, 6, 7, 1, -6 },
  { 341, 5, 9, 7, 1, -9 },
  { 347, 5, 6, 7, 1, -6 },
  { 351, 6, 9, 7, 1, -9 },
  { 358, 5, 9, 7, 1, -6 },
  { 364, 5, 9, 7, 1, -9 },
  { 370, 5, 9, 7, 1, -9 },
  { 376, 4, 12, 7, 1, -9 },
  { 382, 5, 9, 7, 1, -9 },
  { 388, 5, 9, 7, 1, -9 },
  { 394, 7, 6, 7, 0, -6 },
  { 400, 5, 6, 7, 1, -6 },
  { 404, 5, 6, 7, 1, -6 },
  { 408, 5, 8, 7, 1, -6 },
  { 413, 5, 8, 7, 1, -6 },
  { 418, 4, 6, 7, 2, -6 },
  { 421, 5, 6, 7, 1, -6 },
  { 425, 5, 8, 7, 1, -8 },
  { 430, 5, 6, 7, 1, -6 },
  { 434, 6, 6, 7, 1, -6 },
  { 439, 7, 6, 7, 0, -6 },
  { 445, 5, 6, 7, 1, -6 },
  { 449, 7, 9, 7, 0, -6 },
  { 457, 6, 6, 7, 1, -6 },
  { 462, 4, 12, 7, 2, -9 },
  { 468, 1, 11, 7, 3, -9 },
  { 470, 4, 12, 7, 2, -9 },
  { 476, 7, 2, 7, 0, -5 },
};

const GFXfont RobotoMono_Thin12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin12pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_THIN12PT7B_H_
