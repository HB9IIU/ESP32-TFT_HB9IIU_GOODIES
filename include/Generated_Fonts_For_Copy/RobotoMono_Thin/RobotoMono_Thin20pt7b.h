#ifndef _ROBOTOMONO_THIN20PT7B_H_
#define _ROBOTOMONO_THIN20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC4, 0xB6, 0xD0, 0x08, 0x81, 0x10, 0x44, 0x08, 0x8F, 0xFE,
  0x22, 0x04, 0x41, 0x08, 0x22, 0x1F, 0xF8, 0x88, 0x11, 0x02, 0x20, 0x88,
  0x00, 0x08, 0x1C, 0x22, 0x41, 0x81, 0x81, 0x80, 0x40, 0x38, 0x06, 0x01,
  0x01, 0x81, 0x81, 0x41, 0x36, 0x08, 0x08, 0x78, 0x08, 0x88, 0x88, 0x88,
  0x90, 0x89, 0x07, 0x20, 0x02, 0x00, 0x4C, 0x05, 0x20, 0x91, 0x09, 0x11,
  0x11, 0x21, 0x10, 0x0E, 0x3C, 0x22, 0x11, 0x08, 0x84, 0x81, 0x80, 0x80,
  0xA0, 0x88, 0xC2, 0x60, 0xB0, 0x28, 0x33, 0xE4, 0xF0, 0x12, 0x24, 0x48,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x44, 0x21, 0x10, 0x88, 0x42, 0x22, 0x11,
  0x11, 0x11, 0x11, 0x12, 0x22, 0x48, 0x80, 0x08, 0x04, 0x22, 0x6F, 0xC0,
  0x80, 0xA0, 0x88, 0x84, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0xF0, 0xFF, 0x80, 0x06, 0x08, 0x10,
  0x40, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x00, 0x7E,
  0x81, 0x81, 0x81, 0x83, 0x85, 0x89, 0x91, 0xA1, 0xC1, 0x81, 0x81, 0x42,
  0x3C, 0x1B, 0x62, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3E, 0x20,
  0xA0, 0x50, 0x20, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x07, 0xFC, 0x3E, 0x20, 0xA0, 0x30, 0x10, 0x08, 0x08, 0x78, 0x06, 0x00,
  0x80, 0x60, 0x30, 0x14, 0x11, 0xF0, 0x02, 0x01, 0x40, 0x50, 0x24, 0x11,
  0x04, 0x42, 0x11, 0x04, 0x41, 0x3F, 0xF0, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x7F, 0x40, 0x40, 0x40, 0x40, 0x7E, 0x41, 0x01, 0x01, 0x01, 0x81, 0x81,
  0x41, 0x3E, 0x1E, 0x60, 0x40, 0x80, 0x98, 0xE6, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x7C, 0xFF, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x7E, 0x40, 0xA0, 0x50,
  0x18, 0x12, 0x08, 0xF8, 0x84, 0x81, 0x40, 0x60, 0x30, 0x18, 0x13, 0xF0,
  0x7E, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x67, 0x19, 0x01, 0x02,
  0x04, 0x78, 0x80, 0x40, 0x80, 0xF0, 0x07, 0x18, 0x60, 0x80, 0x60, 0x18,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x18, 0x06, 0x01, 0x06, 0x38,
  0xC0, 0x3E, 0x41, 0x81, 0x01, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x00,
  0x00, 0x00, 0x10, 0x0F, 0xC6, 0x04, 0x88, 0xA2, 0x94, 0x8A, 0xA2, 0x64,
  0x4C, 0x89, 0x91, 0x32, 0x25, 0x3B, 0xA0, 0x02, 0x00, 0x3F, 0x00, 0x04,
  0x03, 0x00, 0xA0, 0x48, 0x12, 0x04, 0x42, 0x10, 0x84, 0x20, 0x8F, 0xE4,
  0x09, 0x01, 0x80, 0x60, 0x10, 0xFE, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x1B,
  0xF1, 0x06, 0x81, 0x40, 0x60, 0x30, 0x18, 0x17, 0xF0, 0x3F, 0x10, 0x24,
  0x0A, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x05, 0x02,
  0x20, 0x87, 0xC0, 0xFC, 0x41, 0x20, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x50, 0x28, 0x27, 0xE0, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F,
  0x10, 0x24, 0x0A, 0x01, 0x80, 0x20, 0x08, 0x02, 0x1E, 0x80, 0x60, 0x14,
  0x05, 0x01, 0x20, 0x47, 0xE0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x14, 0x11,
  0xF0, 0x80, 0xC0, 0xA0, 0x90, 0x88, 0x84, 0x82, 0x81, 0xA0, 0x88, 0x42,
  0x20, 0x90, 0x28, 0x14, 0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x81, 0x81, 0xC3, 0xC3, 0xA5,
  0xA5, 0xA5, 0x99, 0x99, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1,
  0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x83, 0x83, 0x81, 0x81, 0x3F,
  0x10, 0x24, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14,
  0x09, 0x02, 0x21, 0x07, 0x80, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06,
  0x05, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x3F, 0x10, 0x24,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x02,
  0x40, 0x8F, 0xC0, 0x10, 0x02, 0x00, 0x40, 0xFE, 0x40, 0xA0, 0x50, 0x18,
  0x0C, 0x0A, 0x0D, 0xF8, 0x84, 0x41, 0x20, 0x90, 0x28, 0x14, 0x04, 0x7E,
  0x40, 0xA0, 0x30, 0x18, 0x02, 0x00, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x30,
  0x18, 0x13, 0xF0, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x80,
  0x60, 0x14, 0x09, 0x02, 0x40, 0x88, 0x42, 0x10, 0x84, 0x12, 0x04, 0x81,
  0x20, 0x30, 0x0C, 0x02, 0x00, 0x84, 0x61, 0x18, 0xC6, 0x31, 0x8A, 0x52,
  0x95, 0x25, 0x4A, 0x52, 0x94, 0x65, 0x18, 0x86, 0x21, 0x08, 0x40, 0xC0,
  0x50, 0x22, 0x10, 0x44, 0x12, 0x02, 0x80, 0x40, 0x30, 0x0A, 0x04, 0x82,
  0x10, 0x82, 0x40, 0xA0, 0x10, 0x80, 0x50, 0x24, 0x08, 0x84, 0x22, 0x04,
  0x81, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x7F,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x04, 0x07, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x82,
  0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0xE4,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x27, 0x80, 0x30, 0xC4, 0x92, 0x4A, 0x18,
  0x61, 0xFF, 0x94, 0x1C, 0x42, 0x81, 0x01, 0x01, 0x3F, 0xC1, 0x81, 0x81,
  0x83, 0x7D, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC2, 0xBC, 0x3C, 0x42, 0x81, 0x81, 0x80, 0x80, 0x80,
  0x80, 0x81, 0x41, 0x3E, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x42, 0x81, 0x81, 0x81,
  0xFE, 0x80, 0x80, 0x80, 0x41, 0x3E, 0x0F, 0x88, 0x04, 0x02, 0x0F, 0xF0,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3D,
  0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01,
  0x82, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xE2, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x08, 0x00, 0x00, 0xF8, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x04, 0x00, 0x1F, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0B, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x82, 0x84, 0x88, 0x90, 0xA0, 0xE0, 0x90, 0x88, 0x88, 0x84, 0x83,
  0xF8, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0xFF, 0xF3, 0xA3, 0x18, 0x46, 0x21, 0x88, 0x62, 0x18, 0x86,
  0x21, 0x88, 0x62, 0x18, 0x84, 0x9C, 0xE2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x1E, 0x08, 0x44, 0x0A, 0x02, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x40, 0x90, 0x23, 0xF0, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x43, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01,
  0x9F, 0xC2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x3C, 0x43,
  0x81, 0x80, 0x40, 0x3C, 0x02, 0x01, 0x81, 0x81, 0x7E, 0x10, 0x10, 0xFE,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x60, 0x14,
  0x09, 0x02, 0x21, 0x08, 0x41, 0x20, 0x48, 0x12, 0x03, 0x00, 0x80, 0x84,
  0x61, 0x18, 0xC6, 0x31, 0x8A, 0x54, 0xA5, 0x29, 0x4A, 0x51, 0x88, 0x42,
  0x10, 0x40, 0x50, 0x22, 0x10, 0x48, 0x0C, 0x01, 0x00, 0xC0, 0x48, 0x21,
  0x08, 0x2C, 0x04, 0x80, 0x60, 0x14, 0x09, 0x02, 0x21, 0x08, 0x42, 0x10,
  0x48, 0x12, 0x03, 0x00, 0x40, 0x20, 0x08, 0x04, 0x0E, 0x00, 0x7F, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC,
  0x02, 0x18, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x43, 0x01, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x20, 0x30, 0xFF, 0xFF, 0x80, 0x80, 0xC0, 0x80,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x18, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x86, 0x00, 0x70, 0x22, 0x18, 0x44, 0x0E,
};

const GFXglyph RobotoMono_Thin20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 1, 14, 12, 5, -14 },
  { 3, 3, 4, 12, 4, -15 },
  { 5, 11, 14, 12, 1, -14 },
  { 25, 8, 18, 12, 2, -16 },
  { 43, 12, 14, 12, 0, -14 },
  { 64, 9, 14, 12, 2, -14 },
  { 80, 1, 4, 12, 5, -15 },
  { 81, 4, 21, 12, 4, -16 },
  { 92, 4, 21, 12, 4, -16 },
  { 103, 9, 8, 12, 2, -14 },
  { 112, 10, 11, 12, 1, -12 },
  { 126, 1, 4, 12, 4, -2 },
  { 127, 8, 1, 12, 2, -7 },
  { 128, 1, 1, 12, 6, -1 },
  { 129, 7, 15, 12, 3, -14 },
  { 143, 8, 14, 12, 2, -14 },
  { 157, 5, 14, 12, 2, -14 },
  { 166, 9, 14, 12, 1, -14 },
  { 182, 9, 14, 12, 1, -14 },
  { 198, 10, 14, 12, 1, -14 },
  { 216, 8, 14, 12, 2, -14 },
  { 230, 8, 14, 12, 2, -14 },
  { 244, 9, 14, 12, 1, -14 },
  { 260, 9, 14, 12, 2, -14 },
  { 276, 8, 14, 12, 2, -14 },
  { 290, 1, 10, 12, 6, -10 },
  { 292, 1, 12, 12, 6, -10 },
  { 294, 8, 7, 12, 2, -10 },
  { 301, 8, 5, 12, 2, -9 },
  { 306, 8, 7, 12, 2, -10 },
  { 313, 8, 14, 12, 2, -14 },
  { 327, 11, 14, 12, 0, -14 },
  { 347, 10, 14, 12, 1, -14 },
  { 365, 9, 14, 12, 2, -14 },
  { 381, 10, 14, 12, 1, -14 },
  { 399, 9, 14, 12, 2, -14 },
  { 415, 8, 14, 12, 2, -14 },
  { 429, 8, 14, 12, 2, -14 },
  { 443, 10, 14, 12, 1, -14 },
  { 461, 8, 14, 12, 2, -14 },
  { 475, 8, 14, 12, 2, -14 },
  { 489, 9, 14, 12, 1, -14 },
  { 505, 9, 14, 12, 2, -14 },
  { 521, 8, 14, 12, 2, -14 },
  { 535, 8, 14, 12, 2, -14 },
  { 549, 8, 14, 12, 2, -14 },
  { 563, 10, 14, 12, 1, -14 },
  { 581, 9, 14, 12, 2, -14 },
  { 597, 10, 17, 12, 1, -14 },
  { 619, 9, 14, 12, 2, -14 },
  { 635, 9, 14, 12, 2, -14 },
  { 651, 10, 14, 12, 1, -14 },
  { 669, 8, 14, 12, 2, -14 },
  { 683, 10, 14, 12, 1, -14 },
  { 701, 10, 14, 12, 1, -14 },
  { 719, 10, 14, 12, 1, -14 },
  { 737, 10, 14, 12, 1, -14 },
  { 755, 9, 14, 12, 1, -14 },
  { 771, 3, 19, 12, 5, -16 },
  { 779, 6, 15, 12, 3, -14 },
  { 791, 3, 19, 12, 4, -16 },
  { 799, 6, 8, 12, 3, -14 },
  { 805, 8, 1, 12, 2, 0 },
  { 806, 2, 3, 12, 5, -15 },
  { 807, 8, 11, 12, 2, -11 },
  { 818, 8, 15, 12, 2, -15 },
  { 833, 8, 11, 12, 2, -11 },
  { 844, 8, 15, 12, 2, -15 },
  { 859, 8, 11, 12, 2, -11 },
  { 870, 9, 15, 12, 2, -15 },
  { 887, 8, 15, 12, 2, -11 },
  { 902, 8, 15, 12, 2, -15 },
  { 917, 8, 14, 12, 2, -14 },
  { 931, 6, 18, 12, 2, -14 },
  { 945, 8, 15, 12, 3, -15 },
  { 960, 8, 15, 12, 2, -15 },
  { 975, 10, 11, 12, 1, -11 },
  { 989, 8, 11, 12, 2, -11 },
  { 1000, 10, 11, 12, 1, -11 },
  { 1014, 8, 15, 12, 2, -11 },
  { 1029, 8, 15, 12, 2, -11 },
  { 1044, 7, 11, 12, 4, -11 },
  { 1054, 8, 11, 12, 2, -11 },
  { 1065, 8, 13, 12, 2, -13 },
  { 1078, 8, 11, 12, 2, -11 },
  { 1089, 10, 11, 12, 1, -11 },
  { 1103, 10, 11, 12, 1, -11 },
  { 1117, 10, 11, 12, 1, -11 },
  { 1131, 10, 15, 12, 1, -11 },
  { 1150, 10, 11, 12, 1, -11 },
  { 1164, 7, 20, 12, 3, -16 },
  { 1182, 1, 17, 12, 6, -14 },
  { 1185, 7, 20, 12, 3, -16 },
  { 1203, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoMono_Thin20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin20pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_THIN20PT7B_H_
