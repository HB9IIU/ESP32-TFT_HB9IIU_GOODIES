#ifndef _ROBOTOMONO_THIN38PT7B_H_
#define _ROBOTOMONO_THIN38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin38pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x3C, 0xC7, 0x1C, 0x61, 0x86,
  0x18, 0x61, 0x00, 0x40, 0xC0, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01,
  0x00, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x20, 0x20, 0x3F,
  0xFF, 0xF8, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x04, 0x00, 0x20, 0x20,
  0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x06, 0x00, 0x10,
  0x20, 0x3F, 0xFF, 0xF8, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00,
  0x10, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x0F, 0xF0, 0x10,
  0x18, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x40,
  0x01, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x60, 0x06, 0x30,
  0x0C, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x3E,
  0x00, 0x02, 0x18, 0x00, 0x20, 0x40, 0x01, 0x02, 0x02, 0x08, 0x08, 0x10,
  0x40, 0x41, 0x02, 0x02, 0x08, 0x10, 0x10, 0x80, 0x81, 0x04, 0x06, 0x08,
  0x40, 0x10, 0x86, 0x00, 0x78, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x7C, 0x00, 0x86, 0x30, 0x04, 0x20, 0x80, 0x42,
  0x02, 0x02, 0x10, 0x10, 0x20, 0x80, 0x83, 0x04, 0x04, 0x10, 0x20, 0x21,
  0x01, 0x01, 0x08, 0x04, 0x10, 0x00, 0x20, 0x80, 0x00, 0xF8, 0x07, 0xE0,
  0x01, 0x06, 0x00, 0x40, 0x40, 0x08, 0x0C, 0x01, 0x00, 0x80, 0x20, 0x20,
  0x04, 0x04, 0x00, 0x81, 0x80, 0x10, 0x20, 0x01, 0x18, 0x00, 0x26, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x16, 0x00, 0x04, 0x60, 0x01, 0x04, 0x02,
  0x40, 0x40, 0x48, 0x04, 0x0A, 0x00, 0x42, 0x40, 0x0C, 0x48, 0x00, 0x89,
  0x00, 0x0A, 0x20, 0x00, 0xC2, 0x00, 0x18, 0x60, 0x04, 0x86, 0x03, 0x18,
  0x3F, 0x81, 0x80, 0xFF, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x60, 0xC0, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x87, 0x38, 0x9C,
  0x07, 0xE0, 0x01, 0x80, 0x02, 0x40, 0x06, 0x60, 0x0C, 0x30, 0x08, 0x18,
  0x10, 0x08, 0x30, 0x04, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x1F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x55, 0x5A, 0xFF, 0xF8, 0xF0, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0x0C, 0x04, 0x04, 0x01, 0x04, 0x00, 0x44,
  0x00, 0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x06, 0x80, 0x04, 0xC0, 0x04,
  0x60, 0x04, 0x30, 0x04, 0x18, 0x04, 0x0C, 0x04, 0x06, 0x04, 0x03, 0x04,
  0x01, 0x84, 0x00, 0xC4, 0x00, 0x64, 0x00, 0x2C, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x09, 0x80, 0x08, 0x40, 0x04, 0x10, 0x04, 0x04, 0x04, 0x01, 0xFC,
  0x00, 0x00, 0x83, 0xC7, 0x2C, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0F, 0xF0, 0x0C, 0x0C,
  0x08, 0x01, 0x08, 0x00, 0x44, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF0, 0x0C, 0x06, 0x08, 0x01,
  0x8C, 0x00, 0x44, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x01, 0x80, 0x07, 0x00, 0x1F, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0B, 0x00, 0x04, 0x80, 0x02, 0x20, 0x02, 0x0C,
  0x06, 0x03, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x01,
  0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x02, 0x02, 0x00, 0x80, 0x40, 0x30,
  0x08, 0x04, 0x01, 0x01, 0x00, 0x20, 0x60, 0x04, 0x08, 0x00, 0x82, 0x00,
  0x10, 0x7F, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x47, 0xE0, 0x58, 0x18, 0x60, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x02, 0x60, 0x02, 0x20, 0x04, 0x18,
  0x08, 0x0F, 0xF0, 0x00, 0xF8, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x41, 0xE0, 0x8E,
  0x38, 0x90, 0x0C, 0xA0, 0x06, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40,
  0x02, 0x20, 0x02, 0x30, 0x04, 0x18, 0x08, 0x07, 0xF0, 0xFF, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x0C, 0x06, 0x0C,
  0x00, 0x84, 0x00, 0x24, 0x00, 0x12, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC3, 0x00, 0xC0, 0xF3, 0x80, 0x3F,
  0xC0, 0x60, 0x10, 0x40, 0x06, 0x60, 0x01, 0x20, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x05, 0x00, 0x02, 0x80, 0x03, 0x20, 0x03,
  0x0C, 0x03, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0C, 0x04, 0x0C, 0x01, 0x04,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x80,
  0x0C, 0x40, 0x0A, 0x18, 0x19, 0x07, 0xF8, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x49, 0x25, 0x20, 0x00, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0xC4, 0x01, 0x20, 0x02, 0x80, 0x0A,
  0x00, 0x20, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x0C, 0x01, 0x00, 0x10, 0x10,
  0x00, 0x41, 0x00, 0x03, 0x18, 0x18, 0x08, 0x83, 0xB0, 0x48, 0x30, 0x42,
  0x41, 0x02, 0x1A, 0x10, 0x10, 0x60, 0x80, 0x83, 0x04, 0x08, 0x18, 0x20,
  0x40, 0xC2, 0x02, 0x06, 0x10, 0x10, 0x30, 0x80, 0x82, 0x84, 0x04, 0x14,
  0x20, 0x60, 0xA0, 0x83, 0x05, 0x04, 0x28, 0x44, 0x32, 0x26, 0x20, 0xE0,
  0xE1, 0x80, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00,
  0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x40, 0x02, 0x08, 0x00,
  0x41, 0x00, 0x08, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x01, 0x02, 0x00, 0x20, 0x7F, 0xFC, 0x08,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0x48, 0x00, 0x06, 0x00, 0x00, 0x80, 0xFF, 0xC0, 0x80, 0x30, 0x80,
  0x08, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x08, 0x80, 0xF0, 0xFF, 0xF0, 0x80,
  0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x04, 0x80, 0x18, 0xFF,
  0xE0, 0x07, 0xF0, 0x0C, 0x06, 0x0C, 0x01, 0x84, 0x00, 0x64, 0x00, 0x12,
  0x00, 0x0A, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x09,
  0x00, 0x04, 0x40, 0x04, 0x30, 0x06, 0x0C, 0x06, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x40, 0x30, 0x20, 0x06, 0x10, 0x01, 0x88, 0x00, 0x44, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24, 0x00, 0x12, 0x00, 0x11,
  0x00, 0x18, 0x80, 0x18, 0x40, 0x30, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xA0,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x03, 0x01, 0x81, 0x80,
  0x30, 0x40, 0x06, 0x20, 0x00, 0x88, 0x00, 0x34, 0x00, 0x05, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x05, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x40, 0x01,
  0x08, 0x00, 0xC1, 0x00, 0x60, 0x3F, 0xE0, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0xC0, 0x04, 0x20,
  0x06, 0x0C, 0x06, 0x03, 0xFC, 0x00, 0x80, 0x01, 0xA0, 0x00, 0xC8, 0x00,
  0x62, 0x00, 0x30, 0x80, 0x18, 0x20, 0x04, 0x08, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x20, 0x40, 0x08, 0x20, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x26,
  0x80, 0x0A, 0x10, 0x03, 0x06, 0x00, 0x80, 0x80, 0x20, 0x10, 0x08, 0x02,
  0x02, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0x42, 0x00, 0x08,
  0x80, 0x01, 0x20, 0x00, 0x68, 0x00, 0x0C, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xE8, 0x00, 0xB4, 0x00, 0x59, 0x00, 0x6C,
  0x80, 0x26, 0x40, 0x13, 0x10, 0x11, 0x88, 0x08, 0xC2, 0x08, 0x61, 0x04,
  0x30, 0x82, 0x18, 0x22, 0x0C, 0x11, 0x06, 0x09, 0x03, 0x02, 0x81, 0x81,
  0x40, 0xC0, 0x40, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0xC0,
  0x00, 0xE0, 0x00, 0x68, 0x00, 0x34, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x06,
  0x20, 0x03, 0x08, 0x01, 0x84, 0x00, 0xC1, 0x00, 0x60, 0x80, 0x30, 0x20,
  0x18, 0x10, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x00, 0x81, 0x80, 0x20, 0xC0,
  0x10, 0x60, 0x04, 0x30, 0x02, 0x18, 0x00, 0x8C, 0x00, 0x46, 0x00, 0x13,
  0x00, 0x05, 0x80, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x07, 0xF0, 0x0C,
  0x04, 0x0C, 0x01, 0x04, 0x00, 0x44, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x40, 0x04,
  0x30, 0x04, 0x0C, 0x04, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x60, 0x0E, 0x30,
  0x01, 0x98, 0x00, 0x6C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x26, 0x00,
  0x23, 0x00, 0xE1, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x80, 0xC0, 0x60, 0x0C,
  0x18, 0x00, 0x82, 0x00, 0x08, 0xC0, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x05,
  0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0xC0, 0x00, 0x88, 0x00, 0x21,
  0x80, 0x0C, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0xFF, 0xC0, 0x40,
  0x18, 0x20, 0x03, 0x10, 0x00, 0x88, 0x00, 0x24, 0x00, 0x12, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x44, 0x00, 0x43, 0xFF, 0xC1, 0x00, 0x80, 0x80, 0x20, 0x40, 0x10, 0x20,
  0x04, 0x10, 0x03, 0x08, 0x00, 0x84, 0x00, 0x22, 0x00, 0x11, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x60, 0x07, 0xF8, 0x0C, 0x06, 0x08,
  0x00, 0x88, 0x00, 0x24, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x02, 0x80, 0x03, 0x20, 0x01,
  0x0C, 0x03, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x28, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x40,
  0x04, 0x30, 0x06, 0x0C, 0x06, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x78, 0x00,
  0x09, 0x00, 0x01, 0x20, 0x00, 0x64, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x01, 0x01, 0x00, 0x20, 0x20, 0x04, 0x08,
  0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x11, 0x00, 0x02, 0x20,
  0x00, 0x48, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x06, 0x02, 0x80,
  0xA0, 0x24, 0x0A, 0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x90, 0x44,
  0x11, 0x04, 0x41, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x22, 0x08, 0x82, 0x20, 0x88, 0x22, 0x0C, 0x81, 0x20, 0x48, 0x12, 0x04,
  0x81, 0x60, 0x48, 0x14, 0x04, 0x81, 0x40, 0x70, 0x14, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x30, 0x08, 0x03, 0x00, 0x40, 0x00, 0x64,
  0x00, 0x08, 0x80, 0x02, 0x08, 0x00, 0xC0, 0x80, 0x10, 0x10, 0x04, 0x01,
  0x01, 0x80, 0x30, 0x20, 0x02, 0x08, 0x00, 0x21, 0x00, 0x06, 0x40, 0x00,
  0x50, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x04, 0x80, 0x01,
  0x10, 0x00, 0x61, 0x00, 0x08, 0x10, 0x02, 0x02, 0x00, 0xC0, 0x20, 0x10,
  0x06, 0x04, 0x00, 0x40, 0x80, 0x04, 0x20, 0x00, 0xC8, 0x00, 0x0B, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x78, 0x00, 0x09, 0x00, 0x02, 0x10, 0x00, 0x42,
  0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x00,
  0x81, 0x00, 0x10, 0x20, 0x01, 0x08, 0x00, 0x21, 0x00, 0x02, 0x40, 0x00,
  0x48, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F,
  0x80, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0xFC, 0x02, 0x00, 0x38, 0x01, 0x40, 0x1A, 0x00,
  0x88, 0x04, 0x40, 0x43, 0x02, 0x08, 0x20, 0x41, 0x01, 0x08, 0x08, 0x80,
  0x24, 0x01, 0x40, 0x0A, 0x00, 0x20, 0xFF, 0xFE, 0xC2, 0x08, 0x21, 0x80,
  0x0F, 0xF8, 0x0C, 0x06, 0x08, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x03, 0xFF, 0x86, 0x00, 0x44,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x40, 0x03,
  0x20, 0x02, 0x8C, 0x06, 0x43, 0xFC, 0x30, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x8F, 0xE0, 0x90, 0x18, 0xA0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0xC0, 0x04, 0xE0,
  0x08, 0xB0, 0x18, 0x8F, 0xE0, 0x07, 0xF8, 0x18, 0x0C, 0x10, 0x02, 0x20,
  0x02, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x01, 0x40,
  0x01, 0x20, 0x03, 0x10, 0x02, 0x08, 0x0C, 0x07, 0xF8, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x0F, 0xF1, 0x18, 0x09, 0x30, 0x05, 0x20, 0x03, 0x40,
  0x03, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20,
  0x03, 0x30, 0x05, 0x18, 0x09, 0x07, 0xF1, 0x07, 0xF8, 0x04, 0x06, 0x04,
  0x00, 0x84, 0x00, 0x64, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x83, 0x01, 0x80,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x0F, 0xF1, 0x18, 0x09, 0x30, 0x05, 0x20, 0x03,
  0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x20, 0x03, 0x30, 0x05, 0x18, 0x09, 0x07, 0xF1, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x20, 0x04, 0x30, 0x0C, 0x18, 0x18, 0x07, 0xE0,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x0F, 0xE2, 0x60, 0x25, 0x80, 0x2A, 0x00,
  0x78, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF,
  0xFF, 0x00, 0x30, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x18, 0xFE, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x1A, 0x00, 0x64, 0x01, 0x88, 0x04, 0x10, 0x10, 0x20, 0x40, 0x43, 0x00,
  0x8C, 0x01, 0x30, 0x02, 0xF0, 0x06, 0x30, 0x08, 0x20, 0x10, 0x20, 0x20,
  0x20, 0x40, 0x20, 0x80, 0x21, 0x00, 0x22, 0x00, 0x24, 0x00, 0x68, 0x00,
  0x60, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xBF,
  0x1F, 0xD8, 0x16, 0x0B, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x87,
  0xF1, 0x30, 0x12, 0xC0, 0x15, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x0F, 0xF0, 0x0C, 0x06, 0x0C, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x04, 0x80, 0x02, 0x60,
  0x02, 0x18, 0x03, 0x06, 0x03, 0x00, 0xFE, 0x00, 0x8F, 0xE1, 0x20, 0x32,
  0x80, 0x26, 0x00, 0x28, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x02, 0xC0, 0x05, 0xC0, 0x12, 0xC0, 0x44, 0x7F, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xF1, 0x18, 0x09, 0x30, 0x05, 0x20, 0x03, 0x40, 0x03, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x03, 0x30,
  0x05, 0x18, 0x09, 0x07, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x87, 0xFC, 0x60,
  0x24, 0x01, 0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x30, 0x0C, 0x40, 0x06,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x30, 0x0C, 0x1F, 0xF0, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x3F, 0xFF, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x40, 0x06, 0x80, 0x14, 0xC0, 0x48, 0xFF,
  0x10, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x00, 0x02, 0x10, 0x00, 0x42, 0x00,
  0x18, 0x20, 0x02, 0x04, 0x00, 0x40, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x80, 0x10, 0x10, 0x02, 0x06, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0xC4,
  0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x20,
  0x00, 0xC0, 0x20, 0x0A, 0x01, 0x00, 0x90, 0x14, 0x04, 0x80, 0xA0, 0x26,
  0x05, 0x01, 0x10, 0x28, 0x10, 0x82, 0x20, 0x84, 0x11, 0x04, 0x20, 0x88,
  0x20, 0x84, 0x42, 0x04, 0x41, 0x10, 0x22, 0x08, 0x81, 0x10, 0x44, 0x04,
  0x82, 0x20, 0x28, 0x0A, 0x01, 0x40, 0x50, 0x0A, 0x02, 0x80, 0x50, 0x14,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x01, 0x98, 0x00, 0xC3, 0x00,
  0x20, 0x40, 0x10, 0x08, 0x08, 0x01, 0x06, 0x00, 0x63, 0x00, 0x0C, 0x80,
  0x01, 0x40, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x05, 0x80, 0x02, 0x30, 0x01,
  0x04, 0x00, 0xC0, 0x80, 0x60, 0x10, 0x10, 0x06, 0x08, 0x00, 0xC4, 0x00,
  0x13, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x62, 0x00, 0x08, 0x40, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x10, 0x02, 0x02, 0x00, 0x60, 0x80, 0x04, 0x10,
  0x00, 0xC6, 0x00, 0x08, 0x80, 0x01, 0xB0, 0x00, 0x14, 0x00, 0x03, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x10, 0x07, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x70, 0x0E,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x30, 0x0C, 0x00, 0x3F, 0x00, 0x12, 0x0C, 0x01, 0x40, 0x60,
  0x14, 0x01, 0x03, 0x80, 0x0C, 0x60, 0x00, 0x38,
};

const GFXglyph RobotoMono_Thin38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 2, 27, 23, 10, -27 },
  { 8, 6, 8, 23, 8, -29 },
  { 14, 21, 27, 23, 1, -27 },
  { 85, 16, 35, 23, 4, -31 },
  { 155, 21, 27, 23, 1, -27 },
  { 226, 19, 27, 23, 3, -27 },
  { 291, 1, 8, 23, 10, -29 },
  { 292, 8, 39, 23, 8, -30 },
  { 331, 8, 39, 23, 7, -30 },
  { 370, 16, 15, 23, 4, -27 },
  { 400, 19, 19, 23, 2, -22 },
  { 446, 2, 8, 23, 8, -3 },
  { 448, 13, 1, 23, 5, -13 },
  { 450, 2, 2, 23, 11, -2 },
  { 451, 12, 29, 23, 6, -27 },
  { 495, 17, 27, 23, 3, -27 },
  { 553, 9, 27, 23, 4, -27 },
  { 584, 17, 27, 23, 2, -27 },
  { 642, 17, 27, 23, 2, -27 },
  { 700, 19, 27, 23, 2, -27 },
  { 765, 16, 27, 23, 4, -27 },
  { 819, 16, 27, 23, 3, -27 },
  { 873, 17, 27, 23, 3, -27 },
  { 931, 17, 27, 23, 3, -27 },
  { 989, 17, 27, 23, 3, -27 },
  { 1047, 2, 18, 23, 12, -18 },
  { 1052, 3, 23, 23, 11, -18 },
  { 1061, 16, 15, 23, 3, -20 },
  { 1091, 17, 9, 23, 3, -17 },
  { 1111, 17, 15, 23, 3, -20 },
  { 1143, 14, 27, 23, 5, -27 },
  { 1191, 21, 27, 23, 1, -27 },
  { 1262, 19, 27, 23, 2, -27 },
  { 1327, 16, 27, 23, 4, -27 },
  { 1381, 17, 27, 23, 3, -27 },
  { 1439, 17, 27, 23, 4, -27 },
  { 1497, 15, 27, 23, 4, -27 },
  { 1548, 16, 27, 23, 4, -27 },
  { 1602, 18, 27, 23, 2, -27 },
  { 1663, 17, 27, 23, 3, -27 },
  { 1721, 15, 27, 23, 4, -27 },
  { 1772, 17, 27, 23, 2, -27 },
  { 1830, 18, 27, 23, 4, -27 },
  { 1891, 16, 27, 23, 4, -27 },
  { 1945, 17, 27, 23, 3, -27 },
  { 2003, 17, 27, 23, 3, -27 },
  { 2061, 17, 27, 23, 3, -27 },
  { 2119, 17, 27, 23, 4, -27 },
  { 2177, 19, 32, 23, 2, -27 },
  { 2253, 17, 27, 23, 4, -27 },
  { 2311, 17, 27, 23, 3, -27 },
  { 2369, 19, 27, 23, 2, -27 },
  { 2434, 17, 27, 23, 3, -27 },
  { 2492, 19, 27, 23, 2, -27 },
  { 2557, 20, 27, 23, 2, -27 },
  { 2625, 19, 27, 23, 2, -27 },
  { 2690, 19, 27, 23, 2, -27 },
  { 2755, 16, 27, 23, 3, -27 },
  { 2809, 5, 37, 23, 9, -31 },
  { 2833, 13, 29, 23, 5, -27 },
  { 2881, 6, 37, 23, 8, -31 },
  { 2909, 13, 15, 23, 5, -27 },
  { 2934, 15, 1, 23, 4, 0 },
  { 2936, 5, 5, 23, 9, -28 },
  { 2940, 17, 20, 23, 3, -20 },
  { 2983, 16, 29, 23, 4, -29 },
  { 3041, 16, 20, 23, 3, -20 },
  { 3081, 16, 29, 23, 3, -29 },
  { 3139, 17, 20, 23, 3, -20 },
  { 3182, 17, 29, 23, 4, -29 },
  { 3244, 16, 28, 23, 3, -20 },
  { 3300, 15, 29, 23, 4, -29 },
  { 3355, 16, 27, 23, 4, -27 },
  { 3409, 12, 35, 23, 3, -27 },
  { 3462, 15, 29, 23, 5, -29 },
  { 3517, 16, 29, 23, 4, -29 },
  { 3575, 19, 20, 23, 2, -20 },
  { 3623, 15, 20, 23, 4, -20 },
  { 3661, 17, 20, 23, 3, -20 },
  { 3704, 15, 28, 23, 4, -20 },
  { 3757, 16, 28, 23, 3, -20 },
  { 3813, 13, 20, 23, 7, -20 },
  { 3846, 16, 20, 23, 4, -20 },
  { 3886, 15, 26, 23, 4, -26 },
  { 3935, 15, 20, 23, 4, -20 },
  { 3973, 19, 20, 23, 2, -20 },
  { 4021, 21, 20, 23, 1, -20 },
  { 4074, 18, 20, 23, 3, -20 },
  { 4119, 19, 28, 23, 2, -20 },
  { 4186, 18, 20, 23, 3, -20 },
  { 4231, 12, 38, 23, 6, -30 },
  { 4288, 1, 32, 23, 11, -27 },
  { 4292, 12, 38, 23, 6, -30 },
  { 4349, 20, 6, 23, 1, -14 },
};

const GFXfont RobotoMono_Thin38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin38pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_THIN38PT7B_H_
