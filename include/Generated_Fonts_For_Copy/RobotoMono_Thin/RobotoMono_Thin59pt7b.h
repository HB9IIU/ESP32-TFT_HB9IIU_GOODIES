#ifndef _ROBOTOMONO_THIN59PT7B_H_
#define _ROBOTOMONO_THIN59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin59pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0x80, 0x00, 0x00, 0x06, 0xFC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x04, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x08, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x20, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x08, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x01,
  0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x00, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x01, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x02, 0x00,
  0x80, 0x30, 0x01, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x40, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x00, 0x60, 0x60, 0x01, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x10,
  0x30, 0x00, 0x20, 0x18, 0x18, 0x00, 0x18, 0x18, 0x18, 0x00, 0x07, 0xF8,
  0x08, 0x00, 0x00, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0xF0, 0x00, 0x01, 0x81, 0xFE, 0x00, 0x01, 0x81, 0x81, 0x80,
  0x00, 0xC0, 0x80, 0x60, 0x00, 0xC0, 0xC0, 0x10, 0x00, 0x40, 0x40, 0x0C,
  0x00, 0x60, 0x60, 0x06, 0x00, 0x20, 0x30, 0x03, 0x00, 0x30, 0x18, 0x01,
  0x80, 0x10, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x30, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x20,
  0x04, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x03, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x01, 0x0C, 0x01, 0x80, 0x08,
  0xC0, 0x06, 0x00, 0xC4, 0x00, 0x18, 0x06, 0x60, 0x00, 0x60, 0x33, 0x00,
  0x01, 0x81, 0x90, 0x00, 0x0C, 0x18, 0x80, 0x00, 0x30, 0xC4, 0x00, 0x00,
  0xC6, 0x20, 0x00, 0x03, 0x61, 0x80, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x36, 0x06, 0x00, 0x03, 0x18, 0x1C,
  0x00, 0x70, 0x60, 0x78, 0x0F, 0x01, 0x80, 0xFF, 0xE0, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x55, 0x55, 0x57, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x0C,
  0x07, 0xBE, 0x04, 0x0F, 0x03, 0xE2, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x20, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x11, 0x11, 0x13, 0x33, 0x26, 0x4C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x38, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x06, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0E, 0x40, 0x00, 0x07,
  0xB0, 0x00, 0x03, 0xAC, 0x00, 0x01, 0xCB, 0x00, 0x00, 0xE2, 0xC0, 0x00,
  0x70, 0xF0, 0x00, 0x18, 0x3C, 0x00, 0x0C, 0x0F, 0x00, 0x06, 0x03, 0xC0,
  0x03, 0x00, 0xF0, 0x01, 0x80, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x03,
  0xC0, 0x30, 0x00, 0xF0, 0x18, 0x00, 0x3C, 0x0C, 0x00, 0x0F, 0x06, 0x00,
  0x03, 0xC3, 0x00, 0x00, 0xB1, 0x80, 0x00, 0x2C, 0xC0, 0x00, 0x0B, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x28, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x7A, 0x0F, 0x11,
  0xE0, 0xBC, 0x07, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x38, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x08, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x64, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x02, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x30, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x63, 0xFF, 0x00, 0x6F, 0x03, 0xC0,
  0x78, 0x00, 0x70, 0x70, 0x00, 0x38, 0x20, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x18, 0x00, 0xC1, 0xFF, 0xC0, 0x63, 0xC0, 0x78, 0x23,
  0x80, 0x0E, 0x13, 0x00, 0x01, 0x8B, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x18, 0x00, 0x38, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x0C, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18, 0x03,
  0x80, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x0E, 0x00,
  0x0E, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x06,
  0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x04, 0x60, 0x00, 0x03, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0A,
  0x60, 0x00, 0x0D, 0x30, 0x00, 0x0C, 0x8C, 0x00, 0x0C, 0x43, 0x80, 0x0C,
  0x60, 0xF0, 0x3C, 0x30, 0x1F, 0xF8, 0x18, 0x00, 0x80, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18,
  0x61, 0x86, 0x10, 0x43, 0x0C, 0x21, 0x8C, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x3C, 0x07,
  0x00, 0x18, 0x38, 0x00, 0x30, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00,
  0x02, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x02, 0x06, 0x00, 0xFE, 0x01, 0x86, 0x01, 0xC1, 0x80, 0xC2,
  0x01, 0x80, 0x60, 0x63, 0x00, 0x80, 0x30, 0x11, 0x80, 0xC0, 0x10, 0x08,
  0x80, 0x40, 0x08, 0x06, 0xC0, 0x60, 0x04, 0x03, 0x60, 0x20, 0x02, 0x01,
  0xB0, 0x10, 0x01, 0x00, 0xD0, 0x18, 0x01, 0x80, 0x68, 0x0C, 0x00, 0xC0,
  0x34, 0x06, 0x00, 0x60, 0x1A, 0x02, 0x00, 0x30, 0x0D, 0x01, 0x00, 0x18,
  0x06, 0x80, 0x80, 0x08, 0x02, 0x40, 0x40, 0x04, 0x01, 0x20, 0x20, 0x06,
  0x00, 0x90, 0x10, 0x03, 0x00, 0xC8, 0x08, 0x03, 0x80, 0x64, 0x06, 0x01,
  0x40, 0x23, 0x03, 0x01, 0xB0, 0x31, 0x80, 0x80, 0x98, 0x10, 0xC0, 0x60,
  0xC4, 0x18, 0x30, 0x1F, 0xC3, 0xF8, 0x18, 0x07, 0x80, 0xF8, 0x04, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x60, 0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x10, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0C,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x7C, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x81, 0xE0, 0x01, 0x80, 0x0E, 0x00,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x08, 0x00, 0x1C,
  0x02, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x38, 0x20, 0x00, 0x06, 0x08, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x18, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x18, 0x20, 0x00, 0x0E, 0x08, 0x00, 0x07, 0x02, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x90, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x81,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x06, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x70, 0x20, 0x00, 0x1C, 0x04,
  0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x02, 0x00, 0x0C,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x20,
  0x0C, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80, 0xE0, 0x00, 0x10, 0x38, 0x00,
  0x02, 0x0E, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x08, 0x6C, 0x00, 0x01, 0x19,
  0x80, 0x00, 0x26, 0x18, 0x00, 0x05, 0x81, 0x80, 0x00, 0xE0, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x30, 0x01, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x60, 0x10, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xD0, 0x00, 0x02, 0xF6, 0x00, 0x01, 0xBD,
  0x80, 0x00, 0x4F, 0x30, 0x00, 0x33, 0xCC, 0x00, 0x0C, 0xF1, 0x00, 0x06,
  0x3C, 0x60, 0x01, 0x8F, 0x18, 0x00, 0x43, 0xC2, 0x00, 0x30, 0xF0, 0xC0,
  0x0C, 0x3C, 0x10, 0x06, 0x0F, 0x06, 0x01, 0x83, 0xC1, 0x80, 0x40, 0xF0,
  0x20, 0x30, 0x3C, 0x0C, 0x08, 0x0F, 0x03, 0x06, 0x03, 0xC0, 0x41, 0x80,
  0xF0, 0x18, 0x40, 0x3C, 0x02, 0x30, 0x0F, 0x00, 0xC8, 0x03, 0xC0, 0x36,
  0x00, 0xF0, 0x05, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1D, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x07, 0x20, 0x00, 0x03, 0x98, 0x00, 0x01, 0xC4, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x20, 0x00, 0x1C, 0x18,
  0x00, 0x0E, 0x04, 0x00, 0x07, 0x03, 0x00, 0x03, 0x80, 0x80, 0x01, 0xC0,
  0x60, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x04, 0x00, 0x38, 0x03, 0x00, 0x1C,
  0x00, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x10, 0x03, 0x80, 0x0C, 0x01,
  0xC0, 0x02, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x38, 0x00, 0x10,
  0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x02, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x41, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x02, 0x38, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x4E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0B, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0x81, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x60,
  0x00, 0xE0, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x70,
  0x03, 0x00, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x30, 0x00, 0x1E, 0x18,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC3, 0x00,
  0x07, 0xC1, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x20, 0x00, 0x78, 0x10, 0x00, 0x0E, 0x08, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x40,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x68, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06,
  0x40, 0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00, 0x03, 0x08, 0x00, 0x03,
  0x04, 0x00, 0x07, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x80, 0x02,
  0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0x60, 0x10, 0x00, 0x30, 0x08, 0x00,
  0x0C, 0x04, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x01, 0x88,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x32, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x07, 0x00, 0x07, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x63, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x03, 0x80, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x02,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x01, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x16, 0x00, 0x1C, 0x00, 0x2C, 0x00, 0x38, 0x00, 0x48, 0x00, 0x50,
  0x00, 0x90, 0x01, 0xA0, 0x03, 0x20, 0x03, 0x60, 0x06, 0x60, 0x04, 0xC0,
  0x08, 0xC0, 0x09, 0x80, 0x11, 0x80, 0x11, 0x00, 0x21, 0x00, 0x62, 0x00,
  0x42, 0x00, 0xC6, 0x01, 0x84, 0x01, 0x8C, 0x03, 0x0C, 0x02, 0x18, 0x06,
  0x18, 0x04, 0x10, 0x08, 0x30, 0x18, 0x20, 0x10, 0x20, 0x30, 0x60, 0x20,
  0x40, 0x60, 0xC0, 0xC0, 0x80, 0x81, 0x81, 0x81, 0x81, 0x03, 0x03, 0x03,
  0x06, 0x02, 0x04, 0x06, 0x0C, 0x06, 0x08, 0x04, 0x18, 0x0C, 0x10, 0x08,
  0x20, 0x18, 0x60, 0x10, 0x40, 0x30, 0xC0, 0x31, 0x80, 0x21, 0x80, 0x63,
  0x00, 0x62, 0x00, 0xC6, 0x00, 0xC4, 0x01, 0x88, 0x01, 0x88, 0x01, 0x10,
  0x03, 0x10, 0x02, 0x60, 0x02, 0x60, 0x04, 0xC0, 0x06, 0xC0, 0x0D, 0x80,
  0x0D, 0x00, 0x1A, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x34, 0x00, 0x38, 0x00,
  0x28, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x01,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x30, 0x00, 0x10,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x18, 0x01, 0x80, 0x00, 0x80, 0x04, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xB0, 0x00, 0x0C,
  0x80, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x10, 0x00, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x40, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x02, 0x01, 0x00, 0x18, 0x18, 0x00, 0x40, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x42, 0x00, 0x03, 0x30, 0x00, 0x0B, 0x00, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC1, 0x81,
  0x81, 0x81, 0x03, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x03, 0x81, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x01, 0xFF, 0xFE, 0x07, 0xF0, 0x01, 0x07, 0x00, 0x00, 0x8E,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x26, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01,
  0x90, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xB3, 0x00, 0x01, 0x99, 0xC0, 0x03,
  0x8C, 0x78, 0x07, 0x06, 0x0F, 0xFE, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x3E, 0x00, 0xC1, 0xFF, 0x80, 0xC7, 0x00, 0xE0, 0xCC, 0x00, 0x30, 0xD8,
  0x00, 0x18, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x08, 0xD8,
  0x00, 0x18, 0xCC, 0x00, 0x70, 0xC7, 0x81, 0xE0, 0xC1, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x1C, 0x00,
  0xC0, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x84,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0xE0,
  0x0F, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x3C,
  0x03, 0x01, 0xFF, 0x83, 0x07, 0x80, 0xE3, 0x0E, 0x00, 0x33, 0x1C, 0x00,
  0x1B, 0x18, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x20, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x0C, 0x00,
  0x1F, 0x06, 0x00, 0x3B, 0x03, 0x80, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x08,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x38, 0x07, 0x00, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x04, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x01,
  0xC0, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x83, 0x03, 0x80,
  0xE3, 0x0E, 0x00, 0x33, 0x0C, 0x00, 0x1B, 0x18, 0x00, 0x0F, 0x30, 0x00,
  0x07, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x07, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x0F, 0x06, 0x00, 0x3B, 0x03, 0x80,
  0xE3, 0x01, 0xFF, 0x83, 0x00, 0x08, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x07, 0x80,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x1F, 0x00, 0xC0, 0xFF,
  0xE0, 0xC3, 0xC0, 0x70, 0xC7, 0x00, 0x18, 0xCC, 0x00, 0x0C, 0xD8, 0x00,
  0x04, 0xD0, 0x00, 0x06, 0xF0, 0x00, 0x02, 0xE0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x3F, 0xF8, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0,
  0x03, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x80, 0x00, 0xC7,
  0x80, 0x00, 0xCD, 0x80, 0x00, 0xD8, 0xC0, 0x00, 0xF0, 0x60, 0x00, 0xE0,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x03, 0xC1, 0x8F, 0xF8, 0x3F,
  0xE3, 0x30, 0x38, 0xC0, 0x66, 0xC0, 0x13, 0x00, 0x6F, 0x00, 0x3C, 0x00,
  0x5C, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xE0, 0x00, 0xC0, 0x03,
  0xC0, 0x01, 0x00, 0x07, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x1E,
  0x00, 0x08, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x78, 0x00, 0x20, 0x00, 0xF0,
  0x00, 0x40, 0x01, 0xE0, 0x00, 0x80, 0x03, 0xC0, 0x01, 0x00, 0x07, 0x80,
  0x02, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x3C, 0x00,
  0x10, 0x00, 0x78, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x40, 0x01, 0xE0, 0x00,
  0x80, 0x03, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x04,
  0x00, 0x1E, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x78, 0x00, 0x20,
  0x00, 0xF0, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x80, 0x03, 0x00, 0x1F, 0x00,
  0xC0, 0xFF, 0xE0, 0xC3, 0xC0, 0x70, 0xC7, 0x00, 0x18, 0xCC, 0x00, 0x0C,
  0xD8, 0x00, 0x04, 0xD0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xC1, 0xFF, 0x80, 0xC7, 0x00, 0xE0, 0xCC, 0x00,
  0x70, 0xD8, 0x00, 0x18, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xE0, 0x00, 0x0C, 0xF0, 0x00,
  0x18, 0xD8, 0x00, 0x38, 0xCC, 0x00, 0x70, 0xC7, 0x81, 0xE0, 0xC1, 0xFF,
  0x80, 0xC0, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC3, 0x07, 0x80, 0xE3, 0x0E, 0x00,
  0x33, 0x1C, 0x00, 0x1B, 0x18, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x20, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x0F, 0x06, 0x00, 0x3B, 0x03, 0x80, 0xE3, 0x01, 0xFF,
  0x83, 0x00, 0x08, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x07, 0xEC, 0x07, 0xFF, 0xC1, 0xE0, 0x0C, 0x30, 0x00, 0xCE,
  0x00, 0x0C, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x69, 0x80, 0x01, 0x91, 0x80, 0x06, 0x21, 0xC0, 0x38,
  0x40, 0xFF, 0xC0, 0x80, 0x14, 0x00, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x40, 0x01, 0x80, 0x02, 0x40, 0x01, 0x80, 0x06, 0x60,
  0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x20, 0x02, 0x40, 0x04, 0x20,
  0x02, 0x40, 0x04, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x60, 0x0C, 0x30,
  0x04, 0x60, 0x08, 0x10, 0x04, 0x20, 0x08, 0x18, 0x0C, 0x30, 0x18, 0x18,
  0x0C, 0x30, 0x18, 0x18, 0x08, 0x30, 0x18, 0x08, 0x08, 0x10, 0x10, 0x08,
  0x18, 0x18, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x0C, 0x10, 0x08, 0x30, 0x04,
  0x10, 0x08, 0x20, 0x04, 0x30, 0x0C, 0x20, 0x06, 0x30, 0x0C, 0x60, 0x06,
  0x20, 0x04, 0x60, 0x06, 0x20, 0x04, 0x40, 0x02, 0x60, 0x06, 0x40, 0x02,
  0x40, 0x06, 0xC0, 0x03, 0x40, 0x02, 0xC0, 0x03, 0x40, 0x02, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xC0,
  0x00, 0x30, 0x00, 0x78, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x02, 0x38,
  0xF0, 0x00, 0x04, 0xC0, 0x38, 0x00, 0x1B, 0x00, 0x38, 0x00, 0x36, 0x00,
  0x18, 0x00, 0x48, 0x00, 0x18, 0x01, 0xB0, 0x00, 0x1C, 0x06, 0x60, 0x00,
  0x1E, 0x38, 0xC0, 0x00, 0x0F, 0xE0,
};

const GFXglyph RobotoMono_Thin59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 3, 42, 35, 16, -42 },
  { 17, 9, 12, 35, 13, -44 },
  { 31, 32, 42, 35, 2, -42 },
  { 199, 25, 54, 35, 6, -48 },
  { 368, 33, 44, 35, 1, -43 },
  { 550, 29, 44, 35, 5, -43 },
  { 710, 2, 12, 35, 15, -44 },
  { 713, 12, 61, 35, 12, -47 },
  { 805, 12, 61, 35, 11, -47 },
  { 897, 25, 23, 35, 6, -42 },
  { 969, 29, 31, 35, 3, -35 },
  { 1082, 4, 12, 35, 12, -5 },
  { 1088, 21, 2, 35, 7, -20 },
  { 1094, 3, 3, 35, 17, -3 },
  { 1096, 19, 46, 35, 9, -42 },
  { 1206, 26, 44, 35, 5, -43 },
  { 1349, 13, 42, 35, 7, -42 },
  { 1418, 26, 43, 35, 3, -43 },
  { 1558, 26, 44, 35, 3, -43 },
  { 1701, 29, 42, 35, 3, -42 },
  { 1854, 24, 43, 35, 7, -42 },
  { 1983, 25, 44, 35, 5, -43 },
  { 2121, 27, 42, 35, 4, -42 },
  { 2263, 27, 44, 35, 5, -43 },
  { 2412, 25, 44, 35, 5, -43 },
  { 2550, 3, 28, 35, 19, -28 },
  { 2561, 6, 35, 35, 16, -28 },
  { 2588, 25, 23, 35, 5, -31 },
  { 2660, 26, 13, 35, 5, -26 },
  { 2703, 25, 23, 35, 5, -31 },
  { 2775, 22, 43, 35, 7, -43 },
  { 2894, 33, 42, 35, 1, -42 },
  { 3068, 29, 42, 35, 4, -42 },
  { 3221, 26, 42, 35, 6, -42 },
  { 3358, 27, 44, 35, 4, -43 },
  { 3507, 26, 42, 35, 6, -42 },
  { 3644, 24, 42, 35, 6, -42 },
  { 3770, 23, 42, 35, 7, -42 },
  { 3891, 27, 44, 35, 4, -43 },
  { 4040, 25, 42, 35, 5, -42 },
  { 4172, 23, 42, 35, 6, -42 },
  { 4293, 25, 43, 35, 4, -42 },
  { 4428, 27, 42, 35, 7, -42 },
  { 4570, 24, 42, 35, 7, -42 },
  { 4696, 26, 42, 35, 5, -42 },
  { 4833, 25, 42, 35, 5, -42 },
  { 4965, 27, 44, 35, 4, -43 },
  { 5114, 25, 42, 35, 7, -42 },
  { 5246, 29, 51, 35, 3, -43 },
  { 5431, 25, 42, 35, 7, -42 },
  { 5563, 28, 44, 35, 4, -43 },
  { 5717, 29, 42, 35, 3, -42 },
  { 5870, 25, 43, 35, 5, -42 },
  { 6005, 29, 42, 35, 3, -42 },
  { 6158, 31, 42, 35, 3, -42 },
  { 6321, 29, 42, 35, 4, -42 },
  { 6474, 29, 42, 35, 3, -42 },
  { 6627, 26, 42, 35, 4, -42 },
  { 6764, 8, 57, 35, 14, -48 },
  { 6821, 19, 46, 35, 8, -42 },
  { 6931, 9, 57, 35, 13, -48 },
  { 6996, 21, 23, 35, 7, -42 },
  { 7057, 25, 2, 35, 5, 0 },
  { 7064, 7, 8, 35, 14, -44 },
  { 7071, 25, 33, 35, 5, -32 },
  { 7175, 24, 45, 35, 6, -44 },
  { 7310, 25, 33, 35, 5, -32 },
  { 7414, 24, 45, 35, 5, -44 },
  { 7549, 26, 33, 35, 5, -32 },
  { 7657, 26, 45, 35, 6, -45 },
  { 7804, 24, 45, 35, 5, -32 },
  { 7939, 24, 44, 35, 6, -44 },
  { 8071, 24, 42, 35, 7, -42 },
  { 8197, 18, 55, 35, 5, -42 },
  { 8321, 24, 44, 35, 7, -44 },
  { 8453, 24, 44, 35, 7, -44 },
  { 8585, 31, 32, 35, 2, -32 },
  { 8709, 24, 32, 35, 6, -32 },
  { 8805, 27, 33, 35, 4, -32 },
  { 8917, 24, 44, 35, 6, -32 },
  { 9049, 24, 44, 35, 5, -32 },
  { 9181, 20, 32, 35, 11, -32 },
  { 9261, 24, 33, 35, 6, -32 },
  { 9360, 23, 41, 35, 6, -40 },
  { 9478, 23, 32, 35, 6, -31 },
  { 9570, 29, 31, 35, 3, -31 },
  { 9683, 32, 31, 35, 2, -31 },
  { 9807, 28, 31, 35, 4, -31 },
  { 9916, 31, 44, 35, 2, -31 },
  { 10087, 28, 31, 35, 4, -31 },
  { 10196, 19, 59, 35, 10, -46 },
  { 10337, 2, 50, 35, 17, -42 },
  { 10350, 18, 59, 35, 10, -46 },
  { 10483, 31, 9, 35, 2, -22 },
};

const GFXfont RobotoMono_Thin59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin59pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_THIN59PT7B_H_
