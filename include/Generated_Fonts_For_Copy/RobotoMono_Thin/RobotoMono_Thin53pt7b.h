#ifndef _ROBOTOMONO_THIN53PT7B_H_
#define _ROBOTOMONO_THIN53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin53pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20,
  0x00, 0x00, 0x2F, 0xC0, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x82, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x02, 0x00, 0x01, 0x00, 0x20, 0x00, 0x10, 0x02, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x04, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x20, 0x04, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x40, 0x08, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x08, 0x01, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x10, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x10, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x40, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0xF0,
  0x07, 0x00, 0x30, 0x18, 0x00, 0x30, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x21,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x4C, 0x00, 0x01, 0x88, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x1C,
  0x00, 0x30, 0x0E, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x40, 0x10, 0x02, 0x03, 0x00, 0x40, 0x08, 0x0C, 0x01, 0x00, 0x60,
  0x30, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x08, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x01, 0x01, 0x00, 0x30, 0x04, 0x0C, 0x00, 0x40, 0x10, 0x20, 0x01, 0x80,
  0xC1, 0x80, 0x02, 0x06, 0x04, 0x00, 0x0E, 0x30, 0x30, 0x00, 0x1F, 0x80,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x1F, 0x00, 0x00, 0xC0, 0xEE,
  0x00, 0x02, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x18, 0x00, 0x40, 0x80, 0x20,
  0x03, 0x06, 0x00, 0x80, 0x08, 0x18, 0x02, 0x00, 0x60, 0x60, 0x0C, 0x03,
  0x01, 0x80, 0x30, 0x08, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x03, 0x01, 0x00,
  0x60, 0x08, 0x0C, 0x00, 0x80, 0x20, 0x10, 0x02, 0x01, 0x80, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x10,
  0x06, 0x00, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00,
  0x20, 0x03, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x20, 0x00, 0xC0, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x00, 0xC0, 0x08, 0x80, 0x18, 0x06, 0x60, 0x02, 0x01, 0x90, 0x00,
  0xC0, 0x64, 0x00, 0x18, 0x13, 0x00, 0x03, 0x04, 0xC0, 0x00, 0x63, 0x30,
  0x00, 0x08, 0x8C, 0x00, 0x01, 0x61, 0x00, 0x00, 0x70, 0x40, 0x00, 0x0C,
  0x18, 0x00, 0x07, 0x83, 0x00, 0x03, 0x30, 0x60, 0x01, 0x84, 0x0E, 0x01,
  0x81, 0x80, 0xFF, 0xC0, 0x30, 0x02, 0x00, 0x00, 0xFF, 0xFA, 0xA8, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x40, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x20, 0x0C, 0x03, 0xF8, 0x18, 0x3C, 0x1E, 0x23, 0xC0, 0x07, 0xDC,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x41, 0x80, 0x01, 0x81, 0x80, 0x06, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x80, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x24, 0x92,
  0x4B, 0x5A, 0x00, 0xFF, 0xFF, 0xC0, 0x7D, 0x80, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0x83, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x0E, 0x40, 0x00, 0x1A,
  0x40, 0x00, 0x32, 0x40, 0x00, 0x62, 0xC0, 0x00, 0xC2, 0xC0, 0x01, 0x83,
  0xC0, 0x03, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x30, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0xC0, 0x03, 0xC1, 0x80, 0x02,
  0x43, 0x00, 0x02, 0x46, 0x00, 0x02, 0x4C, 0x00, 0x02, 0x58, 0x00, 0x02,
  0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C,
  0x10, 0x00, 0x08, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x03, 0x81, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x10, 0x07,
  0x01, 0xD0, 0x71, 0x1C, 0x1F, 0x01, 0xC0, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x01, 0xFE, 0x00, 0x0E, 0x0F, 0x00,
  0x30, 0x03, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10,
  0x00, 0x06, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0x07, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x84, 0x00,
  0x01, 0x18, 0x00, 0x03, 0x20, 0x00, 0x06, 0x40, 0x00, 0x05, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x02, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x60, 0xE0, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x10, 0x00, 0x30,
  0x02, 0x00, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x18, 0x00, 0x20, 0x06, 0x00, 0x04, 0x00, 0x80, 0x00, 0x80, 0x30, 0x00,
  0x10, 0x0C, 0x00, 0x02, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x0F, 0x80, 0x09, 0xFF, 0xC0, 0x7C, 0x01, 0x81, 0xC0, 0x03, 0x82,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x90,
  0x00, 0x06, 0x60, 0x00, 0x18, 0x80, 0x00, 0xC3, 0x00, 0x02, 0x06, 0x00,
  0x38, 0x0E, 0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x0F, 0xC0, 0x10, 0x7F, 0xE0, 0x23, 0x80, 0x70, 0xCC, 0x00, 0x31, 0xA0,
  0x00, 0x33, 0x80, 0x00, 0x27, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x58, 0x00,
  0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x98, 0x00, 0x01, 0x30, 0x00, 0x06, 0x30, 0x00, 0x08, 0x20, 0x00, 0x30,
  0x60, 0x00, 0xC0, 0x70, 0x03, 0x00, 0x38, 0x0C, 0x00, 0x3F, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0x83, 0xC0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x20, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x60,
  0x07, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xE7, 0x80, 0x0C, 0x00, 0x60,
  0x38, 0x00, 0x38, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x06,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0E, 0x00, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x08,
  0x00, 0x03, 0x30, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x80, 0x00,
  0x19, 0x00, 0x00, 0x73, 0x00, 0x00, 0xA3, 0x00, 0x02, 0x43, 0x00, 0x18,
  0x83, 0x00, 0x63, 0x03, 0xFF, 0x86, 0x01, 0xF8, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0xDF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xF8, 0x31, 0xCE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84,
  0x21, 0x08, 0x42, 0x31, 0x18, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x70, 0x70, 0x1C, 0x01, 0x83,
  0x00, 0x0C, 0x20, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x18, 0x03, 0xE0, 0x10,
  0x80, 0x71, 0xC0, 0xCC, 0x06, 0x02, 0x06, 0x60, 0x60, 0x10, 0x32, 0x02,
  0x00, 0x80, 0xB0, 0x30, 0x04, 0x05, 0x81, 0x00, 0x60, 0x28, 0x08, 0x03,
  0x01, 0x40, 0xC0, 0x18, 0x0A, 0x06, 0x00, 0x80, 0x50, 0x20, 0x04, 0x03,
  0x81, 0x00, 0x20, 0x1C, 0x08, 0x01, 0x00, 0xE0, 0x40, 0x08, 0x07, 0x02,
  0x00, 0xC0, 0x78, 0x10, 0x06, 0x03, 0x40, 0x80, 0x30, 0x12, 0x04, 0x02,
  0x80, 0x90, 0x30, 0x14, 0x0C, 0x80, 0x81, 0x20, 0x46, 0x06, 0x19, 0x86,
  0x30, 0x1F, 0x87, 0xE0, 0x80, 0x70, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x30, 0x10, 0x00, 0x08, 0x06, 0x00, 0x02, 0x00,
  0x80, 0x01, 0x80, 0x20, 0x00, 0x40, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x80, 0x02, 0x00, 0x60, 0x00, 0x80,
  0x10, 0x00, 0x30, 0x04, 0x00, 0x04, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x20, 0x00, 0x08, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x04, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x10, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x08, 0x00, 0x38, 0x20, 0x00, 0x30,
  0x80, 0x00, 0x62, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80, 0x00,
  0x12, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC2,
  0x00, 0x1C, 0x0F, 0xFF, 0xC0, 0x20, 0x01, 0xE0, 0x80, 0x00, 0xE2, 0x00,
  0x00, 0xC8, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00,
  0x03, 0x20, 0x00, 0x38, 0x80, 0x0F, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xC1, 0xC0, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x18, 0x00,
  0x18, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x30, 0x03, 0x80,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x1F, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x3F, 0xFF, 0xF9, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x20, 0x00,
  0x01, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x68, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01,
  0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x1C, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xD0, 0x00, 0x01, 0x20, 0x00, 0x06, 0x60, 0x00, 0x08, 0x60,
  0x00, 0x30, 0x40, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x70, 0x1C, 0x00, 0x7F,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0x80,
  0x00, 0xC0, 0x80, 0x01, 0x80, 0x80, 0x03, 0x00, 0x80, 0x06, 0x00, 0x80,
  0x0C, 0x00, 0x80, 0x18, 0x00, 0x80, 0x30, 0x00, 0x80, 0x60, 0x00, 0x80,
  0xC0, 0x00, 0x81, 0x80, 0x00, 0x83, 0x00, 0x00, 0x83, 0x00, 0x00, 0x87,
  0x80, 0x00, 0x8C, 0xC0, 0x00, 0x98, 0x40, 0x00, 0xA0, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x04, 0x00, 0x80,
  0x06, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0x40, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3D, 0x00, 0x00, 0xFA, 0x00, 0x01, 0x76, 0x00,
  0x06, 0xE4, 0x00, 0x09, 0xCC, 0x00, 0x13, 0x88, 0x00, 0x67, 0x10, 0x00,
  0x8E, 0x30, 0x03, 0x1C, 0x20, 0x04, 0x38, 0x60, 0x08, 0x70, 0xC0, 0x30,
  0xE0, 0x80, 0x41, 0xC1, 0x81, 0x83, 0x81, 0x02, 0x07, 0x02, 0x04, 0x0E,
  0x06, 0x18, 0x1C, 0x04, 0x20, 0x38, 0x0C, 0xC0, 0x70, 0x09, 0x00, 0xE0,
  0x16, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xA0, 0x00, 0x06,
  0xC0, 0x00, 0x19, 0x00, 0x00, 0x62, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x10,
  0x00, 0x18, 0x60, 0x00, 0x60, 0x80, 0x01, 0x83, 0x00, 0x06, 0x04, 0x00,
  0x18, 0x08, 0x00, 0x60, 0x30, 0x01, 0x80, 0x40, 0x06, 0x01, 0x80, 0x18,
  0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x06, 0x00, 0x20, 0x18, 0x00,
  0xC0, 0x60, 0x01, 0x01, 0x80, 0x06, 0x06, 0x00, 0x08, 0x18, 0x00, 0x30,
  0x60, 0x00, 0x41, 0x80, 0x00, 0x86, 0x00, 0x02, 0x18, 0x00, 0x04, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x26, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x60, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x03, 0xC3,
  0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x08, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x03,
  0x86, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x02, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00,
  0x03, 0x0C, 0x00, 0x3C, 0x1F, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x20, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x09, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x70, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x02, 0x00, 0x0E, 0x04, 0x00, 0x06, 0x08, 0x00, 0x06, 0x10,
  0x00, 0x06, 0x20, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00,
  0x01, 0x20, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x31, 0x00, 0x00,
  0x42, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x20, 0x01, 0x00, 0x40, 0x03, 0x00, 0x80, 0x02, 0x01, 0x00, 0x06, 0x02,
  0x00, 0x06, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x18, 0x40, 0x00, 0x10, 0x80, 0x00, 0x31, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x68, 0x00, 0x00, 0x50, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xC1, 0xE0, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x01, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x02, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x07,
  0x00, 0x70, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xD0, 0x00, 0x02, 0x60, 0x00, 0x18, 0x80, 0x00, 0xC3, 0x00, 0x06,
  0x07, 0x00, 0x38, 0x0E, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x02, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x80, 0x10, 0x00, 0x60, 0x04, 0x00, 0x18, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x00, 0x40, 0x08, 0x00,
  0x10, 0x06, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x20, 0x30,
  0x00, 0x0C, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18,
  0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xA0, 0x07, 0x80, 0x14, 0x00,
  0xF0, 0x02, 0x80, 0x12, 0x00, 0xD8, 0x02, 0x40, 0x1B, 0x00, 0x48, 0x02,
  0x20, 0x09, 0x00, 0x44, 0x03, 0x30, 0x08, 0x80, 0x66, 0x03, 0x18, 0x08,
  0x40, 0x63, 0x01, 0x08, 0x08, 0x60, 0x21, 0x01, 0x04, 0x04, 0x20, 0x20,
  0x80, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x04, 0x08, 0x20, 0x60, 0x81,
  0x04, 0x04, 0x10, 0x20, 0x80, 0x82, 0x04, 0x30, 0x18, 0x40, 0xC6, 0x03,
  0x18, 0x18, 0x80, 0x63, 0x01, 0x10, 0x04, 0x40, 0x22, 0x00, 0x88, 0x04,
  0xC0, 0x19, 0x00, 0x98, 0x03, 0x20, 0x1A, 0x00, 0x6C, 0x03, 0x40, 0x05,
  0x80, 0x68, 0x00, 0xA0, 0x05, 0x00, 0x14, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x0C, 0x18, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0xC0,
  0x18, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x40, 0x04, 0x00, 0x18, 0x03,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x40, 0x40, 0x00, 0x18, 0x30, 0x00, 0x02,
  0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x08, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x10, 0x08, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x30, 0x04, 0x00, 0x04, 0x00,
  0xC0, 0x01, 0x80, 0x08, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x01,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x14, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07,
  0xF8, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x05, 0x80, 0x01, 0x20,
  0x00, 0xCC, 0x00, 0x21, 0x00, 0x18, 0x60, 0x04, 0x18, 0x03, 0x02, 0x00,
  0xC0, 0xC0, 0x20, 0x10, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x20, 0x80,
  0x0C, 0x20, 0x01, 0x18, 0x00, 0x64, 0x00, 0x0B, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0xFF, 0xFF, 0xFC, 0xC1, 0x82, 0x0C, 0x18, 0x20, 0xC0, 0x00, 0x10,
  0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x31,
  0x80, 0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x02, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x3F,
  0xE0, 0x3F, 0xFF, 0x87, 0x80, 0x02, 0x38, 0x00, 0x09, 0x80, 0x00, 0x24,
  0x00, 0x00, 0xB0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00,
  0x01, 0xA0, 0x00, 0x06, 0xC0, 0x00, 0x3D, 0x00, 0x01, 0xB7, 0x00, 0x1C,
  0xCE, 0x01, 0xC3, 0x0F, 0xFC, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x40, 0x08, 0x3F, 0xE0, 0x47, 0x01, 0x82, 0x60, 0x07,
  0x16, 0x00, 0x18, 0xE0, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x00,
  0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x14,
  0x00, 0x01, 0xB0, 0x00, 0x09, 0x80, 0x00, 0xCA, 0x00, 0x0C, 0x4C, 0x00,
  0xC2, 0x38, 0x0C, 0x10, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xFC, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x02, 0x40, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x02, 0x30, 0x00, 0x18, 0x60, 0x00, 0xC0, 0xC0, 0x06, 0x01,
  0xC0, 0x70, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x40, 0x10, 0x3F, 0xE0, 0x87, 0x01, 0xC4, 0x60, 0x03, 0x26,
  0x00, 0x0D, 0x30, 0x00, 0x2B, 0x00, 0x00, 0xD0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00,
  0x00, 0x58, 0x00, 0x06, 0x60, 0x00, 0x73, 0x00, 0x06, 0x8C, 0x00, 0x64,
  0x38, 0x0E, 0x20, 0x7F, 0xC1, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0x80, 0xE0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x04, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x18, 0x03, 0x80, 0x70, 0x00, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x43, 0x80, 0xE2, 0x30, 0x01,
  0x91, 0x00, 0x06, 0x98, 0x00, 0x15, 0x80, 0x00, 0x68, 0x00, 0x03, 0x40,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x05,
  0x00, 0x00, 0x2C, 0x00, 0x03, 0x30, 0x00, 0x38, 0x80, 0x03, 0x46, 0x00,
  0x32, 0x1C, 0x07, 0x10, 0x3F, 0xE0, 0x80, 0x18, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x43, 0x00, 0x06, 0x0C, 0x00, 0xE0, 0x3C, 0x1E, 0x00, 0x7F, 0xC0, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x20, 0x08, 0x1F, 0xF0, 0x43, 0x80, 0xE2,
  0x30, 0x01, 0x93, 0x00, 0x04, 0xB0, 0x00, 0x35, 0x00, 0x00, 0xB0, 0x00,
  0x05, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0xFF, 0x80, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x03, 0x40, 0x00, 0x72, 0x00, 0x06, 0x10, 0x00,
  0x60, 0x80, 0x06, 0x04, 0x00, 0x60, 0x20, 0x06, 0x01, 0x00, 0x60, 0x08,
  0x0E, 0x00, 0x40, 0xC0, 0x02, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0x8E, 0x00,
  0x04, 0xD8, 0x00, 0x28, 0x60, 0x01, 0x81, 0x80, 0x08, 0x06, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x60, 0x10, 0x01, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x30,
  0x20, 0x00, 0xC1, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x80, 0x04, 0x0C, 0xFF, 0x07,
  0xF8, 0xD8, 0x18, 0xC0, 0xCF, 0x00, 0xD8, 0x06, 0xE0, 0x07, 0x00, 0x2E,
  0x00, 0x60, 0x02, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x08, 0x03, 0x03, 0xFE, 0x0C, 0x38, 0x0C, 0x31, 0x80, 0x18, 0xCC,
  0x00, 0x33, 0x60, 0x00, 0x6F, 0x00, 0x01, 0xB8, 0x00, 0x02, 0xE0, 0x00,
  0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x04, 0x1F, 0xF0, 0x23, 0x80, 0xC1, 0x30, 0x03,
  0x0B, 0x00, 0x0C, 0x70, 0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x06, 0x80,
  0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A,
  0x00, 0x00, 0xD8, 0x00, 0x04, 0xC0, 0x00, 0x65, 0x00, 0x06, 0x2E, 0x00,
  0x61, 0x1C, 0x06, 0x08, 0x7F, 0xE0, 0x40, 0x30, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x43, 0x80, 0xE2, 0x38, 0x01, 0x93, 0x00, 0x06,
  0x98, 0x00, 0x1D, 0x80, 0x00, 0x68, 0x00, 0x03, 0x40, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x2C,
  0x00, 0x03, 0x30, 0x00, 0x38, 0x80, 0x03, 0x46, 0x00, 0x32, 0x1C, 0x07,
  0x10, 0x3F, 0xE0, 0x80, 0x18, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x06, 0x20, 0x3F,
  0xFC, 0x38, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x1E, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x50, 0x00, 0x01, 0x60, 0x00, 0x0C, 0x80,
  0x00, 0x63, 0x80, 0x03, 0x83, 0x80, 0x38, 0x03, 0xFF, 0x80, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x34, 0x00, 0x07, 0x60, 0x00, 0xD3, 0x00, 0x19, 0x1C, 0x07, 0x10, 0xFF,
  0xC1, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x04, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x30, 0x02, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x20, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x18, 0x40, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x40, 0x06, 0x00, 0x34, 0x00, 0x70,
  0x02, 0x60, 0x0D, 0x00, 0x26, 0x00, 0x90, 0x02, 0x60, 0x09, 0x00, 0x62,
  0x00, 0x98, 0x06, 0x20, 0x19, 0x80, 0x43, 0x01, 0x08, 0x04, 0x30, 0x10,
  0x80, 0xC1, 0x01, 0x0C, 0x0C, 0x10, 0x30, 0xC0, 0x81, 0x82, 0x04, 0x08,
  0x18, 0x20, 0x41, 0x80, 0x82, 0x06, 0x18, 0x08, 0x60, 0x21, 0x00, 0x84,
  0x02, 0x10, 0x0C, 0x40, 0x21, 0x00, 0xC4, 0x03, 0x30, 0x04, 0xC0, 0x13,
  0x00, 0x48, 0x01, 0x20, 0x06, 0x80, 0x12, 0x00, 0x68, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x60, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0x00, 0x30, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x20, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x03, 0x20, 0x38, 0x00, 0x36, 0x00, 0xC0, 0x02, 0xC0, 0x06,
  0x00, 0x2C, 0x00, 0x38, 0x06, 0x80, 0x01, 0xC0, 0xC8, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x04, 0x00,
};

const GFXglyph RobotoMono_Thin53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 3, 38, 32, 14, -38 },
  { 16, 8, 11, 32, 12, -40 },
  { 27, 28, 38, 32, 2, -38 },
  { 160, 23, 48, 32, 5, -43 },
  { 298, 30, 39, 32, 1, -38 },
  { 445, 26, 39, 32, 4, -38 },
  { 572, 2, 11, 32, 14, -40 },
  { 575, 12, 54, 32, 10, -42 },
  { 656, 12, 54, 32, 9, -42 },
  { 737, 23, 21, 32, 5, -38 },
  { 798, 26, 27, 32, 3, -31 },
  { 886, 3, 11, 32, 11, -4 },
  { 891, 18, 1, 32, 7, -18 },
  { 894, 3, 3, 32, 15, -3 },
  { 896, 17, 41, 32, 8, -38 },
  { 984, 24, 39, 32, 4, -38 },
  { 1101, 12, 38, 32, 6, -38 },
  { 1158, 23, 38, 32, 3, -38 },
  { 1268, 23, 39, 32, 3, -38 },
  { 1381, 27, 38, 32, 2, -38 },
  { 1510, 22, 39, 32, 6, -38 },
  { 1618, 23, 39, 32, 4, -38 },
  { 1731, 24, 38, 32, 4, -38 },
  { 1845, 24, 39, 32, 5, -38 },
  { 1962, 23, 39, 32, 4, -38 },
  { 2075, 3, 26, 32, 17, -26 },
  { 2085, 5, 33, 32, 15, -26 },
  { 2106, 23, 21, 32, 4, -28 },
  { 2167, 23, 12, 32, 5, -23 },
  { 2202, 22, 21, 32, 5, -28 },
  { 2260, 20, 38, 32, 6, -38 },
  { 2355, 29, 38, 32, 1, -38 },
  { 2493, 26, 38, 32, 3, -38 },
  { 2617, 22, 38, 32, 6, -38 },
  { 2722, 24, 39, 32, 4, -38 },
  { 2839, 24, 38, 32, 5, -38 },
  { 2953, 21, 38, 32, 6, -38 },
  { 3053, 21, 38, 32, 6, -38 },
  { 3153, 25, 39, 32, 3, -38 },
  { 3275, 22, 38, 32, 5, -38 },
  { 3380, 21, 38, 32, 5, -38 },
  { 3480, 23, 39, 32, 3, -38 },
  { 3593, 24, 38, 32, 6, -38 },
  { 3707, 22, 38, 32, 6, -38 },
  { 3812, 23, 38, 32, 5, -38 },
  { 3922, 22, 38, 32, 5, -38 },
  { 4027, 24, 39, 32, 4, -38 },
  { 4144, 23, 38, 32, 6, -38 },
  { 4254, 26, 45, 32, 3, -38 },
  { 4401, 23, 38, 32, 6, -38 },
  { 4511, 24, 39, 32, 4, -38 },
  { 4628, 26, 38, 32, 3, -38 },
  { 4752, 22, 39, 32, 5, -38 },
  { 4860, 26, 38, 32, 3, -38 },
  { 4984, 27, 38, 32, 3, -38 },
  { 5113, 26, 38, 32, 3, -38 },
  { 5237, 27, 38, 32, 2, -38 },
  { 5366, 23, 38, 32, 4, -38 },
  { 5476, 8, 51, 32, 12, -43 },
  { 5527, 18, 41, 32, 7, -38 },
  { 5620, 7, 51, 32, 12, -43 },
  { 5665, 18, 21, 32, 7, -38 },
  { 5713, 22, 1, 32, 5, 0 },
  { 5716, 6, 7, 32, 13, -39 },
  { 5722, 22, 30, 32, 5, -29 },
  { 5805, 21, 41, 32, 6, -40 },
  { 5913, 22, 30, 32, 5, -29 },
  { 5996, 21, 41, 32, 5, -40 },
  { 6104, 24, 30, 32, 4, -29 },
  { 6194, 24, 40, 32, 5, -40 },
  { 6314, 21, 40, 32, 5, -29 },
  { 6419, 21, 40, 32, 6, -40 },
  { 6524, 22, 38, 32, 6, -38 },
  { 6629, 16, 49, 32, 5, -38 },
  { 6727, 21, 40, 32, 7, -40 },
  { 6832, 22, 40, 32, 6, -40 },
  { 6942, 28, 29, 32, 2, -29 },
  { 7044, 22, 29, 32, 5, -29 },
  { 7124, 24, 30, 32, 4, -29 },
  { 7214, 21, 40, 32, 6, -29 },
  { 7319, 21, 40, 32, 5, -29 },
  { 7424, 18, 29, 32, 10, -29 },
  { 7490, 22, 30, 32, 5, -29 },
  { 7573, 21, 37, 32, 5, -36 },
  { 7671, 20, 29, 32, 6, -28 },
  { 7744, 26, 28, 32, 3, -28 },
  { 7835, 28, 28, 32, 2, -28 },
  { 7933, 25, 28, 32, 4, -28 },
  { 8021, 28, 39, 32, 2, -28 },
  { 8158, 25, 28, 32, 4, -28 },
  { 8246, 17, 52, 32, 9, -41 },
  { 8357, 2, 45, 32, 15, -38 },
  { 8369, 17, 52, 32, 9, -41 },
  { 8480, 28, 9, 32, 2, -20 },
};

const GFXfont RobotoMono_Thin53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin53pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_THIN53PT7B_H_
