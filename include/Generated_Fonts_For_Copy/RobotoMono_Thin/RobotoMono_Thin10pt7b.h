#ifndef _ROBOTOMONO_THIN10PT7B_H_
#define _ROBOTOMONO_THIN10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xFC, 0x28, 0xA7, 0xCA, 0xF9, 0x45, 0x00, 0x2D, 0x98, 0x61,
  0x9D, 0x20, 0xE2, 0xAF, 0x0A, 0x35, 0x51, 0xC0, 0xE5, 0x29, 0x8A, 0xCB,
  0xE0, 0xE0, 0x6A, 0xAA, 0x90, 0xA5, 0x55, 0x60, 0x2B, 0x69, 0x44, 0xF4,
  0x40, 0xC0, 0xF0, 0x80, 0x12, 0x22, 0x44, 0x48, 0xF9, 0xBD, 0x99, 0xF0,
  0xD5, 0x54, 0xF9, 0x12, 0x48, 0xF0, 0x7C, 0x42, 0x60, 0xC5, 0xE0, 0x11,
  0x4A, 0x9F, 0x84, 0x20, 0xF8, 0xE1, 0x19, 0xF0, 0x68, 0xE9, 0x99, 0xF0,
  0xF1, 0x22, 0x24, 0x40, 0xF9, 0x96, 0x99, 0xF0, 0xF9, 0x99, 0x71, 0x60,
  0x88, 0x8C, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0xF9, 0x12, 0x40, 0x40, 0x7A,
  0x5B, 0x75, 0xD6, 0xA7, 0x80, 0x43, 0x19, 0x2F, 0x4A, 0x20, 0xF9, 0x9E,
  0x99, 0xF0, 0xF9, 0x88, 0x89, 0xF0, 0xF9, 0x99, 0x99, 0xE0, 0xF8, 0x8F,
  0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0xF9, 0x8A, 0x99, 0xF0, 0x99, 0x9F,
  0x99, 0x90, 0xF4, 0x44, 0x44, 0xF0, 0x11, 0x11, 0x19, 0xF0, 0x9D, 0x31,
  0x8A, 0x4A, 0x20, 0x88, 0x88, 0x88, 0xF0, 0x99, 0xBF, 0xD9, 0x90, 0x99,
  0xDB, 0xB9, 0x90, 0xF9, 0x99, 0x99, 0xF0, 0xF9, 0x9F, 0x88, 0x80, 0xF9,
  0x99, 0x99, 0xF1, 0xF9, 0x9D, 0xA9, 0x90, 0xF9, 0x86, 0x19, 0xF0, 0xF2,
  0x22, 0x22, 0x20, 0x99, 0x99, 0x99, 0xF0, 0x99, 0x99, 0x66, 0x40, 0x96,
  0x57, 0x5D, 0x59, 0x24, 0x80, 0x94, 0x98, 0x46, 0x4A, 0x20, 0x8A, 0x54,
  0x42, 0x10, 0x80, 0xF2, 0x24, 0x48, 0xF0, 0xEA, 0xAA, 0xB0, 0x84, 0x44,
  0x22, 0x11, 0xD5, 0x55, 0x70, 0x46, 0x99, 0xF0, 0xC0, 0xF1, 0xF9, 0xF0,
  0x88, 0xE9, 0x99, 0x9F, 0xF8, 0x89, 0xF0, 0x11, 0x79, 0x99, 0x9F, 0xF9,
  0xE8, 0xF0, 0x34, 0xF4, 0x44, 0x44, 0xF9, 0x99, 0xF1, 0xF0, 0x88, 0xE9,
  0x99, 0x99, 0x2C, 0x22, 0x22, 0xF0, 0x38, 0x92, 0x49, 0xE0, 0x88, 0x8B,
  0xCC, 0xA9, 0xC2, 0x22, 0x22, 0x2F, 0xFE, 0x9A, 0x69, 0xA4, 0xF9, 0x99,
  0x90, 0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9, 0x99, 0xF1, 0x10,
  0xF2, 0x48, 0xF8, 0x61, 0xF0, 0x4F, 0x44, 0x44, 0x70, 0x99, 0x99, 0xF0,
  0x99, 0x96, 0x40, 0xA6, 0xD5, 0x96, 0x48, 0x96, 0x25, 0x90, 0x85, 0x24,
  0x8C, 0x20, 0x86, 0x00, 0xF2, 0x48, 0xF0, 0x29, 0x29, 0x12, 0x4C, 0xFF,
  0x89, 0x24, 0xD2, 0x50, 0x66, 0x60,
};

const GFXglyph RobotoMono_Thin10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 7, 6, 2, -7 },
  { 2, 2, 3, 6, 2, -8 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 6, 7, 6, 0, -7 },
  { 20, 5, 7, 6, 1, -7 },
  { 25, 1, 3, 6, 2, -8 },
  { 26, 2, 10, 6, 2, -8 },
  { 29, 2, 10, 6, 2, -8 },
  { 32, 4, 4, 6, 1, -7 },
  { 34, 4, 5, 6, 1, -6 },
  { 37, 1, 2, 6, 2, -1 },
  { 38, 4, 1, 6, 1, -4 },
  { 39, 1, 1, 6, 3, -1 },
  { 40, 4, 8, 6, 1, -7 },
  { 44, 4, 7, 6, 1, -7 },
  { 48, 2, 7, 6, 1, -7 },
  { 50, 4, 7, 6, 1, -7 },
  { 54, 5, 7, 6, 0, -7 },
  { 59, 5, 7, 6, 0, -7 },
  { 64, 4, 7, 6, 1, -7 },
  { 68, 4, 7, 6, 1, -7 },
  { 72, 4, 7, 6, 1, -7 },
  { 76, 4, 7, 6, 1, -7 },
  { 80, 4, 7, 6, 1, -7 },
  { 84, 1, 5, 6, 3, -5 },
  { 85, 1, 6, 6, 3, -5 },
  { 86, 4, 4, 6, 1, -5 },
  { 88, 4, 2, 6, 1, -4 },
  { 89, 4, 4, 6, 1, -5 },
  { 91, 4, 7, 6, 1, -7 },
  { 95, 6, 7, 6, 0, -7 },
  { 101, 5, 7, 6, 1, -7 },
  { 106, 4, 7, 6, 1, -7 },
  { 110, 4, 7, 6, 1, -7 },
  { 114, 4, 7, 6, 1, -7 },
  { 118, 4, 7, 6, 1, -7 },
  { 122, 4, 7, 6, 1, -7 },
  { 126, 4, 7, 6, 1, -7 },
  { 130, 4, 7, 6, 1, -7 },
  { 134, 4, 7, 6, 1, -7 },
  { 138, 4, 7, 6, 1, -7 },
  { 142, 5, 7, 6, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 4, 7, 6, 1, -7 },
  { 155, 4, 7, 6, 1, -7 },
  { 159, 4, 7, 6, 1, -7 },
  { 163, 4, 7, 6, 1, -7 },
  { 167, 4, 8, 6, 1, -7 },
  { 171, 4, 7, 6, 1, -7 },
  { 175, 4, 7, 6, 1, -7 },
  { 179, 4, 7, 6, 1, -7 },
  { 183, 4, 7, 6, 1, -7 },
  { 187, 4, 7, 6, 1, -7 },
  { 191, 6, 7, 6, 0, -7 },
  { 197, 5, 7, 6, 1, -7 },
  { 202, 5, 7, 6, 0, -7 },
  { 207, 4, 7, 6, 1, -7 },
  { 211, 2, 10, 6, 2, -8 },
  { 214, 4, 8, 6, 1, -7 },
  { 218, 2, 10, 6, 2, -8 },
  { 221, 4, 4, 6, 1, -7 },
  { 223, 4, 1, 6, 1, 0 },
  { 224, 2, 1, 6, 2, -7 },
  { 225, 4, 5, 6, 1, -5 },
  { 228, 4, 8, 6, 1, -8 },
  { 232, 4, 5, 6, 1, -5 },
  { 235, 4, 8, 6, 1, -8 },
  { 239, 4, 5, 6, 1, -5 },
  { 242, 4, 8, 6, 1, -8 },
  { 246, 4, 7, 6, 1, -5 },
  { 250, 4, 8, 6, 1, -8 },
  { 254, 4, 7, 6, 1, -7 },
  { 258, 3, 9, 6, 1, -7 },
  { 262, 4, 8, 6, 1, -8 },
  { 266, 4, 8, 6, 1, -8 },
  { 270, 6, 5, 6, 0, -5 },
  { 274, 4, 5, 6, 1, -5 },
  { 277, 4, 5, 6, 1, -5 },
  { 280, 4, 7, 6, 1, -5 },
  { 284, 4, 7, 6, 1, -5 },
  { 288, 3, 5, 6, 2, -5 },
  { 290, 4, 5, 6, 1, -5 },
  { 293, 4, 7, 6, 1, -7 },
  { 297, 4, 5, 6, 1, -5 },
  { 300, 4, 5, 6, 1, -5 },
  { 303, 6, 5, 6, 0, -5 },
  { 307, 4, 5, 6, 1, -5 },
  { 310, 6, 7, 6, 0, -5 },
  { 316, 4, 5, 6, 1, -5 },
  { 319, 3, 10, 6, 2, -8 },
  { 323, 1, 8, 6, 3, -7 },
  { 324, 3, 10, 6, 2, -8 },
  { 328, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_Thin10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin10pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_THIN10PT7B_H_
