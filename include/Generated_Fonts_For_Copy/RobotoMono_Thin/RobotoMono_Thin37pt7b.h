#ifndef _ROBOTOMONO_THIN37PT7B_H_
#define _ROBOTOMONO_THIN37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin37pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0xF0, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x10,
  0x00, 0x81, 0x00, 0x10, 0x10, 0x01, 0x01, 0x07, 0xFF, 0xFF, 0x01, 0x02,
  0x00, 0x10, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20,
  0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0xFF,
  0xFF, 0xE0, 0x40, 0x80, 0x04, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00,
  0x80, 0x80, 0x08, 0x08, 0x00, 0x81, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0xE0, 0x0E, 0x38, 0x18, 0x04, 0x30, 0x02, 0x20, 0x02, 0x20,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x60,
  0x01, 0x30, 0x02, 0x18, 0x0C, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x60, 0x00, 0x43, 0x00, 0x08, 0x10,
  0x00, 0x81, 0x01, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x81,
  0x0C, 0x08, 0x10, 0x80, 0x43, 0x10, 0x03, 0xE1, 0x00, 0x18, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x3C, 0x00, 0x86, 0x60, 0x08, 0x81,
  0x01, 0x08, 0x10, 0x30, 0x81, 0x02, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x80, 0x81, 0x08, 0x08, 0x10, 0x00, 0x42, 0x00, 0x03, 0xC0, 0x01,
  0x80, 0x03, 0x98, 0x01, 0x83, 0x00, 0x40, 0x40, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x40, 0xC0, 0x10, 0x20, 0x04, 0x10, 0x00, 0x88, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x02, 0x80, 0x01, 0x10, 0x00, 0x82, 0x00, 0x40,
  0xC0, 0x90, 0x10, 0x28, 0x02, 0x0A, 0x00, 0x42, 0x80, 0x09, 0x20, 0x03,
  0x48, 0x00, 0x61, 0x00, 0x18, 0x40, 0x0D, 0x0C, 0x06, 0x20, 0xFE, 0x04,
  0xFF, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x06, 0x01, 0x80, 0x80, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x82, 0x08, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x81, 0x02, 0xE1, 0x0F, 0x1D,
  0x70, 0x03, 0x80, 0x02, 0x80, 0x06, 0x40, 0x04, 0x20, 0x08, 0x30, 0x10,
  0x18, 0x20, 0x0C, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x3F,
  0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x55, 0x7A,
  0xFF, 0xF8, 0xF0, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x01, 0xC0, 0x0C,
  0x70, 0x10, 0x08, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x03, 0x80, 0x05, 0x80, 0x09, 0x80, 0x11, 0x80, 0x21, 0x80, 0x41, 0x80,
  0x81, 0x81, 0x01, 0x82, 0x01, 0x84, 0x01, 0x88, 0x01, 0x90, 0x01, 0xA0,
  0x01, 0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x06, 0x30, 0x04, 0x18,
  0x18, 0x07, 0xF0, 0x01, 0x87, 0x4E, 0x38, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x03, 0x80, 0x0C,
  0x70, 0x30, 0x08, 0x60, 0x04, 0x40, 0x04, 0xC0, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x7F, 0xFF, 0x03, 0xC0, 0x0E, 0x70, 0x10, 0x0C, 0x20, 0x04, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x40, 0x02, 0x20, 0x06, 0x10, 0x0C, 0x0F, 0xF0, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08,
  0x80, 0x04, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x40, 0x80, 0x20, 0x20,
  0x08, 0x08, 0x04, 0x02, 0x02, 0x00, 0x80, 0x80, 0x20, 0x40, 0x08, 0x20,
  0x02, 0x0F, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x3F, 0xFE, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x83, 0x01, 0x7B, 0xC3, 0x00, 0xC4, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28,
  0x00, 0x50, 0x01, 0x10, 0x02, 0x10, 0x18, 0x1F, 0xE0, 0x00, 0x18, 0x01,
  0xE0, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x87, 0xF0, 0x98, 0x18, 0xA0, 0x04, 0xC0,
  0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x18,
  0x18, 0x07, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0x1C, 0x04, 0x01, 0x04, 0x00, 0x46, 0x00, 0x32, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00, 0x82, 0x00,
  0xC0, 0xC1, 0x80, 0x1F, 0x00, 0x30, 0x70, 0x60, 0x0C, 0x60, 0x01, 0x20,
  0x00, 0xA0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x05, 0x00, 0x06,
  0x80, 0x02, 0x20, 0x02, 0x0C, 0x02, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x0C,
  0x70, 0x10, 0x08, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40,
  0x03, 0x40, 0x03, 0x20, 0x05, 0x10, 0x19, 0x0E, 0xF1, 0x01, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x1F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x33, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x22, 0x22, 0x44, 0x80, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x71, 0x83,
  0x01, 0x18, 0x02, 0x40, 0x05, 0x00, 0x1C, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x1E,
  0xF0, 0x06, 0x01, 0x80, 0xC0, 0x04, 0x18, 0x00, 0x63, 0x00, 0x02, 0x20,
  0x78, 0x36, 0x08, 0x41, 0x41, 0x04, 0x14, 0x20, 0x41, 0x42, 0x04, 0x18,
  0x20, 0x41, 0x84, 0x04, 0x18, 0x40, 0x41, 0x84, 0x04, 0x18, 0x40, 0x41,
  0x84, 0x0C, 0x18, 0x40, 0xC1, 0x84, 0x14, 0x28, 0x21, 0x42, 0x42, 0x24,
  0x44, 0x1C, 0x38, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x30, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x13, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02,
  0x08, 0x00, 0x41, 0x00, 0x10, 0x30, 0x02, 0x02, 0x00, 0x40, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x10, 0x02, 0x03, 0xFF, 0xE0, 0x40,
  0x04, 0x10, 0x00, 0x82, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x02, 0x40, 0x00, 0x50, 0x00, 0x0C, 0xFF, 0xE0, 0x80, 0x30, 0x80, 0x08,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x08, 0x80, 0x30, 0xFF, 0xE0, 0x80, 0x18, 0x80, 0x04,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x01, 0xC0,
  0x07, 0x18, 0x04, 0x03, 0x04, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x09, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x38, 0x00, 0x12, 0x00, 0x09, 0x00, 0x0C, 0x40,
  0x04, 0x30, 0x04, 0x0C, 0x04, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x80, 0x30,
  0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x06, 0x80, 0x04, 0x80, 0x08, 0x80, 0x10, 0x80, 0x60, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF,
  0x90, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F,
  0xFF, 0x90, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x00, 0xE0, 0x01, 0xCF, 0x00, 0x80, 0x60, 0x40, 0x0C, 0x20,
  0x01, 0x08, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x01, 0xFE, 0x80, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x40, 0x01, 0x18, 0x00, 0x83, 0x00,
  0xC0, 0x3F, 0xC0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40,
  0x02, 0x40, 0x02, 0x20, 0x04, 0x10, 0x08, 0x0F, 0xF0, 0x80, 0x03, 0x40,
  0x03, 0x20, 0x03, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x02, 0x01, 0x01,
  0x01, 0x00, 0x81, 0x00, 0x41, 0x00, 0x21, 0x80, 0x11, 0x80, 0x09, 0xC0,
  0x05, 0x90, 0x03, 0x84, 0x01, 0x81, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20,
  0x08, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x62, 0x00, 0x11, 0x00, 0x04,
  0x80, 0x01, 0x40, 0x00, 0x40, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x03, 0xA0, 0x03,
  0xA0, 0x05, 0x90, 0x05, 0x90, 0x09, 0x90, 0x09, 0x88, 0x09, 0x88, 0x11,
  0x84, 0x11, 0x84, 0x21, 0x84, 0x21, 0x82, 0x21, 0x82, 0x41, 0x82, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x80, 0x81, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xA0, 0x01, 0xA0, 0x01, 0x90, 0x01, 0x90, 0x01, 0x88, 0x01,
  0x84, 0x01, 0x84, 0x01, 0x82, 0x01, 0x82, 0x01, 0x81, 0x01, 0x81, 0x01,
  0x80, 0x81, 0x80, 0x41, 0x80, 0x41, 0x80, 0x21, 0x80, 0x21, 0x80, 0x11,
  0x80, 0x11, 0x80, 0x09, 0x80, 0x05, 0x80, 0x05, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x01, 0x03, 0xC0, 0x07, 0x38, 0x04, 0x02, 0x04, 0x00, 0x86, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x28, 0x00, 0x12, 0x00,
  0x09, 0x00, 0x08, 0x40, 0x04, 0x30, 0x04, 0x0C, 0x0C, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xCE, 0x00, 0x80, 0x60, 0x40,
  0x0C, 0x20, 0x01, 0x08, 0x00, 0x24, 0x00, 0x09, 0x00, 0x01, 0x40, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x05, 0x00,
  0x01, 0x40, 0x00, 0x90, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x10, 0x02,
  0x03, 0x01, 0x00, 0x3F, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0xE0, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x30, 0xFF, 0xC0, 0x80, 0x40,
  0x80, 0x20, 0x80, 0x20, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x01, 0xC0, 0x07, 0x1C,
  0x0C, 0x01, 0x04, 0x00, 0x44, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80,
  0x01, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x80, 0x02, 0x20,
  0x03, 0x0C, 0x03, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40,
  0x02, 0x60, 0x02, 0x20, 0x04, 0x18, 0x18, 0x0F, 0xF0, 0x80, 0x00, 0x70,
  0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x60, 0x00, 0x88, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x04, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x40, 0x30, 0x08,
  0x06, 0x02, 0x80, 0xC0, 0x50, 0x18, 0x0A, 0x04, 0x81, 0x40, 0x90, 0x28,
  0x12, 0x08, 0x82, 0x41, 0x10, 0x48, 0x22, 0x09, 0x04, 0x41, 0x10, 0x88,
  0x42, 0x21, 0x88, 0x44, 0x11, 0x08, 0x82, 0x21, 0x10, 0x44, 0x22, 0x08,
  0x82, 0xC1, 0x20, 0x50, 0x14, 0x0A, 0x02, 0x81, 0x40, 0x50, 0x28, 0x0A,
  0x05, 0x01, 0x40, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x40, 0x00,
  0x44, 0x00, 0x10, 0xC0, 0x04, 0x08, 0x00, 0x80, 0x80, 0x20, 0x10, 0x0C,
  0x01, 0x01, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x22, 0x00, 0x02, 0x80,
  0x00, 0x50, 0x00, 0x04, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x08, 0x80,
  0x02, 0x18, 0x00, 0x41, 0x00, 0x10, 0x10, 0x06, 0x02, 0x00, 0x80, 0x20,
  0x20, 0x02, 0x04, 0x00, 0x41, 0x00, 0x04, 0x40, 0x00, 0xD8, 0x00, 0x0C,
  0x80, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x04,
  0x00, 0x81, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08, 0x01, 0x02, 0x00, 0x41,
  0x00, 0x08, 0x40, 0x02, 0x20, 0x00, 0x48, 0x00, 0x14, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0xFF,
  0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF0, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0xFC, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x06,
  0x00, 0x30, 0x03, 0x40, 0x12, 0x00, 0x98, 0x08, 0x40, 0x42, 0x04, 0x08,
  0x20, 0x41, 0x01, 0x10, 0x08, 0x80, 0x48, 0x01, 0x40, 0x0C, 0xFF, 0xFF,
  0xC4, 0x21, 0x03, 0xE0, 0x1C, 0x18, 0x30, 0x04, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x03, 0xFE, 0x1C, 0x02,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x06,
  0x40, 0x0D, 0x20, 0x19, 0x1F, 0xE1, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x87, 0xC1, 0x30,
  0x62, 0x80, 0x66, 0x00, 0x4C, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x40, 0x02, 0xC0, 0x05, 0x80, 0x12, 0xC0, 0x44, 0x7F, 0x00, 0x03,
  0xE0, 0x0C, 0x18, 0x10, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x01, 0x40, 0x02, 0x20, 0x02, 0x30, 0x04, 0x18,
  0x0C, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x07, 0xC2, 0x10, 0x64, 0xC0, 0x29,
  0x00, 0x34, 0x00, 0x28, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x20, 0x02, 0x40, 0x0C, 0x60, 0x68, 0x7F, 0x10, 0x03, 0xE0, 0x0C, 0x18,
  0x10, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x03, 0x08, 0x04, 0x07, 0xF8,
  0x00, 0x7F, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0xFF, 0xFC, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x07, 0xC2, 0x18, 0x64,
  0x40, 0x29, 0x00, 0x34, 0x00, 0x28, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x20, 0x02, 0x40, 0x0C, 0x60, 0x68, 0x7F, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x60, 0x04, 0x60, 0x10, 0x70, 0xC0, 0x3E,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x83, 0xE1, 0x18, 0x22, 0x40, 0x25, 0x00, 0x2C,
  0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x03, 0x0F, 0xE0, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x05, 0x00, 0x32, 0x00, 0xC4, 0x03, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x80, 0x46, 0x00, 0x98, 0x01, 0x70, 0x03, 0x10, 0x04, 0x10, 0x08,
  0x30, 0x10, 0x30, 0x20, 0x30, 0x40, 0x30, 0x80, 0x21, 0x00, 0x22, 0x00,
  0x24, 0x00, 0x30, 0xFF, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x07, 0xFF, 0xF0, 0x9E, 0x0F, 0x1C, 0x36,
  0x1B, 0x02, 0x81, 0x40, 0x60, 0x28, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x83, 0xE1, 0x18, 0x22,
  0x40, 0x25, 0x00, 0x2C, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x07, 0xE0,
  0x0E, 0x0C, 0x0C, 0x03, 0x0C, 0x00, 0xC4, 0x00, 0x26, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x14, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x06, 0x40, 0x02, 0x10, 0x02,
  0x06, 0x02, 0x01, 0xFE, 0x00, 0x87, 0xC1, 0x30, 0x62, 0x80, 0x66, 0x00,
  0x4C, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0xC0,
  0x0D, 0x80, 0x12, 0xC0, 0xC4, 0x7F, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x07, 0xC2,
  0x38, 0x64, 0xC0, 0x29, 0x00, 0x34, 0x00, 0x28, 0x00, 0x50, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0x20, 0x02, 0x40, 0x0C, 0x60, 0x68, 0x7F, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x81, 0xF8, 0xE0, 0x90, 0x0A, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0xE0, 0x70,
  0x71, 0x80, 0x32, 0x00, 0x38, 0x00, 0x30, 0x00, 0x50, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x09, 0x80, 0x30, 0xFF, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x03, 0xFF, 0xE0, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xFC, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40,
  0x0D, 0x00, 0x32, 0x03, 0x47, 0xF1, 0x80, 0x00, 0x50, 0x00, 0x34, 0x00,
  0x09, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0x41, 0x00, 0x20, 0x40, 0x08,
  0x08, 0x06, 0x02, 0x01, 0x00, 0xC0, 0x40, 0x10, 0x20, 0x04, 0x08, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x68, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x80, 0x20, 0x14, 0x02, 0x01, 0x40, 0x60, 0x14, 0x06,
  0x02, 0x40, 0x50, 0x22, 0x05, 0x02, 0x20, 0x90, 0x22, 0x09, 0x04, 0x20,
  0x88, 0x43, 0x10, 0x84, 0x11, 0x08, 0x41, 0x10, 0x84, 0x11, 0x04, 0x81,
  0x20, 0x48, 0x0A, 0x04, 0x80, 0xA0, 0x28, 0x0A, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x03, 0x00, 0x40, 0x10, 0x80, 0x01, 0xA0, 0x01, 0x88, 0x00, 0x82,
  0x00, 0x81, 0x80, 0x80, 0x40, 0xC0, 0x10, 0xC0, 0x04, 0x40, 0x01, 0x40,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x68, 0x00, 0x22, 0x00, 0x21, 0x80, 0x20,
  0x60, 0x30, 0x10, 0x30, 0x04, 0x10, 0x01, 0x10, 0x00, 0xD0, 0x00, 0x30,
  0x80, 0x00, 0x70, 0x00, 0x0B, 0x00, 0x01, 0x20, 0x00, 0x46, 0x00, 0x08,
  0x40, 0x02, 0x0C, 0x00, 0x40, 0x80, 0x10, 0x10, 0x02, 0x01, 0x00, 0xC0,
  0x20, 0x10, 0x02, 0x06, 0x00, 0x40, 0x80, 0x04, 0x10, 0x00, 0x84, 0x00,
  0x08, 0x80, 0x01, 0x20, 0x00, 0x14, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x10, 0x06, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x06, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x0C, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x12, 0x18, 0x01, 0x40, 0x40, 0x14, 0x02, 0x02, 0x80, 0x18,
  0x48, 0x00, 0x78,
};

const GFXglyph RobotoMono_Thin37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 2, 26, 22, 10, -26 },
  { 8, 6, 8, 22, 8, -28 },
  { 14, 20, 26, 22, 1, -26 },
  { 79, 16, 34, 22, 3, -30 },
  { 147, 20, 27, 22, 1, -27 },
  { 215, 18, 27, 22, 3, -27 },
  { 276, 1, 8, 22, 10, -28 },
  { 277, 8, 37, 22, 7, -29 },
  { 314, 7, 37, 22, 7, -29 },
  { 347, 16, 14, 22, 4, -26 },
  { 375, 18, 19, 22, 2, -22 },
  { 418, 2, 8, 22, 8, -3 },
  { 420, 13, 1, 22, 5, -13 },
  { 422, 2, 2, 22, 11, -2 },
  { 423, 12, 28, 22, 6, -26 },
  { 465, 16, 27, 22, 3, -27 },
  { 519, 9, 26, 22, 4, -26 },
  { 549, 16, 27, 22, 2, -27 },
  { 603, 16, 27, 22, 2, -27 },
  { 657, 18, 26, 22, 2, -26 },
  { 716, 15, 26, 22, 4, -26 },
  { 765, 16, 27, 22, 3, -27 },
  { 819, 17, 26, 22, 2, -26 },
  { 875, 17, 27, 22, 3, -27 },
  { 933, 16, 27, 22, 3, -27 },
  { 987, 2, 18, 22, 12, -18 },
  { 992, 4, 23, 22, 10, -18 },
  { 1004, 16, 14, 22, 3, -19 },
  { 1032, 16, 8, 22, 3, -16 },
  { 1048, 16, 14, 22, 3, -19 },
  { 1076, 14, 27, 22, 4, -27 },
  { 1124, 20, 27, 22, 1, -27 },
  { 1192, 19, 26, 22, 2, -26 },
  { 1254, 16, 26, 22, 4, -26 },
  { 1306, 17, 27, 22, 3, -27 },
  { 1364, 16, 26, 22, 4, -26 },
  { 1416, 15, 26, 22, 4, -26 },
  { 1465, 15, 26, 22, 4, -26 },
  { 1514, 18, 27, 22, 2, -27 },
  { 1575, 16, 26, 22, 3, -26 },
  { 1627, 14, 26, 22, 4, -26 },
  { 1673, 16, 26, 22, 2, -26 },
  { 1725, 17, 26, 22, 4, -26 },
  { 1781, 15, 26, 22, 4, -26 },
  { 1830, 16, 26, 22, 3, -26 },
  { 1882, 16, 26, 22, 3, -26 },
  { 1934, 17, 27, 22, 3, -27 },
  { 1992, 16, 26, 22, 4, -26 },
  { 2044, 18, 32, 22, 2, -27 },
  { 2116, 16, 26, 22, 4, -26 },
  { 2168, 17, 27, 22, 3, -27 },
  { 2226, 18, 26, 22, 2, -26 },
  { 2285, 16, 26, 22, 3, -26 },
  { 2337, 18, 26, 22, 2, -26 },
  { 2396, 19, 26, 22, 2, -26 },
  { 2458, 19, 26, 22, 2, -26 },
  { 2520, 18, 26, 22, 2, -26 },
  { 2579, 16, 26, 22, 3, -26 },
  { 2631, 5, 36, 22, 9, -30 },
  { 2654, 12, 28, 22, 5, -26 },
  { 2696, 6, 36, 22, 8, -30 },
  { 2723, 13, 14, 22, 5, -26 },
  { 2746, 16, 1, 22, 3, 0 },
  { 2748, 4, 4, 22, 9, -27 },
  { 2750, 16, 20, 22, 3, -20 },
  { 2790, 15, 28, 22, 4, -28 },
  { 2843, 16, 20, 22, 3, -20 },
  { 2883, 15, 28, 22, 3, -28 },
  { 2936, 16, 20, 22, 3, -20 },
  { 2976, 16, 28, 22, 4, -28 },
  { 3032, 15, 28, 22, 3, -20 },
  { 3085, 15, 28, 22, 4, -28 },
  { 3138, 15, 26, 22, 4, -26 },
  { 3187, 12, 34, 22, 3, -26 },
  { 3238, 15, 28, 22, 5, -28 },
  { 3291, 15, 28, 22, 4, -28 },
  { 3344, 19, 20, 22, 2, -20 },
  { 3392, 15, 20, 22, 4, -20 },
  { 3430, 17, 20, 22, 3, -20 },
  { 3473, 15, 28, 22, 4, -20 },
  { 3526, 15, 28, 22, 3, -20 },
  { 3579, 12, 20, 22, 7, -20 },
  { 3609, 15, 20, 22, 4, -20 },
  { 3647, 14, 25, 22, 4, -25 },
  { 3691, 14, 20, 22, 4, -20 },
  { 3726, 18, 20, 22, 2, -20 },
  { 3771, 20, 20, 22, 1, -20 },
  { 3821, 17, 20, 22, 3, -20 },
  { 3864, 19, 28, 22, 2, -20 },
  { 3931, 18, 20, 22, 2, -20 },
  { 3976, 12, 37, 22, 6, -29 },
  { 4032, 1, 31, 22, 11, -26 },
  { 4036, 12, 37, 22, 6, -29 },
  { 4092, 20, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_Thin37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin37pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_THIN37PT7B_H_
