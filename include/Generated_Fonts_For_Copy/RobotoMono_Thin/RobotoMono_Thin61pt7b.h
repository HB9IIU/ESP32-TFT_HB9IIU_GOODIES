#ifndef _ROBOTOMONO_THIN61PT7B_H_
#define _ROBOTOMONO_THIN61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin61pt7bBitmaps[] PROGMEM = {
  0x00, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x40, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xE0, 0x40,
  0xD0, 0x34, 0x0D, 0x03, 0x40, 0xD0, 0x34, 0x0D, 0x03, 0x40, 0xF0, 0x3C,
  0x0B, 0x02, 0xC0, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x40, 0x06,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0x00, 0x18, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x60, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x03, 0x01, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x38,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x10, 0x04, 0x00, 0x40, 0x06, 0x03, 0x00, 0x10,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x10,
  0x01, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x30, 0x30, 0x00,
  0x30, 0x18, 0x08, 0x00, 0x0C, 0x0E, 0x06, 0x00, 0x01, 0xEF, 0x03, 0x00,
  0x00, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x30, 0x38, 0x70, 0x00,
  0x18, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x01, 0x80, 0x03, 0x01, 0x00, 0x20,
  0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x10, 0x02, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x30,
  0x01, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x0C, 0x02, 0x00, 0x10, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x70, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x43, 0x00, 0x30, 0x01, 0x08, 0x00, 0xC0,
  0x04, 0x60, 0x01, 0x80, 0x31, 0x00, 0x03, 0x00, 0xCC, 0x00, 0x06, 0x03,
  0x30, 0x00, 0x0C, 0x0C, 0xC0, 0x00, 0x18, 0x63, 0x00, 0x00, 0x61, 0x8C,
  0x00, 0x00, 0xCC, 0x30, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x03, 0x81, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xB0, 0x38, 0x00,
  0x0C, 0x60, 0x70, 0x00, 0xE0, 0xC0, 0x78, 0x0E, 0x01, 0x80, 0xFF, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x04, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x02, 0x00, 0x10, 0x03, 0xF0, 0x04, 0x03,
  0xCF, 0x81, 0x07, 0xC0, 0x7C, 0x4F, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x42, 0x31,
  0x99, 0x84, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xE4, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x0C, 0xB0, 0x00, 0x03, 0x16,
  0x00, 0x00, 0xC2, 0xC0, 0x00, 0x30, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xB3, 0x80, 0x00, 0x12, 0xE0, 0x00, 0x02, 0x78, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1E, 0x41, 0xE1,
  0x1E, 0x05, 0xC0, 0x1C, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0xF0,
  0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x04, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x01, 0xC0,
  0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x60, 0x01,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x40,
  0x03, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x60, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0xFF, 0x8C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x21, 0xFF, 0x80, 0x13, 0xE1, 0xF0,
  0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x38,
  0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x40, 0xFF, 0xE0, 0x30, 0xF0, 0x3C, 0x0C, 0x60, 0x01, 0xC3,
  0x70, 0x00, 0x38, 0x90, 0x00, 0x06, 0x2C, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01,
  0xC0, 0x06, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x10, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x38, 0x07, 0x80, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x0D, 0x30, 0x00, 0x02, 0x46, 0x00, 0x03, 0x90, 0xC0,
  0x01, 0xCC, 0x1C, 0x01, 0xC3, 0x01, 0xFF, 0xE0, 0xC0, 0x1F, 0xC0, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x60, 0x1C, 0xF1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x41,
  0x04, 0x10, 0x43, 0x0C, 0x31, 0x86, 0x30, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x38,
  0x03, 0x80, 0xE0, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x18, 0x00,
  0x03, 0x30, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x1E, 0x00, 0x60, 0xC0, 0x1F, 0xE0, 0x18, 0x60,
  0x0C, 0x1C, 0x06, 0x18, 0x06, 0x01, 0x80, 0x8C, 0x03, 0x00, 0x40, 0x23,
  0x01, 0x80, 0x10, 0x0C, 0xC0, 0x60, 0x04, 0x03, 0x20, 0x10, 0x01, 0x00,
  0xD8, 0x0C, 0x00, 0xC0, 0x36, 0x03, 0x00, 0x30, 0x0D, 0x80, 0x80, 0x0C,
  0x03, 0x40, 0x60, 0x03, 0x00, 0xD0, 0x18, 0x00, 0xC0, 0x34, 0x06, 0x00,
  0x20, 0x0D, 0x01, 0x80, 0x08, 0x03, 0x40, 0x60, 0x02, 0x00, 0xD0, 0x18,
  0x01, 0x80, 0x24, 0x06, 0x00, 0x60, 0x09, 0x01, 0x80, 0x18, 0x02, 0x40,
  0x60, 0x0E, 0x01, 0x98, 0x18, 0x03, 0x80, 0x66, 0x02, 0x01, 0xA0, 0x11,
  0x80, 0xC0, 0x48, 0x0C, 0x60, 0x30, 0x33, 0x06, 0x08, 0x06, 0x18, 0x63,
  0x83, 0x00, 0xFC, 0x1F, 0xC0, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0xC0, 0x02, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x20, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x7C, 0x03, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02,
  0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x3C, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x08, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x07,
  0x00, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xF8, 0x03,
  0x00, 0x03, 0xC0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x30, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3C,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0xE8, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C,
  0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x08, 0x00, 0x06, 0x00, 0x80,
  0x00, 0xE0, 0x08, 0x00, 0x1C, 0x00, 0x80, 0x03, 0x80, 0x08, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x08, 0x38, 0x00, 0x00, 0x86, 0xC0, 0x00, 0x08, 0xC6, 0x00, 0x00,
  0x98, 0x30, 0x00, 0x0B, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x80, 0x03, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x30, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x80, 0x00, 0x0F, 0xB0, 0x00, 0x06, 0xEC, 0x00, 0x01,
  0xB9, 0x80, 0x00, 0x4E, 0x60, 0x00, 0x33, 0x88, 0x00, 0x08, 0xE3, 0x00,
  0x06, 0x38, 0xC0, 0x01, 0x8E, 0x10, 0x00, 0xC3, 0x86, 0x00, 0x30, 0xE0,
  0x80, 0x08, 0x38, 0x30, 0x06, 0x0E, 0x0C, 0x01, 0x83, 0x81, 0x00, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x18, 0x08, 0x0E, 0x02, 0x06, 0x03, 0x80, 0xC1,
  0x80, 0xE0, 0x10, 0xC0, 0x38, 0x06, 0x30, 0x0E, 0x01, 0x88, 0x03, 0x80,
  0x26, 0x00, 0xE0, 0x0D, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x72, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07,
  0x10, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x70, 0x80, 0x00, 0x1C, 0x30, 0x00,
  0x07, 0x06, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x04,
  0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x20, 0x00, 0x70, 0x0C, 0x00, 0x1C,
  0x01, 0x80, 0x07, 0x00, 0x20, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x01, 0x00,
  0x1C, 0x00, 0x60, 0x07, 0x00, 0x08, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00,
  0x60, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x40, 0x70,
  0x00, 0x18, 0x1C, 0x00, 0x02, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x10,
  0x70, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x11, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x05, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x07, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0xF0, 0x08, 0x00,
  0x07, 0x02, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18,
  0x20, 0x00, 0x0C, 0x08, 0x00, 0x1E, 0x03, 0xFF, 0xFE, 0x00, 0x80, 0x03,
  0x00, 0x20, 0x00, 0x40, 0x08, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x80,
  0x00, 0xC0, 0x20, 0x00, 0x18, 0x08, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x60, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x1C,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x06, 0x00, 0x18, 0x00, 0x08, 0x00, 0x60, 0x00, 0x30, 0x01,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0x80, 0x02, 0x40, 0x03, 0xC0, 0x02, 0x40, 0x03, 0xC0,
  0x02, 0x60, 0x02, 0xC0, 0x06, 0x60, 0x02, 0x40, 0x06, 0x60, 0x06, 0x40,
  0x06, 0x60, 0x06, 0x60, 0x04, 0x20, 0x06, 0x60, 0x04, 0x20, 0x04, 0x60,
  0x04, 0x20, 0x04, 0x20, 0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x08, 0x10, 0x08, 0x30, 0x08, 0x10, 0x08, 0x10,
  0x08, 0x10, 0x18, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x30, 0x08,
  0x10, 0x08, 0x30, 0x0C, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x20, 0x04, 0x30, 0x0C, 0x60, 0x04, 0x20, 0x04, 0x60, 0x06,
  0x20, 0x04, 0x60, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x40, 0x06,
  0x60, 0x06, 0xC0, 0x02, 0x60, 0x06, 0xC0, 0x03, 0x40, 0x02, 0xC0, 0x03,
  0x40, 0x02, 0xC0, 0x03, 0x40, 0x02, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x40, 0x03,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x18, 0x00, 0x40, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x18, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x01, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x3F, 0xE0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x34, 0x00, 0x01, 0xB0, 0x00, 0x09, 0x80,
  0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x60, 0x80, 0x03, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x80, 0xC0, 0x08, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x60, 0x06, 0x03, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x02, 0x08, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x20, 0x00, 0x1B, 0x00, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x81,
  0x03, 0x03, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x38, 0x03, 0xC0,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xE0, 0x00,
  0x21, 0xC0, 0x00, 0x08, 0xE0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x09, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0A, 0x60, 0x00, 0x06,
  0xCC, 0x00, 0x07, 0x31, 0x80, 0x03, 0x8C, 0x38, 0x07, 0x83, 0x03, 0xFF,
  0x80, 0xC0, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x7E, 0x00, 0x83,
  0xFF, 0x80, 0x87, 0x00, 0xE0, 0x9C, 0x00, 0x70, 0x98, 0x00, 0x18, 0xB0,
  0x00, 0x18, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x18, 0xB0,
  0x00, 0x38, 0x9C, 0x00, 0x70, 0x87, 0x01, 0xC0, 0x83, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x03, 0x80,
  0x1C, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x07, 0x01, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0xF0,
  0x0C, 0x07, 0xFF, 0x06, 0x07, 0x00, 0xE3, 0x06, 0x00, 0x19, 0x86, 0x00,
  0x06, 0xC6, 0x00, 0x01, 0xE2, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x8C, 0x00, 0x03, 0xC3, 0x00, 0x03, 0x60, 0xE0, 0x03, 0x30, 0x3C,
  0x0F, 0x18, 0x07, 0xFE, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x00,
  0x60, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x04, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0xC0, 0xE0, 0x1C,
  0x60, 0xC0, 0x03, 0x30, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x3C, 0x40, 0x00,
  0x0E, 0x60, 0x00, 0x07, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x78, 0x60, 0x00,
  0x6C, 0x1C, 0x00, 0x66, 0x07, 0x81, 0xE3, 0x00, 0xFF, 0xC1, 0x80, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xFC, 0x03, 0x03,
  0xFF, 0xC1, 0x83, 0x80, 0x70, 0xC3, 0x00, 0x0C, 0x63, 0x00, 0x03, 0x33,
  0x00, 0x00, 0x9B, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0B,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x00, 0xC0, 0x80, 0x03,
  0x80, 0x80, 0x07, 0x00, 0x80, 0x0E, 0x00, 0x80, 0x18, 0x00, 0x80, 0x30,
  0x00, 0x80, 0x60, 0x00, 0x81, 0xC0, 0x00, 0x83, 0x80, 0x00, 0x87, 0x00,
  0x00, 0x8F, 0x80, 0x00, 0x99, 0x80, 0x00, 0xB0, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x06,
  0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x80, 0x80, 0x01, 0xC0, 0x80, 0x00,
  0xC0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x03, 0xC1, 0x1F,
  0xF0, 0x3F, 0xE2, 0x60, 0x30, 0xC0, 0x65, 0x80, 0x33, 0x00, 0x6E, 0x00,
  0x2C, 0x00, 0x58, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x1F, 0x80, 0x60, 0x7F, 0xF8, 0x30, 0x70, 0x0E,
  0x18, 0xE0, 0x01, 0x8C, 0xE0, 0x00, 0x66, 0x60, 0x00, 0x33, 0x60, 0x00,
  0x0D, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x01, 0x70, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x1C, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x83, 0xFF, 0x80, 0x8F, 0x01, 0xE0, 0x9C, 0x00, 0x70, 0xB0, 0x00,
  0x38, 0xA0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xE0, 0x00,
  0x18, 0xB0, 0x00, 0x30, 0x9C, 0x00, 0x70, 0x8F, 0x01, 0xC0, 0x83, 0xFF,
  0x80, 0x80, 0x10, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0xC0, 0xE0, 0x1C, 0x60, 0xC0,
  0x03, 0x30, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x3C, 0x40, 0x00, 0x0E, 0x60,
  0x00, 0x07, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x78, 0x60, 0x00, 0x6C, 0x1C,
  0x00, 0x66, 0x07, 0x81, 0xE3, 0x00, 0xFF, 0xC1, 0x80, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x0F,
  0xE8, 0x07, 0xFF, 0x81, 0xC0, 0x08, 0x70, 0x00, 0x8C, 0x00, 0x09, 0x80,
  0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x01, 0xC3, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0x70, 0x00, 0x38, 0x1F, 0x00,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3C, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x07, 0x30,
  0x00, 0x0D, 0x18, 0x00, 0x19, 0x1C, 0x00, 0x31, 0x07, 0x01, 0xE1, 0x03,
  0xFF, 0x81, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x60, 0x03, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0xA0, 0x00, 0xE0,
  0x00, 0x98, 0x00, 0x70, 0x00, 0xCC, 0x00, 0x28, 0x00, 0x66, 0x00, 0x14,
  0x00, 0x31, 0x00, 0x1B, 0x00, 0x10, 0xC0, 0x0D, 0x80, 0x08, 0x60, 0x04,
  0x40, 0x0C, 0x30, 0x02, 0x30, 0x06, 0x08, 0x03, 0x18, 0x03, 0x04, 0x01,
  0x8C, 0x01, 0x03, 0x00, 0x82, 0x01, 0x81, 0x80, 0x41, 0x80, 0xC0, 0xC0,
  0x60, 0xC0, 0x60, 0x20, 0x30, 0x60, 0x20, 0x18, 0x10, 0x10, 0x10, 0x0C,
  0x08, 0x0C, 0x18, 0x06, 0x0C, 0x06, 0x0C, 0x01, 0x06, 0x03, 0x06, 0x00,
  0xC2, 0x00, 0x82, 0x00, 0x61, 0x00, 0x63, 0x00, 0x31, 0x80, 0x31, 0x80,
  0x08, 0xC0, 0x18, 0xC0, 0x04, 0x40, 0x04, 0x40, 0x03, 0x20, 0x03, 0x20,
  0x01, 0xB0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x28, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x01,
  0x80, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0x38, 0x0E, 0x00, 0x01, 0x30, 0x07, 0x00, 0x03, 0x60, 0x01,
  0x80, 0x03, 0x40, 0x00, 0xC0, 0x06, 0xC0, 0x00, 0x70, 0x06, 0xC0, 0x00,
  0x38, 0x1C, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_Thin61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 4, 43, 37, 16, -43 },
  { 23, 10, 13, 37, 13, -46 },
  { 40, 33, 43, 37, 2, -43 },
  { 218, 26, 56, 37, 6, -50 },
  { 400, 34, 45, 37, 1, -44 },
  { 592, 30, 45, 37, 5, -44 },
  { 761, 2, 13, 37, 16, -46 },
  { 765, 13, 62, 37, 12, -48 },
  { 866, 13, 62, 37, 11, -48 },
  { 967, 26, 23, 37, 6, -43 },
  { 1042, 29, 32, 37, 4, -36 },
  { 1158, 5, 13, 37, 12, -5 },
  { 1167, 21, 2, 37, 8, -21 },
  { 1173, 3, 3, 37, 18, -3 },
  { 1175, 20, 47, 37, 9, -43 },
  { 1293, 27, 45, 37, 5, -44 },
  { 1445, 14, 43, 37, 7, -43 },
  { 1521, 27, 44, 37, 3, -44 },
  { 1670, 27, 45, 37, 3, -44 },
  { 1822, 30, 43, 37, 3, -43 },
  { 1984, 25, 44, 37, 7, -43 },
  { 2122, 26, 45, 37, 5, -44 },
  { 2269, 28, 43, 37, 4, -43 },
  { 2420, 28, 45, 37, 5, -44 },
  { 2578, 26, 45, 37, 5, -44 },
  { 2725, 4, 29, 37, 19, -29 },
  { 2740, 6, 37, 37, 17, -29 },
  { 2768, 26, 24, 37, 5, -32 },
  { 2846, 27, 14, 37, 5, -27 },
  { 2894, 25, 24, 37, 6, -32 },
  { 2969, 23, 44, 37, 7, -44 },
  { 3096, 34, 44, 37, 1, -44 },
  { 3283, 30, 43, 37, 4, -43 },
  { 3445, 27, 43, 37, 6, -43 },
  { 3591, 28, 45, 37, 4, -44 },
  { 3749, 27, 43, 37, 6, -43 },
  { 3895, 24, 43, 37, 7, -43 },
  { 4024, 24, 43, 37, 7, -43 },
  { 4153, 28, 45, 37, 4, -44 },
  { 4311, 26, 43, 37, 5, -43 },
  { 4451, 24, 43, 37, 6, -43 },
  { 4580, 26, 44, 37, 4, -43 },
  { 4723, 28, 43, 37, 7, -43 },
  { 4874, 25, 43, 37, 7, -43 },
  { 5009, 26, 43, 37, 6, -43 },
  { 5149, 26, 43, 37, 5, -43 },
  { 5289, 28, 45, 37, 4, -44 },
  { 5447, 26, 43, 37, 7, -43 },
  { 5587, 29, 52, 37, 4, -44 },
  { 5776, 26, 43, 37, 7, -43 },
  { 5916, 28, 45, 37, 5, -44 },
  { 6074, 30, 43, 37, 3, -43 },
  { 6236, 26, 44, 37, 5, -43 },
  { 6379, 30, 43, 37, 3, -43 },
  { 6541, 32, 43, 37, 3, -43 },
  { 6713, 30, 43, 37, 4, -43 },
  { 6875, 30, 43, 37, 3, -43 },
  { 7037, 27, 43, 37, 4, -43 },
  { 7183, 9, 59, 37, 14, -50 },
  { 7250, 20, 47, 37, 8, -43 },
  { 7368, 8, 59, 37, 14, -50 },
  { 7427, 21, 23, 37, 8, -43 },
  { 7488, 25, 2, 37, 6, 0 },
  { 7495, 7, 8, 37, 15, -45 },
  { 7502, 26, 34, 37, 5, -33 },
  { 7613, 24, 47, 37, 7, -46 },
  { 7754, 26, 34, 37, 5, -33 },
  { 7865, 25, 47, 37, 5, -46 },
  { 8012, 27, 34, 37, 5, -33 },
  { 8127, 27, 46, 37, 6, -46 },
  { 8283, 25, 46, 37, 5, -33 },
  { 8427, 25, 46, 37, 6, -46 },
  { 8571, 25, 44, 37, 7, -44 },
  { 8709, 19, 57, 37, 5, -44 },
  { 8845, 24, 46, 37, 8, -46 },
  { 8983, 25, 46, 37, 7, -46 },
  { 9127, 31, 33, 37, 3, -33 },
  { 9255, 25, 33, 37, 6, -33 },
  { 9359, 28, 34, 37, 4, -33 },
  { 9478, 24, 45, 37, 7, -33 },
  { 9613, 25, 45, 37, 5, -33 },
  { 9754, 20, 33, 37, 12, -33 },
  { 9837, 25, 34, 37, 6, -33 },
  { 9944, 24, 42, 37, 6, -41 },
  { 10070, 24, 33, 37, 6, -32 },
  { 10169, 30, 32, 37, 3, -32 },
  { 10289, 33, 32, 37, 2, -32 },
  { 10421, 29, 32, 37, 4, -32 },
  { 10537, 32, 45, 37, 2, -32 },
  { 10717, 29, 32, 37, 4, -32 },
  { 10833, 19, 61, 37, 10, -48 },
  { 10978, 1, 51, 37, 18, -43 },
  { 10985, 19, 61, 37, 10, -48 },
  { 11130, 32, 10, 37, 2, -23 },
};

const GFXfont RobotoMono_Thin61pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin61pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin61pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOMONO_THIN61PT7B_H_
