#ifndef _ROBOTOMONO_THIN24PT7B_H_
#define _ROBOTOMONO_THIN24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin24pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x00, 0xC0, 0x99, 0x99, 0x90, 0x04, 0x20, 0x21,
  0x02, 0x10, 0x10, 0x80, 0x84, 0x3F, 0xFC, 0x21, 0x01, 0x10, 0x10, 0x80,
  0x84, 0x04, 0x21, 0xFF, 0xE1, 0x08, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21,
  0x00, 0x04, 0x00, 0x80, 0x6E, 0x10, 0x24, 0x04, 0x80, 0x90, 0x0A, 0x00,
  0x20, 0x02, 0x00, 0x38, 0x00, 0xC0, 0x04, 0x00, 0xA0, 0x0C, 0x01, 0x40,
  0x48, 0x08, 0xEE, 0x02, 0x00, 0x40, 0x70, 0x04, 0x40, 0x22, 0x11, 0x11,
  0x08, 0x88, 0x44, 0x82, 0x44, 0x0C, 0x40, 0x02, 0x00, 0x23, 0x01, 0x24,
  0x12, 0x11, 0x10, 0x88, 0x84, 0x84, 0x20, 0x21, 0x00, 0xF0, 0x1E, 0x02,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x02, 0x20, 0x2C, 0x01, 0x00, 0x28, 0x04,
  0x40, 0x82, 0x28, 0x22, 0x81, 0x28, 0x0C, 0x80, 0x44, 0x0A, 0x3F, 0x30,
  0xF8, 0x08, 0x88, 0x84, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x20, 0x84, 0x10, 0x82, 0x08, 0x82, 0x08, 0x21, 0x08, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x10, 0x88, 0x80, 0x04, 0x00, 0x80,
  0x10, 0x72, 0x71, 0xF0, 0x08, 0x02, 0x80, 0x88, 0x20, 0x80, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x56, 0x80, 0xFF, 0x80, 0x02, 0x04, 0x08, 0x20,
  0x41, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x00,
  0x3F, 0x10, 0x24, 0x06, 0x01, 0x80, 0x60, 0x38, 0x16, 0x09, 0x84, 0x62,
  0x19, 0x06, 0x81, 0xC0, 0x60, 0x14, 0x04, 0x82, 0x1F, 0x00, 0x1B, 0x62,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x3F, 0x08, 0x11,
  0x01, 0x40, 0x28, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x7F, 0xE0, 0x1F, 0x84, 0x09,
  0x01, 0x40, 0x20, 0x02, 0x00, 0x80, 0x10, 0x0C, 0x0F, 0x00, 0x18, 0x01,
  0x00, 0x18, 0x03, 0x00, 0x50, 0x13, 0x02, 0x1F, 0x80, 0x00, 0x80, 0x18,
  0x02, 0x80, 0x28, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08, 0x20, 0x82, 0x08,
  0x40, 0x88, 0x08, 0x7F, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F,
  0x90, 0x04, 0x01, 0x00, 0x80, 0x20, 0x0B, 0xE3, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x60, 0x18, 0x09, 0x02, 0x3F, 0x00, 0x0F, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x0B, 0xF3, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x05, 0x02, 0x3F, 0x00, 0xFF, 0xE0, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x00, 0x3F, 0x88, 0x09, 0x01, 0x40,
  0x18, 0x02, 0x80, 0x90, 0x11, 0x04, 0x1F, 0x0C, 0x1A, 0x01, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0A, 0x02, 0x3F, 0x80, 0x3F, 0x10, 0x24, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x32, 0x34, 0x71, 0x00, 0x40,
  0x20, 0x08, 0x0C, 0x3C, 0x00, 0x80, 0x20, 0x40, 0x00, 0x16, 0xA0, 0x00,
  0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x10,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x30, 0x30, 0x30, 0x70, 0x20, 0x00, 0x3E, 0x20,
  0xA0, 0x30, 0x10, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x81, 0x08, 0x04, 0x86,
  0x28, 0xC8, 0xC4, 0x46, 0x42, 0x32, 0x11, 0x90, 0x8C, 0x84, 0x64, 0x43,
  0x22, 0x29, 0x29, 0x46, 0x31, 0x00, 0x0C, 0x08, 0x1F, 0x80, 0x02, 0x00,
  0x60, 0x05, 0x00, 0x50, 0x09, 0x00, 0x88, 0x08, 0x81, 0x08, 0x10, 0x41,
  0x04, 0x20, 0x43, 0xFE, 0x20, 0x24, 0x02, 0x40, 0x14, 0x01, 0x80, 0x10,
  0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x0C, 0xFF, 0x20,
  0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x06, 0xFE, 0x00, 0x3F, 0x08,
  0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x90, 0x13, 0x04, 0x1F, 0x00, 0xFE, 0x10,
  0x32, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xA0, 0x24, 0x08, 0xFE, 0x00, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x00, 0x3F, 0x08, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x09, 0x02,
  0x1F, 0x80, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xFF, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC0, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x50, 0x11, 0x04, 0x1F, 0x00, 0x80, 0x50,
  0x12, 0x04, 0x41, 0x08, 0x41, 0x10, 0x24, 0x05, 0x00, 0xD0, 0x11, 0x02,
  0x10, 0x42, 0x08, 0x21, 0x02, 0x20, 0x24, 0x02, 0x80, 0x60, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x80, 0x78, 0x0F, 0x02,
  0xD0, 0x5A, 0x0B, 0x42, 0x64, 0x4C, 0x91, 0x8A, 0x31, 0x86, 0x30, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x80, 0x70, 0x1C, 0x06,
  0x81, 0xA0, 0x64, 0x18, 0x86, 0x21, 0x84, 0x61, 0x18, 0x26, 0x09, 0x81,
  0x60, 0x38, 0x0E, 0x01, 0x80, 0x40, 0x3F, 0x08, 0x11, 0x01, 0x40, 0x28,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x90, 0x12, 0x04, 0x3F, 0x00, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x81, 0xBF, 0x88, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x01, 0x40, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14,
  0x01, 0x20, 0x22, 0x04, 0x1F, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFE, 0x20,
  0x48, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x83, 0x3F, 0x08, 0x22,
  0x08, 0x81, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x40, 0x3F, 0x88, 0x0A, 0x01,
  0x40, 0x18, 0x02, 0x80, 0x10, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x3F, 0x80, 0xFF, 0xF0, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x14, 0x05, 0x02, 0x3F, 0x00, 0x80, 0x14, 0x01, 0x40,
  0x24, 0x02, 0x20, 0x22, 0x04, 0x20, 0x41, 0x04, 0x10, 0x81, 0x08, 0x08,
  0x80, 0x90, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x02, 0x00, 0x82, 0x0C,
  0x10, 0x61, 0x82, 0x8A, 0x24, 0x51, 0x22, 0x89, 0x14, 0x49, 0x22, 0x48,
  0x92, 0x45, 0x0A, 0x28, 0x51, 0x43, 0x0A, 0x18, 0x30, 0xC1, 0x02, 0x08,
  0x10, 0x40, 0x40, 0x12, 0x02, 0x20, 0x21, 0x04, 0x10, 0x80, 0x88, 0x05,
  0x00, 0x60, 0x02, 0x00, 0x50, 0x09, 0x00, 0x88, 0x10, 0x41, 0x04, 0x20,
  0x24, 0x01, 0xC0, 0x10, 0x80, 0x14, 0x02, 0x40, 0x22, 0x04, 0x20, 0x41,
  0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xC0, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x00, 0xFF, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x27, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x18, 0x14, 0x24, 0x22,
  0x42, 0x42, 0x41, 0x81, 0xFF, 0xC0, 0x89, 0x80, 0x1F, 0x08, 0x24, 0x06,
  0x01, 0x00, 0x40, 0x13, 0xFD, 0x01, 0x80, 0x60, 0x18, 0x05, 0x03, 0x3F,
  0x40, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xF3, 0x05, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x7F, 0x00, 0x1F, 0x08,
  0x24, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x14, 0x04,
  0x82, 0x1F, 0x00, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x47, 0x92, 0x15,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40,
  0xCF, 0xD0, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x80, 0x7F, 0xF8, 0x02, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x81, 0x1F, 0x80, 0x03, 0xE0, 0x80, 0x20, 0x04,
  0x00, 0x81, 0xFF, 0x82, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x1E, 0x48, 0x54, 0x0E,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x03, 0x3F,
  0x40, 0x10, 0x04, 0x02, 0x40, 0x8F, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x23, 0xCB, 0x0B, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x00, 0x00, 0xF8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0xFF, 0xC0, 0x03, 0x02, 0x00, 0x00, 0x3E, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x04, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x28, 0x12, 0x08,
  0x84, 0x26, 0x0A, 0x03, 0x40, 0x88, 0x21, 0x08, 0x22, 0x04, 0x81, 0x20,
  0x30, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0,
  0xB8, 0xEC, 0x51, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21,
  0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x10, 0x8F, 0x2C, 0x2C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0A, 0x01, 0x20, 0x41, 0xF0, 0xBE, 0x60, 0xA0, 0x50, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x2F, 0xE4, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x00, 0x1E, 0x48, 0x54, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x03, 0x3F, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x9F, 0xA0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x1F, 0x18, 0x24, 0x05, 0x01, 0x40, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x40, 0x18, 0x05, 0x01, 0x3F, 0x80, 0x08, 0x02, 0x00,
  0x83, 0xFE, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x1F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x37, 0xE8, 0x80, 0x14, 0x01, 0x40,
  0x22, 0x02, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x08, 0x80, 0x90, 0x05,
  0x00, 0x60, 0x02, 0x00, 0x82, 0x0C, 0x10, 0x61, 0x85, 0x0A, 0x24, 0x51,
  0x22, 0x89, 0x24, 0x89, 0x14, 0x28, 0xA1, 0x85, 0x0C, 0x28, 0x60, 0x81,
  0x04, 0x00, 0x80, 0x28, 0x08, 0x82, 0x10, 0x81, 0x20, 0x14, 0x01, 0x00,
  0x50, 0x12, 0x04, 0x20, 0x82, 0x20, 0x28, 0x02, 0x80, 0x18, 0x01, 0x40,
  0x14, 0x02, 0x20, 0x22, 0x04, 0x10, 0x41, 0x08, 0x08, 0x80, 0x90, 0x05,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x07, 0x00, 0xFF,
  0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x0F, 0xFE, 0x03, 0x04, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x08, 0x04, 0x03, 0xFF, 0xFF, 0xF0, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x07, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x78, 0x0C, 0x20, 0xA0,
  0xC5, 0x01, 0xC0,
};

const GFXglyph RobotoMono_Thin24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 17, 14, 6, -17 },
  { 6, 4, 5, 14, 5, -18 },
  { 9, 13, 17, 14, 1, -17 },
  { 37, 11, 21, 14, 2, -19 },
  { 66, 13, 17, 14, 1, -17 },
  { 94, 12, 17, 14, 2, -17 },
  { 120, 1, 5, 14, 6, -18 },
  { 121, 5, 25, 14, 5, -19 },
  { 137, 5, 25, 14, 4, -19 },
  { 153, 11, 9, 14, 2, -17 },
  { 166, 12, 12, 14, 1, -14 },
  { 184, 2, 5, 14, 5, -2 },
  { 186, 8, 1, 14, 3, -8 },
  { 187, 1, 1, 14, 7, -1 },
  { 188, 7, 18, 14, 4, -17 },
  { 204, 10, 17, 14, 2, -17 },
  { 226, 5, 17, 14, 3, -17 },
  { 237, 11, 17, 14, 1, -17 },
  { 261, 11, 17, 14, 1, -17 },
  { 285, 12, 17, 14, 1, -17 },
  { 311, 10, 17, 14, 3, -17 },
  { 333, 10, 17, 14, 2, -17 },
  { 355, 11, 17, 14, 2, -17 },
  { 379, 11, 17, 14, 2, -17 },
  { 403, 10, 17, 14, 2, -17 },
  { 425, 1, 11, 14, 8, -11 },
  { 427, 2, 14, 14, 7, -11 },
  { 431, 10, 10, 14, 2, -13 },
  { 444, 11, 6, 14, 2, -11 },
  { 453, 10, 10, 14, 2, -13 },
  { 466, 9, 17, 14, 3, -17 },
  { 486, 13, 17, 14, 1, -17 },
  { 514, 12, 17, 14, 1, -17 },
  { 540, 10, 17, 14, 3, -17 },
  { 562, 11, 17, 14, 2, -17 },
  { 586, 11, 17, 14, 2, -17 },
  { 610, 9, 17, 14, 3, -17 },
  { 630, 9, 17, 14, 3, -17 },
  { 650, 11, 17, 14, 2, -17 },
  { 674, 10, 17, 14, 2, -17 },
  { 696, 10, 17, 14, 2, -17 },
  { 718, 11, 17, 14, 1, -17 },
  { 742, 11, 17, 14, 3, -17 },
  { 766, 10, 17, 14, 3, -17 },
  { 788, 11, 17, 14, 2, -17 },
  { 812, 10, 17, 14, 2, -17 },
  { 834, 11, 17, 14, 2, -17 },
  { 858, 10, 17, 14, 3, -17 },
  { 880, 12, 20, 14, 1, -17 },
  { 910, 10, 17, 14, 3, -17 },
  { 932, 11, 17, 14, 2, -17 },
  { 956, 12, 17, 14, 1, -17 },
  { 982, 10, 17, 14, 2, -17 },
  { 1004, 12, 17, 14, 1, -17 },
  { 1030, 13, 17, 14, 1, -17 },
  { 1058, 12, 17, 14, 1, -17 },
  { 1084, 12, 17, 14, 1, -17 },
  { 1110, 10, 17, 14, 2, -17 },
  { 1132, 3, 24, 14, 6, -20 },
  { 1141, 8, 18, 14, 3, -17 },
  { 1159, 4, 24, 14, 5, -20 },
  { 1171, 8, 9, 14, 3, -17 },
  { 1180, 10, 1, 14, 2, 0 },
  { 1182, 3, 3, 14, 6, -18 },
  { 1184, 10, 13, 14, 2, -13 },
  { 1201, 9, 18, 14, 3, -18 },
  { 1222, 10, 13, 14, 2, -13 },
  { 1239, 10, 18, 14, 2, -18 },
  { 1262, 10, 13, 14, 2, -13 },
  { 1279, 11, 18, 14, 2, -18 },
  { 1304, 10, 18, 14, 2, -13 },
  { 1327, 10, 18, 14, 2, -18 },
  { 1350, 10, 17, 14, 3, -17 },
  { 1372, 8, 22, 14, 2, -17 },
  { 1394, 10, 18, 14, 3, -18 },
  { 1417, 10, 18, 14, 3, -18 },
  { 1440, 12, 13, 14, 1, -13 },
  { 1460, 10, 13, 14, 2, -13 },
  { 1477, 11, 13, 14, 2, -13 },
  { 1495, 9, 18, 14, 3, -13 },
  { 1516, 10, 18, 14, 2, -13 },
  { 1539, 8, 13, 14, 5, -13 },
  { 1552, 10, 13, 14, 2, -13 },
  { 1569, 10, 16, 14, 2, -16 },
  { 1589, 9, 13, 14, 3, -13 },
  { 1604, 12, 13, 14, 1, -13 },
  { 1624, 13, 13, 14, 1, -13 },
  { 1646, 11, 13, 14, 2, -13 },
  { 1664, 12, 18, 14, 1, -13 },
  { 1691, 11, 13, 14, 2, -13 },
  { 1709, 8, 24, 14, 4, -19 },
  { 1733, 1, 20, 14, 7, -17 },
  { 1736, 8, 24, 14, 4, -19 },
  { 1760, 13, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_Thin24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin24pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_THIN24PT7B_H_
