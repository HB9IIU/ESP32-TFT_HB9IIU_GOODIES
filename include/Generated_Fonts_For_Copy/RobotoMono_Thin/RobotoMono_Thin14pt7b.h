#ifndef _ROBOTOMONO_THIN14PT7B_H_
#define _ROBOTOMONO_THIN14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xFC, 0x12, 0x12, 0x12, 0x7D, 0x24, 0x24, 0x24, 0xFF,
  0x24, 0x28, 0x11, 0xA4, 0x61, 0x40, 0x81, 0x81, 0x86, 0x16, 0xC4, 0x60,
  0x92, 0x94, 0x94, 0x68, 0x12, 0x15, 0x29, 0x25, 0x07, 0x78, 0x91, 0x22,
  0x82, 0x0A, 0x24, 0xC5, 0x84, 0xF4, 0xE0, 0x2A, 0x49, 0x24, 0x92, 0x44,
  0xC0, 0xC8, 0x92, 0x49, 0x24, 0x95, 0x80, 0x10, 0x4F, 0xCC, 0x6C, 0x10,
  0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xE0, 0xF8, 0x80, 0x08, 0x84, 0x22,
  0x11, 0x08, 0x44, 0x20, 0x7A, 0x18, 0x63, 0x96, 0x9C, 0x61, 0x85, 0xE0,
  0x74, 0x92, 0x49, 0x24, 0x7A, 0x18, 0x41, 0x08, 0x42, 0x08, 0x43, 0xF0,
  0x7A, 0x18, 0x41, 0x38, 0x20, 0x61, 0x85, 0xE0, 0x08, 0x30, 0xA1, 0x44,
  0x91, 0x22, 0x3F, 0x08, 0x10, 0xFC, 0x21, 0x4D, 0x84, 0x31, 0x8F, 0xC0,
  0x39, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0x85, 0xE0, 0xFC, 0x10, 0x42, 0x08,
  0x41, 0x08, 0x21, 0x00, 0x79, 0x0A, 0x0C, 0x27, 0x88, 0xA0, 0xC1, 0x82,
  0xF8, 0x7A, 0x18, 0x61, 0x86, 0x17, 0xC1, 0x09, 0xC0, 0x82, 0x83, 0x80,
  0x0D, 0xC8, 0x1C, 0x0C, 0xFC, 0x0F, 0xC0, 0xE0, 0x60, 0x46, 0xE0, 0xF4,
  0x42, 0x11, 0x10, 0x80, 0x01, 0x00, 0x3E, 0x41, 0x5D, 0xA5, 0xA5, 0xA5,
  0xA5, 0xBF, 0x40, 0x3C, 0x10, 0x60, 0xA1, 0x44, 0x88, 0x9F, 0x42, 0x83,
  0x04, 0xFA, 0x18, 0x61, 0xFA, 0x18, 0x61, 0x87, 0xE0, 0x7A, 0x18, 0x60,
  0x82, 0x08, 0x21, 0x85, 0xE0, 0xF9, 0x0A, 0x14, 0x18, 0x30, 0x60, 0xC1,
  0x85, 0xF0, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x83, 0xF0, 0xFC, 0x21,
  0x0F, 0xC2, 0x10, 0x84, 0x00, 0x7A, 0x18, 0x60, 0x82, 0x78, 0x61, 0x85,
  0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x13, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x61, 0x85,
  0xE0, 0x86, 0x29, 0x28, 0xC2, 0x8A, 0x24, 0x8A, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x87, 0xC0, 0x86, 0x1C, 0xF3, 0xAE, 0xD9, 0x61, 0x86, 0x10,
  0x86, 0x1C, 0x69, 0xA6, 0x58, 0xE3, 0x86, 0x10, 0x7A, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x85, 0xE0, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x00,
  0x79, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x84, 0xF0, 0x10, 0x10, 0xF2,
  0x28, 0x62, 0x8B, 0xC9, 0x22, 0x8A, 0x10, 0x79, 0x0A, 0x0C, 0x07, 0x01,
  0x80, 0xC1, 0x82, 0xF8, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x83, 0x0A, 0x12,
  0x24, 0x89, 0x12, 0x18, 0x30, 0x20, 0x93, 0x26, 0xCD, 0x5A, 0xB5, 0xAB,
  0x22, 0x44, 0x88, 0x82, 0x89, 0x21, 0x41, 0x06, 0x0A, 0x24, 0x45, 0x04,
  0x83, 0x09, 0x12, 0x43, 0x02, 0x04, 0x08, 0x10, 0x20, 0xFC, 0x10, 0x84,
  0x10, 0x82, 0x10, 0x83, 0xF0, 0xEA, 0xAA, 0xAA, 0xC0, 0x88, 0x44, 0x42,
  0x22, 0x11, 0x10, 0xD5, 0x55, 0x55, 0xC0, 0x23, 0x15, 0x28, 0xC4, 0xFC,
  0xC0, 0x39, 0x18, 0x41, 0x7E, 0x18, 0x5F, 0x84, 0x21, 0xE8, 0xC6, 0x31,
  0x8C, 0x7C, 0x39, 0x18, 0x60, 0x82, 0x08, 0x5E, 0x04, 0x10, 0x4D, 0x4E,
  0x18, 0x61, 0x86, 0x17, 0xC0, 0x39, 0x18, 0x7F, 0x82, 0x08, 0x1F, 0x0E,
  0x20, 0x87, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x31, 0x38, 0x61,
  0x86, 0x18, 0x5F, 0x06, 0x17, 0x80, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61,
  0x86, 0x18, 0x40, 0x20, 0x30, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x08, 0x1C,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x2E, 0x00, 0x84, 0x21, 0x19, 0x53, 0x14,
  0xA4, 0xA2, 0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x6D, 0x26, 0x4C,
  0x99, 0x32, 0x64, 0xC9, 0x3B, 0x18, 0x61, 0x86, 0x18, 0x61, 0x39, 0x18,
  0x61, 0x86, 0x18, 0x5E, 0x3B, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08,
  0x00, 0x31, 0x38, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x10, 0x40, 0x3C, 0x88,
  0x88, 0x88, 0x39, 0x18, 0x58, 0x18, 0x18, 0x5F, 0x23, 0xF2, 0x08, 0x20,
  0x82, 0x08, 0x1C, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x87, 0x09, 0x12,
  0x42, 0x86, 0x04, 0x00, 0x93, 0x66, 0xCD, 0x6A, 0xC8, 0x91, 0x00, 0xC4,
  0x90, 0xC0, 0x82, 0x88, 0xA1, 0x80, 0x83, 0x09, 0x12, 0x42, 0x86, 0x04,
  0x08, 0x21, 0x80, 0xFC, 0x10, 0x41, 0x02, 0x08, 0x3F, 0x80, 0x19, 0x08,
  0x42, 0x11, 0x18, 0x21, 0x08, 0x42, 0x0C, 0xFF, 0xF0, 0xC1, 0x08, 0x42,
  0x10, 0x43, 0x21, 0x08, 0x42, 0x60, 0x71, 0x8E,
};

const GFXglyph RobotoMono_Thin14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 10, 8, 4, -10 },
  { 3, 2, 3, 8, 3, -11 },
  { 4, 8, 10, 8, 0, -10 },
  { 14, 6, 12, 8, 1, -11 },
  { 23, 8, 10, 8, 0, -10 },
  { 33, 7, 10, 8, 1, -10 },
  { 42, 1, 3, 8, 3, -11 },
  { 43, 3, 14, 8, 3, -11 },
  { 49, 3, 14, 8, 2, -11 },
  { 55, 6, 5, 8, 1, -10 },
  { 59, 7, 7, 8, 1, -8 },
  { 66, 1, 3, 8, 3, -1 },
  { 67, 5, 1, 8, 2, -5 },
  { 68, 1, 1, 8, 4, -1 },
  { 69, 5, 11, 8, 2, -10 },
  { 76, 6, 10, 8, 1, -10 },
  { 84, 3, 10, 8, 2, -10 },
  { 88, 6, 10, 8, 1, -10 },
  { 96, 6, 10, 8, 1, -10 },
  { 104, 7, 10, 8, 1, -10 },
  { 113, 5, 10, 8, 2, -10 },
  { 120, 6, 10, 8, 1, -10 },
  { 128, 6, 10, 8, 1, -10 },
  { 136, 7, 10, 8, 1, -10 },
  { 145, 6, 10, 8, 1, -10 },
  { 153, 1, 7, 8, 4, -7 },
  { 154, 1, 9, 8, 4, -7 },
  { 156, 6, 5, 8, 1, -7 },
  { 160, 6, 3, 8, 1, -6 },
  { 163, 6, 5, 8, 1, -7 },
  { 167, 5, 10, 8, 2, -10 },
  { 174, 8, 10, 8, 0, -10 },
  { 184, 7, 10, 8, 1, -10 },
  { 193, 6, 10, 8, 1, -10 },
  { 201, 6, 10, 8, 1, -10 },
  { 209, 7, 10, 8, 1, -10 },
  { 218, 6, 10, 8, 1, -10 },
  { 226, 5, 10, 8, 2, -10 },
  { 233, 6, 10, 8, 1, -10 },
  { 241, 6, 10, 8, 1, -10 },
  { 249, 6, 10, 8, 1, -10 },
  { 257, 6, 10, 8, 1, -10 },
  { 265, 6, 10, 8, 2, -10 },
  { 273, 5, 10, 8, 2, -10 },
  { 280, 6, 10, 8, 1, -10 },
  { 288, 6, 10, 8, 1, -10 },
  { 296, 6, 10, 8, 1, -10 },
  { 304, 6, 10, 8, 2, -10 },
  { 312, 7, 12, 8, 1, -10 },
  { 323, 6, 10, 8, 2, -10 },
  { 331, 7, 10, 8, 1, -10 },
  { 340, 7, 10, 8, 1, -10 },
  { 349, 6, 10, 8, 1, -10 },
  { 357, 7, 10, 8, 1, -10 },
  { 366, 7, 10, 8, 1, -10 },
  { 375, 7, 10, 8, 1, -10 },
  { 384, 7, 10, 8, 1, -10 },
  { 393, 6, 10, 8, 1, -10 },
  { 401, 2, 13, 8, 3, -11 },
  { 405, 4, 11, 8, 2, -10 },
  { 411, 2, 13, 8, 3, -11 },
  { 415, 5, 6, 8, 2, -10 },
  { 419, 6, 1, 8, 1, 0 },
  { 420, 2, 1, 8, 3, -10 },
  { 421, 6, 8, 8, 1, -8 },
  { 427, 5, 11, 8, 2, -11 },
  { 434, 6, 8, 8, 1, -8 },
  { 440, 6, 11, 8, 1, -11 },
  { 449, 6, 8, 8, 1, -8 },
  { 455, 7, 11, 8, 1, -11 },
  { 465, 6, 11, 8, 1, -8 },
  { 474, 6, 11, 8, 1, -11 },
  { 483, 5, 10, 8, 2, -10 },
  { 490, 5, 13, 8, 1, -10 },
  { 499, 5, 11, 8, 2, -11 },
  { 506, 5, 11, 8, 2, -11 },
  { 513, 7, 8, 8, 1, -8 },
  { 520, 6, 8, 8, 1, -8 },
  { 526, 6, 8, 8, 1, -8 },
  { 532, 6, 11, 8, 1, -8 },
  { 541, 6, 11, 8, 1, -8 },
  { 550, 4, 8, 8, 3, -8 },
  { 554, 6, 8, 8, 1, -8 },
  { 560, 6, 9, 8, 1, -9 },
  { 567, 6, 7, 8, 1, -7 },
  { 573, 7, 7, 8, 1, -7 },
  { 580, 7, 7, 8, 1, -7 },
  { 587, 7, 7, 8, 1, -7 },
  { 594, 7, 10, 8, 1, -7 },
  { 603, 7, 7, 8, 1, -7 },
  { 610, 5, 14, 8, 2, -11 },
  { 619, 1, 12, 8, 4, -10 },
  { 621, 5, 14, 8, 2, -11 },
  { 630, 8, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_Thin14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin14pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_THIN14PT7B_H_
