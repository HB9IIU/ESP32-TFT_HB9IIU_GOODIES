#ifndef _ROBOTOMONO_THIN23PT7B_H_
#define _ROBOTOMONO_THIN23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0x99, 0x99, 0x04, 0x40, 0x84, 0x08, 0x40, 0x84, 0x7F,
  0xF0, 0x88, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x0F, 0xFE, 0x21,
  0x02, 0x10, 0x21, 0x02, 0x10, 0x04, 0x01, 0x00, 0xE0, 0xC4, 0x40, 0x90,
  0x14, 0x05, 0x00, 0x40, 0x08, 0x01, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x06,
  0x01, 0x80, 0x50, 0x23, 0xB0, 0x10, 0x04, 0x00, 0x30, 0x02, 0x40, 0x11,
  0x09, 0x08, 0x88, 0x44, 0x42, 0x41, 0x12, 0x07, 0x20, 0x01, 0x00, 0x11,
  0x01, 0x14, 0x09, 0x10, 0x88, 0x84, 0x44, 0x42, 0x22, 0x11, 0x00, 0x70,
  0x1C, 0x04, 0x41, 0x08, 0x20, 0x84, 0x20, 0x84, 0x09, 0x00, 0xC0, 0x30,
  0x09, 0x01, 0x10, 0xC1, 0x18, 0x15, 0x02, 0xA0, 0x22, 0x0A, 0x3E, 0x20,
  0xF0, 0x12, 0x24, 0x48, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x44, 0x42,
  0x10, 0x82, 0x08, 0x21, 0x08, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x84, 0x22, 0x22, 0x00, 0x04, 0x01, 0x08, 0x45, 0xD6, 0x0E, 0x02, 0x81,
  0x20, 0x84, 0x20, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xF8, 0xFF,
  0x80, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x1E, 0x08, 0x44, 0x0A, 0x02, 0x80,
  0x60, 0x38, 0x16, 0x09, 0x84, 0x62, 0x19, 0x06, 0x81, 0xC0, 0x60, 0x14,
  0x09, 0x02, 0x3F, 0x00, 0x3A, 0x62, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x1E, 0x08, 0x44, 0x0A, 0x01, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x7F, 0xC0,
  0x0E, 0x0C, 0x44, 0x09, 0x01, 0x80, 0x40, 0x10, 0x04, 0x02, 0x0F, 0x00,
  0x60, 0x04, 0x01, 0x80, 0x60, 0x18, 0x05, 0x02, 0x3F, 0x00, 0x01, 0x80,
  0x50, 0x0A, 0x02, 0x40, 0x88, 0x11, 0x04, 0x21, 0x04, 0x20, 0x88, 0x12,
  0x02, 0x7F, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x7F, 0xA0, 0x20, 0x10,
  0x08, 0x04, 0x03, 0xF9, 0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x05,
  0x04, 0x7C, 0x07, 0x06, 0x02, 0x01, 0x00, 0x40, 0x20, 0x09, 0xE3, 0x84,
  0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x09, 0x02, 0x3F, 0x00,
  0xFF, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x0E, 0x0C, 0x44, 0x0A,
  0x01, 0x80, 0x60, 0x14, 0x04, 0x82, 0x1F, 0x08, 0x64, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x05, 0x02, 0x3F, 0x00, 0x1C, 0x08, 0xC4, 0x0A, 0x02, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x36, 0x14, 0x79, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x3C, 0x00, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x09, 0x25,
  0x00, 0x00, 0xC0, 0xC1, 0xC1, 0x80, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0x40, 0xE0, 0xC0, 0xC0, 0xC0, 0x00, 0x1C, 0x62, 0x81, 0x81,
  0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x07, 0x01, 0x8C, 0x20, 0x24, 0x01, 0x47, 0x18, 0x89, 0x90, 0x99,
  0x09, 0x91, 0x19, 0x11, 0x91, 0x19, 0x11, 0x93, 0x28, 0xCC, 0x40, 0x06,
  0x00, 0x1F, 0x80, 0x06, 0x00, 0x60, 0x05, 0x00, 0x90, 0x09, 0x00, 0x88,
  0x10, 0x81, 0x08, 0x10, 0x42, 0x04, 0x3F, 0xC2, 0x04, 0x40, 0x24, 0x02,
  0x40, 0x28, 0x01, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x28, 0x1B,
  0xF8, 0x81, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B, 0xFC, 0x1E,
  0x08, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x14, 0x05, 0x02, 0x3F, 0x00, 0xFE, 0x20, 0x68,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x28, 0x13, 0xF8, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x03, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03,
  0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x1E, 0x08, 0x44, 0x0A, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x21, 0xE8, 0x06, 0x01, 0x80, 0x60,
  0x14, 0x05, 0x01, 0x3F, 0x80, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x07, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x50,
  0x14, 0x08, 0xFC, 0x80, 0xE0, 0x48, 0x22, 0x10, 0x88, 0x24, 0x0A, 0x02,
  0x80, 0xD0, 0x22, 0x08, 0x42, 0x08, 0x81, 0x20, 0x48, 0x0A, 0x01, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x70, 0x3C, 0x0E, 0x85, 0xA1, 0x68,
  0x99, 0x26, 0x49, 0x8C, 0x63, 0x18, 0x86, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x06, 0x81, 0x90, 0x64, 0x18, 0x86, 0x21, 0x84,
  0x61, 0x18, 0x26, 0x09, 0x81, 0x60, 0x38, 0x0E, 0x01, 0x1C, 0x08, 0xC4,
  0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x09, 0x02, 0x3F, 0x00, 0xFF, 0x20, 0x28, 0x0A, 0x01,
  0x80, 0x60, 0x18, 0x0A, 0x06, 0xFE, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x0F, 0x01, 0x08, 0x20, 0x44, 0x02, 0x40, 0x28, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02,
  0x40, 0x22, 0x04, 0x1F, 0x80, 0x08, 0x00, 0x40, 0x02, 0xFE, 0x20, 0x48,
  0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0xFE, 0x21, 0x08, 0x22, 0x08,
  0x81, 0x20, 0x48, 0x0A, 0x03, 0x1E, 0x08, 0x44, 0x0A, 0x01, 0x80, 0x60,
  0x04, 0x00, 0x80, 0x1C, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x18, 0x05,
  0x01, 0x3F, 0x80, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x24, 0x08, 0xFC, 0x80,
  0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04, 0x20, 0x81, 0x08, 0x10,
  0x81, 0x10, 0x09, 0x00, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x40, 0x82,
  0x18, 0x21, 0x86, 0x18, 0x61, 0x45, 0x14, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x8A, 0x28, 0xA3, 0x0A, 0x30, 0xC3, 0x04, 0x30, 0x42, 0x04, 0x40,
  0x32, 0x02, 0x20, 0x41, 0x08, 0x08, 0x80, 0x90, 0x06, 0x00, 0x20, 0x06,
  0x00, 0x90, 0x09, 0x01, 0x08, 0x20, 0x42, 0x04, 0x40, 0x2C, 0x01, 0x80,
  0x28, 0x05, 0x01, 0x10, 0x22, 0x08, 0x22, 0x04, 0x40, 0x50, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x03, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x03, 0xE4, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x78, 0x18, 0x18, 0x24, 0x24, 0x44,
  0x42, 0x42, 0x81, 0x81, 0xFF, 0xC0, 0xA4, 0x3F, 0x10, 0x28, 0x04, 0x01,
  0x00, 0x47, 0xE6, 0x06, 0x01, 0x80, 0x60, 0x28, 0x15, 0xF9, 0x80, 0x40,
  0x20, 0x10, 0x09, 0x87, 0x32, 0x05, 0x02, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x05, 0x02, 0xFE, 0x00, 0x3F, 0x10, 0x24, 0x06, 0x01, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x50, 0x14, 0x08, 0xFC, 0x00, 0x80, 0x40,
  0x20, 0x10, 0xC9, 0x9D, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x05, 0x02, 0x81, 0x3F, 0x80, 0x3F, 0x10, 0x28, 0x06, 0x01, 0x80, 0x7F,
  0xF8, 0x02, 0x00, 0x80, 0x10, 0x06, 0x0C, 0x7C, 0x07, 0xC2, 0x00, 0x80,
  0x40, 0x10, 0x3F, 0xE1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x00, 0x3F, 0xA0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x27, 0xF0, 0x08, 0x05, 0x02, 0x82,
  0x3E, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x84, 0x26, 0xCA, 0x0B, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x08, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x2F,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x0A, 0x09, 0x08, 0x88, 0x48,
  0x38, 0x12, 0x08, 0x84, 0x22, 0x09, 0x02, 0x80, 0x80, 0xF8, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0xFF, 0x80, 0xFD, 0xE8, 0x61, 0x84, 0x18, 0x41, 0x84,
  0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x9F,
  0x28, 0x2C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x3F, 0x10, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x08, 0xFC, 0xBF, 0x30, 0x28, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x2C, 0x0A, 0xFC, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x00, 0x3F, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xA0, 0x50, 0x27, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x9F,
  0xA0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F,
  0x10, 0x24, 0x05, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x00, 0x60, 0x14,
  0x04, 0xFE, 0x08, 0x04, 0x02, 0x1F, 0xF0, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x1E, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x27, 0xF0, 0x80, 0x28, 0x05,
  0x01, 0x10, 0x22, 0x04, 0x21, 0x04, 0x20, 0x88, 0x09, 0x01, 0x40, 0x18,
  0x02, 0x00, 0x84, 0x18, 0x61, 0x86, 0x14, 0x62, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x04, 0x80, 0x50, 0x22, 0x10,
  0x48, 0x0A, 0x03, 0x00, 0xC0, 0x48, 0x21, 0x08, 0x24, 0x0A, 0x01, 0x80,
  0x14, 0x02, 0x40, 0x22, 0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x10, 0x09,
  0x00, 0x90, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x70,
  0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x03, 0xFF, 0x02, 0x18, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x86, 0x06, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x01,
  0x80, 0xFF, 0xFF, 0xE0, 0x80, 0xC0, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x20, 0x30, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x0C, 0x20,
  0x00, 0x70, 0x08, 0xC1, 0x82, 0x18, 0x1E,
};

const GFXglyph RobotoMono_Thin23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 1, 16, 14, 6, -16 },
  { 3, 4, 4, 14, 5, -17 },
  { 5, 12, 16, 14, 1, -16 },
  { 29, 10, 21, 14, 2, -19 },
  { 56, 13, 17, 14, 0, -17 },
  { 84, 11, 17, 14, 2, -17 },
  { 108, 1, 4, 14, 6, -17 },
  { 109, 4, 23, 14, 5, -18 },
  { 121, 5, 23, 14, 4, -18 },
  { 136, 10, 9, 14, 2, -16 },
  { 148, 12, 12, 14, 1, -14 },
  { 166, 1, 5, 14, 5, -2 },
  { 167, 8, 1, 14, 3, -8 },
  { 168, 1, 1, 14, 7, -1 },
  { 169, 8, 17, 14, 3, -16 },
  { 186, 10, 17, 14, 2, -17 },
  { 208, 5, 16, 14, 3, -16 },
  { 218, 10, 17, 14, 1, -17 },
  { 240, 10, 17, 14, 1, -17 },
  { 262, 11, 16, 14, 1, -16 },
  { 284, 9, 16, 14, 3, -16 },
  { 302, 10, 17, 14, 2, -17 },
  { 324, 10, 16, 14, 2, -16 },
  { 344, 10, 17, 14, 2, -17 },
  { 366, 10, 17, 14, 2, -17 },
  { 388, 2, 11, 14, 7, -11 },
  { 391, 3, 14, 14, 6, -11 },
  { 397, 10, 9, 14, 2, -12 },
  { 409, 10, 5, 14, 2, -10 },
  { 416, 10, 9, 14, 2, -12 },
  { 428, 8, 17, 14, 3, -17 },
  { 445, 12, 17, 14, 1, -17 },
  { 471, 12, 16, 14, 1, -16 },
  { 495, 10, 16, 14, 2, -16 },
  { 515, 10, 17, 14, 2, -17 },
  { 537, 10, 16, 14, 2, -16 },
  { 557, 10, 16, 14, 2, -16 },
  { 577, 9, 16, 14, 3, -16 },
  { 595, 10, 17, 14, 2, -17 },
  { 617, 10, 16, 14, 2, -16 },
  { 637, 9, 16, 14, 2, -16 },
  { 655, 10, 16, 14, 1, -16 },
  { 675, 10, 16, 14, 3, -16 },
  { 695, 9, 16, 14, 3, -16 },
  { 713, 10, 16, 14, 2, -16 },
  { 733, 10, 16, 14, 2, -16 },
  { 753, 10, 17, 14, 2, -17 },
  { 775, 10, 16, 14, 3, -16 },
  { 795, 12, 20, 14, 1, -17 },
  { 825, 10, 16, 14, 3, -16 },
  { 845, 10, 17, 14, 2, -17 },
  { 867, 12, 16, 14, 1, -16 },
  { 891, 10, 16, 14, 2, -16 },
  { 911, 12, 16, 14, 1, -16 },
  { 935, 12, 16, 14, 1, -16 },
  { 959, 12, 16, 14, 1, -16 },
  { 983, 11, 16, 14, 1, -16 },
  { 1005, 10, 16, 14, 2, -16 },
  { 1025, 4, 23, 14, 5, -19 },
  { 1037, 8, 17, 14, 3, -16 },
  { 1054, 3, 23, 14, 5, -19 },
  { 1063, 8, 9, 14, 3, -16 },
  { 1072, 10, 1, 14, 2, 0 },
  { 1074, 2, 3, 14, 6, -17 },
  { 1075, 10, 12, 14, 2, -12 },
  { 1090, 9, 17, 14, 3, -17 },
  { 1110, 10, 12, 14, 2, -12 },
  { 1125, 9, 17, 14, 2, -17 },
  { 1145, 10, 12, 14, 2, -12 },
  { 1160, 10, 17, 14, 2, -17 },
  { 1182, 9, 17, 14, 2, -12 },
  { 1202, 10, 17, 14, 2, -17 },
  { 1224, 9, 16, 14, 3, -16 },
  { 1242, 7, 21, 14, 2, -16 },
  { 1261, 9, 17, 14, 3, -17 },
  { 1281, 9, 17, 14, 3, -17 },
  { 1301, 12, 12, 14, 1, -12 },
  { 1319, 10, 12, 14, 2, -12 },
  { 1334, 10, 12, 14, 2, -12 },
  { 1349, 10, 17, 14, 2, -12 },
  { 1371, 9, 17, 14, 2, -12 },
  { 1391, 8, 12, 14, 4, -12 },
  { 1403, 10, 12, 14, 2, -12 },
  { 1418, 9, 15, 14, 2, -15 },
  { 1435, 9, 12, 14, 2, -12 },
  { 1449, 11, 12, 14, 1, -12 },
  { 1466, 12, 12, 14, 1, -12 },
  { 1484, 10, 12, 14, 2, -12 },
  { 1499, 12, 17, 14, 1, -12 },
  { 1525, 10, 12, 14, 2, -12 },
  { 1540, 7, 23, 14, 4, -18 },
  { 1561, 1, 19, 14, 6, -16 },
  { 1564, 7, 23, 14, 4, -18 },
  { 1585, 12, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_Thin23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin23pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_THIN23PT7B_H_
