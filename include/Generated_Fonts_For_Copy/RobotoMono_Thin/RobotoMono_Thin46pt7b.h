#ifndef _ROBOTOMONO_THIN46PT7B_H_
#define _ROBOTOMONO_THIN46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin46pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x00,
  0x07, 0xE0, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x00,
  0x10, 0x08, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x01, 0x00,
  0x02, 0x01, 0x80, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x20,
  0x00, 0x40, 0x10, 0x00, 0x20, 0x08, 0x0F, 0xFF, 0xFF, 0xE0, 0x08, 0x04,
  0x00, 0x04, 0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00,
  0xC0, 0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x00, 0x60, 0x10, 0x00, 0x20,
  0x08, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x04, 0x02, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00, 0x80, 0x60, 0x00,
  0x40, 0x20, 0x00, 0x20, 0x10, 0x00, 0x30, 0x08, 0x00, 0x18, 0x04, 0x00,
  0x08, 0x06, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x70, 0x0C, 0x01,
  0x81, 0x00, 0x0C, 0x30, 0x00, 0x62, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00,
  0x03, 0x60, 0x00, 0x12, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x03, 0x60, 0x00, 0x23, 0x00, 0x06, 0x18, 0x00, 0xC0, 0xE0,
  0x38, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x10, 0x20, 0x18, 0x0C, 0x08,
  0x02, 0x02, 0x02, 0x00, 0x81, 0x00, 0x80, 0x20, 0x40, 0x20, 0x18, 0x20,
  0x0C, 0x04, 0x18, 0x01, 0x01, 0x04, 0x00, 0x60, 0xC3, 0x00, 0x0C, 0x60,
  0x80, 0x01, 0xF0, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x41, 0xF8, 0x00, 0x20, 0xC1,
  0x00, 0x18, 0x20, 0x60, 0x04, 0x10, 0x08, 0x03, 0x04, 0x02, 0x00, 0x81,
  0x00, 0xC0, 0x60, 0x40, 0x30, 0x10, 0x10, 0x0C, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x81, 0x00, 0x60, 0x20, 0x00, 0x08, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x60, 0x00, 0xC0, 0xC0,
  0x06, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x10, 0x04, 0x00, 0x40, 0x30, 0x01, 0x81, 0x80, 0x02, 0x0C,
  0x00, 0x0C, 0x60, 0x00, 0x13, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x08, 0x08, 0x02, 0x40,
  0x10, 0x0B, 0x00, 0x60, 0x28, 0x00, 0xC1, 0xA0, 0x01, 0x86, 0x80, 0x02,
  0x12, 0x00, 0x04, 0xC8, 0x00, 0x0A, 0x20, 0x00, 0x38, 0xC0, 0x00, 0x61,
  0x00, 0x02, 0xC2, 0x00, 0x31, 0x06, 0x01, 0x82, 0x0F, 0xF8, 0x04, 0xFF,
  0xEA, 0xA0, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x30,
  0x04, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x30, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x20, 0x10, 0x1F, 0x82, 0x0E, 0x1E, 0x4E, 0x00, 0x7F, 0x00,
  0x03, 0x80, 0x00, 0xD8, 0x00, 0x11, 0x00, 0x04, 0x10, 0x01, 0x81, 0x00,
  0x60, 0x30, 0x18, 0x03, 0x02, 0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x33, 0x33, 0x22, 0x26, 0xC4, 0xFF, 0xFF, 0xFF, 0xFF, 0x5F, 0x80,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x60,
  0x60, 0x18, 0x03, 0x01, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x40,
  0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x68, 0x00, 0x0E, 0x80, 0x01, 0xB8,
  0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x30, 0x01, 0x86, 0x00,
  0x18, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x03, 0xE0, 0x00, 0x24, 0x00,
  0x02, 0x40, 0x00, 0x26, 0x00, 0x04, 0x20, 0x00, 0x43, 0x00, 0x08, 0x18,
  0x01, 0x80, 0xC0, 0x70, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x1C, 0x0C, 0x8E,
  0x17, 0x03, 0x80, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xF8, 0x00, 0xC0, 0xE0, 0x30, 0x03,
  0x02, 0x00, 0x18, 0x40, 0x00, 0x8C, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00,
  0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x38, 0x38, 0x03, 0x00, 0x20,
  0x20, 0x00, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00, 0xC8, 0x00,
  0x02, 0x40, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x90, 0x00, 0x04, 0x80, 0x00, 0x22, 0x00, 0x03, 0x18, 0x00, 0x10, 0x60,
  0x03, 0x01, 0xC0, 0x30, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x48, 0x00, 0x01, 0x90,
  0x00, 0x02, 0x20, 0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x00, 0xC1, 0x00,
  0x01, 0x02, 0x00, 0x06, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20, 0x10, 0x00,
  0xC0, 0x20, 0x03, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x60,
  0x02, 0x00, 0x80, 0x04, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x10, 0x00,
  0x20, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xE2, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x0C,
  0x00, 0x5F, 0xF8, 0x1E, 0x01, 0xC3, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01, 0xA0, 0x00,
  0x26, 0x00, 0x04, 0x40, 0x01, 0x04, 0x00, 0x60, 0x60, 0x38, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x20, 0x08, 0x7F, 0xC1, 0x18, 0x0E, 0x2C, 0x00,
  0x67, 0x00, 0x06, 0xC0, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x01, 0xA0, 0x00, 0x26, 0x00, 0x0C, 0x60, 0x01,
  0x06, 0x00, 0x60, 0x60, 0x38, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x38, 0x38, 0x06, 0x00, 0x60, 0x60, 0x00, 0x82, 0x00, 0x06,
  0x30, 0x00, 0x11, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00,
  0x00, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0x42, 0x00, 0x06, 0x08, 0x00, 0x60,
  0x30, 0x06, 0x00, 0xF3, 0xC0, 0x03, 0xFC, 0x00, 0x70, 0x1C, 0x06, 0x00,
  0x30, 0x40, 0x00, 0xC4, 0x00, 0x03, 0x20, 0x00, 0x0A, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x24, 0x00, 0x03, 0x30, 0x00, 0x10, 0xC0, 0x03, 0x01, 0x80, 0x70, 0x07,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0xE0, 0xE0, 0x18, 0x03, 0x03, 0x00, 0x18,
  0x60, 0x00, 0xC4, 0x00, 0x04, 0x40, 0x00, 0x6C, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x76, 0x00, 0x07, 0x20,
  0x00, 0xB3, 0x00, 0x12, 0x0C, 0x06, 0x20, 0x7F, 0xC2, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x0F, 0xE0,
  0x00, 0xBC, 0x00, 0x00, 0x00, 0x00, 0xBC, 0x23, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x22, 0x26, 0x4C, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xF0, 0x18, 0x18, 0x30, 0x04, 0x40, 0x02, 0xC0,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x78, 0x38, 0x00, 0x60, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0x20, 0x60, 0x00, 0x18, 0x60, 0x00, 0x04, 0x20, 0x3F, 0x03, 0x30, 0x30,
  0xC1, 0x90, 0x30, 0x20, 0x58, 0x10, 0x10, 0x28, 0x10, 0x08, 0x14, 0x08,
  0x04, 0x0A, 0x0C, 0x02, 0x05, 0x04, 0x01, 0x03, 0x82, 0x01, 0x81, 0xC1,
  0x00, 0x80, 0xC0, 0x80, 0x40, 0x60, 0x40, 0x20, 0x30, 0x20, 0x10, 0x1C,
  0x10, 0x18, 0x0E, 0x08, 0x0C, 0x0F, 0x04, 0x0E, 0x04, 0x82, 0x05, 0x02,
  0x40, 0x86, 0xC2, 0x30, 0x7E, 0x3E, 0x18, 0x1C, 0x06, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x07, 0x01,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x80, 0x00, 0x31,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x86, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08,
  0x00, 0x08, 0x18, 0x00, 0x30, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x60,
  0x03, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0x30, 0x01, 0x00,
  0x40, 0x02, 0x00, 0x80, 0x04, 0x03, 0x00, 0x04, 0x07, 0xFF, 0xF8, 0x08,
  0x00, 0x10, 0x10, 0x00, 0x30, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x03, 0x40, 0x00,
  0x02, 0x80, 0x00, 0x06, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x80, 0x06, 0x08,
  0x00, 0x10, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00,
  0x88, 0x00, 0x10, 0x80, 0x06, 0x08, 0x07, 0xC0, 0xFF, 0xFC, 0x08, 0x00,
  0x70, 0x80, 0x01, 0x88, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0xE0,
  0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x1C, 0x03, 0x00, 0x30, 0x10,
  0x00, 0xC1, 0x00, 0x02, 0x18, 0x00, 0x18, 0x80, 0x00, 0x4C, 0x00, 0x03,
  0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x01, 0x40, 0x00, 0x0B, 0x00, 0x00, 0xC8,
  0x00, 0x04, 0x40, 0x00, 0x21, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x30, 0x03,
  0x00, 0xC0, 0x30, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x30,
  0x01, 0x81, 0x80, 0x02, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x23, 0x00, 0x01,
  0x98, 0x00, 0x04, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x16,
  0x00, 0x01, 0x30, 0x00, 0x09, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x60, 0x00,
  0xC3, 0x00, 0x1C, 0x18, 0x03, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0x90, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x1C,
  0x03, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x00, 0x03, 0x10, 0x00, 0x08, 0x80,
  0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x07, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00,
  0x0A, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x11, 0x00, 0x00, 0x8C,
  0x00, 0x04, 0x30, 0x00, 0xC0, 0xE0, 0x1C, 0x01, 0xFF, 0x80, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00,
  0x42, 0x00, 0x08, 0x30, 0x01, 0x81, 0xC0, 0x70, 0x07, 0xFC, 0x00, 0x80,
  0x00, 0x14, 0x00, 0x01, 0x20, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x18,
  0x40, 0x01, 0x82, 0x00, 0x18, 0x10, 0x01, 0x80, 0x80, 0x18, 0x04, 0x01,
  0x80, 0x20, 0x18, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0x80, 0x02,
  0x08, 0x00, 0x10, 0xC0, 0x00, 0x89, 0x00, 0x04, 0x8C, 0x00, 0x28, 0x30,
  0x01, 0x80, 0xC0, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x60, 0x10,
  0x01, 0x80, 0x80, 0x06, 0x04, 0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x03,
  0x08, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x02, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x7A, 0x00, 0x05, 0xB0, 0x00, 0xD9, 0x00, 0x09,
  0x90, 0x00, 0x99, 0x80, 0x19, 0x88, 0x01, 0x18, 0x80, 0x31, 0x84, 0x02,
  0x18, 0x40, 0x21, 0x86, 0x04, 0x18, 0x20, 0x41, 0x82, 0x0C, 0x18, 0x10,
  0x81, 0x81, 0x08, 0x18, 0x19, 0x01, 0x80, 0x90, 0x18, 0x0B, 0x01, 0x80,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3A, 0x00, 0x03, 0xB0, 0x00, 0x39, 0x00, 0x03, 0x98,
  0x00, 0x38, 0x80, 0x03, 0x84, 0x00, 0x38, 0x40, 0x03, 0x82, 0x00, 0x38,
  0x30, 0x03, 0x81, 0x00, 0x38, 0x18, 0x03, 0x80, 0x80, 0x38, 0x04, 0x03,
  0x80, 0x40, 0x38, 0x02, 0x03, 0x80, 0x20, 0x38, 0x01, 0x03, 0x80, 0x18,
  0x38, 0x00, 0x83, 0x80, 0x04, 0x38, 0x00, 0x43, 0x80, 0x02, 0x38, 0x00,
  0x23, 0x80, 0x01, 0x38, 0x00, 0x1B, 0x80, 0x00, 0xB8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x30, 0x01, 0xFC, 0x00, 0x18, 0x38,
  0x03, 0x00, 0x60, 0x30, 0x00, 0x81, 0x00, 0x06, 0x18, 0x00, 0x10, 0x80,
  0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x50, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00,
  0x1B, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x61, 0x00, 0x02, 0x0C,
  0x00, 0x20, 0x30, 0x03, 0x00, 0xC0, 0x70, 0x01, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x2C,
  0x00, 0x04, 0xC0, 0x01, 0xCC, 0x00, 0x70, 0xFF, 0xFC, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1C, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20, 0x80,
  0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x26, 0x00, 0x01, 0x88,
  0x00, 0x04, 0x30, 0x00, 0x30, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0x80,
  0x60, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x80, 0x06, 0x08, 0x00, 0x10, 0x80, 0x00, 0x88, 0x00, 0x0C,
  0x80, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00,
  0x18, 0x80, 0x03, 0x08, 0x00, 0xC0, 0xFF, 0xF0, 0x08, 0x01, 0x80, 0x80,
  0x08, 0x08, 0x00, 0xC0, 0x80, 0x04, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x04,
  0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x10, 0x01, 0xFE, 0x00, 0x1C,
  0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00,
  0x62, 0x00, 0x00, 0x98, 0x00, 0x02, 0x60, 0x00, 0x08, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD8, 0x00,
  0x02, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x41, 0x80, 0x03, 0x01, 0x80, 0x30,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00, 0x43, 0x00,
  0x0C, 0x18, 0x01, 0x80, 0xC0, 0x70, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x13, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x30,
  0x00, 0x20, 0x20, 0x00, 0xC0, 0x40, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x80,
  0x0C, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x01,
  0x00, 0x0C, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x20, 0x40, 0x00, 0x41, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x84, 0x00,
  0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x02, 0x40, 0x00, 0x05, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x80, 0x08, 0x01, 0xC0,
  0x08, 0x01, 0x40, 0x18, 0x01, 0x40, 0x1C, 0x01, 0x40, 0x1C, 0x01, 0x40,
  0x14, 0x03, 0x40, 0x14, 0x02, 0x40, 0x34, 0x02, 0x60, 0x26, 0x02, 0x20,
  0x26, 0x02, 0x20, 0x22, 0x02, 0x20, 0x22, 0x06, 0x20, 0x62, 0x04, 0x20,
  0x43, 0x04, 0x30, 0x43, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0xC1, 0x04, 0x10, 0x81, 0x08, 0x10, 0x81, 0x88, 0x18, 0x80, 0x88, 0x08,
  0x80, 0x88, 0x09, 0x80, 0x88, 0x09, 0x00, 0x88, 0x09, 0x00, 0xD0, 0x09,
  0x00, 0x50, 0x0D, 0x00, 0x50, 0x07, 0x00, 0x50, 0x06, 0x00, 0x50, 0x06,
  0x00, 0x50, 0x06, 0x00, 0x30, 0x06, 0x00, 0x20, 0x06, 0x00, 0x20, 0xC0,
  0x00, 0x04, 0x80, 0x00, 0x10, 0x80, 0x00, 0x61, 0x80, 0x00, 0x81, 0x00,
  0x03, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x80, 0x06, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x40,
  0x00, 0x09, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x20, 0x00, 0x06, 0x20, 0x00, 0x08, 0x60, 0x00,
  0x30, 0x40, 0x00, 0x40, 0x40, 0x01, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x20, 0x01, 0x00, 0xC0, 0x01, 0x01, 0x00, 0x03, 0x04, 0x00,
  0x02, 0x18, 0x00, 0x02, 0x20, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0x80, 0x00, 0x09, 0x80, 0x00, 0x31, 0x00, 0x00, 0x43, 0x00, 0x01,
  0x82, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x0C, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x18, 0x02, 0x00, 0x10, 0x04, 0x00, 0x10, 0x10, 0x00,
  0x20, 0x20, 0x00, 0x20, 0x80, 0x00, 0x43, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x98, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x3F, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x0F, 0xF0, 0x01, 0x00, 0x01, 0x80, 0x03, 0x80, 0x02, 0xC0,
  0x06, 0x40, 0x04, 0x60, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x30, 0x18, 0x10,
  0x10, 0x18, 0x10, 0x08, 0x20, 0x08, 0x20, 0x0C, 0x60, 0x04, 0x40, 0x06,
  0x40, 0x02, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0xC1, 0x82, 0x04, 0x18, 0x30,
  0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1C, 0x01, 0x83, 0x00, 0x0C, 0x20, 0x00,
  0x44, 0x00, 0x06, 0x40, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x07, 0xFF, 0xE1, 0xC0, 0x02, 0x30,
  0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x06, 0xC0, 0x00, 0xE4, 0x00, 0x1A, 0x60, 0x03, 0x23, 0x00, 0xE2,
  0x0F, 0xF8, 0x30, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x07, 0x80, 0x43, 0xFE, 0x09, 0x80, 0x61, 0x60, 0x06,
  0x38, 0x00, 0x66, 0x00, 0x04, 0xC0, 0x00, 0xD0, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05,
  0x00, 0x01, 0x30, 0x00, 0x27, 0x00, 0x08, 0xB0, 0x03, 0x13, 0x81, 0xC2,
  0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFB, 0xC0, 0x30, 0x0C, 0x0C, 0x00,
  0x43, 0x00, 0x04, 0x40, 0x00, 0xD0, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0xB0, 0x00, 0x12, 0x00, 0x06, 0x60, 0x00, 0x86, 0x00, 0x20, 0x70, 0x18,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x07, 0xC1, 0x83, 0xDE, 0x30, 0xC0, 0x66, 0x20, 0x02,
  0xC8, 0x00, 0x3B, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x06,
  0x80, 0x00, 0xC8, 0x00, 0x19, 0x80, 0x07, 0x18, 0x01, 0x61, 0x80, 0xCC,
  0x1F, 0xF1, 0x80, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x0C, 0x03, 0x01, 0x80,
  0x08, 0x30, 0x00, 0x42, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x02, 0x18, 0x00,
  0x40, 0x60, 0x18, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0x81, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFC,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xF7, 0x8C, 0x30, 0x19, 0x88, 0x00, 0xB2, 0x00, 0x0E, 0xC0, 0x00,
  0xD0, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x32, 0x00, 0x06,
  0x60, 0x01, 0xC6, 0x00, 0x78, 0x60, 0x33, 0x07, 0xFC, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x98, 0x00, 0x21,
  0x80, 0x08, 0x18, 0x03, 0x00, 0xF7, 0x80, 0x07, 0xC0, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x07, 0x02, 0x1E,
  0x78, 0x8C, 0x03, 0x26, 0x00, 0x6B, 0x00, 0x0A, 0x80, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x62,
  0x1E, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x06, 0x80, 0x03, 0x20, 0x01, 0x08,
  0x01, 0x82, 0x00, 0xC0, 0x80, 0x60, 0x20, 0x30, 0x08, 0x18, 0x02, 0x0C,
  0x00, 0x84, 0x00, 0x27, 0x00, 0x0B, 0x60, 0x03, 0x8C, 0x00, 0xC1, 0x80,
  0x20, 0x30, 0x08, 0x06, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x02, 0x08,
  0x00, 0x42, 0x00, 0x08, 0x80, 0x03, 0x20, 0x00, 0x68, 0x00, 0x0C, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0xF0, 0x9D, 0xE3, 0xDC, 0xB0, 0x26, 0x06, 0xE0, 0x1C, 0x02, 0xC0,
  0x18, 0x02, 0xC0, 0x18, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x70, 0x21, 0xE7, 0x88, 0xC0, 0x32, 0x60, 0x06, 0xA0,
  0x00, 0xB8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0xF8, 0x00, 0x1E, 0xF8, 0x03, 0x80, 0x60, 0x30, 0x01, 0x81, 0x00, 0x06,
  0x10, 0x00, 0x19, 0x80, 0x00, 0x48, 0x00, 0x03, 0x40, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00,
  0x04, 0x40, 0x00, 0x23, 0x00, 0x03, 0x08, 0x00, 0x30, 0x30, 0x03, 0x00,
  0xC0, 0x70, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x11, 0xFF, 0x82, 0x60, 0x18,
  0x58, 0x01, 0x8E, 0x00, 0x19, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x03, 0x40, 0x00, 0x4C, 0x00, 0x09, 0xC0, 0x02, 0x2C, 0x00, 0xC4,
  0xC0, 0x70, 0x87, 0xF8, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xF7, 0x8C, 0x70, 0x19, 0x88, 0x00, 0xB2,
  0x00, 0x0E, 0xC0, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00, 0x01, 0xA0,
  0x00, 0x32, 0x00, 0x06, 0x60, 0x01, 0xC6, 0x00, 0x78, 0x60, 0x33, 0x07,
  0xFC, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x7F, 0x07, 0xCE, 0x38, 0x04, 0xC0, 0x0B, 0x00, 0x14, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x01, 0xE0,
  0x01, 0xF7, 0xC0, 0xC0, 0x0C, 0x30, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00,
  0xB0, 0x00, 0x1A, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x98, 0x00, 0x21, 0xC0, 0x18, 0x0F, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x07, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF8,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x01, 0x48,
  0x00, 0x91, 0x80, 0xC4, 0x3F, 0xE1, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x24,
  0x00, 0x01, 0x98, 0x00, 0x04, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x81, 0x00,
  0x02, 0x04, 0x00, 0x18, 0x18, 0x00, 0x40, 0x20, 0x03, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x60, 0x06, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x20, 0x00,
  0xC0, 0x80, 0x01, 0x06, 0x00, 0x06, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x32,
  0x00, 0x00, 0x58, 0x00, 0x01, 0x40, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x18, 0x03, 0x40, 0x3C, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x60, 0x24, 0x06, 0x20, 0x66, 0x04,
  0x20, 0x46, 0x04, 0x20, 0x42, 0x04, 0x30, 0x42, 0x04, 0x30, 0xC3, 0x0C,
  0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x19, 0x81, 0x98,
  0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x0B, 0x00, 0xD0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x10, 0x04,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x30, 0x30, 0x00, 0x61, 0x80, 0x00, 0xC4,
  0x00, 0x01, 0x30, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x61, 0x80, 0x03, 0x03, 0x00, 0x08,
  0x06, 0x00, 0x40, 0x08, 0x03, 0x00, 0x10, 0x18, 0x00, 0x60, 0xC0, 0x00,
  0xC2, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x10, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x20,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x80,
  0x01, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x4F, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x60, 0xE0, 0x01, 0x40,
  0x30, 0x03, 0x80, 0x18, 0x02, 0x80, 0x0C, 0x06, 0x80, 0x07, 0x0C, 0x80,
  0x01, 0xF8,
};

const GFXglyph RobotoMono_Thin46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 3, 33, 28, 12, -33 },
  { 14, 7, 10, 28, 10, -35 },
  { 23, 25, 33, 28, 1, -33 },
  { 127, 20, 42, 28, 4, -37 },
  { 232, 26, 33, 28, 1, -33 },
  { 340, 22, 33, 28, 4, -33 },
  { 431, 2, 10, 28, 12, -35 },
  { 434, 10, 47, 28, 9, -36 },
  { 493, 10, 47, 28, 8, -36 },
  { 552, 19, 18, 28, 5, -33 },
  { 595, 22, 24, 28, 3, -27 },
  { 661, 4, 10, 28, 9, -4 },
  { 666, 16, 2, 28, 6, -16 },
  { 670, 3, 3, 28, 13, -3 },
  { 672, 15, 36, 28, 7, -33 },
  { 740, 20, 33, 28, 4, -33 },
  { 823, 11, 33, 28, 5, -33 },
  { 869, 20, 33, 28, 3, -33 },
  { 952, 21, 33, 28, 2, -33 },
  { 1039, 23, 33, 28, 2, -33 },
  { 1134, 19, 33, 28, 5, -33 },
  { 1213, 19, 33, 28, 4, -33 },
  { 1292, 21, 33, 28, 3, -33 },
  { 1379, 21, 33, 28, 4, -33 },
  { 1466, 20, 33, 28, 4, -33 },
  { 1549, 2, 23, 28, 15, -23 },
  { 1555, 4, 29, 28, 13, -23 },
  { 1570, 19, 18, 28, 4, -24 },
  { 1613, 20, 10, 28, 4, -20 },
  { 1638, 20, 18, 28, 4, -24 },
  { 1683, 16, 33, 28, 6, -33 },
  { 1749, 25, 33, 28, 1, -33 },
  { 1853, 23, 33, 28, 3, -33 },
  { 1948, 20, 33, 28, 5, -33 },
  { 2031, 21, 33, 28, 3, -33 },
  { 2118, 21, 33, 28, 4, -33 },
  { 2205, 18, 33, 28, 5, -33 },
  { 2280, 19, 33, 28, 5, -33 },
  { 2359, 21, 33, 28, 3, -33 },
  { 2446, 20, 33, 28, 4, -33 },
  { 2529, 18, 33, 28, 5, -33 },
  { 2604, 20, 33, 28, 3, -33 },
  { 2687, 21, 33, 28, 5, -33 },
  { 2774, 19, 33, 28, 5, -33 },
  { 2853, 20, 33, 28, 4, -33 },
  { 2936, 20, 33, 28, 4, -33 },
  { 3019, 21, 33, 28, 3, -33 },
  { 3106, 20, 33, 28, 5, -33 },
  { 3189, 22, 39, 28, 3, -33 },
  { 3297, 20, 33, 28, 5, -33 },
  { 3380, 22, 33, 28, 3, -33 },
  { 3471, 22, 33, 28, 3, -33 },
  { 3562, 20, 33, 28, 4, -33 },
  { 3645, 23, 33, 28, 2, -33 },
  { 3740, 24, 33, 28, 2, -33 },
  { 3839, 23, 33, 28, 3, -33 },
  { 3934, 23, 33, 28, 2, -33 },
  { 4029, 20, 33, 28, 3, -33 },
  { 4112, 6, 44, 28, 11, -37 },
  { 4145, 15, 36, 28, 6, -33 },
  { 4213, 7, 44, 28, 10, -37 },
  { 4252, 16, 18, 28, 6, -33 },
  { 4288, 19, 1, 28, 4, 0 },
  { 4291, 6, 6, 28, 11, -34 },
  { 4296, 20, 25, 28, 4, -25 },
  { 4359, 19, 35, 28, 5, -35 },
  { 4443, 19, 25, 28, 4, -25 },
  { 4503, 19, 35, 28, 4, -35 },
  { 4587, 20, 25, 28, 4, -25 },
  { 4650, 20, 35, 28, 5, -35 },
  { 4738, 19, 35, 28, 4, -25 },
  { 4822, 18, 35, 28, 5, -35 },
  { 4901, 19, 33, 28, 5, -33 },
  { 4980, 14, 43, 28, 4, -33 },
  { 5056, 18, 35, 28, 6, -35 },
  { 5135, 19, 35, 28, 5, -35 },
  { 5219, 24, 25, 28, 2, -25 },
  { 5294, 18, 25, 28, 5, -25 },
  { 5351, 21, 25, 28, 3, -25 },
  { 5417, 19, 34, 28, 5, -25 },
  { 5498, 19, 34, 28, 4, -25 },
  { 5579, 15, 25, 28, 9, -25 },
  { 5626, 19, 25, 28, 5, -25 },
  { 5686, 19, 31, 28, 4, -31 },
  { 5760, 18, 24, 28, 5, -24 },
  { 5814, 22, 24, 28, 3, -24 },
  { 5880, 24, 24, 28, 2, -24 },
  { 5952, 22, 24, 28, 3, -24 },
  { 6018, 24, 34, 28, 2, -24 },
  { 6120, 22, 24, 28, 3, -24 },
  { 6186, 14, 46, 28, 8, -36 },
  { 6267, 1, 39, 28, 13, -33 },
  { 6272, 14, 46, 28, 8, -36 },
  { 6353, 24, 7, 28, 2, -17 },
};

const GFXfont RobotoMono_Thin46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin46pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_THIN46PT7B_H_
