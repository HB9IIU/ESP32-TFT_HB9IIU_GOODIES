#ifndef _ROBOTOMONO_THIN28PT7B_H_
#define _ROBOTOMONO_THIN28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin28pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x54, 0x03, 0x99, 0x99, 0x99, 0x02, 0x08, 0x04,
  0x10, 0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x1F, 0xFF, 0x82, 0x10,
  0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x84, 0x01, 0x08, 0x3D,
  0xFF, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x00, 0x04,
  0x00, 0x40, 0x04, 0x01, 0xF8, 0x20, 0x44, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x24, 0x04, 0x3F, 0x80, 0x20, 0x02,
  0x00, 0x20, 0x78, 0x01, 0x08, 0x02, 0x10, 0x44, 0x21, 0x08, 0x42, 0x10,
  0x88, 0x21, 0x10, 0x42, 0x40, 0x78, 0x80, 0x02, 0x00, 0x04, 0x00, 0x11,
  0xC0, 0x24, 0x40, 0x88, 0x42, 0x10, 0x84, 0x41, 0x10, 0x82, 0x20, 0x84,
  0x01, 0x08, 0x01, 0xE0, 0x0F, 0x00, 0x42, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x80, 0x82, 0x02, 0x10, 0x04, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x40, 0x08,
  0x82, 0x41, 0x0A, 0x02, 0x28, 0x04, 0xA0, 0x12, 0x80, 0x31, 0x00, 0xC6,
  0x04, 0x87, 0xE1, 0xFC, 0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x41, 0x08, 0x21, 0x04, 0x10, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x42, 0x08, 0x20, 0x84, 0x10, 0x84, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x41, 0xE4, 0x61, 0xF8, 0x06, 0x00, 0x90, 0x11, 0x82, 0x08, 0x20, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x56,
  0x80, 0xFF, 0xC0, 0xB0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x04, 0x00, 0x0F, 0x81, 0x82, 0x08, 0x08, 0x80, 0x24,
  0x01, 0x40, 0x0A, 0x00, 0xB0, 0x09, 0x80, 0x8C, 0x08, 0x60, 0x83, 0x08,
  0x18, 0x80, 0xC8, 0x06, 0x80, 0x48, 0x02, 0x40, 0x11, 0x01, 0x0C, 0x18,
  0x1F, 0x00, 0x06, 0x35, 0x8C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x04, 0x0C, 0x80,
  0x48, 0x02, 0x80, 0x28, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x0F, 0xFF, 0x0F, 0xC1, 0x81, 0x08, 0x04, 0x80, 0x24, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x3E, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00,
  0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x88, 0x08, 0x3F, 0x80, 0x00,
  0x60, 0x01, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x42, 0x01,
  0x08, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x8F,
  0xFF, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x3F, 0xE4,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0xE0, 0x71, 0x84,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x24,
  0x02, 0x20, 0x41, 0xF8, 0x03, 0xC0, 0xC0, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0xF8, 0xB0, 0x4C, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x20, 0x61, 0xF8, 0xFF, 0xF8,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x00, 0x0F, 0xC1, 0x81, 0x08, 0x04,
  0x80, 0x24, 0x00, 0xA0, 0x05, 0x00, 0x44, 0x02, 0x30, 0x20, 0x7E, 0x06,
  0x18, 0x40, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00,
  0x88, 0x0C, 0x3F, 0x80, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x03, 0x10, 0xD0,
  0xF1, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x01, 0x81, 0xE0, 0xC0, 0x0C,
  0x50, 0x00, 0x00, 0x55, 0x80, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x80, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x00, 0x00,
  0x1F, 0x04, 0x11, 0x01, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x10, 0x30, 0x40, 0x11, 0x00, 0x24,
  0x3C, 0x28, 0x84, 0x61, 0x08, 0xC4, 0x11, 0x88, 0x23, 0x10, 0x86, 0x21,
  0x0C, 0x82, 0x18, 0x84, 0x31, 0x18, 0xA2, 0x31, 0x43, 0x9C, 0x40, 0x00,
  0x80, 0x00, 0xC0, 0x40, 0x7F, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x50, 0x01,
  0x40, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x10, 0x10, 0x40, 0x41, 0x01,
  0x02, 0x08, 0x08, 0x20, 0x20, 0xFF, 0x84, 0x01, 0x10, 0x04, 0x40, 0x0A,
  0x00, 0x28, 0x00, 0xA0, 0x01, 0xFF, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0xCF, 0xF0, 0x80, 0xC8, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x4F, 0xF8, 0x0F,
  0x81, 0x83, 0x08, 0x04, 0x80, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x28,
  0x01, 0x40, 0x11, 0x00, 0x88, 0x08, 0x3F, 0x80, 0xFE, 0x08, 0x18, 0x80,
  0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x81,
  0x8F, 0xE0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x0F, 0x81,
  0x83, 0x08, 0x04, 0x80, 0x28, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x40, 0x09, 0x00, 0x4C, 0x04, 0x1F, 0xC0, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x7F, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x28, 0x02, 0x40, 0x43, 0xF8, 0x80,
  0x14, 0x01, 0x20, 0x11, 0x01, 0x08, 0x10, 0x41, 0x82, 0x08, 0x10, 0x80,
  0x88, 0x04, 0xC0, 0x2A, 0x01, 0x88, 0x08, 0x20, 0x40, 0x82, 0x02, 0x10,
  0x10, 0x80, 0x44, 0x01, 0x20, 0x05, 0x00, 0x10, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0x80, 0x38, 0x03, 0xC0, 0x5C, 0x05, 0xC0, 0x5A, 0x09, 0xA0,
  0x99, 0x11, 0x91, 0x19, 0x11, 0x8A, 0x18, 0xA1, 0x84, 0x18, 0x41, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xA0,
  0x1A, 0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0x81, 0x84, 0x18, 0x21, 0x82,
  0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x98, 0x05, 0x80, 0x38, 0x03, 0x80,
  0x18, 0x01, 0x0F, 0x81, 0x82, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x02, 0x40, 0x12, 0x01, 0x08, 0x10, 0x3F, 0x00, 0xFF,
  0x88, 0x04, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x02, 0x80, 0xCF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x81, 0x83, 0x10, 0x04, 0x80, 0x28,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x12, 0x00, 0x88, 0x08,
  0x3F, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFF, 0x08, 0x0C, 0x80,
  0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x81,
  0x8F, 0xF0, 0x81, 0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80,
  0x18, 0x01, 0x1F, 0xC1, 0x01, 0x10, 0x04, 0x80, 0x24, 0x00, 0xA0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x70, 0x00, 0x70, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x48, 0x0C, 0x3F, 0x80, 0xFF,
  0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x14, 0x02, 0x20,
  0x61, 0xF8, 0x80, 0x05, 0x00, 0x14, 0x00, 0x50, 0x02, 0x20, 0x08, 0x80,
  0x22, 0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x80, 0x82, 0x02, 0x08, 0x08,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x30, 0x00,
  0x40, 0x81, 0x03, 0x02, 0x05, 0x06, 0x0A, 0x0C, 0x14, 0x28, 0x48, 0x50,
  0x90, 0xA1, 0x21, 0x22, 0x22, 0x44, 0x48, 0x88, 0x91, 0x11, 0x22, 0x42,
  0x42, 0x84, 0x85, 0x0A, 0x0A, 0x0C, 0x14, 0x18, 0x28, 0x30, 0x20, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x09, 0x00, 0x24, 0x01, 0x08, 0x08, 0x10, 0x20,
  0x41, 0x00, 0x88, 0x01, 0x20, 0x05, 0x00, 0x08, 0x00, 0x30, 0x01, 0x40,
  0x08, 0x80, 0x21, 0x01, 0x04, 0x04, 0x08, 0x20, 0x21, 0x00, 0x44, 0x00,
  0xA0, 0x03, 0x80, 0x05, 0x00, 0x24, 0x00, 0x88, 0x04, 0x20, 0x10, 0x40,
  0x80, 0x82, 0x02, 0x10, 0x04, 0x40, 0x12, 0x00, 0x28, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0xFF, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0,
  0x08, 0x0C, 0x05, 0x02, 0x82, 0x21, 0x11, 0x04, 0x82, 0x81, 0x40, 0x60,
  0x20, 0xFF, 0xE0, 0x89, 0x10, 0x1F, 0x0C, 0x1A, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x09, 0xFF, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x01,
  0x5F, 0xC8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0xC5,
  0x04, 0xC0, 0x50, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x70, 0x69, 0xF0, 0x0F, 0x81, 0x06, 0x20, 0x24,
  0x01, 0x40, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x01, 0x20, 0x13, 0x02, 0x0F, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x0F, 0x93, 0x05, 0x20, 0x34, 0x01, 0x40, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x40, 0x32, 0x05,
  0x1F, 0x90, 0x0F, 0x80, 0x83, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x07,
  0xFF, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x18, 0x3F, 0x00, 0x03, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0xFF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0x93, 0x05, 0x20, 0x34, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x14, 0x01, 0x40, 0x32, 0x05, 0x1F, 0x90, 0x01, 0x00,
  0x10, 0x02, 0x40, 0x23, 0x04, 0x0F, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x23, 0xE5, 0x82, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x7E, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x14, 0x04, 0x81,
  0x10, 0x42, 0x20, 0x48, 0x0A, 0x01, 0xA0, 0x22, 0x04, 0x20, 0x82, 0x10,
  0x22, 0x02, 0x40, 0x68, 0x06, 0xFC, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF,
  0xF0, 0xBC, 0x79, 0x85, 0x0A, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x60, 0x40, 0x80, 0x8F, 0x96, 0x0B, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x0F, 0x81, 0x83, 0x10, 0x08, 0x80, 0x28, 0x01, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x24, 0x01,
  0x10, 0x10, 0x7F, 0x00, 0x9F, 0x14, 0x13, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x05, 0x81, 0xAF,
  0xC4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x0F, 0x93, 0x05,
  0x20, 0x34, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x32, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x8F, 0xE4, 0x0A, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00,
  0x1F, 0x8C, 0x0A, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x78, 0x00,
  0xC0, 0x04, 0x00, 0xC0, 0x18, 0x02, 0x80, 0xCF, 0xE0, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x0F, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x1F, 0x80,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x81, 0x4F, 0xC8, 0x80, 0x0C, 0x00,
  0x60, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0x80, 0x82, 0x08, 0x10, 0x40,
  0x44, 0x02, 0x20, 0x12, 0x00, 0x50, 0x03, 0x00, 0x08, 0x00, 0x81, 0x03,
  0x02, 0x06, 0x0A, 0x0A, 0x14, 0x24, 0x28, 0x48, 0x50, 0x91, 0x11, 0x12,
  0x24, 0x24, 0x48, 0x48, 0x90, 0xA0, 0xA0, 0xC1, 0x41, 0x83, 0x03, 0x06,
  0x04, 0x04, 0x00, 0xC0, 0x0A, 0x00, 0x88, 0x08, 0x20, 0x80, 0x88, 0x02,
  0x40, 0x14, 0x00, 0x40, 0x05, 0x00, 0x44, 0x02, 0x10, 0x20, 0x82, 0x02,
  0x20, 0x0A, 0x00, 0x20, 0x80, 0x02, 0x80, 0x09, 0x00, 0x11, 0x00, 0x42,
  0x00, 0x82, 0x02, 0x04, 0x04, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x11,
  0x00, 0x22, 0x00, 0x28, 0x00, 0x50, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x60, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0xFF, 0xE0, 0x01, 0x01, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x02,
  0x03, 0x00, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x18,
  0x0E, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x18, 0x10, 0x00, 0x38, 0x00, 0x8C, 0x06, 0x04, 0x0C, 0x04, 0x28,
  0x07, 0x80,
};

const GFXglyph RobotoMono_Thin28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 2, 20, 17, 7, -20 },
  { 6, 4, 6, 17, 6, -21 },
  { 9, 15, 20, 17, 1, -20 },
  { 47, 12, 26, 17, 3, -23 },
  { 86, 15, 20, 17, 1, -20 },
  { 124, 14, 20, 17, 2, -20 },
  { 159, 1, 6, 17, 7, -21 },
  { 160, 5, 28, 17, 6, -22 },
  { 178, 6, 28, 17, 5, -22 },
  { 199, 12, 11, 17, 3, -20 },
  { 216, 13, 14, 17, 2, -16 },
  { 239, 2, 5, 17, 6, -2 },
  { 241, 10, 1, 17, 3, -10 },
  { 243, 2, 2, 17, 8, -2 },
  { 244, 9, 22, 17, 4, -20 },
  { 269, 13, 20, 17, 2, -20 },
  { 302, 7, 20, 17, 3, -20 },
  { 320, 12, 20, 17, 2, -20 },
  { 350, 13, 20, 17, 1, -20 },
  { 383, 14, 20, 17, 1, -20 },
  { 418, 12, 20, 17, 3, -20 },
  { 448, 12, 20, 17, 2, -20 },
  { 478, 13, 20, 17, 2, -20 },
  { 511, 13, 20, 17, 2, -20 },
  { 544, 12, 20, 17, 2, -20 },
  { 574, 1, 14, 17, 9, -14 },
  { 576, 2, 17, 17, 8, -14 },
  { 581, 12, 11, 17, 2, -15 },
  { 598, 13, 6, 17, 2, -12 },
  { 608, 11, 11, 17, 3, -15 },
  { 624, 11, 20, 17, 3, -20 },
  { 652, 15, 20, 17, 1, -20 },
  { 690, 14, 20, 17, 2, -20 },
  { 725, 12, 20, 17, 3, -20 },
  { 755, 13, 20, 17, 2, -20 },
  { 788, 12, 20, 17, 3, -20 },
  { 818, 11, 20, 17, 3, -20 },
  { 846, 11, 20, 17, 3, -20 },
  { 874, 13, 20, 17, 2, -20 },
  { 907, 12, 20, 17, 2, -20 },
  { 937, 11, 20, 17, 3, -20 },
  { 965, 12, 20, 17, 2, -20 },
  { 995, 13, 20, 17, 3, -20 },
  { 1028, 12, 20, 17, 3, -20 },
  { 1058, 12, 20, 17, 3, -20 },
  { 1088, 12, 20, 17, 2, -20 },
  { 1118, 13, 20, 17, 2, -20 },
  { 1151, 12, 20, 17, 3, -20 },
  { 1181, 13, 24, 17, 2, -20 },
  { 1220, 12, 20, 17, 3, -20 },
  { 1250, 13, 20, 17, 2, -20 },
  { 1283, 13, 20, 17, 2, -20 },
  { 1316, 12, 20, 17, 2, -20 },
  { 1346, 14, 20, 17, 1, -20 },
  { 1381, 15, 20, 17, 1, -20 },
  { 1419, 14, 20, 17, 2, -20 },
  { 1454, 14, 20, 17, 1, -20 },
  { 1489, 12, 20, 17, 2, -20 },
  { 1519, 4, 27, 17, 7, -23 },
  { 1533, 9, 22, 17, 4, -20 },
  { 1558, 4, 27, 17, 6, -23 },
  { 1572, 9, 11, 17, 4, -20 },
  { 1585, 11, 1, 17, 3, 0 },
  { 1587, 3, 4, 17, 7, -21 },
  { 1589, 11, 15, 17, 3, -15 },
  { 1610, 11, 21, 17, 3, -21 },
  { 1639, 12, 15, 17, 2, -15 },
  { 1662, 12, 21, 17, 2, -21 },
  { 1694, 13, 15, 17, 2, -15 },
  { 1719, 12, 21, 17, 3, -21 },
  { 1751, 12, 21, 17, 2, -15 },
  { 1783, 11, 21, 17, 3, -21 },
  { 1812, 12, 20, 17, 3, -20 },
  { 1842, 9, 26, 17, 2, -20 },
  { 1872, 11, 21, 17, 4, -21 },
  { 1901, 12, 21, 17, 3, -21 },
  { 1933, 15, 15, 17, 1, -15 },
  { 1962, 11, 15, 17, 3, -15 },
  { 1983, 13, 15, 17, 2, -15 },
  { 2008, 11, 21, 17, 3, -15 },
  { 2037, 12, 21, 17, 2, -15 },
  { 2069, 10, 15, 17, 5, -15 },
  { 2088, 11, 15, 17, 3, -15 },
  { 2109, 11, 19, 17, 3, -19 },
  { 2136, 11, 15, 17, 3, -15 },
  { 2157, 13, 15, 17, 2, -15 },
  { 2182, 15, 15, 17, 1, -15 },
  { 2211, 13, 15, 17, 2, -15 },
  { 2236, 15, 21, 17, 1, -15 },
  { 2276, 13, 15, 17, 2, -15 },
  { 2301, 9, 28, 17, 5, -22 },
  { 2333, 1, 24, 17, 8, -20 },
  { 2336, 9, 28, 17, 5, -22 },
  { 2368, 15, 5, 17, 1, -11 },
};

const GFXfont RobotoMono_Thin28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin28pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_THIN28PT7B_H_
