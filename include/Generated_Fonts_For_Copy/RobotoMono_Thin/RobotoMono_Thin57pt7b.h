#ifndef _ROBOTOMONO_THIN57PT7B_H_
#define _ROBOTOMONO_THIN57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin57pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x83, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x08,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x80, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x80, 0x00, 0x10, 0x01, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x40, 0x00, 0x08, 0x01, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x10, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0x87, 0x80, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x1C,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x02, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x06, 0x00, 0x03, 0x81, 0xC0,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x40,
  0x08, 0x00, 0x80, 0xC0, 0x08, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x04, 0x00, 0xC0,
  0x08, 0x0C, 0x00, 0xC0, 0x08, 0x08, 0x00, 0x40, 0x08, 0x18, 0x00, 0x60,
  0x18, 0x10, 0x00, 0x20, 0x30, 0x30, 0x00, 0x30, 0x70, 0x20, 0x00, 0x1F,
  0xE0, 0x60, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x03, 0xF0, 0x00, 0x06, 0x07, 0x18, 0x00, 0x04, 0x0C, 0x0C, 0x00,
  0x0C, 0x08, 0x06, 0x00, 0x18, 0x18, 0x02, 0x00, 0x18, 0x10, 0x03, 0x00,
  0x30, 0x10, 0x03, 0x00, 0x30, 0x10, 0x03, 0x00, 0x60, 0x10, 0x03, 0x00,
  0x40, 0x10, 0x03, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x80, 0x10, 0x03, 0x01,
  0x80, 0x10, 0x03, 0x01, 0x00, 0x18, 0x02, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x80, 0x04, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x80, 0x04, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x01, 0x80, 0x04, 0x30, 0x0C, 0x00, 0x46, 0x00, 0x60, 0x04, 0x40, 0x03,
  0x00, 0xCC, 0x00, 0x18, 0x0C, 0x80, 0x00, 0x80, 0xC8, 0x00, 0x0C, 0x08,
  0x80, 0x00, 0x61, 0x88, 0x00, 0x03, 0x18, 0x80, 0x00, 0x1B, 0x08, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1F,
  0x03, 0x00, 0x03, 0x18, 0x18, 0x00, 0x60, 0xC0, 0xE0, 0x1C, 0x04, 0x07,
  0xFF, 0x00, 0x70, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFA, 0x00, 0x10, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x01, 0xE0, 0x18, 0x07, 0x7C, 0x18, 0x3E, 0x0F, 0x99, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x43, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x03, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x08, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x33, 0x33, 0x22,
  0x26, 0x4C, 0x80, 0xFF, 0xFF, 0xF0, 0x6F, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xF3, 0xE0, 0x01, 0x80, 0x18, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x02, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0xD6, 0x00, 0x00, 0xCA, 0x00, 0x00, 0xC5, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x70, 0x00,
  0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x50,
  0xC0, 0x00, 0x2C, 0xC0, 0x00, 0x16, 0xC0, 0x00, 0x0B, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x03, 0x08, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x07, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0x73, 0x0F, 0x0C, 0xF0, 0x3F, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0xFF, 0x00, 0x01, 0xF3, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x07, 0x01,
  0x80, 0x01, 0x81, 0x80, 0x00, 0x61, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x0C,
  0x40, 0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xF9, 0xF0, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x60, 0x0F, 0x00,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x10, 0x00, 0x33, 0xFF, 0x80, 0x3F,
  0x01, 0xE0, 0x38, 0x00, 0x70, 0x30, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60,
  0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x0E, 0x00, 0x30, 0x07, 0x80, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x38,
  0x00, 0xC1, 0xFF, 0x80, 0x43, 0x80, 0x70, 0x23, 0x00, 0x0C, 0x13, 0x00,
  0x03, 0x0A, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x27, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x10, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x1C, 0x00, 0x60, 0x07, 0x80, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x70,
  0x03, 0x80, 0x30, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x07, 0x00, 0x70, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x44, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xE7, 0xC0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x05, 0x30, 0x00, 0x0D, 0x30, 0x00, 0x19, 0x1C, 0x00, 0x31,
  0x0E, 0x00, 0xE3, 0x03, 0xFF, 0x83, 0x00, 0xFE, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x31, 0x8C, 0x63, 0x11, 0x8C, 0xC4, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3C, 0x78, 0x07, 0x00, 0x70, 0x60, 0x00, 0xC2, 0x00, 0x06,
  0x30, 0x00, 0x19, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x03, 0xF8, 0x06, 0x18, 0x07, 0x0C, 0x06, 0x10, 0x0C, 0x06, 0x06, 0x30,
  0x18, 0x06, 0x02, 0x30, 0x10, 0x06, 0x02, 0x20, 0x30, 0x06, 0x02, 0x60,
  0x20, 0x04, 0x03, 0x60, 0x60, 0x04, 0x03, 0x40, 0x60, 0x04, 0x03, 0x40,
  0x40, 0x04, 0x03, 0x40, 0x40, 0x04, 0x03, 0x40, 0x40, 0x0C, 0x03, 0x40,
  0xC0, 0x0C, 0x03, 0x40, 0xC0, 0x0C, 0x02, 0xC0, 0xC0, 0x0C, 0x02, 0xC0,
  0xC0, 0x0C, 0x02, 0x40, 0xC0, 0x18, 0x06, 0x40, 0x40, 0x18, 0x06, 0x40,
  0x40, 0x38, 0x04, 0x40, 0x40, 0x2C, 0x0C, 0x60, 0x60, 0x6C, 0x0C, 0x60,
  0x20, 0xC4, 0x18, 0x20, 0x39, 0x87, 0x30, 0x30, 0x1F, 0x03, 0xE0, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x20, 0x02, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x18,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x03, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x03, 0x80, 0x03, 0x00, 0x70, 0x01, 0x80, 0x07, 0x01,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x20, 0x01, 0xE0, 0x10, 0x00, 0x18, 0x08, 0x00, 0x06, 0x04,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04,
  0x40, 0x00, 0x03, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x06, 0x40, 0x00, 0x06, 0x20, 0x00, 0x02, 0x10, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x04, 0x00, 0x07, 0x02, 0x00, 0x0F, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x98, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x06, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0x30, 0x00, 0x70, 0x07, 0x00, 0x78, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x60, 0x38, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x38,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x6C, 0x00,
  0x01, 0x98, 0xC0, 0x00, 0x36, 0x0C, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xE0,
  0x08, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x5E, 0x80,
  0x00, 0x6F, 0x60, 0x00, 0x37, 0xB0, 0x00, 0x13, 0xC8, 0x00, 0x19, 0xE6,
  0x00, 0x08, 0xF1, 0x00, 0x0C, 0x78, 0xC0, 0x06, 0x3C, 0x60, 0x02, 0x1E,
  0x10, 0x03, 0x0F, 0x0C, 0x01, 0x07, 0x82, 0x01, 0x83, 0xC1, 0x80, 0x81,
  0xE0, 0xC0, 0xC0, 0xF0, 0x20, 0x60, 0x78, 0x18, 0x20, 0x3C, 0x0C, 0x30,
  0x1E, 0x02, 0x10, 0x0F, 0x01, 0x98, 0x07, 0x80, 0x4C, 0x03, 0xC0, 0x34,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x06, 0x00, 0x78, 0x03, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xA0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x90, 0x00, 0x01, 0x98, 0x00,
  0x01, 0x88, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x82, 0x00,
  0x01, 0x83, 0x00, 0x01, 0x81, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x80,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x20, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x04, 0x01, 0x80, 0x02, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0x41, 0x80, 0x00, 0x61, 0x80, 0x00, 0x31, 0x80, 0x00, 0x11, 0x80, 0x00,
  0x19, 0x80, 0x00, 0x09, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x05, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x38, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x66, 0x00, 0x00, 0x09, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x70,
  0x01, 0x80, 0x07, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x80, 0x01, 0xE0, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x38, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x30, 0x00, 0x70,
  0x18, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x06, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x80,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x30, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x18, 0x38, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0x1E, 0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x07, 0x80, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x08, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x40, 0x02, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0xB0, 0x01, 0xC0, 0x02, 0xC0, 0x07, 0x00, 0x0B, 0x00,
  0x14, 0x00, 0x24, 0x00, 0x58, 0x01, 0x90, 0x01, 0x60, 0x06, 0x40, 0x0D,
  0x80, 0x11, 0x80, 0x32, 0x00, 0x46, 0x00, 0xC8, 0x01, 0x18, 0x02, 0x30,
  0x04, 0x20, 0x08, 0xC0, 0x30, 0x80, 0x63, 0x00, 0xC2, 0x01, 0x84, 0x02,
  0x0C, 0x06, 0x10, 0x08, 0x30, 0x10, 0x60, 0x20, 0xC0, 0x41, 0x80, 0x81,
  0x03, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x40, 0x60,
  0x80, 0xC1, 0x01, 0x82, 0x03, 0x04, 0x06, 0x18, 0x0C, 0x10, 0x08, 0x60,
  0x10, 0xC0, 0x21, 0x80, 0x43, 0x00, 0x84, 0x01, 0x8C, 0x02, 0x10, 0x06,
  0x20, 0x0C, 0xC0, 0x18, 0x80, 0x33, 0x00, 0x22, 0x00, 0xCC, 0x00, 0x98,
  0x01, 0x20, 0x03, 0x60, 0x04, 0x80, 0x0D, 0x80, 0x16, 0x00, 0x34, 0x00,
  0x78, 0x00, 0x50, 0x01, 0xE0, 0x01, 0x40, 0x07, 0x00, 0x05, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x01, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x60, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x40, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x98, 0x00, 0x19, 0x80, 0x01, 0x08, 0x00, 0x30, 0xC0,
  0x03, 0x04, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x40, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x08, 0x01, 0x81, 0x80, 0x18, 0x10, 0x00, 0x83, 0x00,
  0x0C, 0x30, 0x00, 0x42, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x81, 0x81,
  0x81, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0x70,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0x00, 0x02, 0x18, 0x00, 0x02, 0x30, 0x00, 0x02,
  0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x40, 0x00, 0x1B,
  0x60, 0x00, 0x33, 0x30, 0x00, 0xE3, 0x1C, 0x03, 0xC3, 0x07, 0xFF, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x80, 0x18, 0x3F, 0xF0, 0x31, 0xC0, 0x70, 0x66, 0x00,
  0x30, 0xD8, 0x00, 0x31, 0xE0, 0x00, 0x33, 0x80, 0x00, 0x26, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x16, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x06, 0x78, 0x00, 0x18, 0xDC, 0x00,
  0x61, 0x8E, 0x03, 0x83, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00,
  0x02, 0x30, 0x00, 0x06, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x38, 0x03, 0x80, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0x80, 0x60,
  0x3F, 0xF0, 0xC1, 0xC0, 0x71, 0x86, 0x00, 0x33, 0x18, 0x00, 0x16, 0x60,
  0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x68, 0x00,
  0x00, 0xD0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0D,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC4,
  0x00, 0x03, 0x8C, 0x00, 0x0F, 0x0C, 0x00, 0x76, 0x0E, 0x03, 0xCC, 0x07,
  0xFE, 0x18, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x03, 0x20, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x70, 0x00, 0xC0,
  0x1E, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0x80, 0x40, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0x0C, 0x1C, 0x07, 0x18, 0x60, 0x03, 0x31,
  0x80, 0x01, 0x62, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x68, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x20, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0x40, 0x00, 0x38, 0xC0, 0x00, 0xF0, 0xC0, 0x07, 0x60,
  0xE0, 0x3C, 0xC0, 0x7F, 0xE1, 0x80, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0xE0, 0x07, 0xCF,
  0x80, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x01, 0xE0, 0x10, 0x1F, 0xF8, 0x20, 0xE0, 0x18, 0x43,
  0x00, 0x18, 0x8C, 0x00, 0x19, 0x30, 0x00, 0x1A, 0xC0, 0x00, 0x35, 0x00,
  0x00, 0x2E, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x82, 0x03, 0xC0, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x03, 0xB0, 0x00,
  0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03, 0x3C, 0x00, 0x06,
  0xCC, 0x00, 0x0F, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x1C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x18, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xC0, 0x03, 0x83, 0x1F, 0xE0, 0x7F, 0x8D, 0xC0, 0xC7,
  0x03, 0x34, 0x01, 0xB0, 0x06, 0xE0, 0x02, 0x80, 0x0B, 0x80, 0x0E, 0x00,
  0x3E, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x1E, 0x01, 0x01, 0xFF, 0x82, 0x0E, 0x03, 0x84, 0x30, 0x01, 0x88, 0xC0,
  0x01, 0x93, 0x00, 0x01, 0x2C, 0x00, 0x03, 0x50, 0x00, 0x02, 0xC0, 0x00,
  0x05, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x38, 0x07, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x78, 0x01, 0x87, 0xFE, 0x03, 0x1C, 0x07, 0x06, 0x60, 0x03,
  0x0D, 0x80, 0x03, 0x1E, 0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x33, 0x80, 0x00, 0x67, 0x80, 0x01, 0x8D, 0xC0, 0x06,
  0x18, 0xE0, 0x38, 0x30, 0xFF, 0xC0, 0x60, 0x08, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x0C, 0x1C,
  0x07, 0x18, 0x60, 0x03, 0xB1, 0x80, 0x03, 0x66, 0x00, 0x03, 0xCC, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0x20, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x38, 0xC0,
  0x00, 0xF0, 0xE0, 0x07, 0x60, 0xE0, 0x3C, 0xC0, 0x7F, 0xE1, 0x80, 0x08,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x90,
  0x1F, 0xFE, 0x0F, 0x00, 0x43, 0x00, 0x08, 0xC0, 0x01, 0x30, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0x80, 0x38, 0x03, 0xC0, 0xC0, 0x01, 0xC3, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x90, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x40, 0x00,
  0x02, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x05, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x63, 0x80, 0x01, 0x81, 0xC0,
  0x1E, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x53,
  0x00, 0x03, 0x46, 0x00, 0x39, 0x0E, 0x03, 0x84, 0x1F, 0xFC, 0x10, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x07, 0x80, 0x06, 0x00, 0x09, 0x00, 0x0E, 0x00, 0x33, 0x00,
  0x14, 0x00, 0x66, 0x00, 0x68, 0x00, 0x8C, 0x00, 0xD0, 0x01, 0x08, 0x01,
  0x30, 0x06, 0x10, 0x02, 0x60, 0x0C, 0x30, 0x0C, 0x40, 0x18, 0x60, 0x18,
  0x80, 0x20, 0x40, 0x21, 0x80, 0x40, 0x80, 0x43, 0x01, 0x81, 0x81, 0x82,
  0x03, 0x03, 0x03, 0x04, 0x04, 0x06, 0x04, 0x0C, 0x08, 0x04, 0x08, 0x18,
  0x30, 0x0C, 0x30, 0x10, 0x60, 0x18, 0x60, 0x20, 0x80, 0x30, 0x80, 0x61,
  0x00, 0x21, 0x00, 0xC6, 0x00, 0x46, 0x00, 0x8C, 0x00, 0xCC, 0x01, 0x18,
  0x01, 0x90, 0x03, 0x20, 0x01, 0x20, 0x02, 0x40, 0x02, 0xC0, 0x05, 0x80,
  0x05, 0x80, 0x0B, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x20,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x23, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x13, 0x83, 0x80, 0x00,
  0xCC, 0x03, 0x00, 0x03, 0x60, 0x07, 0x00, 0x0D, 0x00, 0x0E, 0x00, 0x2C,
  0x00, 0x0C, 0x01, 0xB0, 0x00, 0x1C, 0x0C, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0C, 0x00,
};

const GFXglyph RobotoMono_Thin57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 3, 41, 34, 15, -41 },
  { 17, 8, 12, 34, 13, -43 },
  { 29, 31, 41, 34, 2, -41 },
  { 188, 25, 52, 34, 5, -46 },
  { 351, 32, 42, 34, 1, -41 },
  { 519, 28, 42, 34, 5, -41 },
  { 666, 2, 12, 34, 15, -43 },
  { 669, 12, 58, 34, 11, -45 },
  { 756, 12, 58, 34, 10, -45 },
  { 843, 24, 23, 34, 6, -41 },
  { 912, 28, 30, 34, 3, -34 },
  { 1017, 4, 11, 34, 12, -4 },
  { 1023, 20, 1, 34, 7, -19 },
  { 1026, 4, 3, 34, 16, -3 },
  { 1028, 18, 44, 34, 9, -41 },
  { 1127, 25, 42, 34, 5, -41 },
  { 1259, 14, 41, 34, 6, -41 },
  { 1331, 25, 41, 34, 3, -41 },
  { 1460, 25, 42, 34, 3, -41 },
  { 1592, 28, 41, 34, 3, -41 },
  { 1736, 24, 42, 34, 6, -41 },
  { 1862, 25, 42, 34, 4, -41 },
  { 1994, 26, 41, 34, 4, -41 },
  { 2128, 26, 42, 34, 5, -41 },
  { 2265, 24, 42, 34, 5, -41 },
  { 2391, 3, 27, 34, 18, -27 },
  { 2402, 5, 34, 34, 16, -27 },
  { 2424, 24, 23, 34, 5, -30 },
  { 2493, 25, 13, 34, 5, -25 },
  { 2534, 24, 23, 34, 5, -30 },
  { 2603, 21, 41, 34, 7, -41 },
  { 2711, 32, 41, 34, 1, -41 },
  { 2875, 29, 41, 34, 3, -41 },
  { 3024, 24, 41, 34, 6, -41 },
  { 3147, 26, 42, 34, 4, -41 },
  { 3284, 25, 41, 34, 6, -41 },
  { 3413, 23, 41, 34, 6, -41 },
  { 3531, 23, 41, 34, 6, -41 },
  { 3649, 26, 42, 34, 4, -41 },
  { 3786, 24, 41, 34, 5, -41 },
  { 3909, 22, 41, 34, 6, -41 },
  { 4022, 25, 42, 34, 3, -41 },
  { 4154, 27, 41, 34, 6, -41 },
  { 4293, 23, 41, 34, 7, -41 },
  { 4411, 25, 41, 34, 5, -41 },
  { 4540, 24, 41, 34, 5, -41 },
  { 4663, 26, 42, 34, 4, -41 },
  { 4800, 24, 41, 34, 7, -41 },
  { 4923, 28, 48, 34, 3, -41 },
  { 5091, 25, 41, 34, 6, -41 },
  { 5220, 27, 42, 34, 4, -41 },
  { 5362, 28, 41, 34, 3, -41 },
  { 5506, 24, 42, 34, 5, -41 },
  { 5632, 28, 41, 34, 3, -41 },
  { 5776, 30, 41, 34, 3, -41 },
  { 5930, 28, 41, 34, 4, -41 },
  { 6074, 29, 41, 34, 2, -41 },
  { 6223, 25, 41, 34, 4, -41 },
  { 6352, 9, 55, 34, 13, -46 },
  { 6414, 18, 44, 34, 8, -41 },
  { 6513, 8, 55, 34, 13, -46 },
  { 6568, 20, 23, 34, 7, -41 },
  { 6626, 24, 2, 34, 5, 0 },
  { 6632, 7, 7, 34, 14, -42 },
  { 6639, 24, 32, 34, 5, -31 },
  { 6735, 23, 44, 34, 6, -43 },
  { 6862, 24, 32, 34, 5, -31 },
  { 6958, 23, 44, 34, 5, -43 },
  { 7085, 25, 32, 34, 5, -31 },
  { 7185, 25, 43, 34, 6, -43 },
  { 7320, 23, 43, 34, 5, -31 },
  { 7444, 23, 43, 34, 6, -43 },
  { 7568, 23, 41, 34, 7, -41 },
  { 7686, 18, 53, 34, 5, -41 },
  { 7806, 23, 43, 34, 7, -43 },
  { 7930, 23, 43, 34, 7, -43 },
  { 8054, 30, 31, 34, 2, -31 },
  { 8171, 23, 31, 34, 6, -31 },
  { 8261, 26, 32, 34, 4, -31 },
  { 8365, 23, 43, 34, 6, -31 },
  { 8489, 23, 43, 34, 5, -31 },
  { 8613, 19, 31, 34, 11, -31 },
  { 8687, 23, 32, 34, 6, -31 },
  { 8779, 23, 39, 34, 5, -38 },
  { 8892, 22, 31, 34, 6, -30 },
  { 8978, 28, 30, 34, 3, -30 },
  { 9083, 31, 30, 34, 2, -30 },
  { 9200, 27, 30, 34, 4, -30 },
  { 9302, 30, 42, 34, 2, -30 },
  { 9460, 27, 30, 34, 4, -30 },
  { 9562, 19, 56, 34, 9, -44 },
  { 9695, 2, 49, 34, 16, -41 },
  { 9708, 19, 56, 34, 9, -44 },
  { 9841, 30, 10, 34, 2, -22 },
};

const GFXfont RobotoMono_Thin57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin57pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_THIN57PT7B_H_
