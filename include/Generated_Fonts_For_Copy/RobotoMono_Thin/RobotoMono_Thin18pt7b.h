#ifndef _ROBOTOMONO_THIN18PT7B_H_
#define _ROBOTOMONO_THIN18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x88, 0xB6, 0xD0, 0x11, 0x08, 0x84, 0x42, 0x4F, 0xF9, 0x10,
  0x88, 0x44, 0x22, 0x7E, 0xD1, 0x08, 0x84, 0x40, 0x10, 0x21, 0xF4, 0x18,
  0x30, 0x60, 0x20, 0x38, 0x08, 0x0C, 0x18, 0x30, 0x5B, 0x08, 0x10, 0x70,
  0x22, 0x08, 0x92, 0x24, 0x8A, 0x1D, 0x00, 0x40, 0x26, 0x0A, 0x44, 0x91,
  0x24, 0x89, 0x01, 0xC0, 0x1C, 0x12, 0x10, 0x88, 0x82, 0x80, 0x80, 0xC0,
  0x91, 0x44, 0xC1, 0x60, 0xC8, 0x23, 0xE8, 0xF0, 0x29, 0x49, 0x24, 0x92,
  0x49, 0x22, 0x44, 0x84, 0x22, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48,
  0x10, 0x10, 0x93, 0x7C, 0x10, 0x28, 0x46, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0xE0, 0xFE, 0x80, 0x04, 0x20,
  0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82, 0x00, 0x79, 0x0A, 0x0C,
  0x18, 0x71, 0x64, 0xD1, 0xC3, 0x06, 0x0C, 0x17, 0xC0, 0x17, 0x91, 0x11,
  0x11, 0x11, 0x11, 0x10, 0x3C, 0x42, 0x82, 0x81, 0x02, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x40, 0xFF, 0x3C, 0x42, 0x81, 0x81, 0x01, 0x02, 0x1C,
  0x02, 0x01, 0x81, 0x81, 0x81, 0x7E, 0x02, 0x03, 0x02, 0x82, 0x41, 0x21,
  0x11, 0x08, 0x84, 0x82, 0x7F, 0xC0, 0x80, 0x40, 0x20, 0x7E, 0x81, 0x04,
  0x08, 0x0F, 0xA0, 0x81, 0x02, 0x06, 0x0C, 0x17, 0xC0, 0x0E, 0x30, 0x40,
  0x40, 0x9C, 0xA2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E, 0xFF, 0x01,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x7C,
  0x82, 0x82, 0x81, 0x82, 0x42, 0x3C, 0xC2, 0x81, 0x81, 0x81, 0x82, 0x7C,
  0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x01, 0x01, 0x02,
  0x3C, 0x80, 0x80, 0x40, 0x00, 0x68, 0x07, 0x18, 0x60, 0xC0, 0x38, 0x06,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x70, 0x10, 0x31, 0x8C, 0x20, 0x00,
  0x7D, 0x06, 0x08, 0x10, 0x20, 0x82, 0x08, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0x0C, 0x22, 0x05, 0x3D, 0x51, 0x64, 0x59, 0x26, 0x49, 0x92, 0x65,
  0x54, 0x89, 0x00, 0x3F, 0x00, 0x08, 0x04, 0x05, 0x02, 0x81, 0x41, 0x10,
  0x88, 0x44, 0x7F, 0x20, 0x90, 0x50, 0x18, 0x08, 0xF8, 0x86, 0x82, 0x82,
  0x82, 0x84, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x3E, 0x20, 0x90,
  0x50, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x50, 0x48, 0x23, 0xE0,
  0xF8, 0x84, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x84,
  0xF8, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x0F,
  0xE0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x00, 0x3E, 0x41, 0x41, 0x81, 0x80, 0x80, 0x80, 0x87, 0x81, 0x81, 0x41,
  0x41, 0x3E, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x8F, 0xE0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81,
  0x81, 0x82, 0x7C, 0x81, 0x82, 0x84, 0x88, 0x90, 0xA0, 0xE0, 0x90, 0x88,
  0x84, 0x82, 0x82, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x0F, 0xE0, 0x83, 0x06, 0x1E, 0x3C, 0x75, 0x6A, 0xD9, 0x93,
  0x06, 0x0C, 0x18, 0x20, 0x83, 0x06, 0x0E, 0x1A, 0x34, 0x64, 0xC9, 0x8B,
  0x0E, 0x1C, 0x18, 0x20, 0x3C, 0x21, 0x10, 0x50, 0x28, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x50, 0x48, 0x23, 0xE0, 0xFC, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x20, 0x90, 0x50,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x48, 0x23, 0xE0, 0x10,
  0x06, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x82, 0x84, 0xF8, 0x84, 0x84, 0x82,
  0x82, 0x81, 0x3E, 0x20, 0x90, 0x30, 0x14, 0x01, 0x00, 0x70, 0x06, 0x00,
  0x80, 0x60, 0x28, 0x23, 0xE0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x17, 0xC0, 0x80, 0xC0, 0x60, 0x48,
  0x24, 0x12, 0x10, 0x88, 0x44, 0x24, 0x0A, 0x05, 0x03, 0x00, 0x80, 0x88,
  0xC4, 0x62, 0x32, 0x99, 0x4C, 0xA5, 0x52, 0xA6, 0x63, 0x31, 0x88, 0xC4,
  0x22, 0x10, 0x80, 0xA0, 0x88, 0x44, 0x41, 0x40, 0xA0, 0x20, 0x28, 0x14,
  0x11, 0x10, 0x48, 0x28, 0x08, 0x80, 0xC0, 0x90, 0x48, 0x42, 0x21, 0x20,
  0x50, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0x01, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0xFF, 0xF2, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x9C, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20,
  0x81, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x3C, 0x10, 0x60,
  0xA1, 0x44, 0x48, 0xA1, 0x80, 0xFE, 0xD0, 0x39, 0x8E, 0x08, 0x11, 0xEC,
  0x60, 0xC1, 0x82, 0xFC, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0x80, 0x38, 0x8A, 0x0C, 0x18, 0x10, 0x20, 0x41,
  0x82, 0xF8, 0x02, 0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x2F, 0xC0, 0x1C, 0x22, 0x41, 0x81, 0xFF, 0x80, 0x80, 0x40, 0x41,
  0x3E, 0x0F, 0x10, 0x20, 0x20, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC,
  0x08, 0x18, 0x4F, 0x00, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x40, 0x10, 0x00, 0x07, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x8F, 0xE0, 0x08, 0x00, 0xF0, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x22, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84, 0x88, 0x90,
  0xA0, 0xD0, 0x88, 0x88, 0x84, 0x83, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC0, 0xF7, 0x44, 0x62, 0x31, 0x18,
  0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x40, 0xBD, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x04, 0x1C, 0x31, 0x10, 0x50, 0x18, 0x0C, 0x06, 0x03,
  0x02, 0x41, 0x1F, 0x00, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0xFA, 0x04, 0x08, 0x10, 0x00, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0xFC, 0x08, 0x10, 0x20, 0x40, 0x9E, 0x8C, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x00, 0x3D, 0x86, 0x0C, 0x06, 0x03, 0x80, 0x81, 0x82, 0xF8, 0x20,
  0x43, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xF0, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x80, 0xC0, 0x50, 0x48, 0x22,
  0x21, 0x10, 0x90, 0x28, 0x18, 0x04, 0x00, 0x88, 0xC4, 0x66, 0x32, 0x99,
  0x4A, 0xA9, 0x94, 0xC6, 0x22, 0x11, 0x00, 0x80, 0xA0, 0x88, 0x82, 0x80,
  0x80, 0x40, 0x50, 0x44, 0x41, 0x60, 0xC0, 0x80, 0xC0, 0x60, 0x48, 0x24,
  0x21, 0x10, 0x88, 0x28, 0x14, 0x04, 0x02, 0x02, 0x01, 0x07, 0x00, 0x7F,
  0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x7F, 0xC0, 0x0C,
  0x42, 0x08, 0x20, 0x82, 0x08, 0xC1, 0x02, 0x08, 0x20, 0x82, 0x08, 0x10,
  0x30, 0xFF, 0xFE, 0xC0, 0x82, 0x08, 0x20, 0x82, 0x04, 0x0C, 0x21, 0x08,
  0x20, 0x82, 0x08, 0x42, 0x00, 0x70, 0xC4, 0x61, 0xC0,
};

const GFXglyph RobotoMono_Thin18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 13, 11, 5, -13 },
  { 3, 3, 4, 11, 4, -14 },
  { 5, 9, 13, 11, 1, -13 },
  { 20, 7, 17, 11, 2, -15 },
  { 35, 10, 13, 11, 0, -13 },
  { 52, 9, 13, 11, 1, -13 },
  { 67, 1, 4, 11, 5, -14 },
  { 68, 3, 18, 11, 4, -14 },
  { 75, 4, 18, 11, 3, -14 },
  { 84, 8, 7, 11, 2, -13 },
  { 91, 9, 10, 11, 1, -11 },
  { 103, 1, 3, 11, 4, -1 },
  { 104, 7, 1, 11, 2, -6 },
  { 105, 1, 1, 11, 5, -1 },
  { 106, 6, 14, 11, 3, -13 },
  { 117, 7, 13, 11, 2, -13 },
  { 129, 4, 13, 11, 2, -13 },
  { 136, 8, 13, 11, 1, -13 },
  { 149, 8, 13, 11, 1, -13 },
  { 162, 9, 13, 11, 1, -13 },
  { 177, 7, 13, 11, 2, -13 },
  { 189, 8, 13, 11, 1, -13 },
  { 202, 8, 13, 11, 1, -13 },
  { 215, 8, 13, 11, 2, -13 },
  { 228, 8, 13, 11, 1, -13 },
  { 241, 1, 9, 11, 6, -9 },
  { 243, 2, 11, 11, 5, -9 },
  { 246, 8, 7, 11, 1, -9 },
  { 253, 7, 4, 11, 2, -8 },
  { 257, 7, 7, 11, 2, -9 },
  { 264, 7, 13, 11, 2, -13 },
  { 276, 10, 13, 11, 0, -13 },
  { 293, 9, 13, 11, 1, -13 },
  { 308, 8, 13, 11, 2, -13 },
  { 321, 9, 13, 11, 1, -13 },
  { 336, 8, 13, 11, 2, -13 },
  { 349, 7, 13, 11, 2, -13 },
  { 361, 7, 13, 11, 2, -13 },
  { 373, 8, 13, 11, 1, -13 },
  { 386, 7, 13, 11, 2, -13 },
  { 398, 7, 13, 11, 2, -13 },
  { 410, 8, 13, 11, 1, -13 },
  { 423, 8, 13, 11, 2, -13 },
  { 436, 7, 13, 11, 2, -13 },
  { 448, 7, 13, 11, 2, -13 },
  { 460, 7, 13, 11, 2, -13 },
  { 472, 9, 13, 11, 1, -13 },
  { 487, 8, 13, 11, 2, -13 },
  { 500, 9, 15, 11, 1, -13 },
  { 517, 8, 13, 11, 2, -13 },
  { 530, 9, 13, 11, 1, -13 },
  { 545, 9, 13, 11, 1, -13 },
  { 560, 7, 13, 11, 2, -13 },
  { 572, 9, 13, 11, 1, -13 },
  { 587, 9, 13, 11, 1, -13 },
  { 602, 9, 13, 11, 1, -13 },
  { 617, 9, 13, 11, 1, -13 },
  { 632, 8, 13, 11, 1, -13 },
  { 645, 3, 18, 11, 4, -15 },
  { 652, 6, 14, 11, 2, -13 },
  { 663, 3, 18, 11, 4, -15 },
  { 670, 7, 7, 11, 2, -13 },
  { 677, 7, 1, 11, 2, 0 },
  { 678, 2, 2, 11, 4, -13 },
  { 679, 7, 10, 11, 2, -10 },
  { 688, 7, 14, 11, 2, -14 },
  { 701, 7, 10, 11, 2, -10 },
  { 710, 7, 14, 11, 2, -14 },
  { 723, 8, 10, 11, 1, -10 },
  { 733, 8, 14, 11, 2, -14 },
  { 747, 7, 14, 11, 2, -10 },
  { 760, 7, 14, 11, 2, -14 },
  { 773, 7, 13, 11, 2, -13 },
  { 785, 5, 17, 11, 2, -13 },
  { 796, 8, 14, 11, 2, -14 },
  { 810, 7, 14, 11, 2, -14 },
  { 823, 9, 10, 11, 1, -10 },
  { 835, 7, 10, 11, 2, -10 },
  { 844, 9, 10, 11, 1, -10 },
  { 856, 7, 14, 11, 2, -10 },
  { 869, 7, 14, 11, 2, -10 },
  { 882, 6, 10, 11, 3, -10 },
  { 890, 7, 10, 11, 2, -10 },
  { 899, 7, 12, 11, 2, -12 },
  { 910, 7, 10, 11, 2, -10 },
  { 919, 9, 10, 11, 1, -10 },
  { 931, 9, 10, 11, 1, -10 },
  { 943, 9, 10, 11, 1, -10 },
  { 955, 9, 14, 11, 1, -10 },
  { 971, 9, 10, 11, 1, -10 },
  { 983, 6, 18, 11, 3, -14 },
  { 997, 1, 15, 11, 5, -13 },
  { 999, 6, 18, 11, 3, -14 },
  { 1013, 9, 3, 11, 1, -7 },
};

const GFXfont RobotoMono_Thin18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin18pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_THIN18PT7B_H_
