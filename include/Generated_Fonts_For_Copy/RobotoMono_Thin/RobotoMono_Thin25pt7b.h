#ifndef _ROBOTOMONO_THIN25PT7B_H_
#define _ROBOTOMONO_THIN25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x40, 0x99, 0x99, 0x90, 0x04, 0x20, 0x21, 0x01, 0x08,
  0x08, 0x40, 0x82, 0x3F, 0xFC, 0x21, 0x01, 0x08, 0x08, 0x40, 0x42, 0x04,
  0x20, 0x21, 0x0F, 0xFF, 0x08, 0x40, 0x42, 0x04, 0x10, 0x21, 0x01, 0x08,
  0x00, 0x04, 0x00, 0x80, 0x3C, 0x10, 0x64, 0x04, 0x80, 0x50, 0x0A, 0x00,
  0x40, 0x04, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x0C, 0x01, 0x80,
  0x28, 0x04, 0x81, 0x0E, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x70, 0x04, 0x40,
  0x22, 0x09, 0x08, 0x88, 0x48, 0x44, 0x42, 0x24, 0x0E, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x1C, 0x09, 0x10, 0x88, 0x84, 0x84, 0x44, 0x24, 0x21, 0x00,
  0x88, 0x03, 0x80, 0x1E, 0x02, 0x10, 0x21, 0x04, 0x10, 0x21, 0x02, 0x20,
  0x24, 0x01, 0x80, 0x18, 0x02, 0x80, 0x44, 0x18, 0x21, 0x81, 0x18, 0x0A,
  0x80, 0x68, 0x04, 0x40, 0xA3, 0xF1, 0xF8, 0x08, 0x84, 0x44, 0x21, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x84, 0x20, 0x82, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x41, 0x08, 0x42, 0x00, 0x08, 0x02, 0x00, 0x82,
  0x21, 0x7B, 0x83, 0x00, 0xC0, 0x48, 0x21, 0x10, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x55, 0x80, 0xFF, 0x80, 0xC0,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x1F, 0x04, 0x11, 0x01,
  0x20, 0x28, 0x03, 0x00, 0xE0, 0x2C, 0x09, 0x82, 0x30, 0x86, 0x20, 0xC8,
  0x1A, 0x03, 0x80, 0x50, 0x0A, 0x02, 0x20, 0x83, 0xE0, 0x0C, 0xDC, 0x61,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x1F,
  0x04, 0x11, 0x01, 0x20, 0x28, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x0F, 0xFC,
  0x1F, 0x04, 0x19, 0x01, 0x20, 0x18, 0x02, 0x00, 0x40, 0x08, 0x02, 0x0F,
  0x80, 0x30, 0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0A, 0x01, 0x20, 0x43,
  0xF0, 0x00, 0x80, 0x08, 0x01, 0x40, 0x24, 0x02, 0x40, 0x44, 0x08, 0x40,
  0x84, 0x10, 0x42, 0x04, 0x20, 0x44, 0x04, 0xFF, 0xF0, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x7F, 0xD0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0xFC, 0xC0, 0x80, 0x10, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x40, 0x8F, 0xC0, 0x07, 0x83, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x23,
  0x05, 0x8C, 0xC0, 0x50, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x12,
  0x02, 0x20, 0x83, 0xE0, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x1F, 0x04, 0x19, 0x01, 0x20, 0x18, 0x02,
  0x80, 0x50, 0x09, 0x02, 0x1F, 0x86, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0A, 0x01, 0x40, 0x47, 0xF0, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x0D, 0x02, 0x8F, 0x90, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x07, 0xC0, 0x80, 0x10, 0x40, 0x00, 0x05,
  0x58, 0x00, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x04, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x70,
  0x10, 0x00, 0x3E, 0x20, 0xA0, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07,
  0xC0, 0xC1, 0x08, 0x04, 0x80, 0x14, 0x78, 0xC4, 0x26, 0x22, 0x32, 0x11,
  0x90, 0x8C, 0x84, 0x64, 0x23, 0x21, 0x19, 0x18, 0xC5, 0x4A, 0x11, 0x88,
  0x00, 0x20, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x18, 0x01, 0x40, 0x0A, 0x00,
  0x48, 0x04, 0x40, 0x22, 0x01, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08, 0x40,
  0x43, 0xFE, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x0C, 0x00, 0x40, 0xFE,
  0x20, 0x48, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x06, 0xFE, 0x20, 0x48,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xBF, 0xC0, 0x1F, 0x04,
  0x11, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0A, 0x02, 0x20, 0x43, 0xF0, 0xFC,
  0x08, 0x18, 0x80, 0x48, 0x04, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x8F, 0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F,
  0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00,
  0x1F, 0x04, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x0F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x01, 0x20, 0x23,
  0xF8, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x7F, 0xC0, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x40, 0x8F, 0xC0, 0x80, 0x30,
  0x0A, 0x02, 0x40, 0x88, 0x21, 0x08, 0x22, 0x04, 0x80, 0xB0, 0x19, 0x02,
  0x20, 0x42, 0x08, 0x21, 0x02, 0x20, 0x24, 0x04, 0x80, 0x50, 0x04, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x80, 0x38,
  0x0F, 0x01, 0xD0, 0x3A, 0x0B, 0x41, 0x64, 0x4C, 0x89, 0x8A, 0x31, 0x46,
  0x28, 0xC2, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x80,
  0x38, 0x07, 0x00, 0xD0, 0x1A, 0x03, 0x20, 0x62, 0x0C, 0x41, 0x84, 0x30,
  0x86, 0x08, 0xC1, 0x18, 0x13, 0x01, 0x60, 0x2C, 0x03, 0x80, 0x70, 0x04,
  0x1F, 0x04, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x20, 0x83,
  0xE0, 0xFE, 0x10, 0x32, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02,
  0x80, 0x50, 0x33, 0xF8, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x00, 0x0F, 0x80, 0x82, 0x08, 0x08, 0x80, 0x24, 0x01, 0x20, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0,
  0x09, 0x00, 0x44, 0x04, 0x10, 0x20, 0x7E, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0xFE, 0x10, 0x22, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x90, 0x63, 0xF8, 0x41, 0x08, 0x11, 0x02, 0x20, 0x24, 0x04, 0x80,
  0x50, 0x04, 0x1F, 0x04, 0x19, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x40, 0x47, 0xF0, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x20, 0x83, 0xE0, 0x80, 0x0A,
  0x00, 0x90, 0x04, 0x80, 0x22, 0x02, 0x10, 0x10, 0x80, 0x84, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x14, 0x00, 0xA0,
  0x06, 0x00, 0x10, 0x00, 0x82, 0x0C, 0x10, 0x60, 0xC2, 0x86, 0x14, 0x50,
  0xA2, 0x85, 0x14, 0x28, 0x92, 0x44, 0x92, 0x44, 0x8A, 0x24, 0x51, 0x22,
  0x85, 0x14, 0x30, 0xC1, 0x82, 0x0C, 0x10, 0x20, 0x81, 0x00, 0x80, 0x18,
  0x02, 0x40, 0x42, 0x04, 0x20, 0x81, 0x10, 0x09, 0x00, 0xA0, 0x04, 0x00,
  0x60, 0x0A, 0x00, 0x90, 0x10, 0x82, 0x08, 0x20, 0x44, 0x04, 0x80, 0x28,
  0x01, 0x80, 0x1A, 0x00, 0x90, 0x08, 0x40, 0x42, 0x04, 0x08, 0x20, 0x42,
  0x01, 0x10, 0x09, 0x00, 0x28, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x1F, 0xFC, 0xF2, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x27, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x4F, 0x08, 0x04, 0x05, 0x02, 0x82, 0x21, 0x11, 0x04, 0x82, 0x41, 0x40,
  0x40, 0xFF, 0xE0, 0x89, 0x10, 0x3F, 0x88, 0x09, 0x01, 0x00, 0x10, 0x02,
  0x07, 0xCF, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x01, 0x20, 0x53, 0xF2, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x23, 0x0B, 0x33, 0x02, 0x80, 0xA0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xB0, 0x4B, 0xE0, 0x1F,
  0x84, 0x09, 0x01, 0x40, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x05, 0x01, 0x10, 0x21, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43,
  0x13, 0x35, 0x03, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x40, 0x48, 0x31, 0xF4, 0x1F, 0x84, 0x09, 0x00, 0xC0, 0x18, 0x03,
  0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x31, 0xF8, 0x07,
  0xE1, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x3F, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x00, 0x3F, 0x50, 0x34, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x04, 0x83, 0x1F, 0x40, 0x10, 0x04, 0x01, 0x40, 0x8F,
  0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x23, 0x0B, 0x33, 0x02, 0x80,
  0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0xFC, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x0A, 0x04, 0x82, 0x21, 0x09,
  0x82, 0xC0, 0xD0, 0x22, 0x08, 0x42, 0x08, 0x81, 0x20, 0x28, 0x04, 0xF8,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0xFD,
  0xF4, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41,
  0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0x80, 0xBF, 0x30, 0x28,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x3F, 0x88, 0x09, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x05, 0x01, 0x30, 0x61, 0xF0, 0xBF, 0x30, 0x28, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0B, 0x04, 0xBE,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x3F, 0x50, 0x34, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x04, 0x83, 0x1F, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xBF, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x88, 0x09, 0x00, 0xA0,
  0x04, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x05, 0x00, 0xA0, 0x23,
  0xF8, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x07, 0xC0, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x37, 0xE8, 0xC0, 0x1A, 0x00, 0x90, 0x08, 0x40, 0x42, 0x02, 0x08, 0x20,
  0x41, 0x01, 0x10, 0x08, 0x80, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x20, 0x00,
  0x82, 0x0C, 0x10, 0x61, 0x42, 0x8A, 0x14, 0x51, 0x22, 0x89, 0x22, 0x45,
  0x12, 0x28, 0xA1, 0x43, 0x0C, 0x18, 0x20, 0xC1, 0x04, 0x00, 0xC0, 0x28,
  0x08, 0x82, 0x08, 0x80, 0x90, 0x0C, 0x01, 0x00, 0x50, 0x11, 0x02, 0x10,
  0x81, 0x20, 0x28, 0x02, 0x80, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x42, 0x02,
  0x08, 0x20, 0x41, 0x01, 0x08, 0x08, 0x80, 0x44, 0x01, 0x40, 0x0A, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x03, 0x80, 0x00, 0xFF, 0xE0,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x00, 0xFF, 0xF0, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xE0, 0x60, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x03, 0xFF, 0xFF, 0xF8, 0x80, 0x60,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x03, 0x06,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x20, 0xC0, 0x7C,
  0x0C, 0x10, 0x60, 0x64, 0x00, 0x80,
};

const GFXglyph RobotoMono_Thin25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 1, 18, 15, 7, -18 },
  { 4, 4, 5, 15, 5, -19 },
  { 7, 13, 18, 15, 1, -18 },
  { 37, 11, 23, 15, 2, -20 },
  { 69, 13, 18, 15, 1, -18 },
  { 99, 12, 18, 15, 2, -18 },
  { 126, 1, 5, 15, 6, -19 },
  { 127, 5, 26, 15, 5, -20 },
  { 144, 6, 26, 15, 4, -20 },
  { 164, 10, 10, 15, 3, -18 },
  { 177, 13, 13, 15, 1, -15 },
  { 199, 2, 5, 15, 5, -2 },
  { 201, 9, 1, 15, 3, -9 },
  { 203, 2, 1, 15, 7, -1 },
  { 204, 8, 20, 15, 4, -18 },
  { 224, 11, 18, 15, 2, -18 },
  { 249, 6, 18, 15, 3, -18 },
  { 263, 11, 18, 15, 1, -18 },
  { 288, 11, 18, 15, 1, -18 },
  { 313, 12, 18, 15, 1, -18 },
  { 340, 10, 18, 15, 3, -18 },
  { 363, 11, 18, 15, 2, -18 },
  { 388, 11, 18, 15, 2, -18 },
  { 413, 11, 18, 15, 2, -18 },
  { 438, 11, 18, 15, 2, -18 },
  { 463, 1, 12, 15, 8, -12 },
  { 465, 2, 15, 15, 7, -12 },
  { 469, 11, 10, 15, 2, -13 },
  { 483, 11, 6, 15, 2, -11 },
  { 492, 11, 10, 15, 2, -13 },
  { 506, 9, 18, 15, 3, -18 },
  { 527, 13, 18, 15, 1, -18 },
  { 557, 13, 18, 15, 1, -18 },
  { 587, 10, 18, 15, 3, -18 },
  { 610, 11, 18, 15, 2, -18 },
  { 635, 12, 18, 15, 2, -18 },
  { 662, 10, 18, 15, 3, -18 },
  { 685, 10, 18, 15, 3, -18 },
  { 708, 11, 18, 15, 2, -18 },
  { 733, 11, 18, 15, 2, -18 },
  { 758, 9, 18, 15, 3, -18 },
  { 779, 10, 18, 15, 2, -18 },
  { 802, 11, 18, 15, 3, -18 },
  { 827, 10, 18, 15, 3, -18 },
  { 850, 11, 18, 15, 2, -18 },
  { 875, 11, 18, 15, 2, -18 },
  { 900, 11, 18, 15, 2, -18 },
  { 925, 11, 18, 15, 3, -18 },
  { 950, 13, 21, 15, 1, -18 },
  { 985, 11, 18, 15, 3, -18 },
  { 1010, 11, 18, 15, 2, -18 },
  { 1035, 13, 18, 15, 1, -18 },
  { 1065, 11, 18, 15, 2, -18 },
  { 1090, 13, 18, 15, 1, -18 },
  { 1120, 13, 18, 15, 1, -18 },
  { 1150, 12, 18, 15, 2, -18 },
  { 1177, 13, 18, 15, 1, -18 },
  { 1207, 11, 18, 15, 2, -18 },
  { 1232, 3, 24, 15, 6, -20 },
  { 1241, 9, 20, 15, 3, -18 },
  { 1264, 3, 24, 15, 6, -20 },
  { 1273, 9, 10, 15, 3, -18 },
  { 1285, 11, 1, 15, 2, 0 },
  { 1287, 3, 4, 15, 6, -19 },
  { 1289, 11, 13, 15, 2, -13 },
  { 1307, 10, 19, 15, 3, -19 },
  { 1331, 11, 13, 15, 2, -13 },
  { 1349, 10, 19, 15, 2, -19 },
  { 1373, 11, 13, 15, 2, -13 },
  { 1391, 11, 19, 15, 3, -19 },
  { 1418, 10, 18, 15, 2, -13 },
  { 1441, 10, 19, 15, 3, -19 },
  { 1465, 10, 18, 15, 3, -18 },
  { 1488, 8, 23, 15, 2, -18 },
  { 1511, 10, 19, 15, 3, -19 },
  { 1535, 10, 19, 15, 3, -19 },
  { 1559, 13, 13, 15, 1, -13 },
  { 1581, 10, 13, 15, 3, -13 },
  { 1598, 11, 13, 15, 2, -13 },
  { 1616, 10, 18, 15, 3, -13 },
  { 1639, 10, 18, 15, 2, -13 },
  { 1662, 8, 13, 15, 5, -13 },
  { 1675, 11, 13, 15, 2, -13 },
  { 1693, 10, 17, 15, 2, -17 },
  { 1715, 9, 13, 15, 3, -13 },
  { 1730, 13, 13, 15, 1, -13 },
  { 1752, 13, 13, 15, 1, -13 },
  { 1774, 11, 13, 15, 2, -13 },
  { 1792, 13, 18, 15, 1, -13 },
  { 1822, 12, 13, 15, 2, -13 },
  { 1842, 8, 25, 15, 4, -20 },
  { 1867, 1, 21, 15, 7, -18 },
  { 1870, 8, 25, 15, 4, -20 },
  { 1895, 13, 4, 15, 1, -9 },
};

const GFXfont RobotoMono_Thin25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin25pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_THIN25PT7B_H_
