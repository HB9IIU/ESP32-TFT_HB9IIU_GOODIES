#ifndef _ROBOTOMONO_THIN44PT7B_H_
#define _ROBOTOMONO_THIN44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin44pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x00, 0x3C, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x84, 0x00, 0x20, 0x10, 0x00, 0x20, 0x10, 0x00, 0x20,
  0x10, 0x00, 0x20, 0x10, 0x00, 0x60, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x20, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x3F, 0xFF, 0xFF, 0x00, 0x80,
  0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80,
  0x40, 0x01, 0x80, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00,
  0x80, 0x01, 0x00, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFE, 0x02, 0x01,
  0x00, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x06, 0x03,
  0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x0F, 0x3C, 0x03, 0x00, 0xC0, 0x80, 0x0C, 0x20, 0x00, 0xC4, 0x00,
  0x09, 0x80, 0x01, 0x20, 0x00, 0x34, 0x00, 0x02, 0x80, 0x00, 0x58, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x50, 0x00, 0x1B, 0x00, 0x02, 0x20, 0x00, 0xC2, 0x00, 0x30, 0x30, 0x0C,
  0x03, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0x80, 0x40, 0x20, 0x80, 0x40, 0x60, 0x80, 0x40, 0x40, 0x80, 0x40, 0xC0,
  0x80, 0x40, 0x80, 0x80, 0x41, 0x80, 0x80, 0x41, 0x00, 0x40, 0xC2, 0x00,
  0x60, 0x82, 0x00, 0x3B, 0x04, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x7C, 0x00, 0x20, 0xC6,
  0x00, 0x61, 0x02, 0x00, 0x41, 0x01, 0x00, 0x82, 0x01, 0x00, 0x82, 0x01,
  0x01, 0x02, 0x01, 0x01, 0x02, 0x01, 0x02, 0x02, 0x01, 0x06, 0x02, 0x01,
  0x04, 0x03, 0x01, 0x00, 0x01, 0x03, 0x00, 0x00, 0x86, 0x00, 0x00, 0xFC,
  0x01, 0xC0, 0x00, 0x3B, 0x80, 0x02, 0x06, 0x00, 0x30, 0x18, 0x01, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x08, 0x00,
  0x80, 0xC0, 0x04, 0x04, 0x00, 0x10, 0x40, 0x00, 0x8C, 0x00, 0x02, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x09, 0x80, 0x00, 0x84, 0x00, 0x08,
  0x10, 0x04, 0xC0, 0x40, 0x24, 0x03, 0x01, 0x40, 0x0C, 0x0A, 0x00, 0x20,
  0xD0, 0x00, 0x84, 0x80, 0x02, 0x24, 0x00, 0x1B, 0x20, 0x00, 0x71, 0x00,
  0x01, 0x84, 0x00, 0x14, 0x30, 0x01, 0x10, 0xE0, 0x30, 0x41, 0xFE, 0x03,
  0xFF, 0x80, 0x00, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x80, 0x60, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x03, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x80, 0xC0, 0x7C, 0x18,
  0x78, 0x73, 0x78, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x02, 0xC0, 0x00, 0xCC,
  0x00, 0x30, 0xC0, 0x0C, 0x0C, 0x01, 0x00, 0x80, 0x40, 0x0C, 0x18, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x24, 0x92, 0x96, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF7,
  0x80, 0x60, 0x18, 0x08, 0x01, 0x82, 0x00, 0x18, 0xC0, 0x01, 0x10, 0x00,
  0x32, 0x00, 0x02, 0x80, 0x00, 0xD0, 0x00, 0x3A, 0x00, 0x05, 0xC0, 0x01,
  0x18, 0x00, 0x43, 0x00, 0x10, 0x60, 0x04, 0x0C, 0x01, 0x01, 0x80, 0x40,
  0x30, 0x10, 0x06, 0x04, 0x00, 0xC1, 0x00, 0x18, 0x40, 0x03, 0x10, 0x00,
  0x64, 0x00, 0x1D, 0x00, 0x02, 0xC0, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03,
  0x30, 0x00, 0x42, 0x00, 0x18, 0x20, 0x06, 0x03, 0x01, 0x80, 0x3F, 0xC0,
  0x00, 0xC0, 0xF0, 0xC5, 0xC1, 0xC0, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0xF0, 0x00, 0x7B, 0xC0, 0x08, 0x03, 0x01, 0x00,
  0x18, 0x20, 0x00, 0x86, 0x00, 0x0C, 0x40, 0x00, 0x44, 0x00, 0x04, 0xC0,
  0x00, 0x4C, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x7D, 0xE0, 0x0C, 0x03, 0x01, 0x00, 0x08, 0x20, 0x00, 0xC2,
  0x00, 0x04, 0x40, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x28, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x41,
  0x80, 0x08, 0x0C, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x50, 0x00, 0x03, 0x40, 0x00, 0x09, 0x00, 0x00, 0x44, 0x00,
  0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x08,
  0x10, 0x00, 0x40, 0x40, 0x03, 0x01, 0x00, 0x08, 0x04, 0x00, 0x40, 0x10,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x04, 0x03, 0x00, 0x10, 0x08,
  0x00, 0x40, 0x40, 0x01, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0xC8,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x07, 0x80,
  0x4F, 0xF8, 0x1C, 0x01, 0x86, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x08, 0x80, 0x06,
  0x30, 0x03, 0x06, 0x01, 0x80, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x0F, 0xC0,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x10, 0x04,
  0x3F, 0xE0, 0x98, 0x06, 0x16, 0x00, 0x67, 0x00, 0x06, 0xE0, 0x00, 0x58,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x80, 0x01, 0x90,
  0x00, 0x21, 0x00, 0x08, 0x30, 0x03, 0x01, 0x80, 0xC0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7B, 0xE0, 0x18, 0x03,
  0x03, 0x00, 0x18, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00, 0x64, 0x00,
  0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x66, 0x00, 0x04, 0x20,
  0x00, 0xC1, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01,
  0x80, 0x30, 0x30, 0x00, 0x86, 0x00, 0x04, 0x40, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x24, 0x00, 0x02, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x1C, 0x03, 0x00, 0x7F,
  0xE0, 0x00, 0xF0, 0x00, 0x79, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x30,
  0x00, 0xC2, 0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03,
  0x40, 0x00, 0x34, 0x00, 0x03, 0x20, 0x00, 0x72, 0x00, 0x07, 0x10, 0x00,
  0xA0, 0x80, 0x32, 0x06, 0x0E, 0x20, 0x1F, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x22, 0x22, 0x22, 0x4C, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x78, 0x18, 0x0C, 0x20, 0x02, 0x60, 0x03,
  0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xC0, 0x30, 0x03, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x02, 0x10, 0x1F, 0x02, 0x20, 0x31, 0x83, 0x20, 0x40, 0x81,
  0x60, 0x80, 0x81, 0x40, 0x80, 0x81, 0x41, 0x00, 0x81, 0x41, 0x00, 0x81,
  0xC1, 0x00, 0x81, 0x81, 0x00, 0x81, 0x83, 0x00, 0x81, 0x82, 0x01, 0x81,
  0x82, 0x01, 0x01, 0x82, 0x01, 0x01, 0x82, 0x03, 0x03, 0xC3, 0x03, 0x02,
  0xC1, 0x03, 0x82, 0x41, 0x04, 0x84, 0x40, 0x88, 0xCC, 0x60, 0x70, 0x78,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x20,
  0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x02, 0x80, 0x00,
  0x14, 0x00, 0x00, 0xA0, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20,
  0x00, 0x30, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC0, 0x80, 0x04,
  0x04, 0x00, 0x20, 0x20, 0x03, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x40, 0x04, 0x02, 0x00, 0x20, 0x30, 0x01, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xC0, 0x01, 0x84, 0x00, 0x04, 0x20, 0x00, 0x23,
  0x00, 0x01, 0x90, 0x00, 0x04, 0x80, 0x00, 0x2C, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0xFF, 0xF0, 0x10, 0x03, 0x82, 0x00, 0x18, 0x40,
  0x01, 0x88, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80,
  0x00, 0x90, 0x00, 0x12, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x21, 0x00,
  0x18, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x80, 0x07, 0x10, 0x00, 0x32, 0x00,
  0x02, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00,
  0x31, 0x00, 0x1C, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x3D, 0xE0, 0x0C,
  0x03, 0x01, 0x80, 0x0C, 0x10, 0x00, 0x42, 0x00, 0x06, 0x20, 0x00, 0x24,
  0x00, 0x03, 0x40, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x16, 0x00, 0x03, 0x20,
  0x00, 0x23, 0x00, 0x06, 0x10, 0x00, 0x40, 0x80, 0x08, 0x06, 0x03, 0x00,
  0x3F, 0xE0, 0xFF, 0xF0, 0x08, 0x01, 0xC0, 0x80, 0x06, 0x08, 0x00, 0x10,
  0x80, 0x00, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x30,
  0x80, 0x06, 0x08, 0x03, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xF9, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3D, 0xE0, 0x0C, 0x03, 0x81, 0x80, 0x0C, 0x10, 0x00,
  0x42, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x1F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01,
  0x40, 0x00, 0x16, 0x00, 0x01, 0x20, 0x00, 0x13, 0x00, 0x01, 0x10, 0x00,
  0x10, 0xC0, 0x02, 0x06, 0x00, 0xC0, 0x1F, 0xF0, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0xFF, 0xFF,
  0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x14, 0x00,
  0x02, 0x80, 0x00, 0x58, 0x00, 0x19, 0x00, 0x02, 0x30, 0x00, 0xC3, 0x00,
  0x30, 0x30, 0x0C, 0x01, 0xFE, 0x00, 0x80, 0x00, 0x68, 0x00, 0x0C, 0x80,
  0x01, 0x88, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x08,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x80, 0x80, 0x08, 0x18, 0x00,
  0x83, 0x00, 0x08, 0x60, 0x00, 0x8E, 0x00, 0x09, 0xB0, 0x00, 0xB1, 0x80,
  0x0E, 0x08, 0x00, 0xC0, 0x40, 0x08, 0x02, 0x00, 0x80, 0x30, 0x08, 0x01,
  0x80, 0x80, 0x08, 0x08, 0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x30, 0x80,
  0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x80, 0x02, 0xD0, 0x00, 0x5B, 0x00, 0x13, 0x20, 0x02,
  0x64, 0x00, 0xCC, 0xC0, 0x11, 0x88, 0x02, 0x31, 0x00, 0x86, 0x10, 0x10,
  0xC2, 0x06, 0x18, 0x60, 0x83, 0x04, 0x10, 0x60, 0x84, 0x0C, 0x08, 0x81,
  0x81, 0x30, 0x30, 0x24, 0x06, 0x02, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xD0, 0x00, 0x3B, 0x00, 0x07,
  0x20, 0x00, 0xE2, 0x00, 0x1C, 0x40, 0x03, 0x84, 0x00, 0x70, 0xC0, 0x0E,
  0x08, 0x01, 0xC1, 0x80, 0x38, 0x10, 0x07, 0x01, 0x00, 0xE0, 0x20, 0x1C,
  0x02, 0x03, 0x80, 0x40, 0x70, 0x04, 0x0E, 0x00, 0xC1, 0xC0, 0x08, 0x38,
  0x00, 0x87, 0x00, 0x10, 0xE0, 0x01, 0x1C, 0x00, 0x23, 0x80, 0x02, 0x70,
  0x00, 0x6E, 0x00, 0x05, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0xF0, 0x00, 0x3D, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x18,
  0x10, 0x00, 0xC2, 0x00, 0x04, 0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x34, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x26, 0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x04,
  0x10, 0x00, 0xC0, 0x80, 0x18, 0x06, 0x03, 0x00, 0x3F, 0xC0, 0xFF, 0xFC,
  0x10, 0x00, 0xC2, 0x00, 0x06, 0x40, 0x00, 0x68, 0x00, 0x05, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x05, 0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x18,
  0x80, 0x1E, 0x1F, 0xFE, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0xF0, 0x03, 0x00, 0xC0, 0x30, 0x01, 0x03, 0x00,
  0x04, 0x10, 0x00, 0x11, 0x80, 0x00, 0x88, 0x00, 0x02, 0xC0, 0x00, 0x14,
  0x00, 0x00, 0xA0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x98, 0x00, 0x08, 0x40,
  0x00, 0xC1, 0x00, 0x04, 0x0C, 0x00, 0x40, 0x18, 0x0C, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0xFF, 0xF0, 0x10, 0x01, 0x82, 0x00, 0x18, 0x40,
  0x00, 0x88, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x06, 0x80,
  0x00, 0x50, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00,
  0x02, 0x20, 0x00, 0xC4, 0x00, 0x20, 0xFF, 0xF8, 0x1F, 0xFC, 0x02, 0x00,
  0x40, 0x40, 0x0C, 0x08, 0x00, 0x81, 0x00, 0x18, 0x20, 0x01, 0x04, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0x22, 0x00, 0x06, 0x40, 0x00, 0x48, 0x00,
  0x0D, 0x00, 0x00, 0xA0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x03,
  0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00,
  0xC8, 0x00, 0x02, 0x40, 0x00, 0x13, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x1A,
  0x00, 0x00, 0xD0, 0x00, 0x04, 0xC0, 0x00, 0x23, 0x00, 0x02, 0x0C, 0x00,
  0x30, 0x38, 0x07, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x02, 0xC0, 0x00, 0x48, 0x00, 0x19, 0x00, 0x02,
  0x10, 0x00, 0xC1, 0x00, 0x30, 0x18, 0x0C, 0x01, 0xFE, 0x00, 0xC0, 0x00,
  0x0D, 0x00, 0x00, 0x24, 0x00, 0x00, 0x98, 0x00, 0x02, 0x20, 0x00, 0x10,
  0x80, 0x00, 0x43, 0x00, 0x01, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x60,
  0x00, 0x80, 0x80, 0x04, 0x02, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x20, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00,
  0x30, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x02, 0x00, 0x06, 0x08, 0x00, 0x08,
  0x60, 0x00, 0x21, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x30, 0x00, 0x04, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x05, 0x00, 0x60, 0x0A, 0x01, 0xC0, 0x14,
  0x02, 0x80, 0x48, 0x05, 0x00, 0x90, 0x0B, 0x01, 0x20, 0x12, 0x02, 0x60,
  0x64, 0x04, 0x40, 0x88, 0x08, 0x81, 0x10, 0x21, 0x02, 0x30, 0x42, 0x04,
  0x20, 0x84, 0x18, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x83,
  0x18, 0x21, 0x02, 0x20, 0x46, 0x04, 0x40, 0x88, 0x08, 0x81, 0x90, 0x11,
  0x01, 0x20, 0x32, 0x02, 0x40, 0x64, 0x05, 0x80, 0x50, 0x0A, 0x00, 0xA0,
  0x14, 0x01, 0x40, 0x28, 0x02, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x88,
  0x00, 0x08, 0x20, 0x00, 0xC1, 0x80, 0x04, 0x04, 0x00, 0x40, 0x30, 0x06,
  0x00, 0x80, 0x20, 0x02, 0x03, 0x00, 0x18, 0x10, 0x00, 0x41, 0x00, 0x01,
  0x18, 0x00, 0x0C, 0x80, 0x00, 0x28, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x50, 0x00, 0x06, 0x40, 0x00, 0x23, 0x00, 0x02, 0x08, 0x00, 0x30,
  0x60, 0x01, 0x01, 0x00, 0x10, 0x04, 0x01, 0x80, 0x30, 0x08, 0x00, 0x80,
  0xC0, 0x02, 0x04, 0x00, 0x18, 0x40, 0x00, 0x46, 0x00, 0x01, 0x20, 0x00,
  0x0E, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x08, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x40, 0x01, 0x80, 0x80, 0x04, 0x02,
  0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x20, 0x10, 0x00, 0x80,
  0x80, 0x01, 0x02, 0x00, 0x04, 0x10, 0x00, 0x08, 0x40, 0x00, 0x32, 0x00,
  0x00, 0x48, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0xFC, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0A,
  0x00, 0x24, 0x00, 0x4C, 0x01, 0x88, 0x02, 0x18, 0x0C, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x80, 0x41, 0x00, 0xC6, 0x00, 0x88, 0x01, 0x10, 0x01, 0x40,
  0x02, 0x80, 0x06, 0xFF, 0xFF, 0xC0, 0x86, 0x10, 0x43, 0x0C, 0x00, 0xE0,
  0x01, 0xF7, 0x80, 0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x01,
  0x90, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x01, 0xFF, 0xE0, 0xF0, 0x04, 0x60, 0x00, 0x98, 0x00, 0x16, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x14,
  0xC0, 0x04, 0x8C, 0x03, 0x10, 0xFF, 0x83, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x70, 0x08, 0xF7, 0x82, 0x60, 0x30, 0xA0, 0x02,
  0x30, 0x00, 0xCC, 0x00, 0x12, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01,
  0x30, 0x00, 0xCA, 0x00, 0x62, 0x60, 0x30, 0x8F, 0xF0, 0x00, 0x00, 0xE0,
  0x01, 0xEF, 0x00, 0xC0, 0x30, 0x40, 0x04, 0x20, 0x00, 0x98, 0x00, 0x34,
  0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x14, 0x00, 0x05, 0x80, 0x03, 0x20, 0x00, 0x84, 0x00, 0x40,
  0xC0, 0x60, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x78, 0x30, 0xFF, 0x8C, 0x60, 0x1B, 0x30, 0x03, 0xC8, 0x00, 0x74,
  0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0xC8, 0x00, 0x71,
  0x00, 0x3C, 0x30, 0x3B, 0x07, 0xF8, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0x80,
  0x30, 0x1C, 0x08, 0x00, 0xC2, 0x00, 0x08, 0xC0, 0x01, 0x90, 0x00, 0x16,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x04, 0x30, 0x01, 0x03,
  0x80, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x03, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xFE, 0x31, 0x80, 0x6C, 0xC0, 0x0F, 0x20, 0x01, 0xD0, 0x00,
  0x34, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x03, 0x20, 0x01, 0xC4, 0x00,
  0xF0, 0xC0, 0xEC, 0x1F, 0xE3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x98, 0x00, 0x43, 0x00, 0x20, 0x70, 0x30, 0x07,
  0xF8, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x70, 0x21,
  0xEF, 0x11, 0x80, 0xC9, 0x00, 0x35, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0F, 0xFF, 0xFC, 0x00,
  0x38, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x03, 0x1F, 0xE0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0xD0, 0x00, 0xC8, 0x00, 0x84, 0x00, 0x82, 0x01, 0x81,
  0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x21, 0x80, 0x11, 0x00, 0x09, 0xC0,
  0x07, 0x30, 0x03, 0x0C, 0x01, 0x03, 0x00, 0x80, 0xC0, 0x40, 0x30, 0x20,
  0x08, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x22, 0x00, 0x19, 0x00, 0x06,
  0x80, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0xE1, 0x3B, 0x8F, 0x72,
  0x81, 0xB0, 0x36, 0x01, 0x40, 0x2C, 0x03, 0x00, 0x50, 0x02, 0x00, 0xE0,
  0x04, 0x01, 0xC0, 0x08, 0x03, 0x80, 0x10, 0x07, 0x00, 0x20, 0x0E, 0x00,
  0x40, 0x1C, 0x00, 0x80, 0x38, 0x01, 0x00, 0x70, 0x02, 0x00, 0xE0, 0x04,
  0x01, 0xC0, 0x08, 0x03, 0x80, 0x10, 0x07, 0x00, 0x20, 0x0E, 0x00, 0x40,
  0x1C, 0x00, 0x80, 0x38, 0x01, 0x00, 0x70, 0x02, 0x00, 0xE0, 0x04, 0x01,
  0xC0, 0x08, 0x03, 0x00, 0xE0, 0x43, 0xDE, 0x23, 0x01, 0x96, 0x00, 0x6A,
  0x00, 0x16, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0C,
  0x03, 0x01, 0x80, 0x08, 0x30, 0x00, 0x42, 0x00, 0x06, 0x40, 0x00, 0x24,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x03, 0x60, 0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80,
  0x18, 0x0E, 0x03, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x23, 0xFE, 0x09, 0x80,
  0xC2, 0x80, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x48, 0x00, 0x1A, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x12, 0x00, 0x04, 0xC0, 0x02, 0x28, 0x01, 0x89, 0x80, 0xC2, 0x3F, 0xC0,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x03,
  0xFE, 0x31, 0x80, 0x6C, 0xC0, 0x0F, 0x20, 0x01, 0xD0, 0x00, 0x34, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x34, 0x00, 0x0D, 0x80, 0x03, 0x20, 0x01, 0xC4, 0x00, 0xF0, 0xC0,
  0xEC, 0x1F, 0xE3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x3D, 0x87, 0xEF, 0x18, 0x06, 0xC0, 0x0D, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x01,
  0xFF, 0xC0, 0x60, 0x0E, 0x18, 0x00, 0x46, 0x00, 0x04, 0x80, 0x00, 0x90,
  0x00, 0x1B, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0x00, 0x00, 0xA0, 0x00, 0x34, 0x00, 0x04, 0x40,
  0x01, 0x86, 0x00, 0xE0, 0x3F, 0xF0, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x03, 0xFF, 0xFE,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xF0, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x56, 0x00, 0x69, 0x80,
  0xE4, 0x3F, 0xC2, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88,
  0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x00, 0x81, 0x80, 0x02, 0x02, 0x00,
  0x10, 0x0C, 0x00, 0x40, 0x10, 0x03, 0x00, 0x40, 0x08, 0x00, 0x80, 0x60,
  0x02, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x20, 0x00, 0x60, 0x80, 0x00,
  0x86, 0x00, 0x03, 0x10, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0F, 0x00, 0xA0, 0x12, 0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x0D, 0x00,
  0x90, 0x13, 0x03, 0x30, 0x22, 0x04, 0x20, 0x44, 0x08, 0x41, 0x88, 0x10,
  0x82, 0x18, 0x61, 0x84, 0x10, 0x81, 0x08, 0x21, 0x02, 0x30, 0x42, 0x04,
  0x40, 0xC4, 0x08, 0x80, 0x90, 0x19, 0x01, 0x20, 0x14, 0x02, 0x40, 0x28,
  0x02, 0x80, 0x50, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x31, 0x80, 0x03, 0x04, 0x00, 0x10, 0x10, 0x01,
  0x00, 0xC0, 0x10, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x20, 0x80, 0x00,
  0x88, 0x00, 0x06, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00,
  0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x03, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x20, 0x30, 0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x1B,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x19, 0x00, 0x00, 0x21,
  0x00, 0x00, 0xC2, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x08, 0x0C,
  0x00, 0x10, 0x08, 0x00, 0x60, 0x18, 0x00, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x04, 0x00, 0x20, 0x18, 0x00, 0x60, 0x20, 0x00, 0x40, 0xC0, 0x00, 0xC1,
  0x00, 0x00, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x02, 0x60,
  0x00, 0x02, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x03, 0x80, 0x07, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x03, 0x80, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x05, 0x03, 0x00, 0x1E, 0x01, 0x80,
  0x28, 0x01, 0x80, 0x50, 0x01, 0x81, 0x20, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoMono_Thin44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 2, 31, 26, 12, -31 },
  { 9, 6, 9, 26, 10, -33 },
  { 16, 24, 31, 26, 1, -31 },
  { 109, 19, 40, 26, 4, -36 },
  { 204, 24, 32, 26, 1, -32 },
  { 300, 21, 32, 26, 4, -32 },
  { 384, 1, 9, 26, 12, -33 },
  { 386, 9, 45, 26, 9, -35 },
  { 437, 9, 45, 26, 8, -35 },
  { 488, 19, 17, 26, 4, -31 },
  { 529, 21, 23, 26, 3, -26 },
  { 590, 3, 8, 26, 9, -3 },
  { 593, 16, 1, 26, 5, -15 },
  { 595, 2, 2, 26, 13, -2 },
  { 596, 14, 34, 26, 7, -31 },
  { 656, 19, 32, 26, 4, -32 },
  { 732, 10, 31, 26, 5, -31 },
  { 771, 20, 32, 26, 2, -32 },
  { 851, 20, 32, 26, 2, -32 },
  { 931, 22, 31, 26, 2, -31 },
  { 1017, 18, 31, 26, 5, -31 },
  { 1087, 19, 32, 26, 3, -32 },
  { 1163, 20, 31, 26, 3, -31 },
  { 1241, 20, 32, 26, 4, -32 },
  { 1321, 20, 32, 26, 3, -32 },
  { 1401, 2, 21, 26, 14, -21 },
  { 1407, 4, 26, 26, 12, -21 },
  { 1420, 19, 17, 26, 3, -23 },
  { 1461, 19, 10, 26, 4, -19 },
  { 1485, 19, 17, 26, 4, -23 },
  { 1526, 16, 32, 26, 5, -32 },
  { 1590, 24, 32, 26, 1, -32 },
  { 1686, 21, 31, 26, 3, -31 },
  { 1768, 19, 31, 26, 5, -31 },
  { 1842, 20, 32, 26, 3, -32 },
  { 1922, 20, 31, 26, 4, -31 },
  { 2000, 17, 31, 26, 5, -31 },
  { 2066, 18, 31, 26, 5, -31 },
  { 2136, 20, 32, 26, 3, -32 },
  { 2216, 19, 31, 26, 4, -31 },
  { 2290, 17, 31, 26, 5, -31 },
  { 2356, 19, 31, 26, 3, -31 },
  { 2430, 20, 31, 26, 5, -31 },
  { 2508, 18, 31, 26, 5, -31 },
  { 2578, 19, 31, 26, 4, -31 },
  { 2652, 19, 31, 26, 4, -31 },
  { 2726, 20, 32, 26, 3, -32 },
  { 2806, 19, 31, 26, 5, -31 },
  { 2880, 21, 38, 26, 3, -32 },
  { 2980, 19, 31, 26, 5, -31 },
  { 3054, 21, 32, 26, 3, -32 },
  { 3138, 22, 31, 26, 2, -31 },
  { 3224, 19, 31, 26, 4, -31 },
  { 3298, 22, 31, 26, 2, -31 },
  { 3384, 23, 31, 26, 2, -31 },
  { 3474, 21, 31, 26, 3, -31 },
  { 3556, 22, 31, 26, 2, -31 },
  { 3642, 19, 31, 26, 3, -31 },
  { 3716, 7, 43, 26, 10, -36 },
  { 3754, 14, 34, 26, 6, -31 },
  { 3814, 6, 43, 26, 10, -36 },
  { 3847, 15, 17, 26, 6, -31 },
  { 3879, 18, 1, 26, 4, 0 },
  { 3882, 5, 6, 26, 11, -33 },
  { 3886, 19, 24, 26, 4, -24 },
  { 3943, 18, 33, 26, 5, -33 },
  { 4018, 18, 24, 26, 4, -24 },
  { 4072, 18, 33, 26, 4, -33 },
  { 4147, 19, 24, 26, 4, -24 },
  { 4204, 19, 33, 26, 5, -33 },
  { 4283, 18, 33, 26, 4, -24 },
  { 4358, 17, 33, 26, 5, -33 },
  { 4429, 18, 31, 26, 5, -31 },
  { 4499, 13, 40, 26, 4, -31 },
  { 4564, 17, 33, 26, 6, -33 },
  { 4635, 18, 33, 26, 5, -33 },
  { 4710, 23, 24, 26, 2, -24 },
  { 4779, 17, 24, 26, 5, -24 },
  { 4830, 20, 24, 26, 3, -24 },
  { 4890, 18, 33, 26, 5, -24 },
  { 4965, 18, 33, 26, 4, -24 },
  { 5040, 15, 24, 26, 8, -24 },
  { 5085, 19, 24, 26, 4, -24 },
  { 5142, 18, 30, 26, 4, -30 },
  { 5210, 17, 23, 26, 5, -23 },
  { 5259, 22, 23, 26, 2, -23 },
  { 5323, 23, 23, 26, 2, -23 },
  { 5390, 21, 23, 26, 3, -23 },
  { 5451, 23, 32, 26, 2, -23 },
  { 5543, 21, 23, 26, 3, -23 },
  { 5604, 14, 43, 26, 7, -34 },
  { 5680, 1, 37, 26, 13, -31 },
  { 5685, 14, 43, 26, 7, -34 },
  { 5761, 23, 7, 26, 2, -17 },
};

const GFXfont RobotoMono_Thin44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin44pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_THIN44PT7B_H_
