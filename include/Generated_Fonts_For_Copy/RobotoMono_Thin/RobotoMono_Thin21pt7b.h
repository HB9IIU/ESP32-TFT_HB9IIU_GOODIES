#ifndef _ROBOTOMONO_THIN21PT7B_H_
#define _ROBOTOMONO_THIN21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE2, 0xB6, 0xDA, 0x08, 0x81, 0x10, 0x22, 0x04, 0x4F, 0xFE,
  0x22, 0x04, 0x40, 0x88, 0x11, 0x04, 0x23, 0xFF, 0x11, 0x02, 0x20, 0x44,
  0x08, 0x80, 0x08, 0x04, 0x0D, 0x88, 0x28, 0x0C, 0x06, 0x00, 0x80, 0x20,
  0x0E, 0x00, 0xC0, 0x10, 0x0C, 0x06, 0x02, 0x82, 0x36, 0x04, 0x02, 0x00,
  0x70, 0x04, 0x80, 0x84, 0x48, 0x48, 0x89, 0x04, 0x90, 0x32, 0x00, 0x20,
  0x04, 0xE0, 0x51, 0x09, 0x10, 0x91, 0x11, 0x11, 0x11, 0x00, 0xE0, 0x3C,
  0x10, 0x84, 0x21, 0x08, 0x44, 0x0A, 0x03, 0x00, 0xC0, 0x48, 0x21, 0x18,
  0x2A, 0x0A, 0x81, 0x20, 0x67, 0xE4, 0xF8, 0x08, 0x88, 0x44, 0x22, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x41, 0x04, 0x88, 0x42, 0x21,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x48, 0x08, 0x04, 0x02, 0x1D,
  0x71, 0xC0, 0xA0, 0x88, 0xC2, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F,
  0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x55, 0x80, 0xFE, 0x80, 0x02,
  0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10,
  0x40, 0x3E, 0x20, 0xA0, 0x50, 0x18, 0x1C, 0x16, 0x13, 0x11, 0x90, 0xD0,
  0x70, 0x30, 0x18, 0x12, 0x08, 0xF8, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x20, 0x3E, 0x20, 0xA0, 0x30, 0x10, 0x08, 0x04, 0x04,
  0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0xFE, 0x3E, 0x20, 0xA0,
  0x30, 0x10, 0x08, 0x04, 0x04, 0x3C, 0x01, 0x00, 0x40, 0x30, 0x18, 0x0A,
  0x04, 0xFC, 0x01, 0x00, 0xC0, 0x50, 0x14, 0x09, 0x04, 0x41, 0x10, 0x84,
  0x41, 0x10, 0x4F, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xA0, 0x10,
  0x08, 0x04, 0x02, 0xE1, 0x88, 0x02, 0x00, 0x80, 0x40, 0x30, 0x14, 0x0A,
  0x08, 0xF8, 0x1E, 0x10, 0x10, 0x10, 0x08, 0x05, 0xE3, 0x0D, 0x02, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x12, 0x08, 0xF8, 0xFF, 0xC0, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0x41,
  0x40, 0x60, 0x30, 0x18, 0x0E, 0x04, 0xFC, 0x3E, 0x20, 0xA0, 0x50, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x41, 0x9F, 0x40, 0x20, 0x20, 0x10, 0x10, 0xF0,
  0x80, 0x40, 0x40, 0x00, 0x5A, 0x80, 0x01, 0x83, 0x0E, 0x08, 0x0C, 0x01,
  0x80, 0x30, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x38, 0x03,
  0x00, 0x60, 0x18, 0x70, 0xC1, 0x80, 0x7D, 0x06, 0x0C, 0x10, 0x20, 0x41,
  0x04, 0x10, 0x20, 0x40, 0x00, 0x00, 0x04, 0x00, 0x1F, 0x84, 0x09, 0x01,
  0x47, 0x19, 0x13, 0x22, 0x68, 0x4D, 0x09, 0xA1, 0x34, 0x46, 0x88, 0xCE,
  0xE8, 0x00, 0x80, 0x0F, 0xC0, 0x04, 0x01, 0x80, 0x28, 0x05, 0x01, 0x20,
  0x22, 0x04, 0x41, 0x08, 0x20, 0x84, 0x10, 0xFE, 0x20, 0x24, 0x04, 0x80,
  0xA0, 0x08, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x0A, 0x09, 0xFC, 0x81,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x0B, 0xF8, 0x1F, 0x08, 0x24, 0x05, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x05, 0x01, 0x40, 0x48,
  0x21, 0xF0, 0xFC, 0x41, 0x20, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x14, 0x13, 0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x87, 0xE0, 0x18, 0x05, 0x01, 0x40, 0x48, 0x11, 0xF8,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0A, 0x08,
  0xF8, 0x80, 0xE0, 0x48, 0x22, 0x08, 0x84, 0x22, 0x09, 0x02, 0xC0, 0xC8,
  0x21, 0x08, 0x22, 0x08, 0x81, 0x20, 0x28, 0x04, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03,
  0xFE, 0x80, 0xC0, 0xF0, 0x78, 0x5A, 0x2D, 0x16, 0x93, 0x29, 0x98, 0xC4,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x80, 0xC0, 0x70, 0x34, 0x1A, 0x0C,
  0x86, 0x43, 0x11, 0x88, 0xC2, 0x61, 0x30, 0x58, 0x1C, 0x0E, 0x02, 0x1F,
  0x08, 0x24, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x05, 0x01, 0x40, 0x88, 0x21, 0xF0, 0xFE, 0x20, 0x68, 0x0A, 0x01, 0x80,
  0x60, 0x18, 0x0A, 0x04, 0xFE, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x20, 0x24, 0x04, 0x41, 0x07, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x06, 0xFC,
  0x41, 0x20, 0x90, 0x28, 0x14, 0x06, 0x02, 0x3E, 0x20, 0xA0, 0x30, 0x18,
  0x02, 0x00, 0x80, 0x38, 0x03, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x05, 0xFC,
  0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A,
  0x08, 0xF8, 0x80, 0x60, 0x14, 0x05, 0x01, 0x40, 0x88, 0x22, 0x08, 0x84,
  0x11, 0x04, 0x41, 0x20, 0x28, 0x0A, 0x03, 0x00, 0x40, 0x84, 0x30, 0x86,
  0x10, 0xC5, 0x18, 0xA2, 0x94, 0x92, 0x92, 0x52, 0x51, 0x4A, 0x29, 0x45,
  0x18, 0xC2, 0x18, 0x41, 0x08, 0x20, 0xC0, 0x68, 0x08, 0x82, 0x10, 0x81,
  0x10, 0x14, 0x02, 0x80, 0x20, 0x0A, 0x01, 0x40, 0x44, 0x10, 0x42, 0x08,
  0x80, 0xA0, 0x08, 0x80, 0x50, 0x14, 0x08, 0x82, 0x21, 0x04, 0x41, 0x20,
  0x28, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x7F, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x0F, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x70, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x80, 0x81, 0x01, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0xF0, 0x10,
  0x60, 0xA2, 0x44, 0x48, 0xA1, 0x41, 0xFF, 0x80, 0x89, 0x80, 0x7E, 0x40,
  0xA0, 0x20, 0x10, 0x0B, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0xDF, 0xA0, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x85, 0xB3, 0x05, 0x02, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x0B, 0x05, 0x7C, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xA0, 0x8F, 0x80, 0x01, 0x01, 0x01, 0x01, 0x09, 0x37,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x3E, 0x20,
  0xA0, 0x30, 0x1F, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x20, 0x4F, 0xC0, 0x07,
  0x84, 0x04, 0x02, 0x01, 0x07, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x3F, 0x01, 0x01, 0x81, 0x7E, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x05, 0xF3, 0x05, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x04, 0x00, 0x00, 0x7C, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x83, 0x84, 0x88, 0x90, 0xA0, 0xE0, 0x90, 0x88, 0x84,
  0x82, 0x81, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0xFB, 0xD0, 0x86, 0x10,
  0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0x80,
  0xBE, 0x60, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40,
  0x48, 0x21, 0xF0, 0xBE, 0x60, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x60, 0xAF, 0x90, 0x08, 0x04, 0x02, 0x00, 0x3F, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x01, 0x01, 0x01, 0x01, 0xBF,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x3F, 0x20, 0x60,
  0x30, 0x06, 0x00, 0xF0, 0x04, 0x01, 0x80, 0xC0, 0x5F, 0xC0, 0x10, 0x10,
  0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x80,
  0x50, 0x14, 0x08, 0x82, 0x20, 0x88, 0x41, 0x10, 0x48, 0x0A, 0x03, 0x00,
  0x40, 0x84, 0x31, 0x86, 0x30, 0xC5, 0x24, 0xA4, 0xA4, 0x94, 0x52, 0x8C,
  0x21, 0x84, 0x10, 0x82, 0x00, 0x80, 0xA0, 0x88, 0x84, 0x81, 0x40, 0x40,
  0x50, 0x44, 0x42, 0x20, 0xA0, 0x20, 0x80, 0x30, 0x09, 0x01, 0x20, 0x42,
  0x08, 0x42, 0x04, 0x40, 0x90, 0x0A, 0x01, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x3C, 0x00, 0x7F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x0F, 0xFC, 0x06, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x43, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x20, 0x20,
  0xFF, 0xFF, 0xC0, 0x60, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x18, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x43, 0x08, 0x00, 0x70, 0x31,
  0x86, 0x0F, 0x00,
};

const GFXglyph RobotoMono_Thin21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 1, 15, 13, 6, -15 },
  { 3, 3, 5, 13, 5, -16 },
  { 5, 11, 15, 13, 1, -15 },
  { 26, 9, 19, 13, 2, -17 },
  { 48, 12, 15, 13, 0, -15 },
  { 71, 10, 15, 13, 2, -15 },
  { 90, 1, 5, 13, 5, -16 },
  { 91, 5, 22, 13, 4, -17 },
  { 105, 4, 22, 13, 4, -17 },
  { 116, 9, 8, 13, 2, -15 },
  { 125, 10, 11, 13, 1, -12 },
  { 139, 2, 5, 13, 4, -2 },
  { 141, 7, 1, 13, 3, -7 },
  { 142, 1, 1, 13, 6, -1 },
  { 143, 7, 16, 13, 3, -15 },
  { 157, 9, 15, 13, 2, -15 },
  { 174, 5, 15, 13, 2, -15 },
  { 184, 9, 15, 13, 1, -15 },
  { 201, 9, 15, 13, 1, -15 },
  { 218, 10, 15, 13, 1, -15 },
  { 237, 9, 15, 13, 2, -15 },
  { 254, 9, 15, 13, 2, -15 },
  { 271, 10, 15, 13, 1, -15 },
  { 290, 9, 15, 13, 2, -15 },
  { 307, 9, 15, 13, 2, -15 },
  { 324, 1, 10, 13, 7, -10 },
  { 326, 2, 13, 13, 6, -10 },
  { 330, 9, 8, 13, 2, -11 },
  { 339, 9, 5, 13, 2, -9 },
  { 345, 9, 8, 13, 2, -11 },
  { 354, 7, 15, 13, 3, -15 },
  { 368, 11, 15, 13, 1, -15 },
  { 389, 11, 15, 13, 1, -15 },
  { 410, 9, 15, 13, 2, -15 },
  { 427, 10, 15, 13, 1, -15 },
  { 446, 9, 15, 13, 2, -15 },
  { 463, 9, 15, 13, 2, -15 },
  { 480, 9, 15, 13, 2, -15 },
  { 497, 10, 15, 13, 1, -15 },
  { 516, 9, 15, 13, 2, -15 },
  { 533, 8, 15, 13, 2, -15 },
  { 548, 9, 15, 13, 1, -15 },
  { 565, 10, 15, 13, 2, -15 },
  { 584, 9, 15, 13, 2, -15 },
  { 601, 9, 15, 13, 2, -15 },
  { 618, 9, 15, 13, 2, -15 },
  { 635, 10, 15, 13, 1, -15 },
  { 654, 10, 15, 13, 2, -15 },
  { 673, 11, 18, 13, 1, -15 },
  { 698, 9, 15, 13, 2, -15 },
  { 715, 9, 15, 13, 2, -15 },
  { 732, 11, 15, 13, 1, -15 },
  { 753, 9, 15, 13, 2, -15 },
  { 770, 10, 15, 13, 1, -15 },
  { 789, 11, 15, 13, 1, -15 },
  { 810, 11, 15, 13, 1, -15 },
  { 831, 10, 15, 13, 1, -15 },
  { 850, 10, 15, 13, 1, -15 },
  { 869, 3, 20, 13, 5, -17 },
  { 877, 7, 16, 13, 3, -15 },
  { 891, 3, 20, 13, 5, -17 },
  { 899, 7, 8, 13, 3, -15 },
  { 906, 9, 1, 13, 2, 0 },
  { 908, 3, 3, 13, 5, -16 },
  { 910, 9, 11, 13, 2, -11 },
  { 923, 9, 16, 13, 2, -16 },
  { 941, 9, 11, 13, 2, -11 },
  { 954, 8, 16, 13, 2, -16 },
  { 970, 9, 11, 13, 2, -11 },
  { 983, 9, 16, 13, 2, -16 },
  { 1001, 8, 15, 13, 2, -11 },
  { 1016, 9, 16, 13, 2, -16 },
  { 1034, 9, 15, 13, 2, -15 },
  { 1051, 6, 19, 13, 2, -15 },
  { 1066, 8, 16, 13, 3, -16 },
  { 1082, 9, 16, 13, 2, -16 },
  { 1100, 11, 11, 13, 1, -11 },
  { 1116, 9, 11, 13, 2, -11 },
  { 1129, 10, 11, 13, 1, -11 },
  { 1143, 9, 15, 13, 2, -11 },
  { 1160, 8, 15, 13, 2, -11 },
  { 1175, 7, 11, 13, 4, -11 },
  { 1185, 9, 11, 13, 2, -11 },
  { 1198, 8, 14, 13, 2, -14 },
  { 1212, 8, 11, 13, 2, -11 },
  { 1223, 10, 11, 13, 1, -11 },
  { 1237, 11, 11, 13, 1, -11 },
  { 1253, 9, 11, 13, 2, -11 },
  { 1266, 11, 15, 13, 1, -11 },
  { 1287, 10, 11, 13, 1, -11 },
  { 1301, 7, 21, 13, 3, -16 },
  { 1320, 1, 18, 13, 6, -15 },
  { 1323, 7, 21, 13, 3, -16 },
  { 1342, 11, 3, 13, 1, -8 },
};

const GFXfont RobotoMono_Thin21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin21pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_THIN21PT7B_H_
