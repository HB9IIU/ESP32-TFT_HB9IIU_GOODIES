#ifndef _ROBOTOMONO_THIN65PT7B_H_
#define _ROBOTOMONO_THIN65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin65pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF6,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x40, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x06, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x08, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0xC0, 0x01, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x06, 0x02, 0x00, 0x01, 0x80, 0x60, 0x30, 0x00, 0x0E, 0x07, 0x03, 0x00,
  0x00, 0x38, 0x70, 0x18, 0x00, 0x00, 0xFF, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x07, 0x80, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x0C, 0x1C, 0x00,
  0x01, 0x80, 0xC0, 0x30, 0x00, 0x0C, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x06, 0x00, 0x06, 0x02, 0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x80, 0x03,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80,
  0x20, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x06, 0x18, 0x01, 0x80, 0x06, 0x30,
  0x00, 0xC0, 0x04, 0x60, 0x00, 0x60, 0x0C, 0x60, 0x00, 0x70, 0x0C, 0x40,
  0x00, 0x30, 0x0C, 0xC0, 0x00, 0x18, 0x0C, 0xC0, 0x00, 0x0C, 0x18, 0xC0,
  0x00, 0x06, 0x18, 0xC0, 0x00, 0x03, 0x18, 0xC0, 0x00, 0x03, 0xB0, 0xC0,
  0x00, 0x01, 0xB0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x03, 0xB8, 0x1C, 0x00, 0x06, 0x18, 0x0E,
  0x00, 0x1C, 0x0C, 0x07, 0xC0, 0x78, 0x06, 0x01, 0xFF, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x80, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x7E, 0x00, 0x80, 0x7C, 0xF8, 0x10, 0x7C, 0x03, 0xE2, 0x3C, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0,
  0x18, 0x00, 0x18, 0x03, 0x80, 0x06, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80,
  0x60, 0x00, 0x38, 0x04, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x62, 0x31, 0x98, 0xCC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x5F, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x79, 0x80,
  0x00, 0x06, 0x48, 0x00, 0x00, 0x62, 0x40, 0x00, 0x06, 0x1A, 0x00, 0x00,
  0x60, 0xF0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x60, 0x3C, 0x00, 0x06, 0x01,
  0xE0, 0x00, 0x60, 0x0F, 0x00, 0x06, 0x00, 0x78, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x1E, 0x00, 0x60, 0x00, 0xF0, 0x06, 0x00, 0x07, 0x80, 0x60,
  0x00, 0x3C, 0x06, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0D, 0x06, 0x00, 0x00,
  0x68, 0x60, 0x00, 0x03, 0x46, 0x00, 0x00, 0x13, 0x60, 0x00, 0x00, 0x9E,
  0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7B, 0x01, 0xE3, 0x07, 0x83,
  0x3C, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x0F, 0xF8, 0x00, 0xCF, 0xFF, 0xC0, 0x1F, 0x80, 0x1E,
  0x03, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x3E, 0x07,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x03, 0xFF, 0x00, 0x41,
  0xF8, 0xFC, 0x04, 0x38, 0x00, 0xE0, 0xCE, 0x00, 0x07, 0x0D, 0xC0, 0x00,
  0x18, 0xD8, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x38, 0x00, 0x78, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x53, 0x80,
  0x00, 0x0D, 0x18, 0x00, 0x01, 0x90, 0xC0, 0x00, 0x33, 0x06, 0x00, 0x0E,
  0x30, 0x38, 0x03, 0xC3, 0x01, 0xFF, 0xF0, 0x30, 0x03, 0xFC, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x5F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0xFF, 0x08, 0x71, 0xC7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x18, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x31, 0x8E,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x5C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x38, 0x70, 0x01, 0xF0, 0x03, 0x0C, 0x00,
  0xFF, 0x80, 0x63, 0x00, 0x70, 0x38, 0x0C, 0x60, 0x0C, 0x03, 0x00, 0xCC,
  0x03, 0x00, 0x60, 0x1B, 0x00, 0xC0, 0x0C, 0x03, 0x60, 0x18, 0x01, 0x80,
  0x6C, 0x06, 0x00, 0x30, 0x0D, 0x00, 0xC0, 0x06, 0x01, 0xE0, 0x18, 0x00,
  0xC0, 0x3C, 0x06, 0x00, 0x10, 0x07, 0x80, 0xC0, 0x02, 0x00, 0xF0, 0x18,
  0x00, 0x40, 0x1E, 0x03, 0x00, 0x18, 0x03, 0x80, 0x60, 0x03, 0x00, 0x70,
  0x08, 0x00, 0x60, 0x0E, 0x01, 0x00, 0x0C, 0x01, 0xC0, 0x20, 0x01, 0x80,
  0x38, 0x04, 0x00, 0x70, 0x07, 0x80, 0x80, 0x0E, 0x00, 0xB0, 0x18, 0x01,
  0xC0, 0x36, 0x03, 0x00, 0x78, 0x06, 0xC0, 0x60, 0x0B, 0x00, 0xD8, 0x04,
  0x03, 0x60, 0x33, 0x00, 0xC0, 0xC4, 0x06, 0x30, 0x18, 0x38, 0xC1, 0x86,
  0x01, 0xFE, 0x0F, 0xE0, 0xC0, 0x1F, 0x00, 0xF8, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xC0,
  0x00, 0x78, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x38, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0C, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x01, 0x80, 0x01, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC6, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x1F,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x0C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03,
  0x07, 0x80, 0x00, 0x0C, 0x36, 0x00, 0x00, 0x31, 0x8C, 0x00, 0x00, 0xCC,
  0x18, 0x00, 0x03, 0x60, 0x30, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xBD, 0x80, 0x00,
  0x1B, 0xD8, 0x00, 0x03, 0x3C, 0x80, 0x00, 0x33, 0xCC, 0x00, 0x03, 0x3C,
  0xC0, 0x00, 0x63, 0xC6, 0x00, 0x06, 0x3C, 0x60, 0x00, 0xC3, 0xC6, 0x00,
  0x0C, 0x3C, 0x30, 0x00, 0xC3, 0xC3, 0x00, 0x18, 0x3C, 0x10, 0x01, 0x83,
  0xC1, 0x80, 0x30, 0x3C, 0x18, 0x03, 0x03, 0xC0, 0xC0, 0x20, 0x3C, 0x0C,
  0x06, 0x03, 0xC0, 0x40, 0x60, 0x3C, 0x06, 0x0C, 0x03, 0xC0, 0x60, 0xC0,
  0x3C, 0x02, 0x08, 0x03, 0xC0, 0x31, 0x80, 0x3C, 0x03, 0x18, 0x03, 0xC0,
  0x1B, 0x00, 0x3C, 0x01, 0xB0, 0x03, 0xC0, 0x0A, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x08, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x1C, 0x08, 0x00, 0x00, 0x70, 0x80,
  0x00, 0x03, 0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0xC8, 0x00,
  0x00, 0x38, 0x80, 0x00, 0x07, 0x08, 0x00, 0x01, 0xE0, 0x80, 0x00, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0x83, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x03, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x01, 0xC0,
  0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x40, 0x01, 0x80,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x40,
  0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0D, 0x00,
  0x03, 0x80, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x26,
  0x00, 0x1A, 0x00, 0x09, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x01, 0x30, 0x01,
  0x88, 0x00, 0xCC, 0x00, 0x62, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C, 0x40,
  0x04, 0x30, 0x03, 0x18, 0x01, 0x0C, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x30, 0x40, 0x18, 0x60, 0x0C, 0x10, 0x06, 0x08, 0x03, 0x06, 0x01,
  0x83, 0x00, 0x81, 0x80, 0x40, 0xC0, 0x20, 0x60, 0x30, 0x30, 0x08, 0x18,
  0x0C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x20, 0x18, 0x10, 0x0C, 0x18, 0x06, 0x04, 0x03, 0x06, 0x01, 0x81,
  0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x04, 0x10, 0x03,
  0x0C, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x30, 0x80, 0x18, 0xC0,
  0x0C, 0x20, 0x06, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x26,
  0x00, 0x19, 0x80, 0x09, 0x80, 0x06, 0x60, 0x03, 0x60, 0x01, 0x90, 0x00,
  0xD8, 0x00, 0x24, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x0D, 0x00, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xA0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x10,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0x80, 0x00, 0x83, 0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0xC1, 0x81, 0x81, 0x81, 0x03, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3E, 0x00, 0x01, 0x0E,
  0x00, 0x00, 0x23, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06,
  0xD8, 0x00, 0x01, 0x9B, 0x80, 0x00, 0x63, 0x38, 0x00, 0x38, 0x61, 0xE0,
  0x3C, 0x0C, 0x1F, 0xFE, 0x01, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x07, 0xF0, 0x03, 0x07, 0xFF,
  0x80, 0xC7, 0x80, 0x78, 0x33, 0x80, 0x07, 0x0D, 0xC0, 0x00, 0xC3, 0xC0,
  0x00, 0x18, 0xF0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0C, 0xF0, 0x00, 0x06, 0x36,
  0x00, 0x03, 0x0C, 0xE0, 0x03, 0x83, 0x0F, 0x03, 0xC0, 0xC1, 0xFF, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x0F, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x07, 0xF0, 0x0C, 0x07, 0xFF, 0x83, 0x03, 0x80,
  0x78, 0xC3, 0x80, 0x07, 0x31, 0xC0, 0x00, 0x6C, 0x60, 0x00, 0x0B, 0x30,
  0x00, 0x03, 0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x03, 0xC3, 0x00, 0x01, 0xB0,
  0x70, 0x01, 0xCC, 0x0F, 0x03, 0xE3, 0x00, 0xFF, 0xE0, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x30, 0x38,
  0x07, 0x8C, 0x38, 0x00, 0x73, 0x0C, 0x00, 0x06, 0xC6, 0x00, 0x00, 0xF3,
  0x00, 0x00, 0x3C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x71, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x1B,
  0x07, 0x00, 0x1C, 0xC0, 0xF0, 0x3E, 0x30, 0x0F, 0xFE, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x01, 0xFC, 0x03, 0x03, 0xFF, 0xC0,
  0xC1, 0xC0, 0x1C, 0x31, 0xC0, 0x03, 0x8C, 0xE0, 0x00, 0x73, 0x30, 0x00,
  0x0C, 0xD8, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x70, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x0C, 0x7C, 0x00, 0x03, 0x33, 0x80, 0x00, 0xF8,
  0x70, 0x00, 0x3C, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF8, 0x03, 0xF8, 0x47, 0xFE, 0x07, 0xFE, 0x27, 0x01, 0x87, 0x01, 0x96,
  0x00, 0x66, 0x00, 0x6A, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x1F, 0xC0, 0x20, 0x3F, 0xFC, 0x08, 0x1C, 0x01, 0xC2, 0x1C, 0x00,
  0x38, 0x8E, 0x00, 0x07, 0x26, 0x00, 0x00, 0xC9, 0x80, 0x00, 0x1A, 0xC0,
  0x00, 0x06, 0xA0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x7F, 0xF8, 0x0C, 0x78, 0x07, 0x03,
  0x38, 0x00, 0x60, 0xD8, 0x00, 0x0C, 0x3C, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x03,
  0x38, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x63, 0x60, 0x00, 0x30, 0xCE, 0x00,
  0x38, 0x31, 0xF0, 0x3C, 0x0C, 0x1F, 0xFC, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x30, 0x78, 0x07, 0x8C,
  0x38, 0x00, 0x73, 0x1C, 0x00, 0x0E, 0xC6, 0x00, 0x00, 0xF3, 0x00, 0x00,
  0x3C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x71, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x1B, 0x07, 0x00,
  0x1C, 0xC0, 0xF0, 0x3C, 0x30, 0x0F, 0xFE, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x00, 0x30, 0xE0,
  0x00, 0xC7, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x69, 0x80, 0x00, 0x34, 0xE0, 0x00,
  0x72, 0x38, 0x00, 0x71, 0x0F, 0x01, 0xF0, 0x81, 0xFF, 0xE0, 0x40, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x00, 0x0D, 0x80,
  0x03, 0x80, 0x01, 0x30, 0x00, 0x78, 0x00, 0x62, 0x00, 0x0B, 0x00, 0x0C,
  0x60, 0x01, 0x60, 0x01, 0x8C, 0x00, 0x64, 0x00, 0x31, 0x80, 0x0C, 0xC0,
  0x0C, 0x30, 0x01, 0x18, 0x01, 0x83, 0x00, 0x23, 0x00, 0x30, 0x60, 0x0C,
  0x60, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x81, 0x80, 0x20, 0xC0, 0x30, 0x10,
  0x04, 0x18, 0x06, 0x03, 0x01, 0x81, 0x00, 0xC0, 0x60, 0x30, 0x30, 0x10,
  0x0C, 0x04, 0x06, 0x06, 0x00, 0x81, 0x80, 0xC0, 0xC0, 0x18, 0x30, 0x08,
  0x18, 0x03, 0x06, 0x01, 0x83, 0x00, 0x60, 0x80, 0x30, 0x40, 0x0C, 0x30,
  0x06, 0x18, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x18, 0xC0, 0x0C, 0x60, 0x03,
  0x10, 0x01, 0x88, 0x00, 0x66, 0x00, 0x33, 0x00, 0x04, 0xC0, 0x02, 0x60,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x01,
  0xA0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x07,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0C, 0x70, 0x78, 0x00, 0x01, 0x9C, 0x03, 0x80, 0x00, 0x23,
  0x00, 0x18, 0x00, 0x0C, 0xC0, 0x01, 0xC0, 0x01, 0x98, 0x00, 0x1C, 0x00,
  0x62, 0x00, 0x01, 0xC0, 0x0C, 0xC0, 0x00, 0x0E, 0x07, 0x18, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph RobotoMono_Thin65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 4, 46, 39, 17, -46 },
  { 24, 10, 13, 39, 14, -49 },
  { 41, 35, 46, 39, 2, -46 },
  { 243, 28, 60, 39, 6, -53 },
  { 453, 37, 48, 39, 1, -47 },
  { 675, 32, 48, 39, 5, -47 },
  { 867, 2, 13, 39, 17, -49 },
  { 871, 14, 67, 39, 13, -52 },
  { 989, 13, 67, 39, 12, -52 },
  { 1098, 27, 25, 39, 7, -46 },
  { 1183, 31, 33, 39, 4, -38 },
  { 1311, 5, 13, 39, 13, -5 },
  { 1320, 23, 2, 39, 8, -22 },
  { 1326, 3, 4, 39, 19, -4 },
  { 1328, 21, 50, 39, 10, -46 },
  { 1460, 29, 48, 39, 5, -47 },
  { 1634, 16, 46, 39, 7, -46 },
  { 1726, 28, 47, 39, 4, -47 },
  { 1891, 29, 48, 39, 3, -47 },
  { 2065, 32, 46, 39, 3, -46 },
  { 2249, 27, 47, 39, 7, -46 },
  { 2408, 28, 48, 39, 5, -47 },
  { 2576, 30, 46, 39, 4, -46 },
  { 2749, 29, 48, 39, 6, -47 },
  { 2923, 28, 48, 39, 5, -47 },
  { 3091, 3, 32, 39, 21, -32 },
  { 3103, 6, 40, 39, 18, -32 },
  { 3133, 28, 26, 39, 5, -34 },
  { 3224, 28, 14, 39, 6, -28 },
  { 3273, 27, 26, 39, 6, -34 },
  { 3361, 24, 47, 39, 8, -47 },
  { 3502, 35, 47, 39, 2, -47 },
  { 3708, 32, 46, 39, 4, -46 },
  { 3892, 28, 46, 39, 7, -46 },
  { 4053, 29, 48, 39, 5, -47 },
  { 4227, 29, 46, 39, 6, -46 },
  { 4394, 26, 46, 39, 7, -46 },
  { 4544, 27, 46, 39, 7, -46 },
  { 4700, 30, 48, 39, 4, -47 },
  { 4880, 27, 46, 39, 6, -46 },
  { 5036, 25, 46, 39, 7, -46 },
  { 5180, 28, 47, 39, 4, -46 },
  { 5345, 30, 46, 39, 7, -46 },
  { 5518, 26, 46, 39, 8, -46 },
  { 5668, 28, 46, 39, 6, -46 },
  { 5829, 27, 46, 39, 6, -46 },
  { 5985, 30, 48, 39, 4, -47 },
  { 6165, 28, 46, 39, 8, -46 },
  { 6326, 32, 55, 39, 4, -47 },
  { 6546, 28, 46, 39, 7, -46 },
  { 6707, 30, 48, 39, 5, -47 },
  { 6887, 32, 46, 39, 4, -46 },
  { 7071, 27, 47, 39, 6, -46 },
  { 7230, 32, 46, 39, 3, -46 },
  { 7414, 34, 46, 39, 3, -46 },
  { 7610, 32, 46, 39, 4, -46 },
  { 7794, 32, 46, 39, 3, -46 },
  { 7978, 28, 46, 39, 5, -46 },
  { 8139, 10, 63, 39, 15, -53 },
  { 8218, 21, 50, 39, 9, -46 },
  { 8350, 10, 63, 39, 14, -53 },
  { 8429, 23, 25, 39, 8, -46 },
  { 8501, 27, 2, 39, 6, 0 },
  { 8508, 7, 8, 39, 16, -48 },
  { 8515, 27, 36, 39, 6, -35 },
  { 8637, 26, 50, 39, 7, -49 },
  { 8800, 27, 36, 39, 6, -35 },
  { 8922, 26, 50, 39, 6, -49 },
  { 9085, 29, 36, 39, 5, -35 },
  { 9216, 28, 49, 39, 7, -49 },
  { 9388, 26, 49, 39, 6, -35 },
  { 9548, 26, 49, 39, 7, -49 },
  { 9708, 26, 46, 39, 8, -46 },
  { 9858, 20, 61, 39, 6, -47 },
  { 10011, 26, 49, 39, 8, -49 },
  { 10171, 26, 49, 39, 8, -49 },
  { 10331, 33, 35, 39, 3, -35 },
  { 10476, 26, 35, 39, 7, -35 },
  { 10590, 31, 36, 39, 4, -35 },
  { 10730, 26, 48, 39, 7, -35 },
  { 10886, 26, 48, 39, 6, -35 },
  { 11042, 22, 35, 39, 12, -35 },
  { 11139, 28, 36, 39, 6, -35 },
  { 11265, 26, 45, 39, 6, -44 },
  { 11412, 25, 35, 39, 7, -34 },
  { 11522, 31, 34, 39, 4, -34 },
  { 11654, 35, 34, 39, 2, -34 },
  { 11803, 30, 34, 39, 5, -34 },
  { 11931, 33, 48, 39, 3, -34 },
  { 12129, 31, 34, 39, 4, -34 },
  { 12261, 20, 65, 39, 11, -51 },
  { 12424, 1, 55, 39, 19, -46 },
  { 12431, 20, 65, 39, 11, -51 },
  { 12594, 35, 11, 39, 2, -25 },
};

const GFXfont RobotoMono_Thin65pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin65pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _ROBOTOMONO_THIN65PT7B_H_
