#ifndef _ROBOTOMONO_THIN41PT7B_H_
#define _ROBOTOMONO_THIN41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin41pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x03, 0xC0, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x84, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40, 0x01, 0x01,
  0x80, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x40, 0x60, 0x3F, 0xFF, 0xFE, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00,
  0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0x40, 0x00,
  0x80, 0x80, 0x03, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x10,
  0x10, 0x0F, 0xFF, 0xFF, 0x80, 0x40, 0x40, 0x01, 0x00, 0x80, 0x02, 0x01,
  0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x60, 0x20,
  0x00, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x7F, 0x80, 0xC0, 0x30, 0xC0, 0x0C, 0x40, 0x02, 0x40, 0x01, 0xA0,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x14, 0x00, 0x0B, 0x00, 0x0C, 0xC0, 0x0C, 0x30, 0x0C,
  0x07, 0xF8, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0x04, 0x00, 0x06, 0x04, 0x00, 0x08, 0x08,
  0x04, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x83,
  0x01, 0x01, 0x04, 0x02, 0x02, 0x18, 0x02, 0x0C, 0x20, 0x06, 0x30, 0x80,
  0x03, 0xC1, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x41, 0xE0, 0x01, 0x04, 0x20, 0x06, 0x10, 0x20, 0x08, 0x60, 0x40,
  0x30, 0x80, 0xC0, 0x41, 0x00, 0x81, 0x02, 0x01, 0x02, 0x04, 0x02, 0x08,
  0x08, 0x0C, 0x30, 0x18, 0x10, 0x00, 0x10, 0x20, 0x00, 0x30, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80, 0x03, 0x06, 0x00, 0x10, 0x10,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x01, 0x80, 0x10,
  0x08, 0x00, 0xC0, 0x80, 0x02, 0x08, 0x00, 0x18, 0x80, 0x00, 0x48, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xB0, 0x00, 0x18, 0x80, 0x01, 0x82,
  0x01, 0x08, 0x08, 0x08, 0x80, 0x20, 0x44, 0x01, 0x82, 0x60, 0x06, 0x12,
  0x00, 0x11, 0x90, 0x00, 0x48, 0xC0, 0x01, 0xC2, 0x00, 0x0C, 0x10, 0x00,
  0x70, 0x40, 0x04, 0x81, 0x80, 0xC2, 0x07, 0xF8, 0x0C, 0xFF, 0x80, 0x01,
  0x81, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x40, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x30, 0x77, 0x8C,
  0x70, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x12, 0x00, 0x08, 0x40,
  0x04, 0x08, 0x03, 0x01, 0x01, 0x80, 0x60, 0x40, 0x08, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xF0, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x24, 0x92, 0xD6, 0xFF, 0xFE, 0xF0, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x01, 0xFE, 0x00, 0xC0, 0x60, 0x40, 0x0C, 0x30, 0x01, 0x08,
  0x00, 0x26, 0x00, 0x09, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x54, 0x00,
  0x27, 0x00, 0x11, 0xC0, 0x08, 0x70, 0x04, 0x1C, 0x02, 0x07, 0x01, 0x01,
  0xC0, 0x80, 0x70, 0x40, 0x1C, 0x20, 0x07, 0x10, 0x01, 0x48, 0x00, 0x54,
  0x00, 0x16, 0x00, 0x05, 0x00, 0x03, 0x60, 0x00, 0x88, 0x00, 0x23, 0x00,
  0x10, 0x60, 0x0C, 0x0C, 0x06, 0x00, 0xFE, 0x00, 0x01, 0x83, 0xC6, 0x2C,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0xC0, 0x01, 0xFE, 0x01, 0x80, 0x40,
  0xC0, 0x08, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x0B, 0x00, 0x02, 0x80,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x40, 0x01, 0xFF, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01,
  0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x07, 0x80, 0x0F,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x26,
  0x00, 0x08, 0xC0, 0x04, 0x1C, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0A, 0x00, 0x01, 0xA0, 0x00, 0x12, 0x00, 0x02, 0x20,
  0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x02,
  0x00, 0x20, 0x20, 0x06, 0x02, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x20, 0x10, 0x02, 0x02, 0x00, 0x20, 0x60, 0x02, 0x0C, 0x00, 0x20, 0xFF,
  0xFF, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x09, 0xFE, 0x07,
  0x01, 0x82, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x02, 0xC0, 0x03, 0x20, 0x01, 0x08, 0x01, 0x83, 0x01, 0x80, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x0F, 0xE0, 0x4C, 0x0C, 0x24, 0x00, 0xCA, 0x00, 0x13, 0x00, 0x02,
  0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x05, 0x00, 0x02, 0x40, 0x00, 0x98, 0x00, 0x22, 0x00,
  0x10, 0x40, 0x0C, 0x0C, 0x06, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0x80, 0x60, 0x80, 0x0C, 0x60,
  0x01, 0x10, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xB0, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x04, 0x20, 0x03, 0x06, 0x01, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x18, 0x06, 0x08, 0x00, 0x44, 0x00, 0x0A, 0x00, 0x02, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x34, 0x00, 0x09, 0x80, 0x04, 0x18, 0x06, 0x03, 0xFE, 0x00, 0x00, 0x80,
  0x01, 0xFE, 0x00, 0x80, 0x60, 0x40, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x02, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x03, 0x20, 0x01,
  0x4C, 0x00, 0xD1, 0x80, 0x64, 0x1D, 0xE1, 0x00, 0xC0, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x70, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x33,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x22, 0x24, 0xC0,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xE0, 0xC0,
  0x63, 0x00, 0x64, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x07, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x60, 0x00, 0xC1, 0x80, 0x00, 0x82, 0x00, 0x01, 0x08, 0x0F, 0x81,
  0x10, 0x20, 0x82, 0x60, 0x81, 0x04, 0x82, 0x02, 0x09, 0x04, 0x04, 0x12,
  0x18, 0x08, 0x28, 0x20, 0x10, 0x50, 0x40, 0x20, 0xA0, 0x80, 0x81, 0x41,
  0x01, 0x02, 0x82, 0x02, 0x05, 0x04, 0x04, 0x0A, 0x08, 0x18, 0x14, 0x10,
  0x30, 0x6C, 0x20, 0xA0, 0x88, 0x23, 0x23, 0x10, 0x7C, 0x7C, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00,
  0x00, 0xA0, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x30,
  0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00,
  0x20, 0x20, 0x01, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x40, 0x04, 0x02, 0x00, 0x20, 0x1F, 0xFF, 0x81, 0x00, 0x04, 0x08,
  0x00, 0x20, 0x40, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01,
  0x90, 0x00, 0x04, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x20,
  0x07, 0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00,
  0x1A, 0x00, 0x02, 0x80, 0x01, 0xA0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08,
  0x80, 0x0C, 0x20, 0x3C, 0x0F, 0xFF, 0xC2, 0x00, 0x18, 0x80, 0x01, 0x20,
  0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x32, 0x00, 0x30,
  0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x30, 0x18, 0x08, 0x00,
  0x83, 0x00, 0x18, 0x40, 0x01, 0x10, 0x00, 0x12, 0x00, 0x02, 0xC0, 0x00,
  0x50, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0xD0, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x44, 0x00, 0x10, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0xC0, 0x60,
  0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x20, 0x0E, 0x08, 0x00, 0xC2, 0x00, 0x18,
  0x80, 0x03, 0x20, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x03, 0x20,
  0x01, 0x88, 0x00, 0xC2, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x80, 0x30, 0x18, 0x08, 0x00, 0x82, 0x00, 0x08, 0x40, 0x01, 0x90,
  0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x04, 0xC0,
  0x01, 0x8C, 0x00, 0x60, 0xC0, 0x18, 0x07, 0xFC, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0xFF,
  0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x05, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x41, 0x00, 0x30, 0x20, 0x18,
  0x07, 0xF8, 0x00, 0x80, 0x00, 0xD0, 0x00, 0x22, 0x00, 0x08, 0x40, 0x02,
  0x08, 0x00, 0x81, 0x00, 0x20, 0x20, 0x0C, 0x04, 0x03, 0x00, 0x80, 0xC0,
  0x10, 0x30, 0x02, 0x0C, 0x00, 0x43, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00,
  0x24, 0x80, 0x05, 0x18, 0x00, 0xC1, 0x80, 0x10, 0x10, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x03, 0x01, 0x00, 0x30, 0x20, 0x02, 0x04, 0x00, 0x20,
  0x80, 0x02, 0x10, 0x00, 0x62, 0x00, 0x06, 0x40, 0x00, 0x48, 0x00, 0x06,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x74, 0x00, 0x5A, 0x00, 0x2D, 0x00, 0x36, 0x40,
  0x13, 0x20, 0x09, 0x98, 0x08, 0xC4, 0x04, 0x62, 0x06, 0x30, 0x82, 0x18,
  0x41, 0x0C, 0x31, 0x06, 0x08, 0x83, 0x04, 0x81, 0x81, 0x40, 0xC0, 0xA0,
  0x60, 0x60, 0x30, 0x10, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0C, 0x80,
  0x06, 0x40, 0x03, 0x10, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x30,
  0x40, 0x18, 0x10, 0x0C, 0x08, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x40,
  0xC0, 0x10, 0x60, 0x08, 0x30, 0x02, 0x18, 0x01, 0x0C, 0x00, 0x46, 0x00,
  0x23, 0x00, 0x09, 0x80, 0x06, 0xC0, 0x01, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x08, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x30, 0x18, 0x08, 0x01, 0x82,
  0x00, 0x10, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00, 0x02, 0xC0, 0x00, 0x50,
  0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x05, 0x00, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0x84, 0x00, 0x10, 0xC0, 0x04, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x07,
  0xF0, 0x00, 0xFF, 0xF0, 0x20, 0x03, 0x08, 0x00, 0x22, 0x00, 0x04, 0x80,
  0x01, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x62,
  0x00, 0xE0, 0xFF, 0xE0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0xE0, 0x06, 0x03, 0x00, 0x80, 0x08, 0x10, 0x00, 0x43, 0x00, 0x04, 0x20,
  0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x16, 0x00, 0x02, 0x20, 0x00, 0x23, 0x00,
  0x04, 0x10, 0x00, 0xC0, 0x80, 0x18, 0x06, 0x03, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0xFF, 0xE0, 0x40, 0x1C, 0x20, 0x03, 0x10, 0x00, 0xC8, 0x00, 0x24, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50,
  0x00, 0x68, 0x00, 0x24, 0x00, 0x22, 0x00, 0x21, 0xFF, 0xE0, 0xFF, 0xC0,
  0x40, 0x10, 0x20, 0x0C, 0x10, 0x02, 0x08, 0x01, 0x84, 0x00, 0x42, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x02, 0x40, 0x01, 0xA0, 0x00, 0x50, 0x00, 0x38,
  0x00, 0x08, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x70, 0x0C, 0x18, 0x00, 0xC2,
  0x00, 0x0C, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x03, 0x40, 0x00, 0x28,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x28, 0x00, 0x0D, 0x80, 0x01, 0x18, 0x00, 0x41, 0xC0, 0x30, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x40, 0x01, 0x30, 0x01, 0x08, 0x01,
  0x83, 0x01, 0x80, 0xFF, 0x00, 0x80, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00,
  0x24, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0x41, 0x00,
  0x04, 0x10, 0x00, 0xC1, 0x00, 0x08, 0x08, 0x00, 0x80, 0x80, 0x18, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x40, 0x20, 0x02, 0x02, 0x00,
  0x20, 0x60, 0x02, 0x04, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80,
  0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x0D, 0x00, 0x00, 0x50,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x80, 0x20, 0x0E, 0x00, 0xC0, 0x28,
  0x03, 0x00, 0x90, 0x0C, 0x02, 0x40, 0x50, 0x09, 0x01, 0x40, 0x24, 0x05,
  0x81, 0x10, 0x12, 0x04, 0x40, 0x48, 0x11, 0x02, 0x20, 0x42, 0x08, 0x81,
  0x08, 0x23, 0x04, 0x20, 0x84, 0x20, 0x82, 0x10, 0x82, 0x10, 0x42, 0x08,
  0x41, 0x08, 0x11, 0x06, 0x20, 0x44, 0x08, 0x81, 0x10, 0x22, 0x04, 0x80,
  0x90, 0x12, 0x02, 0x40, 0x48, 0x0D, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50,
  0x0C, 0x01, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0xC0, 0x00, 0x24, 0x00, 0x04, 0x20, 0x00, 0xC3, 0x00, 0x08,
  0x10, 0x01, 0x80, 0x80, 0x10, 0x08, 0x02, 0x00, 0x40, 0x60, 0x06, 0x04,
  0x00, 0x20, 0x80, 0x01, 0x18, 0x00, 0x19, 0x00, 0x00, 0xA0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x01, 0x90, 0x00, 0x11, 0x80, 0x02,
  0x08, 0x00, 0x20, 0x40, 0x04, 0x04, 0x00, 0xC0, 0x20, 0x08, 0x03, 0x01,
  0x00, 0x10, 0x30, 0x00, 0x82, 0x00, 0x0C, 0x40, 0x00, 0x44, 0x00, 0x02,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x14, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00,
  0x04, 0x30, 0x00, 0xC1, 0x00, 0x08, 0x18, 0x01, 0x80, 0x80, 0x10, 0x0C,
  0x03, 0x00, 0x40, 0x20, 0x06, 0x04, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0xFC, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x1F, 0xC0, 0x01, 0x00, 0x0E, 0x00, 0x28, 0x01, 0x20, 0x04, 0x40, 0x31,
  0x00, 0x86, 0x02, 0x08, 0x10, 0x20, 0x40, 0x43, 0x01, 0x08, 0x06, 0x20,
  0x09, 0x00, 0x24, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0x80, 0xC2, 0x08, 0x21,
  0x80, 0x07, 0xF0, 0x0E, 0x0E, 0x0C, 0x01, 0x88, 0x00, 0x64, 0x00, 0x14,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x81, 0xFF,
  0xC3, 0x80, 0x26, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0xE8, 0x00, 0xB6, 0x01, 0x88, 0xFF, 0x04,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x61, 0xF8, 0x33, 0x06, 0x1A,
  0x00, 0x8E, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0x5C, 0x00, 0x4E,
  0x00, 0x66, 0xC0, 0x63, 0x1F, 0xC0, 0x07, 0xF0, 0x06, 0x0E, 0x0C, 0x01,
  0x84, 0x00, 0x64, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x98, 0x00, 0x46, 0x00,
  0x41, 0x80, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x07,
  0xE1, 0x18, 0x19, 0x30, 0x0D, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60,
  0x03, 0x20, 0x05, 0x18, 0x19, 0x0F, 0xF1, 0x01, 0xF8, 0x01, 0x83, 0x80,
  0x80, 0x30, 0x40, 0x06, 0x20, 0x00, 0x98, 0x00, 0x34, 0x00, 0x05, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x0C, 0x60, 0x02, 0x0E, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x38, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x07, 0xE1, 0x18, 0x19, 0x30,
  0x0D, 0x60, 0x07, 0x40, 0x03, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x03, 0x20, 0x07, 0x18,
  0x0D, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x40,
  0x02, 0x60, 0x04, 0x30, 0x0C, 0x0E, 0x30, 0x03, 0xC0, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x41, 0xFC, 0x21, 0x83, 0x13, 0x00, 0x49, 0x00,
  0x35, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x0F, 0xFF, 0xF8, 0x00, 0x30, 0x07, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x87,
  0x0F, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x01, 0xA0,
  0x01, 0x90, 0x01, 0x88, 0x01, 0x04, 0x01, 0x02, 0x01, 0x01, 0x03, 0x00,
  0x83, 0x00, 0x43, 0x00, 0x23, 0x00, 0x12, 0x80, 0x0A, 0x20, 0x06, 0x08,
  0x02, 0x02, 0x01, 0x01, 0x80, 0x80, 0x60, 0x40, 0x18, 0x20, 0x06, 0x10,
  0x01, 0x88, 0x00, 0x44, 0x00, 0x12, 0x00, 0x06, 0xFF, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03,
  0xFF, 0xFE, 0x9F, 0x07, 0xE5, 0x86, 0x61, 0xB0, 0x14, 0x05, 0x80, 0xE0,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x04,
  0x83, 0xF8, 0x43, 0x06, 0x26, 0x00, 0x92, 0x00, 0x6A, 0x00, 0x16, 0x00,
  0x0B, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x03,
  0xF8, 0x01, 0xC1, 0x80, 0x60, 0x0C, 0x18, 0x00, 0x86, 0x00, 0x08, 0x80,
  0x01, 0x90, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x16, 0x00,
  0x02, 0x40, 0x00, 0x4C, 0x00, 0x10, 0x80, 0x06, 0x08, 0x01, 0x80, 0xC0,
  0x60, 0x0F, 0xF0, 0x00, 0x83, 0xF0, 0x46, 0x0C, 0x24, 0x01, 0x14, 0x00,
  0x4C, 0x00, 0x36, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x02, 0x80, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x94, 0x00, 0xC9, 0x80,
  0xC4, 0x3F, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x07, 0xE1, 0x18, 0x19,
  0x30, 0x0D, 0x60, 0x07, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x03, 0x20, 0x07,
  0x18, 0x0D, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x81, 0xFE, 0x38, 0x09,
  0x80, 0x2C, 0x00, 0xE0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07,
  0xF0, 0x0E, 0x07, 0x08, 0x00, 0xCC, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x50, 0x00, 0x2C, 0x00, 0x23, 0x00, 0x60, 0x7F, 0xE0, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFF, 0xFE,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x20, 0x05, 0x10, 0x19,
  0x0F, 0xF1, 0xC0, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x22, 0x00, 0x02,
  0x20, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0xC1, 0x80, 0x08, 0x08, 0x01,
  0x80, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x02, 0x02, 0x00, 0x20,
  0x40, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00,
  0x90, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x14, 0x03, 0x00, 0xA0, 0x1C, 0x05, 0x01, 0x20, 0x28,
  0x09, 0x03, 0x60, 0x48, 0x11, 0x02, 0x60, 0x88, 0x31, 0x04, 0x41, 0x08,
  0x43, 0x08, 0x42, 0x08, 0x42, 0x10, 0x46, 0x08, 0x82, 0x20, 0x48, 0x19,
  0x02, 0x40, 0x48, 0x12, 0x02, 0x40, 0xD0, 0x14, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0xC0, 0x00, 0x6C, 0x00, 0x18,
  0xC0, 0x02, 0x08, 0x00, 0x80, 0x80, 0x20, 0x08, 0x0C, 0x01, 0x83, 0x00,
  0x18, 0x40, 0x01, 0x10, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0B, 0x00, 0x02, 0x20, 0x00, 0x82, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x01,
  0x00, 0x60, 0x40, 0x04, 0x10, 0x00, 0x46, 0x00, 0x05, 0x80, 0x00, 0xC0,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x42, 0x00,
  0x02, 0x10, 0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x18, 0x08, 0x00, 0x80,
  0x40, 0x0C, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x60, 0x20, 0x01, 0x01,
  0x00, 0x0C, 0x10, 0x00, 0x20, 0x80, 0x01, 0x8C, 0x00, 0x04, 0x40, 0x00,
  0x36, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x47, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0xE0, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x7E, 0x00, 0x12, 0x06, 0x00, 0x50, 0x0C, 0x01, 0x40, 0x18, 0x09,
  0x00, 0x38, 0x6C, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoMono_Thin41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 2, 29, 25, 11, -29 },
  { 9, 6, 9, 25, 9, -31 },
  { 16, 23, 29, 25, 1, -29 },
  { 100, 17, 37, 25, 4, -33 },
  { 179, 23, 30, 25, 1, -30 },
  { 266, 21, 30, 25, 3, -30 },
  { 345, 1, 9, 25, 11, -31 },
  { 347, 9, 41, 25, 8, -32 },
  { 394, 9, 41, 25, 7, -32 },
  { 441, 18, 16, 25, 4, -29 },
  { 477, 20, 21, 25, 2, -24 },
  { 530, 3, 8, 25, 8, -3 },
  { 533, 15, 1, 25, 5, -14 },
  { 535, 2, 2, 25, 12, -2 },
  { 536, 13, 32, 25, 6, -29 },
  { 588, 18, 30, 25, 3, -30 },
  { 656, 9, 29, 25, 5, -29 },
  { 689, 18, 30, 25, 2, -30 },
  { 757, 18, 30, 25, 2, -30 },
  { 825, 20, 29, 25, 2, -29 },
  { 898, 17, 29, 25, 5, -29 },
  { 960, 18, 30, 25, 3, -30 },
  { 1028, 18, 29, 25, 3, -29 },
  { 1094, 18, 30, 25, 4, -30 },
  { 1162, 18, 30, 25, 3, -30 },
  { 1230, 2, 20, 25, 13, -20 },
  { 1235, 4, 25, 25, 11, -20 },
  { 1248, 18, 16, 25, 3, -21 },
  { 1284, 18, 9, 25, 3, -18 },
  { 1305, 17, 16, 25, 4, -21 },
  { 1339, 15, 30, 25, 5, -30 },
  { 1396, 23, 29, 25, 1, -29 },
  { 1480, 21, 29, 25, 2, -29 },
  { 1557, 18, 29, 25, 4, -29 },
  { 1623, 19, 30, 25, 3, -30 },
  { 1695, 18, 29, 25, 4, -29 },
  { 1761, 17, 29, 25, 4, -29 },
  { 1823, 16, 29, 25, 5, -29 },
  { 1881, 19, 30, 25, 3, -30 },
  { 1953, 17, 29, 25, 4, -29 },
  { 2015, 16, 29, 25, 4, -29 },
  { 2073, 18, 29, 25, 2, -29 },
  { 2139, 19, 29, 25, 5, -29 },
  { 2208, 16, 29, 25, 5, -29 },
  { 2266, 17, 29, 25, 4, -29 },
  { 2328, 17, 29, 25, 4, -29 },
  { 2390, 19, 30, 25, 3, -30 },
  { 2462, 18, 29, 25, 5, -29 },
  { 2528, 20, 35, 25, 2, -30 },
  { 2616, 17, 29, 25, 5, -29 },
  { 2678, 19, 30, 25, 3, -30 },
  { 2750, 20, 29, 25, 2, -29 },
  { 2823, 17, 29, 25, 4, -29 },
  { 2885, 20, 29, 25, 2, -29 },
  { 2958, 22, 29, 25, 2, -29 },
  { 3038, 20, 29, 25, 3, -29 },
  { 3111, 20, 29, 25, 2, -29 },
  { 3184, 18, 29, 25, 3, -29 },
  { 3250, 6, 39, 25, 10, -33 },
  { 3280, 13, 32, 25, 6, -29 },
  { 3332, 6, 39, 25, 9, -33 },
  { 3362, 14, 16, 25, 5, -29 },
  { 3390, 17, 1, 25, 4, 0 },
  { 3393, 5, 5, 25, 10, -30 },
  { 3397, 17, 22, 25, 4, -22 },
  { 3444, 17, 31, 25, 4, -31 },
  { 3510, 17, 22, 25, 4, -22 },
  { 3557, 16, 31, 25, 4, -31 },
  { 3619, 18, 22, 25, 3, -22 },
  { 3669, 18, 31, 25, 4, -31 },
  { 3739, 16, 31, 25, 4, -22 },
  { 3801, 17, 31, 25, 4, -31 },
  { 3867, 17, 29, 25, 5, -29 },
  { 3929, 12, 38, 25, 4, -29 },
  { 3986, 17, 31, 25, 5, -31 },
  { 4052, 17, 31, 25, 5, -31 },
  { 4118, 21, 22, 25, 2, -22 },
  { 4176, 17, 22, 25, 4, -22 },
  { 4223, 19, 22, 25, 3, -22 },
  { 4276, 17, 30, 25, 4, -22 },
  { 4340, 16, 30, 25, 4, -22 },
  { 4400, 14, 22, 25, 8, -22 },
  { 4439, 17, 22, 25, 4, -22 },
  { 4486, 16, 28, 25, 4, -28 },
  { 4542, 16, 22, 25, 4, -22 },
  { 4586, 20, 22, 25, 2, -22 },
  { 4641, 21, 22, 25, 2, -22 },
  { 4699, 19, 22, 25, 3, -22 },
  { 4752, 21, 31, 25, 2, -22 },
  { 4834, 19, 22, 25, 3, -22 },
  { 4887, 13, 41, 25, 7, -32 },
  { 4954, 1, 34, 25, 12, -29 },
  { 4959, 13, 41, 25, 7, -32 },
  { 5026, 22, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_Thin41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin41pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_THIN41PT7B_H_
