#ifndef _ROBOTOMONO_THIN35PT7B_H_
#define _ROBOTOMONO_THIN35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin35pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x50, 0x01, 0xC0, 0x8C, 0x63, 0x18, 0xC6,
  0x20, 0x00, 0x81, 0x00, 0x10, 0x20, 0x04, 0x04, 0x00, 0x81, 0x00, 0x10,
  0x20, 0x02, 0x04, 0x00, 0x40, 0x83, 0xFF, 0xFF, 0x02, 0x02, 0x00, 0x40,
  0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x08, 0x08, 0x01, 0x02,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x1F, 0xFF, 0xF8, 0x10, 0x20, 0x04, 0x04,
  0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x10, 0x10,
  0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x3F, 0x01, 0x81, 0x84, 0x01,
  0x88, 0x01, 0x20, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x40, 0x08, 0x40, 0x20, 0x7F, 0x80, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x3C, 0x00, 0x08, 0x40, 0x02, 0x08, 0x00, 0x40, 0x81, 0x08, 0x10,
  0x41, 0x02, 0x08, 0x20, 0x42, 0x04, 0x08, 0x40, 0x81, 0x10, 0x08, 0x42,
  0x00, 0xF0, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x21,
  0xE0, 0x08, 0x42, 0x01, 0x10, 0x20, 0x42, 0x04, 0x08, 0x40, 0x82, 0x08,
  0x10, 0x41, 0x02, 0x10, 0x20, 0x42, 0x04, 0x08, 0x00, 0x42, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x0C, 0x30, 0x04, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x80, 0x10, 0x80, 0x0C, 0x80, 0x02, 0x80,
  0x01, 0x80, 0x01, 0xA0, 0x01, 0x98, 0x01, 0x84, 0x04, 0x81, 0x02, 0x80,
  0x41, 0x40, 0x10, 0xA0, 0x04, 0x90, 0x03, 0x48, 0x00, 0xE4, 0x00, 0x21,
  0x00, 0x28, 0x40, 0x62, 0x1F, 0xC0, 0x80, 0xFE, 0x02, 0x0C, 0x10, 0x41,
  0x02, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x07, 0x84, 0x71, 0xDE, 0x00, 0xC0, 0x03, 0x80, 0x12, 0x00, 0x84, 0x04,
  0x08, 0x30, 0x10, 0x80, 0x60, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x7F, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x24, 0xA4,
  0xA0, 0xFF, 0xF8, 0xF0, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x20,
  0x20, 0x80, 0x23, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0xC0, 0x05,
  0x80, 0x13, 0x00, 0x46, 0x01, 0x0C, 0x04, 0x18, 0x10, 0x30, 0x40, 0x61,
  0x00, 0xC4, 0x01, 0x90, 0x03, 0x40, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x48, 0x00, 0x88, 0x02, 0x08, 0x08, 0x0F, 0xE0, 0x01, 0x07, 0x19, 0xE1,
  0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x0F, 0xE0, 0x60,
  0x60, 0x80, 0x22, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x7F, 0xFE, 0x0F, 0xE0, 0x20, 0x20,
  0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x60, 0x03, 0x80, 0x7E, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28,
  0x00, 0x98, 0x01, 0x18, 0x0C, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0A, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x40, 0x04, 0x20, 0x06, 0x10,
  0x02, 0x08, 0x02, 0x04, 0x03, 0x02, 0x01, 0x01, 0x01, 0x00, 0x81, 0x80,
  0x40, 0x80, 0x20, 0x80, 0x10, 0xC0, 0x08, 0x7F, 0xFF, 0xC0, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x3F, 0xFC, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x0E, 0x05, 0x86, 0x18, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x05, 0x00, 0x26, 0x00, 0x8C, 0x04, 0x0F, 0xE0, 0x01, 0xF0, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x1F, 0xC2, 0xC0, 0x46, 0x00, 0x4C, 0x00, 0x50, 0x00, 0xA0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x2C, 0x00,
  0x48, 0x00, 0x88, 0x02, 0x08, 0x08, 0x0F, 0xE0, 0xFF, 0xFF, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F, 0xE0,
  0x18, 0x18, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x30, 0x08, 0x0C, 0x30, 0x07, 0xE0,
  0x18, 0x18, 0x20, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x0F, 0xF0,
  0x0F, 0xE0, 0x20, 0x60, 0x80, 0x22, 0x00, 0x64, 0x00, 0x50, 0x00, 0xA0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00,
  0x68, 0x01, 0x48, 0x06, 0x88, 0x19, 0x0F, 0xC2, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x12, 0x49, 0x28,
  0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x40, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x0F, 0xC1, 0x81, 0x18, 0x04,
  0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x01, 0xFC, 0x00, 0xE0, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x04,
  0x40, 0xE0, 0x90, 0x63, 0x0A, 0x18, 0x21, 0x42, 0x04, 0x30, 0x41, 0x06,
  0x10, 0x20, 0xC2, 0x04, 0x18, 0x40, 0x83, 0x08, 0x10, 0x61, 0x02, 0x0C,
  0x20, 0xC1, 0x84, 0x18, 0x50, 0x85, 0x0A, 0x18, 0xA2, 0x21, 0xE3, 0xC4,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x07, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x50, 0x00, 0x28, 0x00, 0x12, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x04, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x40, 0x10, 0x20, 0x08, 0x10, 0x02,
  0x0F, 0xFF, 0x08, 0x00, 0x84, 0x00, 0x22, 0x00, 0x12, 0x00, 0x09, 0x00,
  0x02, 0x80, 0x01, 0x80, 0x00, 0x80, 0xFF, 0x81, 0x00, 0xC2, 0x00, 0x44,
  0x00, 0x48, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x44, 0x07, 0x0F, 0xFE, 0x10, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x00, 0xA0,
  0x02, 0x40, 0x18, 0xFF, 0xC0, 0x07, 0xF0, 0x0C, 0x08, 0x10, 0x04, 0x20,
  0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x20,
  0x02, 0x10, 0x06, 0x08, 0x0C, 0x07, 0xF0, 0xFF, 0x80, 0x80, 0x60, 0x80,
  0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x60, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xF2, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xFF, 0xF2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x07, 0xF0, 0x0C, 0x0C, 0x10, 0x06, 0x20, 0x02, 0x20, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7F, 0x80, 0x01, 0x80, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08,
  0x06, 0x07, 0xF8, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x28, 0x00,
  0x88, 0x02, 0x18, 0x0C, 0x0F, 0xE0, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08,
  0x80, 0x10, 0x80, 0x20, 0x80, 0x40, 0x80, 0x80, 0x81, 0x80, 0x83, 0x00,
  0x86, 0x00, 0x84, 0x00, 0x88, 0x00, 0x94, 0x00, 0xA2, 0x00, 0xC3, 0x00,
  0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x08, 0x80, 0x04, 0x80, 0x02, 0x80, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xFF, 0xFC, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1D, 0x00, 0x5A,
  0x00, 0xB2, 0x01, 0x64, 0x04, 0xC8, 0x09, 0x88, 0x23, 0x10, 0x46, 0x10,
  0x8C, 0x22, 0x18, 0x44, 0x30, 0x50, 0x60, 0xA0, 0xC1, 0x41, 0x81, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0D, 0x00, 0x1A, 0x00,
  0x32, 0x00, 0x62, 0x00, 0xC4, 0x01, 0x84, 0x03, 0x08, 0x06, 0x08, 0x0C,
  0x10, 0x18, 0x10, 0x30, 0x10, 0x60, 0x20, 0xC0, 0x21, 0x80, 0x43, 0x00,
  0x46, 0x00, 0x8C, 0x00, 0x98, 0x00, 0xB0, 0x01, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x02, 0x07, 0xF0, 0x04, 0x04, 0x04, 0x01, 0x04, 0x00, 0x42, 0x00,
  0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x22, 0x00, 0x21, 0x00,
  0x10, 0x40, 0x10, 0x10, 0x10, 0x07, 0xF0, 0x00, 0xFF, 0xC1, 0x00, 0x62,
  0x00, 0x24, 0x00, 0x28, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x90, 0x1E, 0x3F, 0xC0,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x04, 0x04, 0x04,
  0x01, 0x04, 0x00, 0x44, 0x00, 0x12, 0x00, 0x09, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x24, 0x00, 0x11, 0x00, 0x10, 0x40, 0x18, 0x10, 0x18, 0x07, 0xF0,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x08, 0xFF,
  0x81, 0x00, 0xC2, 0x00, 0x44, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x03, 0x1F,
  0xF8, 0x20, 0x20, 0x40, 0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0x84, 0x00,
  0x88, 0x00, 0x90, 0x01, 0x20, 0x01, 0x40, 0x02, 0x80, 0x02, 0x0F, 0xE0,
  0x10, 0x18, 0x20, 0x04, 0x40, 0x06, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x0F, 0xF0,
  0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x48, 0x00, 0x88,
  0x02, 0x08, 0x08, 0x0F, 0xE0, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x10, 0x04,
  0x08, 0x02, 0x04, 0x01, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x24, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50,
  0x24, 0x12, 0x09, 0x04, 0x82, 0x41, 0x20, 0x90, 0x48, 0x24, 0x22, 0x11,
  0x08, 0x44, 0x22, 0x11, 0x08, 0x84, 0x42, 0x21, 0x10, 0x90, 0x44, 0x24,
  0x09, 0x09, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x18, 0x0A, 0x06, 0x01,
  0x81, 0x80, 0x40, 0x60, 0x10, 0x08, 0x04, 0x00, 0xC0, 0x00, 0xA0, 0x00,
  0x88, 0x00, 0x42, 0x00, 0x41, 0x00, 0x40, 0x40, 0x20, 0x10, 0x20, 0x08,
  0x20, 0x02, 0x10, 0x01, 0x90, 0x00, 0x58, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x04, 0x80, 0x04, 0x40, 0x02, 0x10, 0x02, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x81, 0x00, 0x21, 0x00, 0x10, 0x80, 0x04, 0x80, 0x03, 0xC0,
  0x00, 0x80, 0x80, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x42, 0x00,
  0x21, 0x00, 0x20, 0x40, 0x30, 0x30, 0x10, 0x08, 0x10, 0x02, 0x08, 0x01,
  0x08, 0x00, 0x44, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0xF8, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0xF8, 0x02, 0x00, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x88, 0x04, 0x40, 0x41, 0x02, 0x08, 0x10, 0x41, 0x01, 0x08, 0x08,
  0x80, 0x24, 0x01, 0x60, 0x0C, 0xFF, 0xFE, 0xC2, 0x08, 0x21, 0x80, 0x07,
  0xC0, 0x30, 0x60, 0x80, 0x22, 0x00, 0x24, 0x00, 0x48, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x1F, 0xF8, 0xC0, 0x0A, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x40, 0x02, 0x40, 0x0A, 0xC0, 0x64, 0x7F, 0x08, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x21,
  0xE0, 0x98, 0x62, 0x80, 0x4C, 0x01, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x28, 0x00, 0xB0, 0x04, 0xA0, 0x22, 0x7F, 0x00, 0x07, 0xC0, 0x30,
  0x60, 0xC0, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x50,
  0x00, 0xA0, 0x02, 0x20, 0x04, 0x20, 0x30, 0x3F, 0x80, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x41, 0xE1, 0x18,
  0x64, 0x80, 0x56, 0x00, 0xD0, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14,
  0x00, 0x48, 0x03, 0x10, 0x14, 0x3F, 0x90, 0x03, 0xC0, 0x18, 0x60, 0xC0,
  0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x06, 0x30, 0x18, 0x1F, 0xC0, 0x00, 0x1C, 0x03, 0x84, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0xFF, 0xF8,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x07, 0x80,
  0x61, 0x93, 0x01, 0x48, 0x03, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00,
  0x50, 0x01, 0x20, 0x0C, 0x40, 0x50, 0xFE, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x98, 0x02, 0x30, 0x10, 0x3F, 0x80, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x21, 0xF0, 0x98, 0x32,
  0x80, 0x4C, 0x00, 0xB0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0xFF, 0xFC, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x47, 0xF0, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x02, 0x80, 0x19, 0x00, 0x62, 0x01, 0x84, 0x04, 0x08, 0x10, 0x10, 0x40,
  0x21, 0x00, 0x4C, 0x00, 0xB4, 0x01, 0x84, 0x02, 0x04, 0x04, 0x0C, 0x08,
  0x0C, 0x10, 0x0C, 0x20, 0x08, 0x40, 0x08, 0x80, 0x09, 0x00, 0x0C, 0xFF,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0, 0x0F, 0x0F, 0x16,
  0x12, 0x1A, 0x81, 0x81, 0x60, 0x20, 0x2C, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x07, 0xC2, 0x60, 0x8A, 0x01,
  0x30, 0x02, 0xC0, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0xE0, 0x06, 0x0C, 0x04, 0x01, 0x04,
  0x00, 0x42, 0x00, 0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x14, 0x00, 0x12, 0x00, 0x09, 0x00,
  0x04, 0x40, 0x04, 0x10, 0x04, 0x0C, 0x06, 0x01, 0xFC, 0x00, 0x07, 0x82,
  0x61, 0x8E, 0x03, 0x30, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0xC0, 0x12, 0x80, 0x89, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07, 0x80, 0x61, 0x93,
  0x01, 0x48, 0x03, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x01,
  0x20, 0x0C, 0x40, 0x50, 0xFE, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x03, 0xF1, 0x82, 0xC0, 0x70, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x30,
  0x30, 0x80, 0x12, 0x00, 0x34, 0x00, 0x28, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xA0, 0x01, 0x40, 0x06, 0x60, 0x18, 0x3F, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0xFF, 0xF8, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x0F, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x28, 0x03, 0x60, 0x28, 0xFE, 0x40, 0x80, 0x01, 0xA0, 0x00,
  0x90, 0x00, 0x44, 0x00, 0x42, 0x00, 0x20, 0x80, 0x20, 0x40, 0x10, 0x30,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x01, 0x04, 0x00, 0x82, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x40, 0x28, 0x0C, 0x05, 0x02, 0x81, 0x20, 0x50, 0x24, 0x0A, 0x04, 0x41,
  0x20, 0x88, 0x44, 0x21, 0x08, 0x84, 0x21, 0x10, 0x82, 0x21, 0x10, 0x48,
  0x24, 0x09, 0x04, 0x81, 0x20, 0x90, 0x14, 0x0A, 0x03, 0x01, 0x40, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x40, 0xC0, 0x07, 0x20, 0x04, 0x30, 0x08,
  0x10, 0x10, 0x08, 0x30, 0x04, 0x60, 0x02, 0x40, 0x03, 0x80, 0x01, 0x00,
  0x03, 0x80, 0x02, 0x40, 0x04, 0x60, 0x08, 0x30, 0x10, 0x10, 0x30, 0x08,
  0x20, 0x04, 0x40, 0x06, 0x80, 0x03, 0xC0, 0x00, 0x68, 0x00, 0x08, 0x80,
  0x02, 0x10, 0x00, 0x41, 0x00, 0x10, 0x20, 0x02, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x04, 0x00, 0x80, 0x80, 0x08, 0x30, 0x01, 0x04, 0x00, 0x10,
  0x80, 0x02, 0x20, 0x00, 0x64, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x60, 0x30,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0xE0, 0x1C, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18,
  0x00, 0xC0, 0x1C, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x18,
  0x02, 0x00, 0x00, 0x3E, 0x00, 0x2C, 0x30, 0x05, 0x01, 0x01, 0x40, 0x10,
  0x28, 0x01, 0xF8,
};

const GFXglyph RobotoMono_Thin35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 2, 25, 21, 9, -25 },
  { 8, 5, 7, 21, 8, -26 },
  { 13, 19, 25, 21, 1, -25 },
  { 73, 15, 32, 21, 3, -28 },
  { 133, 19, 25, 21, 1, -25 },
  { 193, 17, 25, 21, 3, -25 },
  { 247, 1, 7, 21, 9, -26 },
  { 248, 7, 36, 21, 7, -28 },
  { 280, 8, 36, 21, 6, -28 },
  { 316, 14, 14, 21, 4, -25 },
  { 341, 17, 19, 21, 2, -21 },
  { 382, 3, 7, 21, 7, -3 },
  { 385, 13, 1, 21, 4, -12 },
  { 387, 2, 2, 21, 10, -2 },
  { 388, 12, 27, 21, 5, -25 },
  { 429, 15, 25, 21, 3, -25 },
  { 476, 8, 25, 21, 4, -25 },
  { 501, 15, 25, 21, 2, -25 },
  { 548, 15, 25, 21, 2, -25 },
  { 595, 17, 25, 21, 2, -25 },
  { 649, 14, 25, 21, 4, -25 },
  { 693, 15, 25, 21, 3, -25 },
  { 740, 16, 25, 21, 2, -25 },
  { 790, 16, 25, 21, 3, -25 },
  { 840, 15, 25, 21, 3, -25 },
  { 887, 2, 17, 21, 11, -17 },
  { 892, 3, 21, 21, 10, -17 },
  { 900, 15, 14, 21, 3, -18 },
  { 927, 15, 8, 21, 3, -15 },
  { 942, 15, 13, 21, 3, -18 },
  { 967, 13, 25, 21, 4, -25 },
  { 1008, 19, 25, 21, 1, -25 },
  { 1068, 17, 25, 21, 2, -25 },
  { 1122, 15, 25, 21, 4, -25 },
  { 1169, 16, 25, 21, 2, -25 },
  { 1219, 16, 25, 21, 3, -25 },
  { 1269, 14, 25, 21, 4, -25 },
  { 1313, 14, 25, 21, 4, -25 },
  { 1357, 16, 25, 21, 2, -25 },
  { 1407, 15, 25, 21, 3, -25 },
  { 1454, 13, 25, 21, 4, -25 },
  { 1495, 15, 25, 21, 2, -25 },
  { 1542, 16, 25, 21, 4, -25 },
  { 1592, 14, 25, 21, 4, -25 },
  { 1636, 15, 25, 21, 3, -25 },
  { 1683, 15, 25, 21, 3, -25 },
  { 1730, 17, 25, 21, 2, -25 },
  { 1784, 15, 25, 21, 4, -25 },
  { 1831, 17, 30, 21, 2, -25 },
  { 1895, 15, 25, 21, 4, -25 },
  { 1942, 16, 25, 21, 3, -25 },
  { 1992, 17, 25, 21, 2, -25 },
  { 2046, 15, 25, 21, 3, -25 },
  { 2093, 17, 25, 21, 2, -25 },
  { 2147, 18, 25, 21, 2, -25 },
  { 2204, 17, 25, 21, 2, -25 },
  { 2258, 17, 25, 21, 2, -25 },
  { 2312, 16, 25, 21, 2, -25 },
  { 2362, 5, 33, 21, 8, -28 },
  { 2383, 11, 27, 21, 5, -25 },
  { 2421, 5, 33, 21, 8, -28 },
  { 2442, 13, 14, 21, 4, -25 },
  { 2465, 15, 1, 21, 3, 0 },
  { 2467, 5, 5, 21, 8, -26 },
  { 2471, 15, 19, 21, 3, -19 },
  { 2507, 14, 26, 21, 4, -26 },
  { 2553, 15, 19, 21, 3, -19 },
  { 2589, 14, 26, 21, 3, -26 },
  { 2635, 15, 19, 21, 3, -19 },
  { 2671, 15, 27, 21, 4, -27 },
  { 2722, 14, 26, 21, 3, -19 },
  { 2768, 14, 26, 21, 4, -26 },
  { 2814, 14, 25, 21, 4, -25 },
  { 2858, 11, 32, 21, 3, -25 },
  { 2902, 15, 26, 21, 4, -26 },
  { 2951, 14, 26, 21, 4, -26 },
  { 2997, 19, 19, 21, 1, -19 },
  { 3043, 14, 19, 21, 4, -19 },
  { 3077, 17, 19, 21, 2, -19 },
  { 3118, 14, 26, 21, 4, -19 },
  { 3164, 14, 26, 21, 3, -19 },
  { 3210, 11, 19, 21, 7, -19 },
  { 3237, 15, 19, 21, 3, -19 },
  { 3273, 14, 23, 21, 3, -23 },
  { 3314, 13, 18, 21, 4, -18 },
  { 3344, 17, 18, 21, 2, -18 },
  { 3383, 19, 18, 21, 1, -18 },
  { 3426, 16, 18, 21, 3, -18 },
  { 3462, 19, 25, 21, 1, -18 },
  { 3522, 17, 18, 21, 2, -18 },
  { 3561, 11, 35, 21, 6, -27 },
  { 3610, 1, 30, 21, 10, -25 },
  { 3614, 11, 35, 21, 6, -27 },
  { 3663, 19, 5, 21, 1, -13 },
};

const GFXfont RobotoMono_Thin35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin35pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_THIN35PT7B_H_
