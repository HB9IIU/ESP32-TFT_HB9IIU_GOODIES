#ifndef _ROBOTOMONO_THIN51PT7B_H_
#define _ROBOTOMONO_THIN51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin51pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x00, 0x2F, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0xC3, 0x00, 0x10, 0x06, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x40, 0x18, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x60, 0x08, 0x00, 0x0C, 0x01, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x0C,
  0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0x30, 0x04, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x80, 0x30, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0x80,
  0x00, 0xC0, 0x10, 0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40,
  0x18, 0x00, 0x08, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0,
  0x0C, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x01,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x04, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x80, 0x30, 0x00, 0x10, 0x06, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xFC, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0x80,
  0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x06, 0x40, 0x00, 0x09, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x98, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xA0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x90, 0x00,
  0x02, 0x60, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x80, 0x70,
  0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x20, 0x00, 0x0C, 0x03,
  0x00, 0x40, 0xC0, 0x10, 0x0C, 0x08, 0x01, 0x00, 0x80, 0x80, 0x10, 0x18,
  0x08, 0x01, 0x01, 0x00, 0xC0, 0x10, 0x30, 0x0C, 0x03, 0x02, 0x00, 0x40,
  0x30, 0x40, 0x04, 0x02, 0x0C, 0x00, 0x20, 0x60, 0x80, 0x03, 0x9C, 0x18,
  0x00, 0x0F, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0xF8, 0x00, 0x08,
  0x38, 0xC0, 0x01, 0x02, 0x02, 0x00, 0x30, 0x60, 0x30, 0x02, 0x04, 0x01,
  0x00, 0x60, 0x40, 0x10, 0x04, 0x0C, 0x01, 0x00, 0xC0, 0xC0, 0x10, 0x08,
  0x0C, 0x01, 0x01, 0x80, 0xC0, 0x10, 0x10, 0x04, 0x01, 0x03, 0x00, 0x40,
  0x10, 0x20, 0x06, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x80, 0x02, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x20,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x80, 0xC0, 0x08, 0xC0, 0x20, 0x0C, 0xC0, 0x18, 0x06, 0x40, 0x06, 0x03,
  0x60, 0x01, 0x81, 0x30, 0x00, 0x60, 0x90, 0x00, 0x10, 0xC8, 0x00, 0x04,
  0x66, 0x00, 0x03, 0x63, 0x00, 0x00, 0xF0, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x3C, 0x10, 0x00, 0x32, 0x0E, 0x00, 0x30, 0x81, 0xC0, 0x70, 0x60, 0x7F,
  0xE0, 0x18, 0x01, 0x00, 0x00, 0x55, 0x55, 0xF0, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x80, 0x10, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x04, 0x01, 0x00, 0xFC, 0x04, 0x1E, 0x1E, 0x31, 0xE0, 0x0F, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x4C, 0x00, 0x02, 0x18, 0x00, 0x18,
  0x20, 0x00, 0xC0, 0x40, 0x06, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x06,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x11, 0x11, 0x33, 0x22, 0x6C, 0xFF, 0xFF, 0xC0, 0xDF, 0x00, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0x40, 0x00, 0x42, 0x00, 0x01,
  0x88, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x34, 0x00, 0x01, 0xD0,
  0x00, 0x0D, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x1C, 0x00, 0x18, 0x70, 0x00,
  0xC1, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x1C, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0xC0, 0x60, 0x07, 0x03, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xC0, 0x01, 0xC6,
  0x00, 0x07, 0x30, 0x00, 0x15, 0x80, 0x00, 0x5C, 0x00, 0x01, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x22, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x10, 0x00, 0x30,
  0x60, 0x00, 0x80, 0xC0, 0x06, 0x01, 0xC0, 0x60, 0x01, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x1F, 0x07, 0x31, 0xC3, 0x70, 0x3C, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x30, 0x30, 0x00, 0x61, 0x80, 0x00,
  0x84, 0x00, 0x03, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x48,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x60,
  0x01, 0x81, 0x80, 0x01, 0x82, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x10, 0x00,
  0x02, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x90, 0x00, 0x02, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x20, 0x00, 0x06, 0x08,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x20, 0x00, 0x30,
  0x08, 0x00, 0x08, 0x02, 0x00, 0x06, 0x00, 0x80, 0x03, 0x00, 0x20, 0x00,
  0x80, 0x08, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0x20,
  0x06, 0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x20, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x1F, 0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0xFC, 0x01, 0xBF, 0xF8, 0x0B, 0x00, 0x70, 0x60, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x09, 0x00, 0x00, 0xCC, 0x00,
  0x04, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x03, 0x80, 0xE0, 0x07, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x01, 0xF0, 0x04, 0x3F, 0xF8, 0x33, 0x80, 0x30, 0xD8,
  0x00, 0x62, 0xC0, 0x00, 0xCE, 0x00, 0x01, 0x30, 0x00, 0x06, 0xC0, 0x00,
  0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x26, 0x00, 0x01, 0x88, 0x00, 0x06, 0x30, 0x00, 0x30, 0x60, 0x00,
  0x80, 0xC0, 0x0E, 0x01, 0xC0, 0x60, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x08, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x03, 0xC3, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0x81, 0xC0,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x04,
  0x40, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x1C, 0x00, 0x38, 0x07, 0x00, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x60, 0x1C, 0x07, 0x00, 0x18, 0x10, 0x00, 0x20, 0xC0, 0x00, 0xC6, 0x00,
  0x01, 0x98, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x05, 0x30, 0x00, 0x34, 0x60, 0x01, 0x90, 0xC0, 0x0C, 0x41, 0xC0, 0xE3,
  0x03, 0xFE, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x5F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x17,
  0xE0, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x46, 0x23, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x70, 0x0C,
  0x18, 0x00, 0xC2, 0x00, 0x0C, 0xC0, 0x00, 0x90, 0x00, 0x16, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x06, 0x18, 0x07, 0xC0, 0x21, 0x00, 0xE7, 0x02, 0x30, 0x10, 0x10, 0x32,
  0x02, 0x01, 0x03, 0x20, 0x60, 0x10, 0x16, 0x04, 0x01, 0x01, 0x40, 0xC0,
  0x10, 0x14, 0x0C, 0x01, 0x01, 0x40, 0x80, 0x30, 0x14, 0x08, 0x03, 0x01,
  0xC0, 0x80, 0x30, 0x1C, 0x18, 0x02, 0x01, 0xC1, 0x80, 0x20, 0x1C, 0x18,
  0x02, 0x03, 0xC1, 0x80, 0x60, 0x3C, 0x18, 0x06, 0x03, 0x40, 0x80, 0x60,
  0x24, 0x08, 0x0A, 0x02, 0x40, 0x81, 0xA0, 0x44, 0x0C, 0x13, 0x0C, 0x60,
  0x66, 0x19, 0x82, 0x03, 0xC0, 0xF0, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x10, 0x10, 0x00, 0x08, 0x0C, 0x00,
  0x0C, 0x02, 0x00, 0x04, 0x01, 0x00, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x01,
  0x00, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x10, 0x0F, 0xFF,
  0xFC, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x10, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x20, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x10,
  0xFF, 0xFC, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x23, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x30, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x70, 0xC0, 0x0F, 0x03, 0xFF,
  0xFC, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x03, 0x8C, 0x00, 0x78,
  0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x18, 0x03, 0x00,
  0x60, 0x03, 0x01, 0x80, 0x03, 0x06, 0x00, 0x03, 0x08, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x98, 0x00, 0x03, 0x10, 0x00, 0x04, 0x10,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x30, 0x01, 0x80, 0x38, 0x0E, 0x00, 0x1F,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0x00, 0x1C, 0x02, 0x00,
  0x0E, 0x04, 0x00, 0x06, 0x08, 0x00, 0x06, 0x10, 0x00, 0x06, 0x20, 0x00,
  0x04, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x09, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40,
  0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x90, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00,
  0x30, 0x80, 0x00, 0xC1, 0x00, 0x06, 0x02, 0x00, 0x78, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01,
  0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x0E, 0x01, 0x80, 0x38, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x26, 0x00, 0x01, 0x88, 0x00,
  0x0C, 0x30, 0x00, 0x20, 0x60, 0x03, 0x80, 0xE0, 0x38, 0x00, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC4,
  0x00, 0x03, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x40,
  0x03, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x04, 0x01,
  0x00, 0x08, 0x04, 0x00, 0x10, 0x18, 0x00, 0x20, 0x60, 0x00, 0x41, 0x80,
  0x00, 0x87, 0x00, 0x01, 0x1A, 0x00, 0x02, 0x62, 0x00, 0x05, 0x86, 0x00,
  0x0E, 0x06, 0x00, 0x18, 0x06, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x0C, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x08,
  0x00, 0x08, 0x10, 0x00, 0x18, 0x20, 0x00, 0x18, 0x40, 0x00, 0x18, 0x80,
  0x00, 0x11, 0x00, 0x00, 0x12, 0x00, 0x00, 0x34, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE8, 0x00, 0x0B, 0xA0, 0x00, 0x2E,
  0xC0, 0x01, 0xB9, 0x00, 0x04, 0xE6, 0x00, 0x33, 0x88, 0x00, 0x8E, 0x20,
  0x02, 0x38, 0xC0, 0x18, 0xE1, 0x00, 0x43, 0x84, 0x03, 0x0E, 0x18, 0x08,
  0x38, 0x20, 0x20, 0xE0, 0xC1, 0x83, 0x81, 0x04, 0x0E, 0x04, 0x30, 0x38,
  0x18, 0x80, 0xE0, 0x22, 0x03, 0x80, 0xD0, 0x0E, 0x01, 0x40, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x74, 0x00, 0x01,
  0xD0, 0x00, 0x07, 0x20, 0x00, 0x1C, 0xC0, 0x00, 0x71, 0x00, 0x01, 0xC6,
  0x00, 0x07, 0x08, 0x00, 0x1C, 0x30, 0x00, 0x70, 0x40, 0x01, 0xC0, 0x80,
  0x07, 0x03, 0x00, 0x1C, 0x04, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x20, 0x07,
  0x00, 0xC0, 0x1C, 0x01, 0x00, 0x70, 0x02, 0x01, 0xC0, 0x0C, 0x07, 0x00,
  0x10, 0x1C, 0x00, 0x60, 0x70, 0x00, 0x81, 0xC0, 0x03, 0x07, 0x00, 0x04,
  0x1C, 0x00, 0x08, 0x70, 0x00, 0x21, 0xC0, 0x00, 0x47, 0x00, 0x01, 0x9C,
  0x00, 0x02, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x17, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x18, 0x07,
  0x00, 0x60, 0x03, 0x01, 0x80, 0x03, 0x06, 0x00, 0x02, 0x08, 0x00, 0x06,
  0x30, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x48, 0x00, 0x01, 0x98, 0x00, 0x02, 0x10, 0x00, 0x0C,
  0x10, 0x00, 0x10, 0x30, 0x00, 0x40, 0x30, 0x01, 0x80, 0x38, 0x0C, 0x00,
  0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x0E, 0x08,
  0x00, 0x0E, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x12, 0x00, 0x00, 0x68, 0x00,
  0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0,
  0x00, 0x06, 0x80, 0x00, 0x32, 0x00, 0x01, 0x88, 0x00, 0x1C, 0x3F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x04, 0x60, 0x00,
  0x02, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0x80, 0x00, 0x18, 0x20, 0x00,
  0x08, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0xFF, 0xFC, 0x02, 0x00, 0x3C, 0x08, 0x00, 0x18, 0x20,
  0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x00, 0x88, 0x00, 0x03, 0x20, 0x00,
  0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80,
  0x00, 0x42, 0x00, 0x06, 0x08, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0x80, 0x08,
  0x02, 0x00, 0x30, 0x08, 0x00, 0x40, 0x20, 0x01, 0x80, 0x80, 0x02, 0x02,
  0x00, 0x0C, 0x08, 0x00, 0x18, 0x20, 0x00, 0x20, 0x80, 0x00, 0xC2, 0x00,
  0x01, 0x08, 0x00, 0x06, 0x20, 0x00, 0x08, 0x80, 0x00, 0x32, 0x00, 0x00,
  0x68, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x38, 0x03, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x84, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x20, 0x00, 0x02, 0x40, 0x00, 0x06, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x04, 0x60, 0x00, 0x18, 0x70, 0x00, 0x60, 0x38,
  0x07, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x50, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x22,
  0x00, 0x01, 0x8C, 0x00, 0x04, 0x18, 0x00, 0x30, 0x30, 0x01, 0x80, 0x70,
  0x1C, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x08,
  0x00, 0x06, 0x06, 0x00, 0x02, 0x03, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x80, 0x30, 0x00, 0x40, 0x08, 0x00, 0x60, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x18, 0x00, 0x40, 0x08, 0x00, 0x30, 0x04,
  0x00, 0x08, 0x06, 0x00, 0x04, 0x02, 0x00, 0x03, 0x01, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x40, 0x80, 0x00, 0x30, 0x40, 0x00, 0x08, 0x60, 0x00, 0x04,
  0x20, 0x00, 0x03, 0x10, 0x00, 0x00, 0x98, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x28, 0x00, 0xC0, 0x05, 0x00, 0x18, 0x00, 0xA0, 0x07,
  0x00, 0x34, 0x00, 0xE0, 0x04, 0xC0, 0x16, 0x00, 0x98, 0x02, 0xC0, 0x11,
  0x00, 0x48, 0x02, 0x20, 0x19, 0x00, 0x44, 0x03, 0x20, 0x18, 0x80, 0x46,
  0x03, 0x18, 0x08, 0xC0, 0x43, 0x01, 0x08, 0x08, 0x20, 0x61, 0x01, 0x04,
  0x0C, 0x20, 0x20, 0x81, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08,
  0x20, 0x61, 0x81, 0x04, 0x04, 0x30, 0x20, 0x80, 0x84, 0x06, 0x10, 0x10,
  0x80, 0xC2, 0x02, 0x10, 0x08, 0xC0, 0x66, 0x01, 0x10, 0x0C, 0xC0, 0x22,
  0x00, 0x98, 0x06, 0x40, 0x12, 0x00, 0xC8, 0x02, 0x40, 0x09, 0x00, 0x48,
  0x01, 0x60, 0x0B, 0x00, 0x28, 0x01, 0xE0, 0x05, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x60, 0x00, 0x01, 0x90, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x83,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x18, 0x00, 0x60,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x20, 0x00, 0x80, 0x30, 0x00, 0x60, 0x10,
  0x00, 0x18, 0x10, 0x00, 0x04, 0x18, 0x00, 0x03, 0x08, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x08, 0x00, 0x01,
  0x06, 0x00, 0x01, 0x81, 0x00, 0x01, 0x80, 0x40, 0x00, 0x80, 0x30, 0x00,
  0xC0, 0x08, 0x00, 0x40, 0x06, 0x00, 0x40, 0x01, 0x80, 0x60, 0x00, 0x40,
  0x20, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x10, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x58, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x04, 0x00, 0x18,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00,
  0x60, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x08, 0x40, 0x00, 0x03, 0x30, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x7F, 0xFE, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x06, 0xC0, 0x01,
  0x30, 0x00, 0xC4, 0x00, 0x21, 0x80, 0x18, 0x20, 0x04, 0x0C, 0x01, 0x01,
  0x00, 0xC0, 0x40, 0x20, 0x18, 0x18, 0x02, 0x04, 0x00, 0xC1, 0x00, 0x10,
  0xC0, 0x04, 0x20, 0x01, 0x98, 0x00, 0x24, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0xC1, 0x82, 0x04, 0x18, 0x20, 0x40, 0x03, 0xFE, 0x00, 0x70,
  0x1C, 0x06, 0x00, 0x30, 0x40, 0x00, 0xC6, 0x00, 0x03, 0x20, 0x00, 0x0B,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0x07, 0xE0, 0x08, 0xE0, 0x00, 0x4C,
  0x00, 0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00,
  0x28, 0x00, 0x01, 0x40, 0x00, 0x1A, 0x00, 0x01, 0xD8, 0x00, 0x1B, 0x60,
  0x01, 0x99, 0xC0, 0x78, 0xC3, 0xFF, 0x06, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x7F, 0xC0, 0x8C, 0x07, 0x09, 0x80, 0x18, 0xA0, 0x00, 0x8C,
  0x00, 0x0C, 0xC0, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x6C, 0x00, 0x04, 0xE0,
  0x00, 0x8B, 0x00, 0x18, 0x9C, 0x07, 0x08, 0x7F, 0xC0, 0x00, 0x40, 0x00,
  0x01, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x10,
  0x00, 0x18, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x98, 0x00, 0x03, 0x40, 0x00,
  0x0D, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x03, 0x20, 0x00, 0x0C, 0xC0, 0x00,
  0x21, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x1C, 0x07, 0x00,
  0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x03, 0xFC,
  0x10, 0x70, 0x38, 0x86, 0x00, 0x64, 0x60, 0x01, 0xA6, 0x00, 0x07, 0x30,
  0x00, 0x19, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00,
  0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05,
  0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00,
  0x0A, 0x18, 0x01, 0x90, 0x60, 0x38, 0x80, 0xFF, 0x04, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0x03, 0x80, 0x38, 0x01, 0x80, 0xC0, 0x01, 0x81,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x08, 0x00, 0x03, 0x30, 0x00, 0x02, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x17, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x02, 0x04, 0x00, 0x06, 0x06, 0x00, 0x38,
  0x07, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xFE, 0x08, 0x38, 0x1C, 0x43, 0x00, 0x32, 0x30, 0x00,
  0xD1, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00,
  0x00, 0x50, 0x00, 0x02, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x98, 0x00, 0x0C,
  0x40, 0x00, 0x63, 0x00, 0x05, 0x0C, 0x00, 0x68, 0x38, 0x1C, 0x40, 0x7F,
  0xC2, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x10, 0x00, 0x31, 0x80, 0x01, 0x06, 0x00, 0x10, 0x1C, 0x03,
  0x80, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x83,
  0xFE, 0x0C, 0x38, 0x1C, 0x67, 0x00, 0x33, 0x20, 0x00, 0x9A, 0x00, 0x06,
  0xE0, 0x00, 0x17, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x63, 0xE0, 0xFF, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00,
  0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C,
  0x18, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x19, 0xE0, 0x00, 0xD9, 0x80,
  0x07, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x04, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C,
  0x30, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x7F, 0xFF, 0xFC, 0x8F, 0xE0, 0x7F, 0x13, 0x06, 0x30, 0x32, 0xC0, 0x2C,
  0x03, 0x70, 0x07, 0x00, 0x2C, 0x00, 0xE0, 0x05, 0x80, 0x08, 0x00, 0xB0,
  0x01, 0x00, 0x1C, 0x00, 0x20, 0x03, 0x80, 0x04, 0x00, 0x70, 0x00, 0x80,
  0x0E, 0x00, 0x10, 0x01, 0xC0, 0x02, 0x00, 0x38, 0x00, 0x40, 0x07, 0x00,
  0x08, 0x00, 0xA0, 0x01, 0x00, 0x14, 0x00, 0x20, 0x02, 0x80, 0x04, 0x00,
  0x50, 0x00, 0x80, 0x0A, 0x00, 0x10, 0x01, 0x40, 0x02, 0x00, 0x28, 0x00,
  0x40, 0x05, 0x00, 0x08, 0x00, 0xA0, 0x01, 0x00, 0x14, 0x00, 0x20, 0x02,
  0x80, 0x04, 0x00, 0x50, 0x00, 0x80, 0x0A, 0x00, 0x10, 0x01, 0x00, 0xC1,
  0xFF, 0x06, 0x18, 0x0E, 0x33, 0x00, 0x19, 0xB0, 0x00, 0x4D, 0x00, 0x03,
  0x70, 0x00, 0x0B, 0x80, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x01, 0xFF,
  0x00, 0x0E, 0x03, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x10, 0x00, 0x03, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x05,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x16, 0x00, 0x00, 0x24, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0E, 0x03,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xC3, 0xFE, 0x06, 0x30, 0x18,
  0x36, 0x00, 0x31, 0xA0, 0x00, 0x8E, 0x00, 0x06, 0x70, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C,
  0x00, 0x01, 0x60, 0x00, 0x1B, 0x80, 0x01, 0x9E, 0x00, 0x08, 0xD8, 0x00,
  0xC6, 0x70, 0x1C, 0x30, 0xFF, 0x81, 0x80, 0x40, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x08,
  0x38, 0x1C, 0x43, 0x00, 0x32, 0x30, 0x00, 0xD1, 0x00, 0x03, 0x98, 0x00,
  0x0C, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0xC0,
  0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x05,
  0x0C, 0x00, 0xE8, 0x38, 0x1C, 0x40, 0x7F, 0x82, 0x00, 0x20, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x80,
  0xFF, 0xC1, 0xC0, 0x23, 0x00, 0x13, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x70, 0x0E, 0x06, 0x00, 0x18, 0x40, 0x00, 0x66, 0x00, 0x01, 0xA0, 0x00,
  0x05, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x6C, 0x00, 0x02,
  0x30, 0x00, 0x70, 0xE0, 0x0F, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0x60, 0x00,
  0x73, 0x00, 0x05, 0x10, 0x01, 0x90, 0xC0, 0x71, 0x07, 0xFE, 0x10, 0x04,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x90, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0x40, 0x00, 0x30, 0x30,
  0x00, 0x10, 0x08, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x04, 0x00,
  0x80, 0x06, 0x00, 0x60, 0x02, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x01, 0x00,
  0x02, 0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x60,
  0x00, 0x18, 0x20, 0x00, 0x04, 0x30, 0x00, 0x03, 0x10, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x38, 0x00, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xA0, 0x05, 0x00, 0x24, 0x00, 0xA0, 0x04, 0xC0, 0x16, 0x01, 0x98, 0x06,
  0xC0, 0x31, 0x00, 0x88, 0x04, 0x20, 0x11, 0x00, 0x86, 0x02, 0x30, 0x10,
  0xC0, 0xC6, 0x06, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41,
  0x82, 0x06, 0x18, 0x30, 0xC0, 0xC2, 0x02, 0x18, 0x08, 0x40, 0x42, 0x01,
  0x08, 0x0C, 0x40, 0x33, 0x01, 0x98, 0x06, 0x40, 0x13, 0x00, 0x48, 0x02,
  0x40, 0x09, 0x00, 0x68, 0x01, 0x40, 0x05, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x20, 0x04, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x83,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x46, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x83, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x30, 0x10, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x04,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x01, 0x00, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x80, 0x60, 0x00, 0x30, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x2F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x66,
  0x0E, 0x00, 0x0D, 0x80, 0x60, 0x01, 0xA0, 0x06, 0x00, 0x2C, 0x00, 0x60,
  0x0D, 0x00, 0x07, 0x03, 0x20, 0x00, 0x39, 0xC4, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_Thin51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 2, 36, 31, 14, -36 },
  { 10, 8, 10, 31, 11, -38 },
  { 20, 27, 36, 31, 2, -36 },
  { 142, 22, 46, 31, 5, -41 },
  { 269, 28, 38, 31, 1, -37 },
  { 402, 25, 38, 31, 4, -37 },
  { 521, 2, 10, 31, 13, -38 },
  { 524, 11, 52, 31, 10, -40 },
  { 596, 11, 52, 31, 9, -40 },
  { 668, 22, 20, 31, 5, -36 },
  { 723, 25, 26, 31, 3, -30 },
  { 805, 4, 10, 31, 10, -4 },
  { 810, 18, 1, 31, 6, -17 },
  { 813, 3, 3, 31, 15, -3 },
  { 815, 16, 39, 31, 8, -36 },
  { 893, 22, 38, 31, 4, -37 },
  { 998, 12, 36, 31, 6, -36 },
  { 1052, 22, 37, 31, 3, -37 },
  { 1154, 23, 38, 31, 2, -37 },
  { 1264, 26, 36, 31, 2, -36 },
  { 1381, 21, 37, 31, 6, -36 },
  { 1479, 22, 38, 31, 4, -37 },
  { 1584, 24, 36, 31, 3, -36 },
  { 1692, 24, 38, 31, 4, -37 },
  { 1806, 22, 38, 31, 4, -37 },
  { 1911, 3, 25, 31, 16, -25 },
  { 1921, 5, 31, 31, 14, -25 },
  { 1941, 22, 20, 31, 4, -27 },
  { 1996, 23, 11, 31, 4, -22 },
  { 2028, 21, 20, 31, 5, -27 },
  { 2081, 19, 37, 31, 6, -37 },
  { 2169, 28, 37, 31, 1, -37 },
  { 2299, 25, 36, 31, 3, -36 },
  { 2412, 22, 36, 31, 5, -36 },
  { 2511, 23, 38, 31, 4, -37 },
  { 2621, 23, 36, 31, 5, -36 },
  { 2725, 21, 36, 31, 5, -36 },
  { 2820, 20, 36, 31, 6, -36 },
  { 2910, 24, 38, 31, 3, -37 },
  { 3024, 22, 36, 31, 4, -36 },
  { 3123, 20, 36, 31, 5, -36 },
  { 3213, 22, 37, 31, 3, -36 },
  { 3315, 23, 36, 31, 6, -36 },
  { 3419, 21, 36, 31, 6, -36 },
  { 3514, 22, 36, 31, 5, -36 },
  { 3613, 22, 36, 31, 4, -36 },
  { 3712, 23, 38, 31, 4, -37 },
  { 3822, 22, 36, 31, 6, -36 },
  { 3921, 25, 44, 31, 3, -37 },
  { 4059, 22, 36, 31, 6, -36 },
  { 4158, 23, 38, 31, 4, -37 },
  { 4268, 25, 36, 31, 3, -36 },
  { 4381, 22, 37, 31, 4, -36 },
  { 4483, 25, 36, 31, 3, -36 },
  { 4596, 27, 36, 31, 2, -36 },
  { 4718, 25, 36, 31, 3, -36 },
  { 4831, 26, 36, 31, 2, -36 },
  { 4948, 22, 36, 31, 4, -36 },
  { 5047, 7, 49, 31, 12, -41 },
  { 5090, 17, 39, 31, 7, -36 },
  { 5173, 8, 49, 31, 11, -41 },
  { 5222, 18, 20, 31, 6, -36 },
  { 5267, 21, 1, 31, 5, 0 },
  { 5270, 6, 7, 31, 12, -38 },
  { 5276, 21, 28, 31, 5, -27 },
  { 5350, 20, 39, 31, 6, -38 },
  { 5448, 22, 28, 31, 4, -27 },
  { 5525, 21, 39, 31, 4, -38 },
  { 5628, 23, 28, 31, 4, -27 },
  { 5709, 23, 39, 31, 5, -39 },
  { 5822, 21, 38, 31, 4, -27 },
  { 5922, 21, 38, 31, 5, -38 },
  { 6022, 21, 36, 31, 6, -36 },
  { 6117, 16, 47, 31, 4, -36 },
  { 6211, 21, 38, 31, 6, -38 },
  { 6311, 21, 38, 31, 6, -38 },
  { 6411, 27, 27, 31, 2, -27 },
  { 6503, 21, 27, 31, 5, -27 },
  { 6574, 23, 28, 31, 4, -27 },
  { 6655, 21, 37, 31, 5, -27 },
  { 6753, 21, 37, 31, 4, -27 },
  { 6851, 17, 27, 31, 10, -27 },
  { 6909, 21, 28, 31, 5, -27 },
  { 6983, 20, 35, 31, 5, -34 },
  { 7071, 20, 28, 31, 5, -27 },
  { 7141, 25, 27, 31, 3, -27 },
  { 7226, 27, 27, 31, 2, -27 },
  { 7318, 24, 27, 31, 4, -27 },
  { 7399, 26, 38, 31, 2, -27 },
  { 7523, 25, 27, 31, 3, -27 },
  { 7608, 17, 51, 31, 8, -40 },
  { 7717, 1, 43, 31, 15, -36 },
  { 7723, 17, 51, 31, 8, -40 },
  { 7832, 27, 8, 31, 2, -19 },
};

const GFXfont RobotoMono_Thin51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin51pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_THIN51PT7B_H_
