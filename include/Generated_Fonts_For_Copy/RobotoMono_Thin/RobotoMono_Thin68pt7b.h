#ifndef _ROBOTOMONO_THIN68PT7B_H_
#define _ROBOTOMONO_THIN68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin68pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x40, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x20, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x30, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x01, 0x80, 0x00, 0x0F, 0x78, 0x06, 0x00, 0x00, 0x1F, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x3F, 0xC0,
  0x00, 0x03, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x0E, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x06, 0x00, 0x03, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x10, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x03, 0x00,
  0x40, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x10, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x06, 0x00, 0x30, 0x00, 0xC3,
  0x80, 0x06, 0x00, 0x30, 0xC0, 0x01, 0xC0, 0x0C, 0x60, 0x00, 0x30, 0x03,
  0x18, 0x00, 0x06, 0x00, 0xC6, 0x00, 0x00, 0xC0, 0x61, 0x00, 0x00, 0x18,
  0x18, 0xC0, 0x00, 0x03, 0x06, 0x30, 0x00, 0x00, 0xE3, 0x0C, 0x00, 0x00,
  0x18, 0xC1, 0x00, 0x00, 0x03, 0x70, 0x60, 0x00, 0x00, 0x78, 0x18, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x03, 0xF0, 0x18,
  0x00, 0x01, 0xCC, 0x07, 0x00, 0x00, 0xE1, 0x80, 0x70, 0x00, 0xE0, 0x30,
  0x0F, 0x81, 0xF0, 0x06, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x17, 0x80, 0x10, 0x07, 0xDF, 0x80, 0x81, 0xF8, 0x1F, 0x84, 0x3E,
  0x00, 0x0F, 0xAF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x06,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80,
  0x20, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x99,
  0xCC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x5F, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0x78, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x03, 0x1E, 0x00,
  0x00, 0x30, 0xF0, 0x00, 0x03, 0x07, 0x80, 0x00, 0x30, 0x3C, 0x00, 0x03,
  0x01, 0xE0, 0x00, 0x30, 0x0F, 0x00, 0x03, 0x00, 0x78, 0x00, 0x30, 0x03,
  0xC0, 0x03, 0x00, 0x1E, 0x00, 0x30, 0x00, 0xF0, 0x03, 0x00, 0x07, 0x80,
  0x30, 0x00, 0x3C, 0x03, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x0F, 0x03, 0x00,
  0x00, 0x78, 0x30, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x00,
  0xF3, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7B, 0x03, 0xE3, 0x0F, 0x03, 0x3C, 0x03, 0xF0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x3C, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x60, 0x08, 0x00, 0x00, 0x38, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x03, 0x80, 0x08, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x38, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x08, 0x00, 0x38, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x00, 0x20, 0x03, 0x80, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0F,
  0xFF, 0xFF, 0xE1, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0xFF, 0xE0, 0x02, 0x7E, 0x1F, 0x80, 0x2E, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x07,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x1F, 0x80, 0x06, 0x07,
  0xFF, 0xC0, 0x18, 0x7C, 0x07, 0x80, 0x63, 0x80, 0x07, 0x81, 0x18, 0x00,
  0x07, 0x04, 0xC0, 0x00, 0x0C, 0x36, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0xF1, 0x80, 0x00, 0x06, 0xC7, 0x00, 0x00, 0x33, 0x0E, 0x00,
  0x01, 0xCC, 0x1C, 0x00, 0x0E, 0x30, 0x38, 0x00, 0xE0, 0x80, 0x7E, 0x3F,
  0x06, 0x00, 0x7F, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x27, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x7F, 0x70, 0x08, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC6, 0x18, 0xC0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x03, 0x81,
  0x80, 0x00, 0xE1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x03, 0x00, 0x0F, 0x00, 0x18,
  0x38, 0x01, 0xFE, 0x00, 0x61, 0x80, 0x1C, 0x1C, 0x03, 0x18, 0x01, 0x80,
  0x60, 0x18, 0xC0, 0x18, 0x01, 0x00, 0xC6, 0x01, 0x80, 0x08, 0x03, 0x60,
  0x0C, 0x00, 0xC0, 0x1B, 0x00, 0xC0, 0x06, 0x00, 0xD8, 0x06, 0x00, 0x30,
  0x06, 0x80, 0x60, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x0C, 0x01, 0xE0, 0x18,
  0x00, 0x60, 0x0F, 0x00, 0xC0, 0x03, 0x00, 0x78, 0x04, 0x00, 0x10, 0x03,
  0xC0, 0x60, 0x00, 0x80, 0x1E, 0x03, 0x00, 0x0C, 0x00, 0xF0, 0x18, 0x00,
  0x60, 0x07, 0x80, 0xC0, 0x03, 0x00, 0x3C, 0x06, 0x00, 0x18, 0x01, 0x60,
  0x30, 0x00, 0xC0, 0x1B, 0x01, 0x80, 0x0E, 0x00, 0xD8, 0x0C, 0x00, 0x70,
  0x06, 0xC0, 0x20, 0x07, 0x80, 0x36, 0x01, 0x00, 0x3C, 0x03, 0x30, 0x0C,
  0x03, 0x60, 0x19, 0x80, 0x60, 0x19, 0x01, 0x86, 0x01, 0x81, 0x8C, 0x0C,
  0x30, 0x0E, 0x38, 0x71, 0xC1, 0x80, 0x3F, 0x81, 0xFC, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x3F, 0xC0, 0x30, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xC0,
  0x00, 0x3E, 0x06, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x0F, 0x83, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x3F, 0x80, 0x08,
  0x00, 0x07, 0x80, 0x20, 0x00, 0x07, 0x00, 0x80, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x01, 0xC2, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x70, 0x20, 0x00, 0x03,
  0x80, 0x80, 0x00, 0x3C, 0x02, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x80, 0x00, 0x00, 0x39, 0x00, 0x00, 0x00, 0xE2,
  0x00, 0x00, 0x03, 0x84, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x70, 0x02, 0x00, 0x01, 0xC0, 0x04, 0x00,
  0x07, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x70, 0x00, 0x20, 0x01,
  0xC0, 0x00, 0x40, 0x03, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x10, 0x38, 0x00, 0x00, 0x20, 0xF8, 0x00, 0x00, 0x43, 0xB0, 0x00,
  0x00, 0x8E, 0x30, 0x00, 0x01, 0x38, 0x30, 0x00, 0x02, 0xE0, 0x30, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80, 0x00, 0xE0, 0x01,
  0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x81, 0x00, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x03, 0x84, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xDD, 0x80, 0x00, 0x06, 0xEC, 0x00,
  0x00, 0x67, 0x60, 0x00, 0x03, 0x39, 0x80, 0x00, 0x31, 0xCC, 0x00, 0x01,
  0x8E, 0x30, 0x00, 0x0C, 0x71, 0x80, 0x00, 0xC3, 0x8C, 0x00, 0x06, 0x1C,
  0x30, 0x00, 0x60, 0xE1, 0x80, 0x03, 0x07, 0x04, 0x00, 0x18, 0x38, 0x30,
  0x01, 0x81, 0xC1, 0x80, 0x0C, 0x0E, 0x06, 0x00, 0xC0, 0x70, 0x30, 0x06,
  0x03, 0x80, 0x80, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xE0, 0x30, 0x18, 0x07,
  0x00, 0xC1, 0x80, 0x38, 0x06, 0x0C, 0x01, 0xC0, 0x30, 0x40, 0x0E, 0x00,
  0xC6, 0x00, 0x70, 0x06, 0x30, 0x03, 0x80, 0x13, 0x00, 0x1C, 0x00, 0xD8,
  0x00, 0xE0, 0x06, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3D, 0x00, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x79,
  0x80, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x00, 0xF0, 0xC0,
  0x00, 0x07, 0x82, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x01, 0xE0, 0x60, 0x00,
  0x0F, 0x03, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x1E,
  0x01, 0x80, 0x00, 0xF0, 0x04, 0x00, 0x07, 0x80, 0x30, 0x00, 0x3C, 0x00,
  0x80, 0x01, 0xE0, 0x06, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x78, 0x00, 0xC0,
  0x03, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x60, 0x07,
  0x80, 0x01, 0x00, 0x3C, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x30, 0x0F, 0x00,
  0x01, 0x80, 0x78, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x30, 0x1E, 0x00, 0x00,
  0xC0, 0xF0, 0x00, 0x02, 0x07, 0x80, 0x00, 0x18, 0x3C, 0x00, 0x00, 0x61,
  0xE0, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x0C, 0x78, 0x00, 0x00, 0x63, 0xC0,
  0x00, 0x01, 0x9E, 0x00, 0x00, 0x04, 0xF0, 0x00, 0x00, 0x37, 0x80, 0x00,
  0x00, 0xBC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x0F,
  0xE0, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07,
  0x06, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x3F, 0x80, 0x20, 0x00, 0x0F, 0x01, 0x00,
  0x00, 0x1C, 0x08, 0x00, 0x00, 0x70, 0x40, 0x00, 0x01, 0xC2, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x01, 0xC0, 0x80, 0x00, 0x1C, 0x04, 0x00, 0x1F, 0x80, 0x3F, 0xFF,
  0xF0, 0x01, 0x00, 0x01, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x30,
  0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x04,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x03, 0xC0, 0x07,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x34, 0x00,
  0x06, 0x00, 0x03, 0x40, 0x00, 0x70, 0x00, 0x36, 0x00, 0x07, 0x00, 0x02,
  0x60, 0x00, 0xF0, 0x00, 0x26, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x00, 0xD0,
  0x00, 0x66, 0x00, 0x0D, 0x80, 0x06, 0x20, 0x00, 0x98, 0x00, 0x62, 0x00,
  0x19, 0x80, 0x04, 0x30, 0x01, 0x98, 0x00, 0x43, 0x00, 0x18, 0x80, 0x0C,
  0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x10, 0xC0, 0x0C, 0x10, 0x03, 0x0C,
  0x00, 0xC1, 0x00, 0x30, 0xC0, 0x08, 0x18, 0x03, 0x0C, 0x00, 0x81, 0x80,
  0x30, 0x60, 0x18, 0x18, 0x02, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18,
  0x08, 0x06, 0x06, 0x01, 0x80, 0x80, 0x60, 0x60, 0x10, 0x0C, 0x06, 0x03,
  0x01, 0x00, 0xC0, 0x40, 0x30, 0x10, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x04, 0x0C, 0x03, 0x03, 0x00, 0x40, 0xC0, 0x18, 0x30,
  0x06, 0x08, 0x01, 0x82, 0x00, 0x61, 0x80, 0x18, 0x20, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x21,
  0x00, 0x0C, 0x60, 0x03, 0x30, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x0C, 0x40,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x04, 0xC0, 0x03, 0x20, 0x00,
  0x6C, 0x00, 0x16, 0x00, 0x06, 0xC0, 0x01, 0x60, 0x00, 0x68, 0x00, 0x1E,
  0x00, 0x06, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x60,
  0x00, 0x04, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00,
  0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03,
  0xCC, 0x00, 0x00, 0x36, 0x70, 0x00, 0x03, 0x31, 0xC0, 0x00, 0x31, 0x87,
  0x00, 0x07, 0x0C, 0x1F, 0x03, 0xE0, 0x30, 0x3F, 0xFC, 0x01, 0x80, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x07, 0xFE, 0x00, 0xC1, 0xE0,
  0xF8, 0x0C, 0x70, 0x01, 0xC0, 0xCE, 0x00, 0x06, 0x0D, 0xC0, 0x00, 0x30,
  0xD8, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x18, 0xD8, 0x00, 0x03, 0x0C, 0xC0,
  0x00, 0x60, 0xC7, 0x00, 0x1C, 0x0C, 0x3E, 0x07, 0x80, 0xC0, 0xFF, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x06, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x01, 0xC0,
  0x08, 0x07, 0xFF, 0x01, 0x01, 0xF0, 0x78, 0x20, 0xF0, 0x03, 0x84, 0x38,
  0x00, 0x1C, 0x86, 0x00, 0x01, 0x91, 0x80, 0x00, 0x1A, 0x60, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x68, 0x70, 0x00, 0x19, 0x07, 0x00, 0x0E, 0x20, 0x3C, 0x0F, 0x84, 0x03,
  0xFF, 0xC0, 0x80, 0x0B, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x40, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFC, 0x04, 0x07, 0xC1, 0xE0, 0x81, 0xC0, 0x0E, 0x10, 0x60, 0x00,
  0x72, 0x18, 0x00, 0x06, 0x46, 0x00, 0x00, 0x69, 0xC0, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xA1,
  0xC0, 0x00, 0x64, 0x0C, 0x00, 0x38, 0x80, 0xF0, 0x3E, 0x10, 0x0F, 0xFF,
  0x02, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x01, 0xFF, 0xC0, 0xC0, 0xF8, 0x3E, 0x18, 0x38,
  0x00, 0xE3, 0x1C, 0x00, 0x0E, 0x63, 0x00, 0x00, 0xCC, 0xC0, 0x00, 0x0D,
  0xB0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x40, 0x3E, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x70, 0x40, 0x00, 0x1C, 0x08, 0x00, 0x07, 0x01, 0x00, 0x01, 0xC0,
  0x20, 0x00, 0x60, 0x04, 0x00, 0x18, 0x00, 0x80, 0x0E, 0x00, 0x10, 0x03,
  0x80, 0x02, 0x00, 0xE0, 0x00, 0x40, 0x38, 0x00, 0x08, 0x0E, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x20, 0xE0, 0x00, 0x04, 0x7C, 0x00, 0x00, 0x9C, 0xC0,
  0x00, 0x17, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x08,
  0x00, 0xC0, 0x01, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x04, 0x00, 0x1C,
  0x00, 0x80, 0x01, 0xC0, 0x10, 0x00, 0x1C, 0x02, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x18, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x38, 0x80, 0x00, 0x03, 0x90, 0x00, 0x00, 0x3A, 0x00,
  0x00, 0x03, 0x80, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x00, 0x30, 0x18, 0xFF, 0xC0, 0x7F, 0xC3, 0x3C,
  0x3C, 0x1C, 0x1E, 0x6C, 0x01, 0xCE, 0x00, 0xCF, 0x00, 0x19, 0x80, 0x0D,
  0xC0, 0x01, 0xE0, 0x01, 0xB8, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x07, 0x80,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00,
  0x80, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x03, 0xC0,
  0x00, 0x40, 0x00, 0x78, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x01,
  0xE0, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x07, 0x80, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x03, 0x80, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x01, 0xC0,
  0x00, 0x20, 0x00, 0x38, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x07, 0xFF, 0x03, 0x03, 0xE0, 0xF0, 0x61, 0xE0, 0x03, 0x8C, 0x70, 0x00,
  0x39, 0x9C, 0x00, 0x03, 0x33, 0x00, 0x00, 0x36, 0xC0, 0x00, 0x06, 0xF0,
  0x00, 0x00, 0x5C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x0F, 0xFE, 0x00,
  0xC1, 0xE0, 0xF8, 0x0C, 0x70, 0x01, 0xC0, 0xCE, 0x00, 0x06, 0x0D, 0x80,
  0x00, 0x30, 0xF0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x18, 0xD8, 0x00, 0x03,
  0x0D, 0xC0, 0x00, 0x60, 0xC7, 0x00, 0x1C, 0x0C, 0x3E, 0x07, 0x80, 0xC0,
  0xFF, 0xE0, 0x0C, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x04, 0x07,
  0xC3, 0xE0, 0x83, 0xC0, 0x0F, 0x10, 0xE0, 0x00, 0x72, 0x18, 0x00, 0x07,
  0x46, 0x00, 0x00, 0x69, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xA1, 0xC0, 0x00, 0x64, 0x1C,
  0x00, 0x38, 0x80, 0xF0, 0x3E, 0x10, 0x0F, 0xFF, 0x02, 0x00, 0x1C, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE1,
  0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x0E, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x80, 0x7C,
  0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE8,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1B,
  0x18, 0x00, 0x0E, 0x61, 0xC0, 0x03, 0x8C, 0x1E, 0x03, 0xE1, 0x80, 0xFF,
  0xF0, 0x30, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x6C,
  0x00, 0x0E, 0x00, 0x06, 0x40, 0x00, 0xB0, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x06, 0x60, 0x01, 0xB0, 0x00, 0xC6, 0x00, 0x19, 0x00, 0x0C, 0x60, 0x01,
  0x98, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x03, 0x18, 0x00, 0x83,
  0x00, 0x31, 0x80, 0x18, 0x30, 0x03, 0x0C, 0x01, 0x81, 0x80, 0x60, 0xC0,
  0x18, 0x18, 0x06, 0x0C, 0x01, 0x01, 0x80, 0x60, 0x40, 0x30, 0x18, 0x04,
  0x06, 0x03, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0xC0, 0x20, 0x60, 0x0C, 0x08, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x06, 0x18, 0x03, 0x06, 0x00, 0x61, 0x80, 0x10, 0x40, 0x06, 0x10,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00,
  0x33, 0x00, 0x08, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x36, 0x00, 0x0D,
  0x80, 0x01, 0x60, 0x00, 0xD8, 0x00, 0x16, 0x00, 0x05, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x21, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0x1E, 0x0F, 0x00, 0x00, 0x31,
  0x80, 0x38, 0x00, 0x03, 0x30, 0x01, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x00,
  0x03, 0x60, 0x00, 0x38, 0x00, 0x66, 0x00, 0x01, 0xC0, 0x0E, 0x40, 0x00,
  0x0F, 0x01, 0xCC, 0x00, 0x00, 0x3E, 0xF8, 0xC0, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph RobotoMono_Thin68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 4, 48, 41, 18, -48 },
  { 25, 10, 14, 41, 15, -51 },
  { 43, 37, 48, 41, 2, -48 },
  { 265, 30, 62, 41, 6, -55 },
  { 498, 38, 50, 41, 1, -49 },
  { 736, 34, 50, 41, 5, -49 },
  { 949, 2, 14, 41, 18, -51 },
  { 953, 15, 70, 41, 13, -54 },
  { 1085, 15, 70, 41, 12, -54 },
  { 1217, 29, 26, 41, 7, -48 },
  { 1312, 33, 35, 41, 4, -40 },
  { 1457, 5, 13, 41, 14, -5 },
  { 1466, 24, 2, 41, 8, -23 },
  { 1472, 3, 4, 41, 20, -4 },
  { 1474, 22, 52, 41, 10, -48 },
  { 1617, 29, 50, 41, 6, -49 },
  { 1799, 16, 48, 41, 8, -48 },
  { 1895, 30, 49, 41, 4, -49 },
  { 2079, 30, 50, 41, 3, -49 },
  { 2267, 34, 48, 41, 3, -48 },
  { 2471, 28, 49, 41, 8, -48 },
  { 2643, 30, 50, 41, 5, -49 },
  { 2831, 30, 48, 41, 5, -48 },
  { 3011, 31, 50, 41, 6, -49 },
  { 3205, 30, 50, 41, 5, -49 },
  { 3393, 4, 33, 41, 21, -33 },
  { 3410, 6, 41, 41, 19, -33 },
  { 3441, 29, 27, 41, 5, -36 },
  { 3539, 29, 16, 41, 6, -30 },
  { 3597, 29, 27, 41, 6, -36 },
  { 3695, 25, 49, 41, 8, -49 },
  { 3849, 37, 49, 41, 2, -49 },
  { 4076, 34, 48, 41, 4, -48 },
  { 4280, 29, 48, 41, 7, -48 },
  { 4454, 31, 50, 41, 5, -49 },
  { 4648, 30, 48, 41, 7, -48 },
  { 4828, 28, 48, 41, 7, -48 },
  { 4996, 27, 48, 41, 8, -48 },
  { 5158, 32, 50, 41, 4, -49 },
  { 5358, 29, 48, 41, 6, -48 },
  { 5532, 27, 48, 41, 7, -48 },
  { 5694, 29, 49, 41, 4, -48 },
  { 5872, 31, 48, 41, 8, -48 },
  { 6058, 27, 48, 41, 8, -48 },
  { 6220, 29, 48, 41, 6, -48 },
  { 6394, 29, 48, 41, 6, -48 },
  { 6568, 31, 50, 41, 5, -49 },
  { 6762, 29, 48, 41, 8, -48 },
  { 6936, 33, 58, 41, 4, -49 },
  { 7176, 29, 48, 41, 8, -48 },
  { 7350, 31, 50, 41, 5, -49 },
  { 7544, 33, 48, 41, 4, -48 },
  { 7742, 29, 49, 41, 6, -48 },
  { 7920, 33, 48, 41, 4, -48 },
  { 8118, 36, 48, 41, 3, -48 },
  { 8334, 34, 48, 41, 4, -48 },
  { 8538, 34, 48, 41, 3, -48 },
  { 8742, 30, 48, 41, 5, -48 },
  { 8922, 10, 65, 41, 16, -55 },
  { 9004, 22, 52, 41, 9, -48 },
  { 9147, 10, 65, 41, 15, -55 },
  { 9229, 23, 26, 41, 9, -48 },
  { 9304, 28, 2, 41, 6, 0 },
  { 9311, 8, 9, 41, 16, -50 },
  { 9320, 29, 38, 41, 6, -37 },
  { 9458, 28, 52, 41, 7, -51 },
  { 9640, 29, 38, 41, 6, -37 },
  { 9778, 27, 52, 41, 6, -51 },
  { 9954, 30, 38, 41, 5, -37 },
  { 10097, 30, 52, 41, 7, -52 },
  { 10292, 27, 51, 41, 6, -37 },
  { 10465, 27, 51, 41, 7, -51 },
  { 10638, 28, 49, 41, 8, -49 },
  { 10810, 21, 64, 41, 6, -49 },
  { 10978, 27, 51, 41, 9, -51 },
  { 11151, 28, 51, 41, 8, -51 },
  { 11330, 35, 37, 41, 3, -37 },
  { 11492, 27, 37, 41, 7, -37 },
  { 11617, 31, 38, 41, 5, -37 },
  { 11765, 28, 51, 41, 7, -37 },
  { 11944, 27, 51, 41, 6, -37 },
  { 12117, 23, 37, 41, 13, -37 },
  { 12224, 28, 38, 41, 7, -37 },
  { 12357, 27, 47, 41, 7, -46 },
  { 12516, 27, 37, 41, 7, -36 },
  { 12641, 33, 36, 41, 4, -36 },
  { 12790, 36, 36, 41, 3, -36 },
  { 12952, 32, 36, 41, 5, -36 },
  { 13096, 35, 51, 41, 3, -36 },
  { 13320, 32, 36, 41, 5, -36 },
  { 13464, 22, 68, 41, 11, -53 },
  { 13651, 1, 57, 41, 20, -48 },
  { 13659, 22, 68, 41, 11, -53 },
  { 13846, 36, 11, 41, 2, -26 },
};

const GFXfont RobotoMono_Thin68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin68pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_THIN68PT7B_H_
