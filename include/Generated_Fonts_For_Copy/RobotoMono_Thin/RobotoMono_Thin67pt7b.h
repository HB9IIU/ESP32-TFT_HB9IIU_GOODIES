#ifndef _ROBOTOMONO_THIN67PT7B_H_
#define _ROBOTOMONO_THIN67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin67pt7bBitmaps[] PROGMEM = {
  0x00, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0xFE, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x02, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x20, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x60, 0x00,
  0x07, 0x06, 0x01, 0x80, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x71, 0xE0,
  0x00, 0x06, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x06, 0x00, 0x02, 0x01, 0x00, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x20,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x10, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x61, 0x80, 0x18, 0x00, 0x30, 0xC0,
  0x06, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x0C, 0xC0, 0x00, 0x60, 0x0C, 0x60,
  0x00, 0x18, 0x06, 0x30, 0x00, 0x0E, 0x03, 0x10, 0x00, 0x03, 0x01, 0x98,
  0x00, 0x00, 0xC1, 0x8C, 0x00, 0x00, 0x30, 0xC6, 0x00, 0x00, 0x0C, 0xE3,
  0x00, 0x00, 0x07, 0x60, 0xC0, 0x00, 0x01, 0xF0, 0x60, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x36, 0x07, 0x00, 0x00, 0x31,
  0x81, 0xC0, 0x00, 0x30, 0xE0, 0x78, 0x00, 0x70, 0x30, 0x0F, 0x01, 0xE0,
  0x0C, 0x01, 0xFF, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xEA, 0x80, 0x00, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x07, 0xF8,
  0x06, 0x01, 0xF3, 0xF0, 0x60, 0xF8, 0x03, 0xE6, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x11, 0x11, 0x33, 0x33, 0x36, 0x6C, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xF7, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x06,
  0x58, 0x00, 0x00, 0x62, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x60, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38,
  0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x78, 0x60,
  0x00, 0x03, 0xC6, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x00, 0xB6, 0x00, 0x00,
  0x0D, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xB0,
  0x7C, 0x63, 0xC0, 0xDE, 0x01, 0xF0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x81, 0xFE, 0x00, 0x11, 0xFF, 0xF8, 0x06, 0xF0, 0x07,
  0x80, 0xF8, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x01, 0xFF, 0x80, 0x18, 0x3F, 0xBF, 0x00, 0xC7, 0x80, 0x1E,
  0x04, 0x70, 0x00, 0x38, 0x66, 0x00, 0x00, 0xE3, 0x60, 0x00, 0x03, 0x1E,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x0E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x29, 0xC0, 0x00, 0x03,
  0x46, 0x00, 0x00, 0x32, 0x18, 0x00, 0x03, 0x30, 0x60, 0x00, 0x39, 0x81,
  0xC0, 0x07, 0x0C, 0x07, 0x81, 0xF0, 0x60, 0x0F, 0xFE, 0x03, 0x00, 0x0F,
  0x80, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x6F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0xFF, 0x70, 0x18, 0xF3, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x41, 0x04, 0x10, 0xC3, 0x0C, 0x31, 0x86, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x03, 0xC0, 0x0E, 0x03, 0x80,
  0x03, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x40, 0x00, 0x03, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x7E, 0x00, 0x61, 0x80, 0x1F, 0xF8,
  0x06, 0x18, 0x03, 0x81, 0xC0, 0x33, 0x00, 0x60, 0x0C, 0x03, 0x30, 0x0C,
  0x00, 0xC0, 0x36, 0x00, 0xC0, 0x0C, 0x03, 0x60, 0x18, 0x00, 0xC0, 0x36,
  0x01, 0x80, 0x0C, 0x03, 0x40, 0x30, 0x00, 0x80, 0x3C, 0x03, 0x00, 0x08,
  0x01, 0xC0, 0x30, 0x00, 0x80, 0x1C, 0x02, 0x00, 0x18, 0x01, 0xC0, 0x20,
  0x01, 0x80, 0x1C, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x3C,
  0x06, 0x00, 0x18, 0x03, 0xC0, 0x60, 0x01, 0x80, 0x3C, 0x06, 0x00, 0x18,
  0x03, 0xC0, 0x60, 0x03, 0x00, 0x3C, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x60,
  0x03, 0x00, 0x2C, 0x06, 0x00, 0x70, 0x06, 0xC0, 0x20, 0x05, 0x00, 0x6C,
  0x02, 0x00, 0xD8, 0x04, 0xC0, 0x30, 0x19, 0x80, 0xC6, 0x03, 0x01, 0x98,
  0x18, 0x60, 0x18, 0x70, 0xC3, 0x86, 0x00, 0xFE, 0x07, 0xF0, 0x30, 0x07,
  0x80, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x7E, 0x01,
  0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x07, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xC0, 0x01, 0xFC, 0x06, 0x00, 0x00, 0x78, 0x30,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x78, 0x60, 0x00, 0x0F, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0xF8, 0x01, 0x00, 0x00,
  0xF0, 0x08, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0xC4, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x32, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0xC1, 0x00,
  0x00, 0x1C, 0x08, 0x00, 0x03, 0x80, 0x40, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x30, 0x78, 0x00, 0x00, 0x61, 0xD8, 0x00, 0x00, 0xC7, 0x38,
  0x00, 0x01, 0x9C, 0x30, 0x00, 0x03, 0x70, 0x30, 0x00, 0x07, 0xC0, 0x30,
  0x00, 0x0F, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60,
  0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0D, 0xEC, 0x00, 0x00, 0x6F, 0x60,
  0x00, 0x03, 0x7B, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x01, 0x9E, 0x60, 0x00,
  0x18, 0xF1, 0x80, 0x00, 0xC7, 0x8C, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x61,
  0xE1, 0x80, 0x03, 0x0F, 0x0C, 0x00, 0x30, 0x78, 0x20, 0x01, 0x83, 0xC1,
  0x80, 0x0C, 0x1E, 0x0C, 0x00, 0xC0, 0xF0, 0x30, 0x06, 0x07, 0x81, 0x80,
  0x60, 0x3C, 0x04, 0x03, 0x01, 0xE0, 0x30, 0x10, 0x0F, 0x01, 0x81, 0x80,
  0x78, 0x06, 0x0C, 0x03, 0xC0, 0x30, 0xC0, 0x1E, 0x01, 0x86, 0x00, 0xF0,
  0x06, 0x20, 0x07, 0x80, 0x33, 0x00, 0x3C, 0x00, 0x98, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1D, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x01, 0xC1, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x1C, 0x01, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x01,
  0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x01, 0xC0, 0x01, 0x00, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x80,
  0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x30, 0x1C, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x81, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0x9C, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x30, 0x00, 0x1F, 0x01, 0x80, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x3E, 0x01, 0x80, 0x00, 0x3C, 0x0C, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x0E, 0x06, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C,
  0x40, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x01, 0xA0, 0x00, 0x70, 0x00, 0x36, 0x00, 0x0E, 0x00,
  0x06, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x13, 0x00, 0x05,
  0x80, 0x02, 0x60, 0x01, 0x90, 0x00, 0xC4, 0x00, 0x32, 0x00, 0x18, 0x80,
  0x06, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x11, 0x80, 0x08,
  0x60, 0x06, 0x30, 0x01, 0x0C, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x60,
  0x0C, 0x10, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x41, 0x80, 0x30, 0x60, 0x18,
  0x30, 0x06, 0x0C, 0x03, 0x02, 0x00, 0x81, 0x80, 0x60, 0x60, 0x10, 0x10,
  0x0C, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x02, 0x03, 0x01, 0x81, 0x80, 0x60, 0x40, 0x30, 0x30, 0x0C,
  0x08, 0x06, 0x04, 0x01, 0x83, 0x00, 0x41, 0x80, 0x30, 0x60, 0x0C, 0x30,
  0x02, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x0C, 0x20, 0x06,
  0x10, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x02, 0x30,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x40, 0x01,
  0x90, 0x00, 0xD8, 0x00, 0x32, 0x00, 0x1B, 0x00, 0x02, 0x40, 0x01, 0x60,
  0x00, 0x58, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x40, 0x01,
  0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3,
  0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x07,
  0xF0, 0x00, 0x20, 0xF0, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xB6, 0x00, 0x00, 0x33,
  0x30, 0x00, 0x0E, 0x31, 0xC0, 0x03, 0xC3, 0x0F, 0x01, 0xF0, 0x30, 0x3F,
  0xFC, 0x03, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x06, 0x0F, 0xFF, 0x80,
  0xC3, 0x80, 0x38, 0x18, 0xC0, 0x01, 0x83, 0x30, 0x00, 0x18, 0x6C, 0x00,
  0x01, 0x8F, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x02, 0x70, 0x00, 0x00, 0xCF, 0x00,
  0x00, 0x31, 0xB0, 0x00, 0x0E, 0x37, 0x00, 0x03, 0x86, 0x38, 0x00, 0xE0,
  0xC3, 0xE0, 0x78, 0x18, 0x1F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xE0, 0x18,
  0x0F, 0xFF, 0x83, 0x03, 0x80, 0x38, 0x60, 0xE0, 0x01, 0xCC, 0x30, 0x00,
  0x1D, 0x8C, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x1E, 0x60, 0x00, 0x01, 0xC8,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xD8,
  0x38, 0x00, 0xF3, 0x03, 0xC0, 0xF8, 0x60, 0x1F, 0xFC, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x0C, 0x0E, 0x00, 0xE1,
  0x83, 0x80, 0x07, 0x30, 0xC0, 0x00, 0x76, 0x30, 0x00, 0x06, 0xC6, 0x00,
  0x00, 0x79, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x1F, 0x0E, 0x00, 0x07, 0x60, 0xE0, 0x01, 0xCC, 0x07, 0x81, 0xE1,
  0x80, 0x7F, 0xF0, 0x30, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x07, 0xF8, 0x06, 0x03, 0xFF, 0xC0, 0xC1, 0xE0, 0x1E,
  0x18, 0x70, 0x00, 0xE3, 0x18, 0x00, 0x0E, 0x66, 0x00, 0x00, 0xCD, 0x80,
  0x00, 0x0D, 0xA0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x02,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x0F,
  0x1F, 0x80, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC3, 0xC0, 0x00, 0x0C, 0xEE, 0x00, 0x00, 0xDC, 0x70, 0x00,
  0x0F, 0x83, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x23, 0xFF, 0x81, 0xFF, 0x89, 0xC0, 0x70,
  0xE0, 0x32, 0xE0, 0x06, 0x60, 0x06, 0xB0, 0x01, 0xB0, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x1F,
  0xE0, 0x18, 0x0F, 0xFF, 0x03, 0x07, 0x80, 0x78, 0x61, 0xC0, 0x03, 0x8C,
  0x60, 0x00, 0x31, 0x98, 0x00, 0x03, 0x36, 0x00, 0x00, 0x26, 0x80, 0x00,
  0x06, 0xF0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x18, 0x3F, 0xFE, 0x03, 0x0E, 0x00, 0xE0, 0x67, 0x00,
  0x0E, 0x0D, 0xC0, 0x00, 0x61, 0xB0, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x38,
  0xDC, 0x00, 0x0E, 0x19, 0xC0, 0x03, 0x83, 0x0F, 0x81, 0xE0, 0x60, 0x7F,
  0xF0, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x0C, 0x0E, 0x00, 0xE1, 0x83,
  0x80, 0x07, 0x30, 0xC0, 0x00, 0x76, 0x30, 0x00, 0x06, 0xC6, 0x00, 0x00,
  0x79, 0x80, 0x00, 0x07, 0x20, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x1F, 0x0E, 0x00, 0x07, 0x60, 0xE0, 0x01, 0xCC, 0x0F, 0x01, 0xE1, 0x80,
  0x7F, 0xF0, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x00, 0x30, 0xE0,
  0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0x80, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xD3, 0x00, 0x00, 0x64, 0x60, 0x00, 0x39, 0x0E,
  0x00, 0x3C, 0x41, 0xE0, 0x3C, 0x10, 0x3F, 0xFC, 0x04, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x50,
  0x00, 0x66, 0x00, 0x1A, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x00,
  0x6C, 0x00, 0x33, 0x00, 0x09, 0x80, 0x04, 0x20, 0x03, 0x10, 0x01, 0x86,
  0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x0C, 0x00,
  0xC3, 0x00, 0x60, 0x80, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x83,
  0x00, 0xC0, 0xC0, 0x20, 0x60, 0x18, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x18, 0x06, 0x04, 0x03, 0x03, 0x00,
  0xC1, 0x80, 0x20, 0x40, 0x08, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0x30, 0x80, 0x18, 0x60, 0x06, 0x30, 0x01, 0x0C, 0x00, 0xC6, 0x00,
  0x33, 0x00, 0x08, 0x80, 0x06, 0x60, 0x01, 0x90, 0x00, 0x4C, 0x00, 0x36,
  0x00, 0x09, 0x80, 0x06, 0xC0, 0x01, 0xA0, 0x00, 0x50, 0x00, 0x3C, 0x00,
  0x0A, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x30, 0xFB, 0xE0, 0x00, 0x03, 0x18,
  0x07, 0x00, 0x00, 0x33, 0x00, 0x1C, 0x00, 0x02, 0x60, 0x00, 0xE0, 0x00,
  0x66, 0x00, 0x07, 0x00, 0x06, 0x60, 0x00, 0x38, 0x00, 0xC4, 0x00, 0x00,
  0xE0, 0x18, 0xC0, 0x00, 0x07, 0x87, 0x8C, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x10, 0x00,
};

const GFXglyph RobotoMono_Thin67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 4, 48, 40, 18, -48 },
  { 25, 10, 13, 40, 15, -50 },
  { 42, 37, 48, 40, 2, -48 },
  { 264, 29, 61, 40, 6, -54 },
  { 486, 38, 49, 40, 1, -48 },
  { 719, 33, 49, 40, 5, -48 },
  { 922, 2, 13, 40, 18, -50 },
  { 926, 14, 68, 40, 13, -53 },
  { 1045, 14, 68, 40, 12, -53 },
  { 1164, 28, 26, 40, 7, -48 },
  { 1255, 33, 34, 40, 4, -39 },
  { 1396, 4, 13, 40, 14, -5 },
  { 1403, 24, 2, 40, 8, -23 },
  { 1409, 4, 4, 40, 19, -4 },
  { 1411, 22, 52, 40, 10, -48 },
  { 1554, 29, 49, 40, 6, -48 },
  { 1732, 15, 48, 40, 8, -48 },
  { 1822, 29, 48, 40, 4, -48 },
  { 1996, 30, 49, 40, 3, -48 },
  { 2180, 33, 48, 40, 3, -48 },
  { 2378, 27, 49, 40, 8, -48 },
  { 2544, 29, 49, 40, 5, -48 },
  { 2722, 30, 48, 40, 5, -48 },
  { 2902, 30, 49, 40, 6, -48 },
  { 3086, 29, 49, 40, 5, -48 },
  { 3264, 4, 33, 40, 21, -33 },
  { 3281, 6, 41, 40, 19, -33 },
  { 3312, 29, 26, 40, 5, -35 },
  { 3407, 29, 15, 40, 6, -29 },
  { 3462, 28, 26, 40, 6, -35 },
  { 3553, 25, 48, 40, 8, -48 },
  { 3703, 36, 48, 40, 2, -48 },
  { 3919, 33, 48, 40, 4, -48 },
  { 4117, 29, 48, 40, 7, -48 },
  { 4291, 30, 49, 40, 5, -48 },
  { 4475, 29, 48, 40, 7, -48 },
  { 4649, 27, 48, 40, 7, -48 },
  { 4811, 27, 48, 40, 8, -48 },
  { 4973, 31, 49, 40, 4, -48 },
  { 5163, 28, 48, 40, 6, -48 },
  { 5331, 26, 48, 40, 7, -48 },
  { 5487, 29, 49, 40, 4, -48 },
  { 5665, 31, 48, 40, 7, -48 },
  { 5851, 27, 48, 40, 8, -48 },
  { 6013, 29, 48, 40, 6, -48 },
  { 6187, 28, 48, 40, 6, -48 },
  { 6355, 31, 49, 40, 5, -48 },
  { 6545, 29, 48, 40, 8, -48 },
  { 6719, 33, 57, 40, 4, -48 },
  { 6955, 29, 48, 40, 7, -48 },
  { 7129, 31, 49, 40, 5, -48 },
  { 7319, 33, 48, 40, 4, -48 },
  { 7517, 28, 49, 40, 6, -48 },
  { 7689, 33, 48, 40, 3, -48 },
  { 7887, 35, 48, 40, 3, -48 },
  { 8097, 33, 48, 40, 4, -48 },
  { 8295, 33, 48, 40, 3, -48 },
  { 8493, 29, 48, 40, 5, -48 },
  { 8667, 9, 64, 40, 16, -54 },
  { 8739, 22, 52, 40, 9, -48 },
  { 8882, 10, 64, 40, 15, -54 },
  { 8962, 24, 26, 40, 8, -48 },
  { 9040, 28, 2, 40, 6, 0 },
  { 9047, 8, 9, 40, 16, -50 },
  { 9056, 28, 37, 40, 6, -36 },
  { 9186, 27, 51, 40, 7, -50 },
  { 9359, 28, 37, 40, 6, -36 },
  { 9489, 27, 51, 40, 6, -50 },
  { 9662, 30, 37, 40, 5, -36 },
  { 9801, 29, 51, 40, 7, -51 },
  { 9986, 27, 50, 40, 6, -36 },
  { 10155, 27, 50, 40, 7, -50 },
  { 10324, 27, 48, 40, 8, -48 },
  { 10486, 21, 62, 40, 6, -48 },
  { 10649, 28, 50, 40, 8, -50 },
  { 10824, 27, 50, 40, 8, -50 },
  { 10993, 34, 36, 40, 3, -36 },
  { 11146, 27, 36, 40, 7, -36 },
  { 11268, 31, 37, 40, 5, -36 },
  { 11412, 27, 50, 40, 7, -36 },
  { 11581, 27, 50, 40, 6, -36 },
  { 11750, 22, 36, 40, 13, -36 },
  { 11849, 28, 37, 40, 7, -36 },
  { 11979, 27, 46, 40, 6, -45 },
  { 12135, 26, 36, 40, 7, -35 },
  { 12252, 32, 35, 40, 4, -35 },
  { 12392, 35, 35, 40, 3, -35 },
  { 12546, 31, 35, 40, 5, -35 },
  { 12682, 34, 49, 40, 3, -35 },
  { 12891, 32, 35, 40, 4, -35 },
  { 13031, 21, 66, 40, 11, -52 },
  { 13205, 2, 57, 40, 19, -48 },
  { 13220, 21, 66, 40, 11, -52 },
  { 13394, 36, 11, 40, 2, -25 },
};

const GFXfont RobotoMono_Thin67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin67pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_THIN67PT7B_H_
