#ifndef _ROBOTOMONO_THIN19PT7B_H_
#define _ROBOTOMONO_THIN19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC4, 0xB6, 0xD0, 0x09, 0x04, 0x41, 0x10, 0x44, 0xFF, 0xC4,
  0x41, 0x20, 0x88, 0x22, 0x3F, 0xE2, 0x20, 0x90, 0x44, 0x11, 0x00, 0x08,
  0x3C, 0x42, 0x81, 0x81, 0x80, 0x40, 0x20, 0x1C, 0x02, 0x01, 0x81, 0x81,
  0x81, 0x76, 0x08, 0x08, 0x30, 0x09, 0x02, 0x22, 0x44, 0x88, 0x90, 0x94,
  0x0C, 0x80, 0x20, 0x09, 0xC1, 0x44, 0x48, 0x89, 0x12, 0x22, 0x03, 0x80,
  0x38, 0x22, 0x11, 0x08, 0x84, 0x82, 0x80, 0x80, 0xA0, 0x88, 0xC4, 0xA1,
  0x50, 0x68, 0x33, 0xE4, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x84, 0x42, 0x30, 0x84, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22,
  0xC0, 0x08, 0x08, 0x08, 0xEF, 0x18, 0x18, 0x24, 0x42, 0x08, 0x04, 0x02,
  0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0xE0, 0xFE, 0xC0,
  0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x00,
  0x38, 0x46, 0x82, 0x81, 0x83, 0x85, 0x89, 0x91, 0xA1, 0xC1, 0x81, 0x81,
  0x82, 0x7C, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3C,
  0x42, 0x81, 0x81, 0x01, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFF, 0x3C, 0x42, 0x81, 0x81, 0x01, 0x01, 0x02, 0x1E, 0x01, 0x01, 0x81,
  0x81, 0x41, 0x3E, 0x02, 0x01, 0x01, 0x81, 0x41, 0x20, 0x90, 0x88, 0x84,
  0x42, 0x41, 0x1F, 0xE0, 0x40, 0x20, 0x10, 0x7F, 0x40, 0x40, 0x40, 0x40,
  0xB8, 0x46, 0x01, 0x01, 0x01, 0x81, 0x81, 0x42, 0x3C, 0x06, 0x0C, 0x08,
  0x08, 0x04, 0x05, 0xF3, 0x05, 0x02, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x11,
  0xF0, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x01, 0x01, 0x00, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x7E, 0x81, 0x81, 0x81, 0x81, 0x81, 0x7E, 0x1C, 0x11, 0x90, 0x50, 0x18,
  0x0C, 0x06, 0x02, 0x81, 0x23, 0x8E, 0x40, 0x40, 0x20, 0x21, 0xE0, 0x80,
  0x80, 0x40, 0x00, 0x58, 0x01, 0x83, 0x0E, 0x18, 0x02, 0x00, 0xE0, 0x0C,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x70, 0x0C, 0x03, 0x06, 0x18, 0x60,
  0x80, 0x3C, 0x86, 0x0C, 0x10, 0x20, 0x41, 0x04, 0x10, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x07, 0x03, 0x18, 0x81, 0x23, 0x14, 0x92, 0xA2, 0x64, 0x4C,
  0x89, 0x91, 0x32, 0x45, 0x4D, 0x26, 0x42, 0x00, 0x3F, 0x00, 0x08, 0x02,
  0x00, 0xC0, 0x50, 0x12, 0x04, 0x82, 0x20, 0x84, 0x21, 0x0F, 0xC4, 0x09,
  0x02, 0x80, 0xA0, 0x10, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x82, 0x84, 0xFE,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xFE, 0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x28, 0x14, 0x11, 0xF0, 0xF8, 0x84,
  0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x00, 0x87, 0xC0, 0x60, 0x28, 0x14, 0x09, 0xF8, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC0, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x41,
  0x3E, 0x80, 0xC0, 0xA0, 0x90, 0x88, 0x84, 0x82, 0x81, 0xA0, 0x88, 0x44,
  0x21, 0x10, 0x48, 0x14, 0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x81, 0x81, 0x83, 0xC3, 0xC5,
  0xA5, 0xA9, 0xA9, 0x91, 0x91, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x83, 0x83, 0x81, 0x1C,
  0x11, 0x90, 0x48, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28,
  0x14, 0x11, 0xF0, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x86, 0xF8,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x11, 0xF0, 0x04, 0x01, 0xF8,
  0x86, 0x81, 0x81, 0x81, 0x81, 0x82, 0xF4, 0x88, 0x84, 0x82, 0x82, 0x81,
  0x81, 0x1E, 0x10, 0x90, 0x28, 0x14, 0x02, 0x00, 0xE0, 0x0C, 0x01, 0x00,
  0x60, 0x30, 0x14, 0x09, 0xF8, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x80,
  0xC0, 0x60, 0x28, 0x14, 0x12, 0x08, 0x84, 0x44, 0x22, 0x09, 0x05, 0x02,
  0x80, 0x80, 0x40, 0x88, 0x62, 0x18, 0xC6, 0x31, 0x8C, 0x65, 0x25, 0x29,
  0x4A, 0x52, 0x94, 0xA6, 0x29, 0x84, 0x21, 0x08, 0x40, 0x80, 0x50, 0x24,
  0x10, 0x84, 0x12, 0x05, 0x00, 0xC0, 0x20, 0x14, 0x04, 0x82, 0x10, 0x84,
  0x40, 0xA0, 0x30, 0x80, 0xC0, 0x50, 0x48, 0x22, 0x21, 0x10, 0x50, 0x28,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x7F, 0x00, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x07, 0xFC, 0xF2,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x20, 0x40, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x3C, 0x10, 0x20, 0xA1, 0x42, 0x48, 0x90, 0xC1, 0xFF, 0xB0, 0x7C, 0x82,
  0x81, 0x01, 0x3E, 0x41, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x80, 0x80, 0x80,
  0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x7C, 0x82,
  0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0x7C, 0x02, 0x04, 0x08, 0x17,
  0xF0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x2F, 0xC0, 0x7C, 0x82, 0x81,
  0x81, 0xFF, 0x80, 0x80, 0x80, 0x81, 0x7E, 0x0F, 0x10, 0x20, 0x20, 0xFE,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x7F, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x18, 0x2F, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x08, 0x18, 0x00, 0x00, 0xF8, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x08, 0x30, 0x00, 0x78, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0B, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x83, 0x84, 0x88, 0x90,
  0xA0, 0xD0, 0x88, 0x84, 0x82, 0x81, 0xF8, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0xFF, 0xA2, 0x18, 0x86,
  0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x10, 0xBC, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3E, 0x20, 0x90, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0x81, 0x41, 0x1F, 0x00, 0xFC, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x7F, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x7E, 0x81, 0x81, 0x80, 0x78, 0x06,
  0x01, 0x81, 0x81, 0x7E, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0xE0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82,
  0xFC, 0x80, 0xA0, 0x50, 0x48, 0x22, 0x11, 0x10, 0x48, 0x28, 0x0C, 0x04,
  0x00, 0x88, 0x62, 0x18, 0xCA, 0x52, 0x54, 0x94, 0xA5, 0x29, 0x8C, 0x21,
  0x08, 0x40, 0x40, 0x90, 0x88, 0x82, 0x80, 0x80, 0x60, 0x48, 0x44, 0x41,
  0x60, 0x40, 0x80, 0x60, 0x24, 0x09, 0x04, 0x21, 0x08, 0x81, 0x20, 0x50,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x38, 0x00, 0x7F, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x7F, 0xC0, 0x04, 0x21, 0x04, 0x20,
  0x82, 0x08, 0x23, 0x06, 0x08, 0x20, 0x82, 0x04, 0x10, 0x40, 0xC0, 0xFF,
  0xFF, 0x80, 0xC0, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x30, 0x84, 0x10,
  0x41, 0x04, 0x10, 0x8C, 0x00, 0xF0, 0x62, 0x18, 0x78,
};

const GFXglyph RobotoMono_Thin19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 14, 11, 5, -14 },
  { 3, 3, 4, 11, 4, -14 },
  { 5, 10, 14, 11, 1, -14 },
  { 23, 8, 17, 11, 2, -15 },
  { 40, 11, 14, 11, 0, -14 },
  { 60, 9, 14, 11, 2, -14 },
  { 76, 1, 4, 11, 5, -14 },
  { 77, 4, 19, 11, 4, -15 },
  { 87, 4, 19, 11, 3, -15 },
  { 97, 8, 8, 11, 2, -14 },
  { 105, 9, 10, 11, 1, -11 },
  { 117, 1, 3, 11, 4, -1 },
  { 118, 7, 1, 11, 2, -7 },
  { 119, 2, 1, 11, 5, -1 },
  { 120, 6, 15, 11, 3, -14 },
  { 132, 8, 14, 11, 2, -14 },
  { 146, 5, 14, 11, 2, -14 },
  { 155, 8, 14, 11, 1, -14 },
  { 169, 8, 14, 11, 1, -14 },
  { 183, 9, 14, 11, 1, -14 },
  { 199, 8, 14, 11, 2, -14 },
  { 213, 9, 14, 11, 1, -14 },
  { 229, 9, 14, 11, 1, -14 },
  { 245, 8, 14, 11, 2, -14 },
  { 259, 9, 14, 11, 1, -14 },
  { 275, 1, 9, 11, 6, -9 },
  { 277, 2, 11, 11, 5, -9 },
  { 280, 9, 8, 11, 1, -10 },
  { 289, 8, 4, 11, 2, -8 },
  { 293, 8, 8, 11, 2, -10 },
  { 301, 7, 14, 11, 2, -14 },
  { 314, 11, 14, 11, 0, -14 },
  { 334, 10, 14, 11, 1, -14 },
  { 352, 8, 14, 11, 2, -14 },
  { 366, 9, 14, 11, 1, -14 },
  { 382, 8, 14, 11, 2, -14 },
  { 396, 8, 14, 11, 2, -14 },
  { 410, 8, 14, 11, 2, -14 },
  { 424, 9, 14, 11, 1, -14 },
  { 440, 8, 14, 11, 2, -14 },
  { 454, 7, 14, 11, 2, -14 },
  { 467, 8, 14, 11, 1, -14 },
  { 481, 9, 14, 11, 2, -14 },
  { 497, 8, 14, 11, 2, -14 },
  { 511, 8, 14, 11, 2, -14 },
  { 525, 8, 14, 11, 2, -14 },
  { 539, 9, 14, 11, 1, -14 },
  { 555, 8, 14, 11, 2, -14 },
  { 569, 9, 16, 11, 1, -14 },
  { 587, 8, 14, 11, 2, -14 },
  { 601, 9, 14, 11, 1, -14 },
  { 617, 9, 14, 11, 1, -14 },
  { 633, 8, 14, 11, 2, -14 },
  { 647, 9, 14, 11, 1, -14 },
  { 663, 10, 14, 11, 1, -14 },
  { 681, 10, 14, 11, 1, -14 },
  { 699, 9, 14, 11, 1, -14 },
  { 715, 9, 14, 11, 1, -14 },
  { 731, 3, 18, 11, 4, -15 },
  { 738, 6, 15, 11, 3, -14 },
  { 750, 3, 18, 11, 4, -15 },
  { 757, 7, 8, 11, 2, -14 },
  { 764, 8, 1, 11, 2, 0 },
  { 765, 2, 2, 11, 5, -14 },
  { 766, 8, 10, 11, 2, -10 },
  { 776, 8, 14, 11, 2, -14 },
  { 790, 8, 10, 11, 2, -10 },
  { 800, 7, 14, 11, 2, -14 },
  { 813, 8, 10, 11, 2, -10 },
  { 823, 8, 14, 11, 2, -14 },
  { 837, 7, 14, 11, 2, -10 },
  { 850, 8, 14, 11, 2, -14 },
  { 864, 8, 14, 11, 2, -14 },
  { 878, 6, 18, 11, 2, -14 },
  { 892, 8, 14, 11, 2, -14 },
  { 906, 8, 14, 11, 2, -14 },
  { 920, 10, 10, 11, 1, -10 },
  { 933, 8, 10, 11, 2, -10 },
  { 943, 9, 10, 11, 1, -10 },
  { 955, 8, 14, 11, 2, -10 },
  { 969, 7, 14, 11, 2, -10 },
  { 982, 6, 10, 11, 4, -10 },
  { 990, 8, 10, 11, 2, -10 },
  { 1000, 7, 13, 11, 2, -13 },
  { 1012, 7, 10, 11, 2, -10 },
  { 1021, 9, 10, 11, 1, -10 },
  { 1033, 10, 10, 11, 1, -10 },
  { 1046, 9, 10, 11, 1, -10 },
  { 1058, 10, 14, 11, 1, -10 },
  { 1076, 9, 10, 11, 1, -10 },
  { 1088, 6, 19, 11, 3, -15 },
  { 1103, 1, 17, 11, 5, -14 },
  { 1106, 6, 19, 11, 3, -15 },
  { 1121, 10, 3, 11, 1, -7 },
};

const GFXfont RobotoMono_Thin19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin19pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_THIN19PT7B_H_
