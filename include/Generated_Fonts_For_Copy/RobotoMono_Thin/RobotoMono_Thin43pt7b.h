#ifndef _ROBOTOMONO_THIN43PT7B_H_
#define _ROBOTOMONO_THIN43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin43pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x01,
  0xD8, 0x42, 0x85, 0x0A, 0x14, 0x28, 0x50, 0xE1, 0x00, 0x20, 0x10, 0x00,
  0x20, 0x10, 0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x40, 0x20, 0x00,
  0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40, 0x60, 0x3F,
  0xFF, 0xFF, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00,
  0x80, 0xC0, 0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01,
  0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x01, 0x00, 0x03, 0x01, 0x00, 0xFF,
  0xFF, 0xFC, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x02, 0x03, 0x00, 0x06,
  0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04,
  0x06, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x01, 0xF8, 0x03, 0x83, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x20,
  0x00, 0x98, 0x00, 0x34, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00,
  0x14, 0x00, 0x04, 0x80, 0x02, 0x30, 0x01, 0x87, 0x01, 0xC0, 0x7F, 0xC0,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x80, 0x40, 0x60,
  0x80, 0x40, 0x40, 0x80, 0x40, 0xC0, 0x80, 0x40, 0x80, 0x80, 0x41, 0x00,
  0x80, 0x41, 0x00, 0xC0, 0xC2, 0x00, 0x40, 0x82, 0x00, 0x61, 0x04, 0x00,
  0x1E, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x20, 0xDC, 0x00, 0x41, 0x06, 0x00, 0x43, 0x02,
  0x00, 0x82, 0x03, 0x00, 0x82, 0x01, 0x01, 0x02, 0x01, 0x03, 0x02, 0x01,
  0x02, 0x02, 0x01, 0x06, 0x02, 0x01, 0x04, 0x02, 0x02, 0x00, 0x01, 0x02,
  0x00, 0x01, 0x84, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x18, 0x60, 0x00,
  0xC0, 0xC0, 0x02, 0x01, 0x00, 0x18, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00,
  0x60, 0x04, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x81, 0x00,
  0x01, 0x08, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xA0, 0x00, 0x08, 0xC0, 0x00, 0x41, 0x80, 0x03, 0x02, 0x01, 0x88, 0x04,
  0x04, 0x40, 0x08, 0x11, 0x00, 0x30, 0x44, 0x00, 0x61, 0x30, 0x00, 0xCC,
  0xC0, 0x01, 0x21, 0x00, 0x03, 0x84, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30,
  0x03, 0x30, 0x60, 0x18, 0x40, 0x7F, 0x80, 0xC0, 0xFF, 0xFA, 0x01, 0x81,
  0x81, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x10,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x30, 0x30, 0x30,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x38, 0x10, 0x39, 0xE2, 0x3C, 0x07, 0x5C, 0x00,
  0x1C, 0x00, 0x02, 0x80, 0x00, 0xC8, 0x00, 0x31, 0x80, 0x04, 0x18, 0x01,
  0x01, 0x80, 0x40, 0x18, 0x18, 0x01, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x24, 0x94, 0xB4, 0xFF, 0xFF, 0xFF, 0xFC,
  0xEC, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0x07, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x01,
  0x10, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x58,
  0x00, 0x26, 0x00, 0x11, 0x80, 0x08, 0x60, 0x04, 0x18, 0x02, 0x06, 0x01,
  0x01, 0x80, 0x80, 0x60, 0x40, 0x18, 0x20, 0x06, 0x10, 0x01, 0x88, 0x00,
  0x64, 0x00, 0x1A, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x90, 0x00, 0x26,
  0x00, 0x18, 0x80, 0x04, 0x10, 0x02, 0x03, 0x03, 0x00, 0x7F, 0x80, 0x00,
  0x40, 0x70, 0x74, 0x61, 0xE0, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0xF0, 0x01, 0xC3, 0x80, 0x60, 0x0C, 0x18, 0x00, 0x82,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x32, 0x00, 0x02, 0xC0, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0xC1, 0xC0, 0x60, 0x0C, 0x18,
  0x00, 0x42, 0x00, 0x0C, 0xC0, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0x10, 0x00, 0x61, 0x00,
  0x18, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x08, 0x80, 0x00, 0xC4,
  0x00, 0x04, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x20, 0x40, 0x02,
  0x02, 0x00, 0x30, 0x10, 0x01, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20,
  0x08, 0x01, 0x00, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x40, 0x02, 0x04, 0x00,
  0x10, 0x60, 0x00, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE2, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x4F, 0xF0, 0x16, 0x03, 0x06,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00,
  0xB0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x04, 0x30, 0x02, 0x06, 0x03, 0x00,
  0x7F, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0xFC, 0x04, 0x60, 0x60, 0xB0, 0x06, 0x3C,
  0x00, 0x25, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0A, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x03, 0x40,
  0x00, 0x4C, 0x00, 0x08, 0x80, 0x03, 0x18, 0x00, 0x41, 0x80, 0x10, 0x1C,
  0x0C, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xC1, 0xC0, 0x60,
  0x0C, 0x10, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x30, 0x00, 0x42, 0x00,
  0x18, 0x30, 0x06, 0x03, 0x87, 0x00, 0x1F, 0xC0, 0x0C, 0x06, 0x06, 0x00,
  0x31, 0x80, 0x03, 0x20, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0x20, 0x00,
  0x63, 0x00, 0x18, 0x30, 0x06, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0xC1,
  0xC0, 0x20, 0x0C, 0x08, 0x00, 0xC2, 0x00, 0x08, 0x40, 0x00, 0x90, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0B, 0x00, 0x03, 0x20, 0x00,
  0xA6, 0x00, 0x34, 0x60, 0x0C, 0x87, 0x07, 0x10, 0x3F, 0x86, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x03, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x22, 0x22, 0x44, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x1C, 0x38, 0x30, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xF1, 0xE0, 0x03, 0x80, 0x30, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x10, 0x04, 0x06, 0x30, 0x3F,
  0x02, 0x20, 0x61, 0x82, 0x60, 0xC0, 0x82, 0x40, 0x80, 0x82, 0x41, 0x00,
  0x83, 0x41, 0x00, 0x83, 0xC1, 0x01, 0x03, 0x83, 0x01, 0x03, 0x82, 0x01,
  0x03, 0x82, 0x01, 0x02, 0x82, 0x01, 0x02, 0x82, 0x01, 0x02, 0x82, 0x03,
  0x02, 0x82, 0x03, 0x02, 0xC3, 0x05, 0x04, 0x41, 0x05, 0x04, 0x41, 0x88,
  0x88, 0x40, 0xF0, 0xF0, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x07, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x00,
  0x4C, 0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x0C, 0x00, 0x08, 0x20,
  0x00, 0x81, 0x00, 0x04, 0x0C, 0x00, 0x20, 0x20, 0x02, 0x01, 0x00, 0x10,
  0x0C, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x20,
  0x20, 0x01, 0x01, 0x00, 0x08, 0x0F, 0xFF, 0xE0, 0xC0, 0x01, 0x04, 0x00,
  0x08, 0x20, 0x00, 0x23, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x2C,
  0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x20, 0xFF, 0x00, 0x3F, 0xFC,
  0x08, 0x00, 0xC2, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x04, 0x80,
  0x02, 0x20, 0x01, 0x08, 0x03, 0x83, 0xFF, 0xE0, 0x80, 0x0E, 0x20, 0x00,
  0xC8, 0x00, 0x1A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80,
  0x03, 0x20, 0x07, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x70, 0x60, 0x0C,
  0x01, 0x01, 0x80, 0x08, 0x30, 0x00, 0x42, 0x00, 0x06, 0x60, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x06, 0x20,
  0x00, 0x41, 0x00, 0x0C, 0x08, 0x01, 0x80, 0x60, 0x30, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xFE, 0x02, 0x00, 0x30, 0x40, 0x03, 0x08, 0x00, 0x11,
  0x00, 0x03, 0x20, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0xD0,
  0x00, 0x12, 0x00, 0x04, 0x40, 0x01, 0x88, 0x00, 0x61, 0x00, 0x70, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFC,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0xFF, 0xFC, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x70, 0xE0, 0x0C, 0x01, 0x81, 0x00, 0x08,
  0x30, 0x00, 0x42, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x03, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x11, 0x00, 0x03,
  0x08, 0x00, 0x60, 0x60, 0x1C, 0x03, 0xFF, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x24, 0x00,
  0x09, 0x00, 0x04, 0x20, 0x03, 0x06, 0x03, 0x00, 0xFF, 0x80, 0x80, 0x00,
  0x68, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00,
  0xC0, 0x80, 0x08, 0x08, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x80,
  0xC0, 0x08, 0x18, 0x00, 0x83, 0x00, 0x08, 0x60, 0x00, 0x8C, 0x00, 0x09,
  0xA0, 0x00, 0xB1, 0x00, 0x0E, 0x18, 0x00, 0xC0, 0xC0, 0x08, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x04,
  0x08, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00,
  0x04, 0x80, 0x00, 0x30, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFE, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x80, 0x07, 0xA0, 0x01, 0x6C, 0x00, 0x59,
  0x00, 0x26, 0x40, 0x09, 0x98, 0x06, 0x62, 0x01, 0x18, 0x80, 0x46, 0x10,
  0x21, 0x84, 0x08, 0x61, 0x86, 0x18, 0x21, 0x06, 0x08, 0x41, 0x81, 0x20,
  0x60, 0x48, 0x18, 0x14, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xA0, 0x00, 0x64, 0x00, 0x19, 0x00, 0x06,
  0x20, 0x01, 0x88, 0x00, 0x61, 0x00, 0x18, 0x60, 0x06, 0x08, 0x01, 0x81,
  0x00, 0x60, 0x40, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x40, 0x60, 0x18,
  0x18, 0x02, 0x06, 0x00, 0xC1, 0x80, 0x10, 0x60, 0x02, 0x18, 0x00, 0x86,
  0x00, 0x11, 0x80, 0x04, 0x60, 0x00, 0x98, 0x00, 0x36, 0x00, 0x05, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x04, 0x01, 0xF8, 0x00, 0x70, 0xE0, 0x0C,
  0x03, 0x01, 0x00, 0x18, 0x30, 0x00, 0x82, 0x00, 0x04, 0x60, 0x00, 0x44,
  0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x62, 0x00, 0x04, 0x20,
  0x00, 0xC1, 0x00, 0x08, 0x08, 0x01, 0x00, 0x60, 0x60, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0x82, 0x00, 0x18, 0x40, 0x00, 0xC8, 0x00, 0x09,
  0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0xA0, 0x00, 0x64,
  0x00, 0x18, 0x80, 0x0E, 0x1F, 0xFF, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0x1C, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x10, 0x10, 0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x41, 0x00, 0x02, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x10, 0xFF, 0x80, 0x3F, 0xFE,
  0x08, 0x00, 0xC2, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00, 0x48, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80,
  0x01, 0xA0, 0x00, 0x48, 0x00, 0x22, 0x00, 0x10, 0x80, 0x18, 0x3F, 0xF8,
  0x08, 0x02, 0x02, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0xC2,
  0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x12, 0x00, 0x06, 0x80,
  0x00, 0xA0, 0x00, 0x38, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x70, 0x70, 0x18,
  0x01, 0x83, 0x00, 0x0C, 0x20, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x03, 0x40, 0x00, 0x16, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x60,
  0x00, 0x32, 0x00, 0x02, 0x18, 0x00, 0x40, 0xC0, 0x18, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xD0, 0x00,
  0x24, 0x00, 0x08, 0x80, 0x04, 0x30, 0x03, 0x06, 0x03, 0x00, 0x7F, 0x80,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x20,
  0x80, 0x02, 0x06, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x08, 0x06, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x30, 0x06, 0x01, 0x00, 0x10, 0x08, 0x00,
  0x80, 0xC0, 0x06, 0x04, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00, 0x06, 0x10,
  0x00, 0x10, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00,
  0xB0, 0x00, 0x05, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x0A, 0x00, 0xC0, 0x12, 0x01, 0xC0, 0x24, 0x02, 0x80,
  0x48, 0x05, 0x00, 0x90, 0x0A, 0x01, 0x20, 0x34, 0x06, 0x40, 0x4C, 0x08,
  0xC0, 0x88, 0x10, 0x81, 0x10, 0x21, 0x02, 0x20, 0x42, 0x0C, 0x40, 0x84,
  0x10, 0xC1, 0x08, 0x21, 0x84, 0x18, 0x41, 0x08, 0x10, 0x82, 0x10, 0x23,
  0x04, 0x20, 0x44, 0x08, 0x40, 0x88, 0x18, 0x81, 0x10, 0x12, 0x03, 0x20,
  0x24, 0x02, 0xC0, 0x48, 0x05, 0x00, 0x90, 0x0A, 0x01, 0xA0, 0x14, 0x01,
  0x40, 0x28, 0x03, 0x00, 0x50, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x98, 0x00, 0x08,
  0x40, 0x00, 0xC1, 0x00, 0x04, 0x0C, 0x00, 0x40, 0x20, 0x06, 0x00, 0x80,
  0x20, 0x06, 0x02, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x00, 0x02, 0x18, 0x00,
  0x08, 0x80, 0x00, 0x68, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x80, 0x00, 0x22, 0x00, 0x02, 0x18, 0x00, 0x30, 0x40, 0x01,
  0x01, 0x00, 0x10, 0x0C, 0x01, 0x80, 0x20, 0x08, 0x01, 0x80, 0x80, 0x04,
  0x04, 0x00, 0x10, 0x40, 0x00, 0xC6, 0x00, 0x02, 0x20, 0x00, 0x0A, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x04, 0x40, 0x00,
  0x62, 0x00, 0x02, 0x08, 0x00, 0x30, 0x40, 0x01, 0x01, 0x00, 0x10, 0x08,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x80, 0x40, 0x04, 0x04, 0x00, 0x30, 0x20,
  0x00, 0x82, 0x00, 0x06, 0x10, 0x00, 0x11, 0x00, 0x00, 0xD8, 0x00, 0x02,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFF, 0xF0, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0xFC, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0xFF, 0xF0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x16, 0x00, 0x24, 0x00, 0x8C, 0x01, 0x08, 0x06, 0x10, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x60, 0x80, 0x43, 0x00, 0x84, 0x00, 0x88, 0x01, 0x20, 0x03,
  0xC0, 0x02, 0xFF, 0xFF, 0xC0, 0xC3, 0x08, 0x21, 0x84, 0x07, 0xF8, 0x07,
  0x03, 0x83, 0x00, 0x31, 0x80, 0x06, 0x40, 0x00, 0x90, 0x00, 0x2C, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x07, 0xF8, 0x3F, 0x82,
  0x38, 0x00, 0x98, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x1B, 0x00, 0x0F, 0x40, 0x06, 0xCC, 0x07, 0x31, 0xFF,
  0x04, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x43, 0xF0, 0x27, 0x06,
  0x16, 0x00, 0x8E, 0x00, 0x26, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x6C, 0x00, 0x27, 0x00, 0x22, 0x60, 0x31, 0x1F, 0xE0, 0x03, 0xF8, 0x03,
  0x03, 0x81, 0x80, 0x30, 0x80, 0x04, 0x60, 0x00, 0x90, 0x00, 0x2C, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x50,
  0x00, 0x36, 0x00, 0x08, 0x80, 0x06, 0x10, 0x03, 0x03, 0x01, 0x80, 0x7F,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x83, 0xF8, 0x43, 0x07,
  0x22, 0x00, 0xD2, 0x00, 0x3B, 0x00, 0x0D, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x12, 0x00, 0x19, 0x80, 0x14, 0x60, 0x32, 0x0F, 0xF1, 0x01, 0xFC, 0x00,
  0xE0, 0xE0, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x04, 0x40, 0x00, 0xD8,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x30, 0xC0, 0x0C, 0x0C,
  0x03, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x07, 0xCC, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x03, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xF0, 0x86, 0x0E, 0x44, 0x01, 0xA4, 0x00, 0x76, 0x00, 0x1A, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x24, 0x00, 0x33, 0x00, 0x28, 0xC0, 0x64, 0x1F, 0xE2,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x26, 0x00,
  0x31, 0x80, 0x30, 0x70, 0x70, 0x0F, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x7E, 0x0C, 0x60, 0x63, 0x30, 0x0C, 0xD0, 0x01,
  0xB8, 0x00, 0x2E, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x0F, 0xFF, 0xFC, 0x00, 0x10, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x06, 0x1F, 0xE0, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x33, 0x00,
  0x18, 0xC0, 0x08, 0x30, 0x04, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80,
  0x30, 0xC0, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xD2, 0x00, 0x38, 0x40, 0x0C,
  0x08, 0x03, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00,
  0x30, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0x9F, 0x83,
  0xF2, 0xC3, 0x10, 0x6E, 0x02, 0x80, 0xB0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00,
  0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80,
  0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18,
  0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18, 0x02,
  0x00, 0x40, 0xC1, 0xF8, 0x31, 0x81, 0x8C, 0x80, 0x33, 0x40, 0x06, 0xE0,
  0x00, 0xB8, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0C, 0x03, 0xF8, 0x00, 0xE0, 0x60, 0x18,
  0x01, 0x03, 0x00, 0x08, 0x20, 0x00, 0x46, 0x00, 0x06, 0x40, 0x00, 0x2C,
  0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00,
  0x24, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0,
  0x70, 0x03, 0xFC, 0x00, 0x87, 0xE0, 0x4C, 0x0C, 0x2C, 0x03, 0x18, 0x00,
  0xCC, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD8, 0x00, 0x4E, 0x00,
  0x45, 0xC0, 0xC2, 0x3F, 0xC1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x07, 0xF0, 0x86, 0x0E, 0x4C, 0x01, 0xA4, 0x00, 0x76, 0x00, 0x1A, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x24, 0x00, 0x33, 0x00, 0x28, 0xC0, 0x64, 0x1F,
  0xE2, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x81, 0xFF, 0x0E, 0x02,
  0x30, 0x04, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x07, 0x01, 0x83, 0x00, 0x18, 0x80,
  0x02, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x05, 0x00,
  0x03, 0x20, 0x01, 0x86, 0x00, 0xC0, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x03, 0xFF, 0xFC, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xF8, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x40, 0x03, 0x60, 0x05, 0x30, 0x19, 0x1F, 0xF1, 0xC0, 0x00, 0x0A, 0x00,
  0x00, 0xD8, 0x00, 0x04, 0x40, 0x00, 0x23, 0x00, 0x02, 0x08, 0x00, 0x10,
  0x40, 0x01, 0x81, 0x00, 0x08, 0x08, 0x00, 0xC0, 0x60, 0x04, 0x01, 0x00,
  0x20, 0x0C, 0x02, 0x00, 0x20, 0x10, 0x01, 0x01, 0x80, 0x04, 0x08, 0x00,
  0x20, 0xC0, 0x01, 0x84, 0x00, 0x04, 0x60, 0x00, 0x32, 0x00, 0x00, 0x90,
  0x00, 0x05, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0A, 0x00, 0xC0, 0x16, 0x01, 0x80, 0x24, 0x07, 0x80, 0xC8,
  0x09, 0x01, 0x10, 0x12, 0x02, 0x20, 0x24, 0x04, 0x60, 0xCC, 0x18, 0x41,
  0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x83, 0x18, 0x21, 0x02, 0x20,
  0x44, 0x04, 0x40, 0x88, 0x08, 0x81, 0x10, 0x1B, 0x01, 0x20, 0x14, 0x02,
  0xC0, 0x28, 0x05, 0x00, 0x50, 0x0A, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x20, 0x00, 0x40, 0x00, 0x32, 0x00, 0x06, 0x30, 0x00, 0xC1,
  0x80, 0x08, 0x0C, 0x01, 0x00, 0x40, 0x30, 0x02, 0x06, 0x00, 0x30, 0xC0,
  0x01, 0x88, 0x00, 0x0D, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x09, 0x80, 0x01, 0x08, 0x00, 0x30, 0x40, 0x06, 0x02, 0x00, 0x40,
  0x30, 0x08, 0x01, 0x81, 0x00, 0x08, 0x30, 0x00, 0x46, 0x00, 0x02, 0xC0,
  0x00, 0x30, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x24, 0x00, 0x00, 0x98, 0x00,
  0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC1, 0x00, 0x02, 0x06, 0x00, 0x18,
  0x08, 0x00, 0x40, 0x20, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x01, 0x00, 0x08, 0x04, 0x00, 0x30, 0x30, 0x00, 0x40, 0x80, 0x01, 0x86,
  0x00, 0x02, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x18, 0x03, 0x80, 0x0F, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x03, 0x80, 0x01, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x70, 0x03, 0xC0, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x60, 0xC0, 0x05, 0x80,
  0xC0, 0x0A, 0x00, 0xC0, 0x34, 0x00, 0xC0, 0x48, 0x00, 0x77, 0x20, 0x00,
  0x38, 0x00,
};

const GFXglyph RobotoMono_Thin43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 3, 31, 26, 11, -31 },
  { 13, 7, 8, 26, 9, -32 },
  { 20, 24, 31, 26, 1, -31 },
  { 113, 18, 39, 26, 4, -35 },
  { 201, 24, 31, 26, 1, -31 },
  { 294, 22, 31, 26, 3, -31 },
  { 380, 2, 8, 26, 11, -32 },
  { 382, 9, 44, 26, 9, -34 },
  { 432, 9, 44, 26, 8, -34 },
  { 482, 19, 17, 26, 4, -31 },
  { 523, 21, 22, 26, 2, -25 },
  { 581, 3, 8, 26, 9, -3 },
  { 584, 15, 2, 26, 5, -15 },
  { 588, 3, 2, 26, 12, -2 },
  { 589, 14, 34, 26, 6, -31 },
  { 649, 18, 31, 26, 4, -31 },
  { 719, 10, 31, 26, 5, -31 },
  { 758, 19, 31, 26, 2, -31 },
  { 832, 19, 31, 26, 2, -31 },
  { 906, 21, 31, 26, 2, -31 },
  { 988, 18, 31, 26, 5, -31 },
  { 1058, 19, 31, 26, 3, -31 },
  { 1132, 19, 31, 26, 3, -31 },
  { 1206, 19, 31, 26, 4, -31 },
  { 1280, 19, 31, 26, 3, -31 },
  { 1354, 2, 20, 26, 14, -20 },
  { 1359, 4, 25, 26, 12, -20 },
  { 1372, 19, 17, 26, 3, -22 },
  { 1413, 18, 10, 26, 4, -19 },
  { 1436, 18, 17, 26, 4, -23 },
  { 1475, 16, 31, 26, 5, -31 },
  { 1537, 24, 31, 26, 1, -31 },
  { 1630, 21, 31, 26, 3, -31 },
  { 1712, 18, 31, 26, 5, -31 },
  { 1782, 20, 31, 26, 3, -31 },
  { 1860, 19, 31, 26, 4, -31 },
  { 1934, 17, 31, 26, 5, -31 },
  { 2000, 17, 31, 26, 5, -31 },
  { 2066, 20, 31, 26, 3, -31 },
  { 2144, 18, 31, 26, 4, -31 },
  { 2214, 17, 31, 26, 4, -31 },
  { 2280, 18, 31, 26, 3, -31 },
  { 2350, 20, 31, 26, 5, -31 },
  { 2428, 17, 31, 26, 5, -31 },
  { 2494, 18, 31, 26, 4, -31 },
  { 2564, 18, 31, 26, 4, -31 },
  { 2634, 20, 31, 26, 3, -31 },
  { 2712, 19, 31, 26, 5, -31 },
  { 2786, 22, 37, 26, 2, -31 },
  { 2888, 18, 31, 26, 5, -31 },
  { 2958, 20, 31, 26, 3, -31 },
  { 3036, 22, 31, 26, 2, -31 },
  { 3122, 18, 31, 26, 4, -31 },
  { 3192, 21, 31, 26, 2, -31 },
  { 3274, 23, 31, 26, 2, -31 },
  { 3364, 21, 31, 26, 3, -31 },
  { 3446, 21, 31, 26, 2, -31 },
  { 3528, 19, 31, 26, 3, -31 },
  { 3602, 6, 42, 26, 10, -35 },
  { 3634, 14, 34, 26, 6, -31 },
  { 3694, 6, 42, 26, 10, -35 },
  { 3726, 15, 17, 26, 5, -31 },
  { 3758, 18, 1, 26, 4, 0 },
  { 3761, 5, 6, 26, 10, -32 },
  { 3765, 18, 23, 26, 4, -23 },
  { 3817, 17, 32, 26, 5, -32 },
  { 3885, 18, 23, 26, 4, -23 },
  { 3937, 17, 32, 26, 4, -32 },
  { 4005, 19, 23, 26, 3, -23 },
  { 4060, 19, 33, 26, 4, -33 },
  { 4139, 17, 32, 26, 4, -23 },
  { 4207, 18, 32, 26, 4, -32 },
  { 4279, 18, 31, 26, 5, -31 },
  { 4349, 13, 40, 26, 4, -31 },
  { 4414, 18, 32, 26, 5, -32 },
  { 4486, 18, 32, 26, 5, -32 },
  { 4558, 22, 23, 26, 2, -23 },
  { 4622, 18, 23, 26, 4, -23 },
  { 4674, 20, 23, 26, 3, -23 },
  { 4732, 17, 32, 26, 5, -23 },
  { 4800, 17, 32, 26, 4, -23 },
  { 4868, 15, 23, 26, 8, -23 },
  { 4912, 18, 23, 26, 4, -23 },
  { 4964, 17, 29, 26, 4, -29 },
  { 5026, 16, 23, 26, 5, -23 },
  { 5072, 21, 23, 26, 2, -23 },
  { 5133, 23, 23, 26, 2, -23 },
  { 5200, 20, 23, 26, 3, -23 },
  { 5258, 22, 32, 26, 2, -23 },
  { 5346, 20, 23, 26, 3, -23 },
  { 5404, 14, 43, 26, 7, -34 },
  { 5480, 1, 37, 26, 12, -31 },
  { 5485, 14, 43, 26, 7, -34 },
  { 5561, 23, 7, 26, 1, -16 },
};

const GFXfont RobotoMono_Thin43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin43pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_THIN43PT7B_H_
