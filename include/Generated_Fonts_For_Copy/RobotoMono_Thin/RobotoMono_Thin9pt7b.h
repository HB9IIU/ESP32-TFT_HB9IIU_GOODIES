#ifndef _ROBOTOMONO_THIN9PT7B_H_
#define _ROBOTOMONO_THIN9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x2B, 0xD4, 0xAF, 0xA8, 0x69, 0x84, 0x39, 0xB4, 0xF5,
  0x98, 0x75, 0x8C, 0xEA, 0x4D, 0xBF, 0xC0, 0x6A, 0xAA, 0x40, 0xA5, 0x56,
  0x80, 0x5E, 0xE0, 0x44, 0xF4, 0xC0, 0xE0, 0x80, 0x24, 0xA5, 0x20, 0xF9,
  0xBD, 0x9E, 0xD5, 0x50, 0xF1, 0x12, 0x47, 0xF1, 0x31, 0x97, 0x31, 0x95,
  0x27, 0x88, 0xF8, 0xE1, 0x9F, 0xEC, 0xA9, 0x9E, 0xF2, 0x24, 0x48, 0xF9,
  0xE9, 0x9F, 0xF9, 0x9F, 0x16, 0x88, 0x8C, 0x34, 0xC3, 0xFF, 0x86, 0x78,
  0xE4, 0xA0, 0x80, 0x7D, 0xF7, 0xBA, 0xB8, 0x46, 0xAF, 0x99, 0xF9, 0xE9,
  0x9F, 0xF9, 0x88, 0x9E, 0xF9, 0x99, 0x9E, 0xF8, 0xE8, 0x8F, 0xF8, 0xE8,
  0x88, 0xF8, 0x8B, 0x9F, 0x99, 0xF9, 0x99, 0xE9, 0x25, 0xC0, 0x24, 0x9B,
  0xC0, 0xBA, 0xCA, 0xA9, 0x88, 0x88, 0x8F, 0x99, 0xBD, 0x99, 0x99, 0xDB,
  0x99, 0xF9, 0x99, 0x9E, 0xF9, 0x9E, 0x88, 0xF9, 0x99, 0x9E, 0x10, 0xF9,
  0x9E, 0xA9, 0xF8, 0x61, 0x9F, 0xF9, 0x08, 0x42, 0x10, 0x99, 0x99, 0x9E,
  0x8A, 0x54, 0xA2, 0x10, 0xAD, 0x6A, 0xB5, 0x24, 0x9A, 0x44, 0xA9, 0xCA,
  0x88, 0x42, 0x10, 0xE2, 0x44, 0x8F, 0xFF, 0x89, 0x22, 0x48, 0xFF, 0x56,
  0x80, 0xF0, 0xC0, 0xE9, 0x69, 0xF0, 0x88, 0xE9, 0x99, 0xE0, 0xE9, 0x89,
  0xE0, 0x27, 0xDB, 0x78, 0xE9, 0xE8, 0xF0, 0x34, 0xE4, 0x44, 0x40, 0xF6,
  0xDE, 0x78, 0x88, 0xE9, 0x99, 0x90, 0x0C, 0x44, 0x4F, 0x3C, 0x92, 0x4E,
  0x88, 0x9A, 0xCA, 0x90, 0xC4, 0x44, 0x44, 0xF0, 0xFD, 0x6B, 0x5A, 0x80,
  0xE9, 0x99, 0x90, 0xE9, 0x99, 0xE0, 0xE9, 0x99, 0xE8, 0x80, 0xF6, 0xDE,
  0x48, 0xF2, 0x48, 0xE9, 0x61, 0xF0, 0x5D, 0x24, 0xC0, 0xB6, 0xDE, 0x99,
  0xA4, 0x40, 0xAD, 0x6A, 0xA5, 0x00, 0x9A, 0x46, 0x90, 0x8A, 0x54, 0x62,
  0x11, 0x00, 0xF2, 0x48, 0xF0, 0x29, 0x28, 0x92, 0x20, 0xFE, 0xC9, 0x12,
  0x52, 0xC0, 0xF8,
};

const GFXglyph RobotoMono_Thin9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 1, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 4, 6, 5, 1, -6 },
  { 18, 1, 2, 5, 2, -7 },
  { 19, 2, 9, 5, 2, -7 },
  { 22, 2, 9, 5, 2, -7 },
  { 25, 4, 3, 5, 1, -6 },
  { 27, 4, 4, 5, 1, -5 },
  { 29, 1, 2, 5, 2, -1 },
  { 30, 3, 1, 5, 1, -3 },
  { 31, 1, 1, 5, 2, -1 },
  { 32, 3, 7, 5, 1, -6 },
  { 35, 4, 6, 5, 1, -6 },
  { 38, 2, 6, 5, 1, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 5, 6, 5, 0, -6 },
  { 50, 4, 6, 5, 1, -6 },
  { 53, 4, 6, 5, 1, -6 },
  { 56, 4, 6, 5, 1, -6 },
  { 59, 4, 6, 5, 1, -6 },
  { 62, 4, 6, 5, 1, -6 },
  { 65, 1, 5, 5, 3, -5 },
  { 66, 1, 6, 5, 2, -5 },
  { 67, 4, 4, 5, 1, -5 },
  { 69, 4, 2, 5, 1, -4 },
  { 70, 4, 4, 5, 1, -5 },
  { 72, 3, 6, 5, 1, -6 },
  { 75, 5, 6, 5, 0, -6 },
  { 79, 4, 6, 5, 1, -6 },
  { 82, 4, 6, 5, 1, -6 },
  { 85, 4, 6, 5, 1, -6 },
  { 88, 4, 6, 5, 1, -6 },
  { 91, 4, 6, 5, 1, -6 },
  { 94, 4, 6, 5, 1, -6 },
  { 97, 4, 6, 5, 1, -6 },
  { 100, 4, 6, 5, 1, -6 },
  { 103, 3, 6, 5, 1, -6 },
  { 106, 3, 6, 5, 1, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 4, 6, 5, 1, -6 },
  { 115, 4, 6, 5, 1, -6 },
  { 118, 4, 6, 5, 1, -6 },
  { 121, 4, 6, 5, 1, -6 },
  { 124, 4, 6, 5, 1, -6 },
  { 127, 4, 7, 5, 1, -6 },
  { 131, 4, 6, 5, 1, -6 },
  { 134, 4, 6, 5, 1, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 4, 6, 5, 1, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 4, 6, 5, 1, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 4, 6, 5, 1, -6 },
  { 162, 1, 8, 5, 2, -7 },
  { 163, 3, 7, 5, 1, -6 },
  { 166, 1, 8, 5, 2, -7 },
  { 167, 3, 3, 5, 1, -6 },
  { 169, 4, 1, 5, 1, 0 },
  { 170, 1, 2, 5, 2, -7 },
  { 171, 4, 5, 5, 1, -5 },
  { 174, 4, 7, 5, 1, -7 },
  { 178, 4, 5, 5, 1, -5 },
  { 181, 3, 7, 5, 1, -7 },
  { 184, 4, 5, 5, 1, -5 },
  { 187, 4, 7, 5, 1, -7 },
  { 191, 3, 7, 5, 1, -5 },
  { 194, 4, 7, 5, 1, -7 },
  { 198, 4, 6, 5, 1, -6 },
  { 201, 3, 8, 5, 1, -6 },
  { 204, 4, 7, 5, 1, -7 },
  { 208, 4, 7, 5, 1, -7 },
  { 212, 5, 5, 5, 0, -5 },
  { 216, 4, 5, 5, 1, -5 },
  { 219, 4, 5, 5, 1, -5 },
  { 222, 4, 7, 5, 1, -5 },
  { 226, 3, 7, 5, 1, -5 },
  { 229, 3, 5, 5, 2, -5 },
  { 231, 4, 5, 5, 1, -5 },
  { 234, 3, 6, 5, 1, -6 },
  { 237, 3, 5, 5, 1, -5 },
  { 239, 4, 5, 5, 1, -5 },
  { 242, 5, 5, 5, 0, -5 },
  { 246, 4, 5, 5, 1, -5 },
  { 249, 5, 7, 5, 0, -5 },
  { 254, 4, 5, 5, 1, -5 },
  { 257, 3, 9, 5, 1, -7 },
  { 261, 1, 7, 5, 2, -6 },
  { 262, 3, 9, 5, 1, -7 },
  { 266, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_Thin9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin9pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_THIN9PT7B_H_
