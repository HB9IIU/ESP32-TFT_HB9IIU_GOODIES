#ifndef _ROBOTOMONO_THIN45PT7B_H_
#define _ROBOTOMONO_THIN45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0xE1, 0xC3, 0x86, 0x00, 0x30, 0x08, 0x00, 0x10, 0x0C, 0x00,
  0x08, 0x04, 0x00, 0x04, 0x02, 0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0x80,
  0x01, 0x80, 0x40, 0x00, 0x80, 0x60, 0x00, 0x40, 0x20, 0x1F, 0xFF, 0xFF,
  0xC0, 0x10, 0x08, 0x00, 0x18, 0x04, 0x00, 0x08, 0x06, 0x00, 0x04, 0x02,
  0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0xC0,
  0x20, 0x00, 0x40, 0x30, 0x00, 0x20, 0x10, 0x00, 0x10, 0x08, 0x00, 0x08,
  0x04, 0x03, 0xFF, 0xFF, 0xF8, 0x04, 0x03, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x00,
  0x20, 0x18, 0x00, 0x10, 0x08, 0x00, 0x08, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x07, 0xFC, 0x03,
  0x80, 0xC0, 0xC0, 0x0C, 0x30, 0x00, 0xC4, 0x00, 0x08, 0x80, 0x01, 0xB0,
  0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00,
  0x01, 0x60, 0x00, 0x64, 0x00, 0x08, 0x60, 0x03, 0x06, 0x01, 0xC0, 0x7F,
  0xE0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x3F, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x18, 0x08,
  0x04, 0x08, 0x04, 0x03, 0x04, 0x02, 0x01, 0x02, 0x01, 0x01, 0x01, 0x00,
  0x81, 0x80, 0x80, 0x40, 0x80, 0x40, 0x20, 0xC0, 0x30, 0x10, 0x40, 0x08,
  0x18, 0x60, 0x06, 0x18, 0x20, 0x01, 0xF8, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x1F,
  0x00, 0x04, 0x18, 0x40, 0x06, 0x18, 0x10, 0x02, 0x08, 0x08, 0x03, 0x04,
  0x02, 0x01, 0x06, 0x01, 0x01, 0x03, 0x00, 0x80, 0x81, 0x80, 0x40, 0x80,
  0xC0, 0x20, 0x40, 0x20, 0x10, 0x40, 0x10, 0x18, 0x00, 0x0C, 0x08, 0x00,
  0x03, 0x08, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x30, 0x60, 0x00, 0x80,
  0xC0, 0x04, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x18, 0x01, 0x00, 0x40,
  0x04, 0x01, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x60, 0x01, 0x83, 0x00, 0x02,
  0x18, 0x00, 0x04, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00, 0x01, 0x40,
  0x00, 0x08, 0x80, 0x00, 0x43, 0x00, 0x02, 0x06, 0x01, 0x90, 0x0C, 0x06,
  0x40, 0x10, 0x12, 0x00, 0x20, 0x48, 0x00, 0x41, 0x20, 0x01, 0x8C, 0x80,
  0x03, 0x22, 0x00, 0x05, 0x88, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x40, 0x01,
  0xE1, 0x80, 0x0C, 0xC1, 0x80, 0xE1, 0x83, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x40,
  0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x30, 0x10, 0x3B, 0xC2, 0x3C, 0x07, 0x7C, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x98, 0x00, 0x21, 0x80, 0x0C, 0x10, 0x03, 0x01,
  0x00, 0x40, 0x10, 0x30, 0x03, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x24, 0x92, 0x5A, 0xD0, 0xFF, 0xFE, 0xF8, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFC, 0x01,
  0x80, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC2, 0x00, 0x0C, 0x80, 0x00, 0x90,
  0x00, 0x16, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0C, 0xC0,
  0x03, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x10, 0x06, 0x04, 0x00, 0xC1, 0x00, 0x18, 0x40, 0x03, 0x10,
  0x00, 0x64, 0x00, 0x0D, 0x00, 0x01, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x00,
  0x01, 0x10, 0x00, 0x63, 0x00, 0x18, 0x30, 0x06, 0x03, 0x01, 0x80, 0x3F,
  0xE0, 0x00, 0x60, 0x3C, 0x19, 0x9C, 0x3E, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x03, 0xFC, 0x00,
  0xC0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x08, 0x20, 0x00, 0x44, 0x00, 0x04,
  0x40, 0x00, 0x64, 0x00, 0x06, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0xE0, 0x30, 0x18, 0x00,
  0x83, 0x00, 0x04, 0x20, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00,
  0x36, 0x00, 0x02, 0x30, 0x00, 0x61, 0x80, 0x0C, 0x0E, 0x03, 0x80, 0x3F,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x01, 0x20,
  0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x20, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x01, 0x00,
  0x80, 0x0C, 0x02, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x80,
  0x60, 0x02, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x60, 0x00, 0x81, 0x00,
  0x02, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xC2, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x7F, 0x80,
  0xF8, 0x1C, 0x1C, 0x00, 0xC2, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x80, 0x00, 0x58, 0x00, 0x09, 0x00, 0x01, 0x30, 0x00, 0x42,
  0x00, 0x08, 0x20, 0x02, 0x03, 0x01, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x1F, 0xC0, 0x47, 0x07, 0x04, 0xC0, 0x18, 0x50, 0x00, 0xC6, 0x00,
  0x04, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x36,
  0x00, 0x02, 0x20, 0x00, 0x23, 0x00, 0x04, 0x10, 0x00, 0xC0, 0x80, 0x18,
  0x06, 0x03, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xFC, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x20,
  0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x18,
  0x0E, 0x07, 0x00, 0x3F, 0xC0, 0x07, 0x0E, 0x01, 0x80, 0x18, 0x30, 0x00,
  0x46, 0x00, 0x02, 0x40, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x02, 0x60,
  0x00, 0x63, 0x00, 0x0C, 0x1C, 0x03, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x01,
  0x80, 0xC0, 0x40, 0x0C, 0x10, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x00, 0xB0,
  0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03, 0x40,
  0x00, 0x6C, 0x00, 0x14, 0xC0, 0x04, 0x8C, 0x03, 0x10, 0xFF, 0xC6, 0x03,
  0x80, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x77, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x44, 0xC8, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xF8, 0x0C, 0x06, 0x0C, 0x00, 0x84, 0x00, 0x24, 0x00, 0x12, 0x00, 0x0D,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x10, 0x40, 0x18, 0x0C, 0x60, 0x7F, 0x02, 0x20, 0x60, 0xC1, 0x10,
  0x20, 0x20, 0x98, 0x20, 0x10, 0x68, 0x10, 0x18, 0x34, 0x10, 0x08, 0x1A,
  0x08, 0x04, 0x07, 0x04, 0x02, 0x03, 0x02, 0x01, 0x01, 0x81, 0x00, 0x81,
  0xC1, 0x80, 0x40, 0xE0, 0xC0, 0x20, 0x50, 0x60, 0x30, 0x2C, 0x10, 0x18,
  0x16, 0x08, 0x14, 0x09, 0x04, 0x0A, 0x08, 0x83, 0x09, 0x0C, 0x40, 0xC8,
  0x4C, 0x30, 0x38, 0x1C, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x16, 0x00, 0x00, 0x48,
  0x00, 0x03, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00,
  0x04, 0x18, 0x00, 0x10, 0x20, 0x00, 0xC0, 0x80, 0x02, 0x03, 0x00, 0x08,
  0x04, 0x00, 0x60, 0x10, 0x01, 0x00, 0x60, 0x04, 0x00, 0x80, 0x30, 0x02,
  0x00, 0x80, 0x0C, 0x02, 0x00, 0x10, 0x18, 0x00, 0x40, 0x7F, 0xFF, 0x81,
  0x00, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00,
  0x01, 0x10, 0x00, 0x06, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x28, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x10, 0x07, 0x82, 0x00, 0x18, 0x40, 0x00,
  0x88, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00,
  0xD0, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x04,
  0x20, 0x03, 0x07, 0xFF, 0xC0, 0x80, 0x0E, 0x10, 0x00, 0x62, 0x00, 0x02,
  0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x09,
  0x00, 0x06, 0x20, 0x03, 0x87, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x30, 0x1C,
  0x03, 0x00, 0x30, 0x30, 0x00, 0x83, 0x00, 0x02, 0x10, 0x00, 0x19, 0x80,
  0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00,
  0x13, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x60, 0x00, 0x41, 0x80, 0x04, 0x06,
  0x00, 0x60, 0x18, 0x0E, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x0C, 0x03, 0xC0,
  0xC0, 0x06, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0x8C, 0x00, 0x0C, 0xC0, 0x00,
  0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x04,
  0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x0C, 0x00, 0x60, 0xC0, 0x1C,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0xFC, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0xFC, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x30, 0x30,
  0x00, 0xC3, 0x00, 0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0x48, 0x00, 0x02,
  0x40, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x48,
  0x00, 0x02, 0x60, 0x00, 0x11, 0x80, 0x01, 0x86, 0x00, 0x18, 0x18, 0x03,
  0x80, 0x3F, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0B, 0x00, 0x01, 0x20, 0x00, 0x66, 0x00, 0x08,
  0x60, 0x06, 0x07, 0x01, 0x80, 0x3F, 0xE0, 0x80, 0x00, 0x34, 0x00, 0x02,
  0x20, 0x00, 0x31, 0x00, 0x03, 0x08, 0x00, 0x30, 0x40, 0x03, 0x02, 0x00,
  0x30, 0x10, 0x03, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x20, 0x10, 0x01,
  0x01, 0x00, 0x08, 0x10, 0x00, 0x41, 0x00, 0x02, 0x18, 0x00, 0x11, 0xE0,
  0x00, 0x99, 0x00, 0x05, 0x84, 0x00, 0x38, 0x30, 0x01, 0x80, 0xC0, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x20, 0x10, 0x01, 0x80, 0x80, 0x06,
  0x04, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40,
  0x00, 0x32, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x80, 0x01, 0xD0, 0x00, 0x7B, 0x00, 0x0B, 0x20, 0x03, 0x64, 0x00, 0x4C,
  0xC0, 0x09, 0x88, 0x02, 0x31, 0x00, 0x46, 0x10, 0x18, 0xC2, 0x02, 0x18,
  0x60, 0x43, 0x04, 0x10, 0x60, 0x82, 0x0C, 0x08, 0xC1, 0x81, 0x10, 0x30,
  0x32, 0x06, 0x02, 0x80, 0xC0, 0x50, 0x18, 0x0E, 0x03, 0x00, 0x80, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x03, 0x20,
  0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x84, 0x00, 0x30, 0x80, 0x06, 0x08,
  0x00, 0xC1, 0x80, 0x18, 0x10, 0x03, 0x01, 0x00, 0x60, 0x20, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x04, 0x06, 0x00, 0xC0, 0xC0, 0x08, 0x18, 0x01,
  0x83, 0x00, 0x10, 0x60, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x02, 0x30, 0x00,
  0x66, 0x00, 0x04, 0xC0, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x03, 0xFE, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x30,
  0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00, 0xC8, 0x00, 0x02,
  0x40, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x0D, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x13, 0x00, 0x01, 0x88,
  0x00, 0x08, 0x60, 0x00, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x0C,
  0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0x0C, 0x00, 0xE0, 0xC0, 0x01, 0x8C, 0x00,
  0x0C, 0xC0, 0x00, 0x4C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2C,
  0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x08, 0xC0, 0x03, 0x0F, 0xFF, 0xE0,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x10, 0x20, 0x00,
  0x20, 0x80, 0x00, 0xC4, 0x00, 0x01, 0x10, 0x00, 0x06, 0xC0, 0x00, 0x0A,
  0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28,
  0x00, 0x00, 0xB0, 0x00, 0x02, 0x40, 0x00, 0x19, 0x00, 0x00, 0x42, 0x00,
  0x03, 0x08, 0x00, 0x08, 0x10, 0x00, 0x40, 0x20, 0x03, 0x00, 0x60, 0x38,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xF0, 0x08, 0x01,
  0xC0, 0x80, 0x06, 0x08, 0x00, 0x10, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x80,
  0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48,
  0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x30,
  0x80, 0x0C, 0x0F, 0xFF, 0x80, 0x80, 0x10, 0x08, 0x01, 0x80, 0x80, 0x08,
  0x08, 0x00, 0xC0, 0x80, 0x04, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80,
  0x00, 0x68, 0x00, 0x03, 0x03, 0xFF, 0x00, 0x30, 0x0C, 0x06, 0x00, 0x30,
  0x20, 0x00, 0x42, 0x00, 0x03, 0x10, 0x00, 0x09, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x09, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00,
  0x50, 0x00, 0x02, 0x40, 0x00, 0x23, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x38,
  0x07, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x0D, 0x00, 0x01, 0x30, 0x00, 0x62, 0x00, 0x08, 0x20, 0x02, 0x03,
  0x01, 0x80, 0x3F, 0xE0, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x03, 0x0C, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x30, 0x00, 0x40, 0x20, 0x00, 0x80,
  0x40, 0x01, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x40, 0x02, 0x00, 0x80, 0x04, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x08,
  0x08, 0x00, 0x10, 0x10, 0x00, 0x30, 0x60, 0x00, 0x20, 0x80, 0x00, 0x41,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x60,
  0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40, 0x18, 0x02, 0x40, 0x18, 0x02,
  0x40, 0x18, 0x02, 0x40, 0x3C, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x60, 0x24, 0x04, 0x20, 0x24, 0x04, 0x20, 0x66, 0x04, 0x20, 0x42, 0x04,
  0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x30, 0x42, 0x08, 0x10, 0xC3, 0x08,
  0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08,
  0x19, 0x81, 0x98, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90,
  0x09, 0x00, 0x90, 0x0B, 0x00, 0xD0, 0x0E, 0x00, 0xF0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x60,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x62, 0x00, 0x01, 0x0C, 0x00, 0x08, 0x10,
  0x00, 0x60, 0x20, 0x01, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x60, 0x02, 0x01,
  0x00, 0x0C, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x21, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x20, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x60, 0x00, 0x0C, 0x80, 0x00, 0x21, 0x00, 0x01, 0x06, 0x00, 0x0C, 0x08,
  0x00, 0x20, 0x10, 0x01, 0x80, 0x60, 0x04, 0x00, 0x80, 0x20, 0x01, 0x01,
  0x80, 0x06, 0x04, 0x00, 0x08, 0x20, 0x00, 0x31, 0x80, 0x00, 0x44, 0x00,
  0x00, 0xA0, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x88, 0x00, 0x04, 0x30, 0x00, 0x10, 0x40, 0x00, 0x81, 0x80, 0x02, 0x02,
  0x00, 0x10, 0x0C, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x20, 0x18, 0x00, 0x80,
  0x40, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x08, 0x60, 0x00, 0x21, 0x00,
  0x00, 0x4C, 0x00, 0x01, 0x20, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xF0, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0xFF, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x01, 0x00,
  0x07, 0x00, 0x0A, 0x00, 0x36, 0x00, 0x44, 0x00, 0x88, 0x03, 0x18, 0x04,
  0x10, 0x18, 0x30, 0x20, 0x20, 0x40, 0x41, 0x00, 0xC2, 0x00, 0x8C, 0x01,
  0x90, 0x01, 0x20, 0x03, 0x80, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xE0, 0xC2,
  0x08, 0x61, 0x84, 0x03, 0xFC, 0x01, 0xC0, 0xE0, 0x40, 0x06, 0x10, 0x00,
  0x46, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x01, 0xFF, 0xE1, 0xE0, 0x04, 0x60, 0x00,
  0x98, 0x00, 0x16, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x64, 0x00, 0x1E, 0xC0, 0x06, 0xCC, 0x03, 0x18, 0x7F, 0xC1,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x7F,
  0x02, 0x30, 0x30, 0xB0, 0x06, 0x28, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x02, 0x80, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x12, 0xC0, 0x08,
  0x98, 0x0C, 0x21, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0xC0, 0x60, 0x04,
  0x18, 0x00, 0x42, 0x00, 0x0C, 0x80, 0x00, 0x90, 0x00, 0x1E, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x05,
  0x00, 0x01, 0x90, 0x00, 0x23, 0x00, 0x0C, 0x30, 0x03, 0x03, 0x00, 0xC0,
  0x1F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x3F, 0x84, 0x30, 0x31, 0x18, 0x03, 0x4C, 0x00, 0x52, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x58, 0x00, 0x32, 0x00, 0x0C,
  0x40, 0x0D, 0x0C, 0x06, 0x41, 0xFE, 0x10, 0x03, 0xFC, 0x00, 0xC0, 0xC0,
  0x60, 0x06, 0x18, 0x00, 0x42, 0x00, 0x04, 0x80, 0x00, 0xD0, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x06, 0x30, 0x01, 0x83,
  0x80, 0x60, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x03, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xF8, 0x43, 0x03, 0x11, 0x80, 0x34, 0xC0, 0x05, 0x20, 0x00,
  0xD0, 0x00, 0x34, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80, 0x03, 0x20, 0x00,
  0xC4, 0x00, 0xD0, 0xC0, 0x64, 0x1F, 0xE1, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x98, 0x00, 0x63, 0x00, 0x30, 0x60,
  0x18, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x3F, 0x82, 0x38, 0x18, 0x98, 0x03, 0x2C,
  0x00, 0x6A, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x07, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x30, 0xFF, 0x80, 0xF0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x1A, 0x00, 0x0C, 0x80, 0x06, 0x20, 0x02,
  0x08, 0x03, 0x02, 0x01, 0x80, 0x80, 0xC0, 0x20, 0x60, 0x08, 0x30, 0x02,
  0x10, 0x00, 0x8C, 0x00, 0x2D, 0x80, 0x0E, 0x30, 0x03, 0x04, 0x00, 0x80,
  0x80, 0x20, 0x10, 0x08, 0x06, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x03,
  0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x30, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x8F, 0xC1, 0xF9, 0x60, 0xCC,
  0x1B, 0x80, 0xB0, 0x16, 0x00, 0xC0, 0x1C, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x83, 0xF8, 0x23, 0x81, 0x89, 0x80, 0x32, 0xC0,
  0x06, 0xA0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x01, 0xFC,
  0x00, 0x38, 0x38, 0x03, 0x00, 0x60, 0x20, 0x00, 0x83, 0x00, 0x06, 0x10,
  0x00, 0x11, 0x00, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0x98, 0x00, 0x0C,
  0x40, 0x00, 0x41, 0x00, 0x04, 0x0C, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x7F,
  0xC0, 0x87, 0xF0, 0x27, 0x03, 0x0B, 0x00, 0x63, 0x80, 0x0C, 0xC0, 0x01,
  0x20, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0B, 0x00, 0x04, 0xC0, 0x03,
  0x28, 0x01, 0x89, 0x80, 0xC2, 0x1F, 0xE0, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x43, 0x03, 0x11, 0x80, 0x34, 0xC0,
  0x05, 0x20, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80,
  0x03, 0x20, 0x00, 0xC4, 0x00, 0x50, 0xC0, 0x64, 0x1F, 0xE1, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x81, 0xFF, 0x0E, 0x02, 0x60,
  0x05, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x03, 0xFC, 0x01, 0x80, 0xE0, 0x40, 0x03, 0x10,
  0x00, 0x26, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x09, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x05, 0x00,
  0x00, 0xA0, 0x00, 0x16, 0x00, 0x06, 0x60, 0x01, 0x87, 0x00, 0xE0, 0x3F,
  0xF0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x0F, 0xFF, 0xF8, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x34, 0x00, 0x3B, 0x00, 0x34, 0xC0, 0x32, 0x1F, 0xE1,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xD0, 0x00, 0x04, 0x80, 0x00, 0x26, 0x00,
  0x02, 0x10, 0x00, 0x10, 0xC0, 0x01, 0x82, 0x00, 0x08, 0x18, 0x00, 0xC0,
  0x40, 0x04, 0x02, 0x00, 0x20, 0x18, 0x02, 0x00, 0x40, 0x10, 0x03, 0x01,
  0x80, 0x08, 0x08, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00,
  0x62, 0x00, 0x01, 0x10, 0x00, 0x0D, 0x80, 0x00, 0x28, 0x00, 0x01, 0xC0,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x03, 0x80, 0x18, 0x02, 0x80, 0x18, 0x02,
  0xC0, 0x28, 0x02, 0x40, 0x28, 0x06, 0x40, 0x2C, 0x04, 0x40, 0x24, 0x04,
  0x60, 0x64, 0x04, 0x20, 0x44, 0x04, 0x20, 0x46, 0x0C, 0x20, 0x42, 0x08,
  0x30, 0x82, 0x08, 0x30, 0x82, 0x08, 0x10, 0x83, 0x18, 0x10, 0x81, 0x10,
  0x11, 0x01, 0x10, 0x19, 0x01, 0x10, 0x09, 0x01, 0xB0, 0x09, 0x00, 0xA0,
  0x0A, 0x00, 0xA0, 0x0A, 0x00, 0xA0, 0x06, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x60, 0x00, 0x19, 0x00, 0x01, 0x84, 0x00, 0x18, 0x30,
  0x00, 0x80, 0xC0, 0x08, 0x03, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0x20, 0xC0,
  0x01, 0x84, 0x00, 0x06, 0x40, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x2C, 0x00, 0x02, 0x30, 0x00, 0x30, 0xC0, 0x03, 0x02, 0x00,
  0x30, 0x08, 0x01, 0x00, 0x60, 0x10, 0x01, 0x81, 0x80, 0x04, 0x18, 0x00,
  0x11, 0x80, 0x00, 0x58, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0D,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x62, 0x00, 0x00, 0x86, 0x00, 0x03, 0x04,
  0x00, 0x04, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x10,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x10, 0x00, 0x40,
  0x60, 0x00, 0x80, 0x80, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00, 0x03, 0x18,
  0x00, 0x02, 0x20, 0x00, 0x06, 0x40, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x18, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x07, 0x80, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x63, 0x80, 0x05,
  0x01, 0x80, 0x0E, 0x01, 0x80, 0x18, 0x00, 0x80, 0x50, 0x00, 0xC1, 0xA0,
  0x00, 0xFC, 0x00,
};

const GFXglyph RobotoMono_Thin45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 2, 32, 27, 12, -32 },
  { 9, 7, 9, 27, 10, -34 },
  { 17, 25, 32, 27, 1, -32 },
  { 117, 19, 42, 27, 4, -37 },
  { 217, 25, 32, 27, 1, -32 },
  { 317, 22, 32, 27, 4, -32 },
  { 405, 1, 9, 27, 12, -34 },
  { 407, 9, 46, 27, 9, -36 },
  { 459, 10, 46, 27, 8, -36 },
  { 517, 19, 17, 27, 5, -32 },
  { 558, 22, 24, 27, 3, -27 },
  { 624, 3, 10, 27, 9, -4 },
  { 628, 15, 1, 27, 6, -15 },
  { 630, 3, 2, 27, 13, -2 },
  { 631, 14, 35, 27, 7, -32 },
  { 693, 19, 32, 27, 4, -32 },
  { 769, 11, 32, 27, 5, -32 },
  { 813, 20, 32, 27, 2, -32 },
  { 893, 20, 32, 27, 2, -32 },
  { 973, 22, 32, 27, 2, -32 },
  { 1061, 19, 32, 27, 5, -32 },
  { 1137, 20, 32, 27, 3, -32 },
  { 1217, 20, 32, 27, 3, -32 },
  { 1297, 20, 32, 27, 4, -32 },
  { 1377, 19, 32, 27, 4, -32 },
  { 1453, 3, 21, 27, 14, -21 },
  { 1461, 4, 27, 27, 13, -21 },
  { 1475, 19, 17, 27, 4, -23 },
  { 1516, 19, 10, 27, 4, -20 },
  { 1540, 19, 18, 27, 4, -24 },
  { 1583, 17, 32, 27, 5, -32 },
  { 1651, 25, 32, 27, 1, -32 },
  { 1751, 22, 32, 27, 3, -32 },
  { 1839, 19, 32, 27, 5, -32 },
  { 1915, 21, 32, 27, 3, -32 },
  { 1999, 20, 32, 27, 4, -32 },
  { 2079, 18, 32, 27, 5, -32 },
  { 2151, 18, 32, 27, 5, -32 },
  { 2223, 21, 32, 27, 3, -32 },
  { 2307, 19, 32, 27, 4, -32 },
  { 2383, 17, 32, 27, 5, -32 },
  { 2451, 19, 32, 27, 3, -32 },
  { 2527, 21, 32, 27, 5, -32 },
  { 2611, 18, 32, 27, 5, -32 },
  { 2683, 19, 32, 27, 4, -32 },
  { 2759, 19, 32, 27, 4, -32 },
  { 2835, 21, 32, 27, 3, -32 },
  { 2919, 20, 32, 27, 5, -32 },
  { 2999, 22, 38, 27, 3, -32 },
  { 3104, 20, 32, 27, 5, -32 },
  { 3184, 21, 32, 27, 3, -32 },
  { 3268, 23, 32, 27, 2, -32 },
  { 3360, 19, 32, 27, 4, -32 },
  { 3436, 23, 32, 27, 2, -32 },
  { 3528, 24, 32, 27, 2, -32 },
  { 3624, 22, 32, 27, 3, -32 },
  { 3712, 22, 32, 27, 2, -32 },
  { 3800, 20, 32, 27, 3, -32 },
  { 3880, 7, 44, 27, 10, -37 },
  { 3919, 15, 35, 27, 6, -32 },
  { 3985, 6, 44, 27, 10, -37 },
  { 4018, 15, 18, 27, 6, -32 },
  { 4052, 19, 1, 27, 4, 0 },
  { 4055, 5, 6, 27, 11, -33 },
  { 4059, 19, 24, 27, 4, -24 },
  { 4116, 18, 34, 27, 5, -34 },
  { 4193, 19, 24, 27, 4, -24 },
  { 4250, 18, 34, 27, 4, -34 },
  { 4327, 19, 24, 27, 4, -24 },
  { 4384, 19, 34, 27, 5, -34 },
  { 4465, 18, 34, 27, 4, -24 },
  { 4542, 18, 34, 27, 5, -34 },
  { 4619, 19, 32, 27, 5, -32 },
  { 4695, 14, 42, 27, 4, -32 },
  { 4769, 18, 34, 27, 6, -34 },
  { 4846, 19, 34, 27, 5, -34 },
  { 4927, 23, 24, 27, 2, -24 },
  { 4996, 18, 24, 27, 5, -24 },
  { 5050, 21, 24, 27, 3, -24 },
  { 5113, 18, 33, 27, 5, -24 },
  { 5188, 18, 33, 27, 4, -24 },
  { 5263, 15, 24, 27, 9, -24 },
  { 5308, 19, 24, 27, 4, -24 },
  { 5365, 18, 30, 27, 4, -30 },
  { 5433, 17, 24, 27, 5, -24 },
  { 5484, 21, 24, 27, 3, -24 },
  { 5547, 24, 24, 27, 2, -24 },
  { 5619, 21, 24, 27, 3, -24 },
  { 5682, 23, 34, 27, 2, -24 },
  { 5780, 21, 24, 27, 3, -24 },
  { 5843, 15, 45, 27, 7, -35 },
  { 5928, 1, 38, 27, 13, -32 },
  { 5933, 15, 45, 27, 7, -35 },
  { 6018, 23, 7, 27, 2, -17 },
};

const GFXfont RobotoMono_Thin45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin45pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_THIN45PT7B_H_
