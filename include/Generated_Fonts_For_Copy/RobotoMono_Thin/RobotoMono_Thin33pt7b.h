#ifndef _ROBOTOMONO_THIN33PT7B_H_
#define _ROBOTOMONO_THIN33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin33pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x2C, 0x8C, 0x63, 0x18, 0xC6, 0x20,
  0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x10, 0x02, 0x04, 0x00,
  0x81, 0x07, 0xFF, 0xFC, 0x08, 0x10, 0x02, 0x04, 0x00, 0x82, 0x00, 0x40,
  0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x41, 0x03, 0xFF, 0xFE,
  0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08, 0x20, 0x04,
  0x08, 0x01, 0x02, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xF0, 0x18,
  0x30, 0x80, 0x66, 0x00, 0x90, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x60, 0x08,
  0xC0, 0x60, 0xFE, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x38, 0x00, 0x11,
  0x00, 0x08, 0x20, 0x02, 0x08, 0x10, 0x82, 0x04, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x40, 0x82, 0x20, 0x11, 0x08, 0x03, 0xC4, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x80, 0x10, 0x98, 0x04, 0x42, 0x02, 0x10, 0x40,
  0x88, 0x10, 0x42, 0x04, 0x20, 0x81, 0x08, 0x20, 0x44, 0x04, 0x10, 0x01,
  0x08, 0x00, 0x3C, 0x07, 0x00, 0x18, 0x80, 0x30, 0x40, 0x20, 0x40, 0x20,
  0x20, 0x20, 0x40, 0x20, 0x40, 0x20, 0x80, 0x11, 0x00, 0x12, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x16, 0x00, 0x22, 0x00, 0x41, 0x02, 0x80, 0x82, 0x80,
  0x42, 0x80, 0x26, 0x80, 0x24, 0x80, 0x14, 0x80, 0x08, 0xC0, 0x14, 0x60,
  0x22, 0x1F, 0xC3, 0xFE, 0x06, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x80, 0x80,
  0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x30, 0xC1, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0xE1,
  0x0C, 0x75, 0xC0, 0x38, 0x00, 0xA0, 0x04, 0x40, 0x31, 0x80, 0x83, 0x0C,
  0x06, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x55,
  0x68, 0xFF, 0xF0, 0x70, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x00, 0x07, 0x80, 0x61, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A,
  0x00, 0x28, 0x00, 0xE0, 0x05, 0x80, 0x26, 0x01, 0x18, 0x08, 0x60, 0x41,
  0x82, 0x06, 0x10, 0x18, 0x80, 0x64, 0x01, 0xA0, 0x07, 0x00, 0x18, 0x00,
  0x50, 0x02, 0x40, 0x08, 0x80, 0x43, 0x02, 0x03, 0xF0, 0x06, 0x35, 0x8C,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x07, 0x00, 0x61, 0x82, 0x01, 0x10,
  0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFF,
  0x07, 0x80, 0x61, 0x82, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x03, 0x00, 0x70, 0x07, 0xE0, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x05, 0x00, 0x22, 0x01, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x04, 0x10, 0x02,
  0x08, 0x02, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x00, 0x81, 0x00, 0x40,
  0x80, 0x20, 0x80, 0x10, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x7F, 0xFA, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x47, 0x03, 0x86, 0x10,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x14, 0x01, 0x10, 0x10, 0x7F, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x7F, 0x0A, 0x03, 0x30, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x40, 0x09, 0x00, 0x43,
  0x02, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x00, 0x03,
  0x80, 0x30, 0xE0, 0x80, 0x62, 0x00, 0x44, 0x00, 0x48, 0x00, 0xA0, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x10, 0xC0, 0x40, 0x77, 0x01, 0xFE, 0x04,
  0x03, 0x10, 0x01, 0x40, 0x02, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x48, 0x01, 0x88, 0x06, 0x0F, 0xF0, 0x07, 0x80, 0x61, 0x82,
  0x01, 0x10, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0D, 0x00, 0x52, 0x02, 0x47, 0x71,
  0x02, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x07, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x49,
  0x49, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x08, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x04, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x00, 0x07, 0x03, 0x0C, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x60, 0x00, 0xF0, 0x01, 0xC3, 0x80, 0xC0, 0x30, 0x60, 0x04, 0x30, 0x00,
  0x88, 0x38, 0x24, 0x11, 0x85, 0x08, 0x21, 0x44, 0x08, 0x61, 0x02, 0x18,
  0x40, 0x86, 0x10, 0x41, 0x88, 0x10, 0x62, 0x04, 0x18, 0x81, 0x06, 0x20,
  0x42, 0x84, 0x30, 0xA1, 0x14, 0x28, 0x2C, 0xF1, 0x04, 0x10, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x40, 0x1F, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10,
  0x04, 0x3F, 0xFC, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xE1, 0x00, 0x22, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x63,
  0xFF, 0x04, 0x07, 0x08, 0x01, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90, 0x02, 0x3F, 0xF8,
  0x00, 0x03, 0xC0, 0x18, 0x60, 0x40, 0x21, 0x00, 0x22, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x05, 0x00,
  0x0A, 0x00, 0x12, 0x00, 0x42, 0x00, 0x86, 0x06, 0x03, 0xF0, 0xFF, 0xC1,
  0x00, 0x42, 0x00, 0x44, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48,
  0x01, 0x10, 0x0C, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xF9,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0xFF, 0xE8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x03, 0xC0,
  0x18, 0x60, 0x40, 0x21, 0x00, 0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x1F,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x12,
  0x00, 0x22, 0x00, 0x42, 0x01, 0x03, 0xFC, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03,
  0xFF, 0xE0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x50,
  0x02, 0x40, 0x08, 0xC0, 0xC0, 0xFC, 0x00, 0x80, 0x0D, 0x00, 0x22, 0x00,
  0x84, 0x03, 0x08, 0x0C, 0x10, 0x10, 0x20, 0x40, 0x41, 0x00, 0x84, 0x01,
  0x10, 0x02, 0x60, 0x05, 0x20, 0x0C, 0x60, 0x10, 0x40, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x41, 0x00, 0xC2, 0x00, 0x84, 0x00, 0x88, 0x00, 0x90, 0x00,
  0xA0, 0x01, 0x80, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0xFF, 0xE0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE8, 0x05,
  0xA0, 0x16, 0x40, 0x99, 0x02, 0x64, 0x09, 0x88, 0x46, 0x21, 0x18, 0x88,
  0x61, 0x21, 0x84, 0x86, 0x0C, 0x18, 0x30, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x68, 0x01, 0x90, 0x06, 0x40, 0x18, 0x80, 0x62, 0x01,
  0x84, 0x06, 0x10, 0x18, 0x20, 0x60, 0x41, 0x81, 0x06, 0x02, 0x18, 0x08,
  0x60, 0x11, 0x80, 0x46, 0x00, 0x98, 0x01, 0x60, 0x05, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x40, 0x03, 0x80, 0x0C, 0x30, 0x10, 0x08, 0x20, 0x04, 0x20,
  0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x10, 0x08, 0x18,
  0x10, 0x07, 0xE0, 0xFF, 0xE2, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x0C,
  0xFF, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x0C, 0x30,
  0x10, 0x08, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02,
  0x20, 0x04, 0x20, 0x04, 0x18, 0x18, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0xFF, 0xC2, 0x00, 0x88, 0x01, 0x20, 0x04, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x02, 0x20,
  0x10, 0xFF, 0x82, 0x02, 0x08, 0x08, 0x20, 0x10, 0x80, 0x42, 0x00, 0x88,
  0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x40, 0x07, 0xC0, 0x30,
  0x60, 0x80, 0x62, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x48, 0x00, 0x88, 0x06, 0x0F, 0xF0, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x90, 0x02, 0x60, 0x10, 0xC0, 0xC0, 0xFC, 0x00, 0x80, 0x01, 0x80,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x28, 0x28, 0x14, 0x14, 0x0A, 0x09, 0x09, 0x04, 0x84, 0x82,
  0x42, 0x41, 0x21, 0x11, 0x10, 0x88, 0x88, 0x84, 0x42, 0x42, 0x21, 0x21,
  0x10, 0x90, 0x48, 0x48, 0x28, 0x28, 0x14, 0x14, 0x0A, 0x06, 0x05, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x80, 0x40, 0x40, 0x20, 0xC0, 0x03, 0x20, 0x02,
  0x20, 0x04, 0x10, 0x04, 0x08, 0x08, 0x08, 0x10, 0x04, 0x10, 0x04, 0x20,
  0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40,
  0x04, 0x20, 0x04, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x0C, 0x20, 0x04,
  0x20, 0x02, 0x40, 0x02, 0x80, 0x01, 0xC0, 0x01, 0xB0, 0x00, 0x88, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x40, 0x40, 0x20, 0x20, 0x20, 0x08, 0x10, 0x04,
  0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x24, 0x00, 0x14, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x7F, 0xFC, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0x80, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3F, 0x06,
  0x00, 0x60, 0x09, 0x00, 0x90, 0x11, 0x01, 0x08, 0x10, 0x82, 0x04, 0x20,
  0x44, 0x04, 0x40, 0x2C, 0x03, 0xFF, 0xFC, 0xC4, 0x21, 0x07, 0x80, 0x61,
  0x82, 0x01, 0x10, 0x02, 0x80, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x07,
  0xF8, 0xE0, 0x16, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0,
  0x05, 0x40, 0x64, 0xFE, 0x10, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x11, 0xE0, 0xB0, 0xC6, 0x01, 0x20, 0x05, 0x00,
  0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x40, 0x0B, 0x00, 0x9C, 0x0C, 0x9F, 0x80, 0x07, 0x80,
  0x61, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x14, 0x00,
  0x88, 0x02, 0x30, 0x10, 0x3F, 0x80, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0xF1, 0x18, 0x49, 0x01, 0xD0, 0x06,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xA0, 0x05, 0x80, 0x66, 0x05, 0x1F, 0xC8, 0x07,
  0x80, 0x61, 0x82, 0x01, 0x10, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x01, 0x10, 0x18, 0x3F, 0x80, 0x00, 0xFE, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0xFF, 0xF8,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x07, 0x80, 0xC2, 0x48, 0x0E, 0x80,
  0x34, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x28, 0x03, 0x30, 0x28, 0x7E, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x09, 0x00, 0x46, 0x0C, 0x0F, 0x80, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0xE0, 0x8C, 0x32, 0x40, 0x6A, 0x00, 0xB0, 0x02, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x02, 0x00, 0x38, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x00, 0x80,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x8F,
  0xC0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x02, 0x80, 0x12, 0x01, 0x88, 0x0C, 0x20, 0x40, 0x82, 0x02,
  0x10, 0x08, 0x80, 0x26, 0x00, 0xE4, 0x02, 0x08, 0x08, 0x30, 0x20, 0x60,
  0x80, 0x82, 0x01, 0x08, 0x02, 0x20, 0x04, 0x80, 0x0C, 0xFE, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0xFF, 0xF8, 0x0E, 0x0E, 0x58, 0x98, 0xB0, 0x30, 0x38, 0x18, 0x18, 0x08,
  0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x40, 0x03, 0x82, 0x30, 0xC9, 0x01, 0x28, 0x02,
  0xC0, 0x0B, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x03, 0xC0, 0x0C, 0x30, 0x10, 0x08, 0x20, 0x04, 0x40, 0x06, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x04, 0x20, 0x0C, 0x18, 0x18, 0x0F,
  0xE0, 0x0F, 0x05, 0x86, 0x30, 0x09, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0A,
  0x00, 0x50, 0x04, 0xE0, 0x44, 0xFC, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x07, 0x80, 0xC3, 0x48, 0x0E, 0x80,
  0x34, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x2C, 0x03, 0x30, 0x28, 0xFE, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x03,
  0xF1, 0x82, 0x40, 0x50, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x01, 0x40, 0x05, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x50, 0x01, 0x20, 0x18, 0x7F, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x7F, 0xFC, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0xFC, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x64, 0x05, 0x1F, 0xC8,
  0x80, 0x03, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x08,
  0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0xC0,
  0x50, 0x30, 0x24, 0x0C, 0x09, 0x03, 0x02, 0x41, 0x20, 0x88, 0x48, 0x22,
  0x12, 0x10, 0x84, 0x84, 0x22, 0x11, 0x08, 0x84, 0x41, 0x21, 0x20, 0x48,
  0x28, 0x14, 0x0A, 0x05, 0x02, 0x80, 0xC0, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x60, 0x02, 0x20, 0x04, 0x10, 0x08, 0x08, 0x10, 0x04, 0x30, 0x06,
  0x20, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x60, 0x04,
  0x20, 0x08, 0x10, 0x10, 0x08, 0x30, 0x04, 0x20, 0x06, 0xC0, 0x03, 0xC0,
  0x00, 0xA0, 0x00, 0x88, 0x00, 0x44, 0x00, 0x21, 0x00, 0x20, 0x80, 0x10,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x08, 0x02, 0x04, 0x01, 0x84, 0x00, 0x42,
  0x00, 0x21, 0x00, 0x09, 0x00, 0x04, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0x00, 0x20, 0x18, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0xE0, 0x06,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xE0, 0x40, 0x04, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x00, 0xE0, 0x18, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x01, 0x80, 0xC0, 0x00,
  0x3E, 0x00, 0x50, 0x60, 0x28, 0x04, 0x0A, 0x00, 0x84, 0x80, 0x1E, 0x00,
};

const GFXglyph RobotoMono_Thin33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 2, 23, 20, 9, -23 },
  { 7, 5, 7, 20, 7, -25 },
  { 12, 18, 23, 20, 1, -23 },
  { 64, 14, 30, 20, 3, -27 },
  { 117, 18, 24, 20, 1, -24 },
  { 171, 16, 24, 20, 3, -24 },
  { 219, 1, 7, 20, 9, -25 },
  { 220, 7, 34, 20, 7, -26 },
  { 250, 7, 34, 20, 6, -26 },
  { 280, 14, 12, 20, 3, -23 },
  { 301, 16, 17, 20, 2, -19 },
  { 335, 2, 7, 20, 7, -3 },
  { 337, 12, 1, 20, 4, -11 },
  { 339, 2, 2, 20, 9, -2 },
  { 340, 11, 25, 20, 5, -23 },
  { 375, 14, 24, 20, 3, -24 },
  { 417, 7, 23, 20, 4, -23 },
  { 438, 14, 24, 20, 2, -24 },
  { 480, 14, 24, 20, 2, -24 },
  { 522, 17, 23, 20, 1, -23 },
  { 571, 13, 23, 20, 4, -23 },
  { 609, 14, 24, 20, 3, -24 },
  { 651, 15, 23, 20, 2, -23 },
  { 695, 15, 24, 20, 3, -24 },
  { 740, 14, 24, 20, 3, -24 },
  { 782, 2, 16, 20, 10, -16 },
  { 786, 3, 20, 20, 9, -16 },
  { 794, 14, 13, 20, 3, -17 },
  { 817, 14, 7, 20, 3, -14 },
  { 830, 14, 13, 20, 3, -17 },
  { 853, 12, 24, 20, 4, -24 },
  { 889, 18, 24, 20, 1, -24 },
  { 943, 16, 23, 20, 2, -23 },
  { 989, 15, 23, 20, 3, -23 },
  { 1033, 15, 24, 20, 2, -24 },
  { 1078, 15, 23, 20, 3, -23 },
  { 1122, 13, 23, 20, 4, -23 },
  { 1160, 13, 23, 20, 4, -23 },
  { 1198, 15, 24, 20, 2, -24 },
  { 1243, 14, 23, 20, 3, -23 },
  { 1284, 13, 23, 20, 3, -23 },
  { 1322, 14, 23, 20, 2, -23 },
  { 1363, 15, 23, 20, 4, -23 },
  { 1407, 13, 23, 20, 4, -23 },
  { 1445, 14, 23, 20, 3, -23 },
  { 1486, 14, 23, 20, 3, -23 },
  { 1527, 16, 24, 20, 2, -24 },
  { 1575, 14, 23, 20, 4, -23 },
  { 1616, 16, 28, 20, 2, -24 },
  { 1672, 14, 23, 20, 4, -23 },
  { 1713, 15, 24, 20, 3, -24 },
  { 1758, 16, 23, 20, 2, -23 },
  { 1804, 14, 23, 20, 3, -23 },
  { 1845, 16, 23, 20, 2, -23 },
  { 1891, 17, 23, 20, 2, -23 },
  { 1940, 16, 23, 20, 2, -23 },
  { 1986, 17, 23, 20, 1, -23 },
  { 2035, 15, 23, 20, 2, -23 },
  { 2079, 4, 32, 20, 8, -27 },
  { 2095, 10, 25, 20, 5, -23 },
  { 2127, 5, 32, 20, 7, -27 },
  { 2147, 12, 12, 20, 4, -23 },
  { 2165, 14, 1, 20, 3, 0 },
  { 2167, 4, 4, 20, 8, -24 },
  { 2169, 14, 18, 20, 3, -18 },
  { 2201, 13, 25, 20, 4, -25 },
  { 2242, 14, 18, 20, 3, -18 },
  { 2274, 13, 25, 20, 3, -25 },
  { 2315, 14, 18, 20, 3, -18 },
  { 2347, 15, 25, 20, 3, -25 },
  { 2394, 13, 25, 20, 3, -18 },
  { 2435, 14, 25, 20, 3, -25 },
  { 2479, 13, 24, 20, 4, -24 },
  { 2518, 10, 31, 20, 3, -24 },
  { 2557, 14, 25, 20, 4, -25 },
  { 2601, 13, 25, 20, 4, -25 },
  { 2642, 17, 18, 20, 1, -18 },
  { 2681, 14, 18, 20, 3, -18 },
  { 2713, 16, 18, 20, 2, -18 },
  { 2749, 13, 25, 20, 4, -18 },
  { 2790, 13, 25, 20, 3, -18 },
  { 2831, 11, 18, 20, 6, -18 },
  { 2856, 14, 18, 20, 3, -18 },
  { 2888, 13, 22, 20, 3, -22 },
  { 2924, 13, 17, 20, 3, -17 },
  { 2952, 16, 17, 20, 2, -17 },
  { 2986, 18, 17, 20, 1, -17 },
  { 3025, 16, 17, 20, 2, -17 },
  { 3059, 17, 24, 20, 1, -17 },
  { 3110, 16, 17, 20, 2, -17 },
  { 3144, 11, 33, 20, 5, -26 },
  { 3190, 1, 27, 20, 9, -23 },
  { 3194, 11, 33, 20, 5, -26 },
  { 3240, 18, 5, 20, 1, -12 },
};

const GFXfont RobotoMono_Thin33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin33pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_THIN33PT7B_H_
