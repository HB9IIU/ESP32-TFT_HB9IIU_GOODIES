#ifndef _ROBOTOMONO_THIN58PT7B_H_
#define _ROBOTOMONO_THIN58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin58pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00, 0x6F, 0x60, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x20,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x08, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x80, 0x00, 0x10, 0x01, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x20, 0x00, 0x04, 0x00, 0x40,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x10, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x01, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x06, 0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xC0, 0xE0, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x80, 0xC0, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x01,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x40, 0x08, 0x0C, 0x00, 0x60, 0x08, 0x18,
  0x00, 0x60, 0x18, 0x10, 0x00, 0x30, 0x30, 0x30, 0x00, 0x18, 0x60, 0x20,
  0x00, 0x0F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x02, 0x03, 0xF8, 0x00, 0x06, 0x06, 0x0C, 0x00, 0x04, 0x0C,
  0x06, 0x00, 0x0C, 0x0C, 0x02, 0x00, 0x08, 0x18, 0x03, 0x00, 0x18, 0x18,
  0x01, 0x00, 0x10, 0x18, 0x01, 0x00, 0x30, 0x10, 0x01, 0x00, 0x60, 0x10,
  0x01, 0x00, 0x60, 0x10, 0x01, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x80, 0x18,
  0x01, 0x01, 0x80, 0x18, 0x01, 0x01, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x00, 0x80, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x0C, 0x00, 0x63, 0x00, 0x60, 0x06,
  0x60, 0x03, 0x00, 0x64, 0x00, 0x30, 0x06, 0xC0, 0x01, 0x80, 0x4C, 0x00,
  0x0C, 0x0C, 0x80, 0x00, 0x60, 0xC8, 0x00, 0x03, 0x0C, 0x80, 0x00, 0x19,
  0x88, 0x00, 0x01, 0x98, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x70, 0x40,
  0x00, 0x07, 0x06, 0x00, 0x00, 0xD8, 0x30, 0x00, 0x18, 0x81, 0x80, 0x07,
  0x0C, 0x0F, 0x01, 0xC0, 0x60, 0x3F, 0xF0, 0x03, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xDF, 0xFF, 0x00, 0x10, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x40, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x06, 0xF0, 0x08, 0x0F, 0x9F, 0x04, 0x3E, 0x00, 0xF2,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0x98, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x33, 0x33, 0x33, 0x32, 0x66, 0xC8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x40, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x6F, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x63, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x3C, 0x60, 0x00, 0x1E, 0x60, 0x00, 0x0F,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x02, 0x60, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x80, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x72, 0x1E, 0x13,
  0xC0, 0xF8, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x30, 0x00,
  0xE0, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x68, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x18, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x07, 0x80,
  0x78, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x08,
  0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x00, 0x80, 0x01,
  0x80, 0x08, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x80, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFE, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x67, 0xFF, 0x80, 0xF8, 0x01, 0xC1,
  0xC0, 0x01, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x63, 0x00, 0x01, 0x87, 0x00, 0x03, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0xFE,
  0x00, 0x61, 0xF3, 0xF0, 0x11, 0xC0, 0x0E, 0x04, 0xE0, 0x00, 0xC1, 0x60,
  0x00, 0x18, 0x50, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x02, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x78, 0x07, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x02, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x70, 0x03, 0x80, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x02, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x07, 0x80, 0x78, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x38,
  0x01, 0x80, 0x06, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x1E, 0x60, 0x00, 0x1B, 0x18, 0x00, 0x19, 0x86, 0x00, 0x18,
  0x81, 0xC0, 0x38, 0x40, 0x7F, 0xF0, 0x20, 0x07, 0xC0, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xF6, 0x18, 0xF1, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC3, 0x08, 0x61, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0x70, 0x30, 0x00, 0xC3,
  0x00, 0x02, 0x30, 0x00, 0x19, 0x80, 0x00, 0x68, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x06, 0x0C, 0x01, 0xF8, 0x06, 0x18, 0x03, 0xFC, 0x02,
  0x18, 0x06, 0x06, 0x03, 0x30, 0x0C, 0x02, 0x03, 0x30, 0x18, 0x02, 0x03,
  0x20, 0x10, 0x02, 0x03, 0x20, 0x30, 0x06, 0x03, 0x60, 0x20, 0x06, 0x01,
  0x60, 0x60, 0x06, 0x01, 0x40, 0x60, 0x06, 0x01, 0x40, 0x60, 0x04, 0x01,
  0x40, 0x40, 0x04, 0x01, 0x40, 0x40, 0x04, 0x01, 0x40, 0x40, 0x04, 0x03,
  0x40, 0x40, 0x04, 0x03, 0x40, 0x40, 0x0C, 0x03, 0x40, 0x40, 0x0C, 0x03,
  0x40, 0x40, 0x0C, 0x02, 0x40, 0x40, 0x1C, 0x02, 0x40, 0x40, 0x1C, 0x06,
  0x60, 0x60, 0x34, 0x06, 0x60, 0x60, 0x64, 0x0C, 0x60, 0x30, 0xC6, 0x08,
  0x20, 0x1F, 0xC3, 0xF8, 0x30, 0x0F, 0x01, 0xE0, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08,
  0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x60, 0x00, 0x20, 0x03,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x06, 0x00, 0x00, 0x40, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x40, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0xFF, 0xFE, 0x00,
  0x60, 0x03, 0xE0, 0x30, 0x00, 0x38, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x38, 0x30, 0x00, 0x70, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x06, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x02, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xE1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x78,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x40,
  0x0F, 0xC0, 0x20, 0x00, 0x70, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x04,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06,
  0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x04, 0x00, 0x03, 0x02, 0x00, 0x07, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x10,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x70,
  0x07, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x06,
  0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x61, 0xE0, 0x00, 0x0C, 0x66, 0x00, 0x01, 0x98, 0x60, 0x00, 0x36,
  0x0C, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xBE,
  0x00, 0x00, 0xDD, 0x00, 0x00, 0x6E, 0xC0, 0x00, 0x27, 0x60, 0x00, 0x33,
  0x90, 0x00, 0x11, 0xCC, 0x00, 0x18, 0xE2, 0x00, 0x0C, 0x71, 0x80, 0x04,
  0x38, 0xC0, 0x06, 0x1C, 0x20, 0x02, 0x0E, 0x18, 0x03, 0x07, 0x04, 0x01,
  0x83, 0x83, 0x01, 0x81, 0xC1, 0x80, 0xC0, 0xE0, 0x40, 0x40, 0x70, 0x30,
  0x60, 0x38, 0x18, 0x20, 0x1C, 0x04, 0x30, 0x0E, 0x03, 0x18, 0x07, 0x00,
  0x88, 0x03, 0x80, 0x6C, 0x01, 0xC0, 0x34, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3D,
  0x00, 0x00, 0x1E, 0xC0, 0x00, 0x0F, 0x20, 0x00, 0x07, 0x98, 0x00, 0x03,
  0xC4, 0x00, 0x01, 0xE1, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x78, 0x20, 0x00,
  0x3C, 0x18, 0x00, 0x1E, 0x04, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x80, 0x80,
  0x03, 0xC0, 0x60, 0x01, 0xE0, 0x18, 0x00, 0xF0, 0x04, 0x00, 0x78, 0x03,
  0x00, 0x3C, 0x00, 0x80, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x10, 0x07, 0x80,
  0x0C, 0x03, 0xC0, 0x03, 0x01, 0xE0, 0x00, 0x80, 0xF0, 0x00, 0x60, 0x78,
  0x00, 0x10, 0x3C, 0x00, 0x0C, 0x1E, 0x00, 0x02, 0x0F, 0x00, 0x01, 0x87,
  0x80, 0x00, 0x63, 0xC0, 0x00, 0x11, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x02,
  0x78, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x5E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x30,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x40, 0x01, 0xF0, 0x20, 0x00, 0x0E, 0x10, 0x00, 0x03, 0x88, 0x00,
  0x00, 0xE4, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x01, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x90, 0x00, 0x01,
  0x88, 0x00, 0x03, 0x84, 0x00, 0x07, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08, 0x06, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0xF0, 0x0C,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x70, 0x0F, 0xFF, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x0E, 0x00, 0xF0, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x20, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x38, 0x00, 0x38, 0x03, 0xC0,
  0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0x40, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xE0, 0x00,
  0xC0, 0x38, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40,
  0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0xC0, 0x00, 0xC0, 0x04, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x10, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x09, 0x00, 0x1E, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20,
  0x02, 0x60, 0x04, 0x80, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01,
  0x88, 0x03, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x43,
  0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0x40,
  0x40, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x30,
  0x30, 0x20, 0x60, 0xC0, 0xC1, 0x81, 0x82, 0x01, 0x06, 0x02, 0x08, 0x04,
  0x10, 0x08, 0x60, 0x18, 0x40, 0x21, 0x80, 0x61, 0x00, 0x86, 0x01, 0x84,
  0x03, 0x10, 0x02, 0x30, 0x0C, 0x40, 0x08, 0xC0, 0x33, 0x00, 0x32, 0x00,
  0x4C, 0x00, 0xC8, 0x01, 0x30, 0x03, 0x20, 0x04, 0x80, 0x04, 0x80, 0x1A,
  0x00, 0x16, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x08, 0x01, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0xFF, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x50,
  0x00, 0x0D, 0x80, 0x00, 0x98, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30,
  0x40, 0x03, 0x06, 0x00, 0x20, 0x60, 0x06, 0x03, 0x00, 0x40, 0x30, 0x0C,
  0x01, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x81, 0x80, 0x0C, 0x10, 0x00, 0xC3,
  0x00, 0x04, 0x30, 0x00, 0x62, 0x00, 0x02, 0x60, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x81, 0x81, 0x81, 0x03,
  0x03, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0xF8, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x31, 0x80, 0x00, 0x08, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xFC,
  0x07, 0xF8, 0x06, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x64, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x20, 0x00, 0x03, 0x98, 0x00,
  0x03, 0xCC, 0x00, 0x07, 0x63, 0x80, 0x06, 0x10, 0xF0, 0x1E, 0x0C, 0x1F,
  0xFC, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0x00, 0xC3,
  0xC3, 0xC0, 0xCE, 0x00, 0xE0, 0xDC, 0x00, 0x30, 0xD0, 0x00, 0x18, 0xF0,
  0x00, 0x08, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x0C, 0xF0, 0x00, 0x18, 0xD8, 0x00, 0x30, 0xCC, 0x00, 0x60, 0xC7,
  0x01, 0xC0, 0xC1, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xE1, 0xE0, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x10,
  0x00, 0x06, 0x30, 0x00, 0x02, 0x20, 0x00, 0x03, 0x60, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x02, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x03,
  0x80, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x1F, 0xE0,
  0x40, 0xF8, 0xF0, 0x83, 0x00, 0x31, 0x0C, 0x00, 0x32, 0x30, 0x00, 0x34,
  0xC0, 0x00, 0x39, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x05, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x24, 0x00, 0x00, 0x4C, 0x00, 0x01,
  0x8C, 0x00, 0x07, 0x1C, 0x00, 0x1A, 0x1C, 0x00, 0x64, 0x0E, 0x07, 0x88,
  0x0F, 0xFC, 0x10, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0xF0,
  0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x20, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0xC0, 0x1E, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFC, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x03,
  0x03, 0xE3, 0xC3, 0x06, 0x00, 0x63, 0x0C, 0x00, 0x33, 0x18, 0x00, 0x1B,
  0x30, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x03,
  0x30, 0x00, 0x07, 0x18, 0x00, 0x0F, 0x0C, 0x00, 0x1B, 0x0E, 0x00, 0x33,
  0x03, 0x81, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x08, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x07, 0xC1, 0xC0, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x0F, 0xF0, 0x30, 0x78,
  0x78, 0x63, 0x80, 0x18, 0xCE, 0x00, 0x19, 0x90, 0x00, 0x1B, 0x40, 0x00,
  0x17, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x10, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x07, 0x00, 0xC0,
  0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC7, 0x00, 0x00, 0xCF, 0x80, 0x00, 0xD8,
  0xC0, 0x00, 0xF0, 0x60, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0xF8, 0x0F, 0xE3, 0x38, 0x70,
  0xF1, 0xCD, 0x80, 0x66, 0x01, 0xBC, 0x00, 0xB0, 0x03, 0xE0, 0x03, 0x80,
  0x0F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x70, 0x00, 0x40, 0x01,
  0xC0, 0x01, 0x00, 0x07, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x70,
  0x00, 0x40, 0x01, 0xC0, 0x01, 0x00, 0x07, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x10, 0x00, 0x70, 0x00, 0x40, 0x01, 0xC0, 0x01, 0x00, 0x07, 0x00, 0x04,
  0x00, 0x1C, 0x00, 0x10, 0x00, 0x70, 0x00, 0x40, 0x01, 0xC0, 0x01, 0x00,
  0x07, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x70, 0x00, 0x40, 0x01,
  0xC0, 0x01, 0x00, 0x07, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x70,
  0x00, 0x40, 0x01, 0xC0, 0x01, 0x00, 0x07, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x10, 0x00, 0x40, 0xC0, 0x7F, 0x81, 0x83, 0xC3, 0xC3, 0x1C, 0x00, 0xC6,
  0x70, 0x00, 0xCD, 0x80, 0x00, 0xDA, 0x00, 0x01, 0xBC, 0x00, 0x01, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xC0, 0xFF, 0x00,
  0xC3, 0xC7, 0xC0, 0xCE, 0x00, 0xE0, 0xD8, 0x00, 0x30, 0xF0, 0x00, 0x18,
  0xE0, 0x00, 0x08, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C,
  0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x18, 0xF0, 0x00, 0x30, 0xDC, 0x00, 0x60,
  0xC7, 0x01, 0xC0, 0xC1, 0xFF, 0x80, 0xC0, 0x10, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x02, 0x07, 0xC7, 0x84,
  0x18, 0x01, 0x88, 0x60, 0x01, 0x91, 0x80, 0x01, 0xA6, 0x00, 0x01, 0xCC,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x58, 0x00, 0x00,
  0xB0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x38,
  0xE0, 0x00, 0xD0, 0xE0, 0x03, 0x20, 0x70, 0x3C, 0x40, 0x7F, 0xE0, 0x80,
  0x04, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0xC0, 0x3F,
  0xF8, 0x1F, 0x07, 0x0E, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xC3, 0xE0, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x0C,
  0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0x80, 0x00,
  0x79, 0x80, 0x01, 0xB1, 0x80, 0x06, 0x61, 0xC0, 0x78, 0xC1, 0xFF, 0xC1,
  0x80, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x10, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x80, 0x08, 0x00, 0x08, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x03, 0x00, 0x0D,
  0x00, 0x0E, 0x00, 0x1B, 0x00, 0x1C, 0x00, 0x26, 0x00, 0x28, 0x00, 0x4C,
  0x00, 0x58, 0x01, 0x88, 0x01, 0xB0, 0x03, 0x10, 0x03, 0x20, 0x04, 0x30,
  0x04, 0x40, 0x08, 0x60, 0x08, 0xC0, 0x30, 0x40, 0x31, 0x80, 0x60, 0x80,
  0x61, 0x00, 0xC1, 0x80, 0x82, 0x01, 0x03, 0x01, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x04, 0x0C, 0x08, 0x18, 0x0C, 0x10, 0x10, 0x20, 0x18, 0x20,
  0x30, 0x40, 0x30, 0xC0, 0x61, 0x80, 0x21, 0x80, 0x43, 0x00, 0x42, 0x00,
  0x84, 0x00, 0xC4, 0x01, 0x88, 0x01, 0x98, 0x03, 0x30, 0x03, 0x30, 0x02,
  0x60, 0x02, 0x40, 0x04, 0xC0, 0x04, 0x80, 0x0D, 0x00, 0x0F, 0x00, 0x1A,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x03,
  0x00, 0x01, 0x80, 0x04, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0C, 0xC0, 0x70, 0x00, 0x1B, 0x00, 0x30, 0x00, 0x26, 0x00, 0x30,
  0x00, 0xC8, 0x00, 0x30, 0x01, 0xB0, 0x00, 0x38, 0x06, 0x60, 0x00, 0x1C,
  0x38, 0xC0, 0x00, 0x1F, 0xE0,
};

const GFXglyph RobotoMono_Thin58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 4, 41, 35, 15, -41 },
  { 22, 9, 12, 35, 13, -44 },
  { 36, 31, 41, 35, 2, -41 },
  { 195, 25, 53, 35, 5, -47 },
  { 361, 32, 43, 35, 1, -42 },
  { 533, 28, 43, 35, 5, -42 },
  { 684, 2, 12, 35, 15, -44 },
  { 687, 13, 59, 35, 11, -46 },
  { 783, 13, 59, 35, 10, -46 },
  { 879, 25, 22, 35, 6, -41 },
  { 948, 29, 30, 35, 3, -34 },
  { 1057, 4, 12, 35, 12, -5 },
  { 1063, 21, 2, 35, 7, -20 },
  { 1069, 3, 3, 35, 17, -3 },
  { 1071, 19, 45, 35, 9, -41 },
  { 1178, 25, 43, 35, 5, -42 },
  { 1313, 13, 41, 35, 7, -41 },
  { 1380, 26, 42, 35, 3, -42 },
  { 1517, 25, 43, 35, 3, -42 },
  { 1652, 28, 41, 35, 3, -41 },
  { 1796, 23, 42, 35, 7, -41 },
  { 1917, 26, 43, 35, 4, -42 },
  { 2057, 26, 41, 35, 4, -41 },
  { 2191, 26, 43, 35, 5, -42 },
  { 2331, 25, 43, 35, 5, -42 },
  { 2466, 4, 28, 35, 18, -28 },
  { 2480, 6, 35, 35, 16, -28 },
  { 2507, 24, 23, 35, 5, -30 },
  { 2576, 25, 13, 35, 5, -25 },
  { 2617, 25, 23, 35, 5, -30 },
  { 2689, 21, 42, 35, 7, -42 },
  { 2800, 32, 42, 35, 1, -42 },
  { 2968, 29, 41, 35, 3, -41 },
  { 3117, 25, 41, 35, 6, -41 },
  { 3246, 27, 43, 35, 4, -42 },
  { 3392, 25, 41, 35, 6, -41 },
  { 3521, 24, 41, 35, 6, -41 },
  { 3644, 23, 41, 35, 7, -41 },
  { 3762, 27, 43, 35, 4, -42 },
  { 3908, 25, 41, 35, 5, -41 },
  { 4037, 23, 41, 35, 6, -41 },
  { 4155, 24, 42, 35, 4, -41 },
  { 4281, 27, 41, 35, 6, -41 },
  { 4420, 23, 41, 35, 7, -41 },
  { 4538, 25, 41, 35, 5, -41 },
  { 4667, 25, 41, 35, 5, -41 },
  { 4796, 27, 43, 35, 4, -42 },
  { 4942, 25, 41, 35, 7, -41 },
  { 5071, 29, 49, 35, 3, -42 },
  { 5249, 26, 41, 35, 6, -41 },
  { 5383, 27, 43, 35, 4, -42 },
  { 5529, 29, 41, 35, 3, -41 },
  { 5678, 25, 42, 35, 5, -41 },
  { 5810, 29, 41, 35, 3, -41 },
  { 5959, 30, 41, 35, 3, -41 },
  { 6113, 28, 41, 35, 4, -41 },
  { 6257, 28, 41, 35, 3, -41 },
  { 6401, 25, 41, 35, 4, -41 },
  { 6530, 8, 56, 35, 14, -47 },
  { 6586, 19, 45, 35, 8, -41 },
  { 6693, 8, 56, 35, 13, -47 },
  { 6749, 20, 22, 35, 7, -41 },
  { 6804, 24, 2, 35, 5, 0 },
  { 6810, 7, 8, 35, 14, -43 },
  { 6817, 25, 32, 35, 5, -31 },
  { 6917, 24, 45, 35, 6, -44 },
  { 7052, 24, 32, 35, 5, -31 },
  { 7148, 23, 45, 35, 5, -44 },
  { 7278, 25, 32, 35, 5, -31 },
  { 7378, 26, 44, 35, 6, -44 },
  { 7521, 24, 43, 35, 5, -31 },
  { 7650, 23, 44, 35, 6, -44 },
  { 7777, 23, 41, 35, 7, -41 },
  { 7895, 18, 53, 35, 5, -41 },
  { 8015, 24, 44, 35, 7, -44 },
  { 8147, 23, 44, 35, 7, -44 },
  { 8274, 30, 31, 35, 2, -31 },
  { 8391, 23, 31, 35, 6, -31 },
  { 8481, 27, 32, 35, 4, -31 },
  { 8589, 24, 43, 35, 6, -31 },
  { 8718, 23, 43, 35, 5, -31 },
  { 8842, 19, 31, 35, 11, -31 },
  { 8916, 24, 32, 35, 6, -31 },
  { 9012, 23, 40, 35, 6, -39 },
  { 9127, 23, 32, 35, 6, -31 },
  { 9219, 28, 31, 35, 3, -31 },
  { 9328, 31, 31, 35, 2, -31 },
  { 9449, 27, 31, 35, 4, -31 },
  { 9554, 30, 43, 35, 2, -31 },
  { 9716, 27, 31, 35, 4, -31 },
  { 9821, 18, 57, 35, 10, -45 },
  { 9950, 1, 49, 35, 17, -41 },
  { 9957, 18, 57, 35, 10, -45 },
  { 10086, 31, 9, 35, 2, -22 },
};

const GFXfont RobotoMono_Thin58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin58pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_THIN58PT7B_H_
