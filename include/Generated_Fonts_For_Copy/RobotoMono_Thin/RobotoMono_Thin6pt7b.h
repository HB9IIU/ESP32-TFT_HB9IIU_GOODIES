#ifndef _ROBOTOMONO_THIN6PT7B_H_
#define _ROBOTOMONO_THIN6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0xC0, 0x7D, 0x50, 0xB9, 0xE0, 0xF9, 0xD0, 0xEA, 0xF0, 0xC0,
  0xFC, 0xFC, 0xF0, 0x4B, 0xA0, 0x80, 0xC0, 0x00, 0x5A, 0xF7, 0xF0, 0xF0,
  0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0xF7, 0xFE, 0xF0, 0xE5, 0x20, 0xFF,
  0xF5, 0xB0, 0x00, 0x10, 0x7C, 0xF0, 0xB0, 0xD8, 0xF6, 0xF0, 0x4F, 0xD0,
  0xFF, 0xF2, 0x70, 0xFF, 0xFB, 0xFA, 0xF2, 0xF0, 0xFF, 0xEB, 0x24, 0xF0,
  0xEB, 0xAB, 0xFF, 0xFF, 0xF6, 0xF0, 0xFA, 0xF6, 0xF2, 0xFB, 0xE8, 0xF0,
  0xE9, 0x20, 0xFF, 0xB5, 0x20, 0xEE, 0xD0, 0xA9, 0x50, 0xA9, 0x20, 0x69,
  0x70, 0xFC, 0xA9, 0xFC, 0xB0, 0xC0, 0x80, 0xFC, 0xAF, 0xC0, 0xEC, 0x5F,
  0xC0, 0xFB, 0x80, 0x7A, 0x80, 0xFF, 0xAF, 0xC0, 0x2B, 0x78, 0xAE, 0xC0,
  0xAA, 0xC0, 0xFF, 0x80, 0xFC, 0xF7, 0x80, 0xFE, 0xFD, 0xE8, 0xDC, 0xEB,
  0xFC, 0xAD, 0x00, 0xF6, 0x80, 0xEA, 0x80, 0xAD, 0x60, 0xEB, 0x80, 0x6A,
  0xB0, 0xF8, 0xA9, 0xA0, 0xE0,
};

const GFXglyph RobotoMono_Thin6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 1, 2, 4, 1, -5 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 2, 6, 4, 1, -5 },
  { 7, 3, 4, 4, 0, -4 },
  { 9, 3, 4, 4, 0, -4 },
  { 11, 1, 2, 4, 1, -5 },
  { 12, 1, 6, 4, 1, -5 },
  { 13, 1, 6, 4, 1, -5 },
  { 14, 2, 2, 4, 1, -4 },
  { 15, 3, 4, 4, 0, -4 },
  { 17, 1, 1, 4, 1, 0 },
  { 18, 2, 1, 4, 1, -2 },
  { 19, 1, 1, 4, 1, -1 },
  { 20, 2, 4, 4, 1, -4 },
  { 21, 3, 4, 4, 0, -4 },
  { 23, 1, 4, 4, 1, -4 },
  { 24, 3, 4, 4, 0, -4 },
  { 26, 3, 4, 4, 0, -4 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 2, 4, 4, 1, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 2, 4, 4, 1, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 1, 3, 4, 2, -3 },
  { 39, 1, 4, 4, 1, -3 },
  { 40, 3, 2, 4, 0, -3 },
  { 41, 2, 2, 4, 1, -3 },
  { 42, 2, 2, 4, 1, -3 },
  { 43, 2, 4, 4, 1, -4 },
  { 44, 3, 4, 4, 0, -4 },
  { 46, 3, 4, 4, 0, -4 },
  { 48, 2, 4, 4, 1, -4 },
  { 49, 3, 4, 4, 0, -4 },
  { 51, 2, 4, 4, 1, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 2, 4, 4, 1, -4 },
  { 54, 3, 4, 4, 0, -4 },
  { 56, 2, 4, 4, 1, -4 },
  { 57, 2, 4, 4, 1, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 2, 4, 4, 1, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 2, 4, 4, 1, -4 },
  { 67, 3, 5, 4, 0, -4 },
  { 69, 2, 4, 4, 1, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 2, 4, 4, 1, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 1, 6, 4, 1, -5 },
  { 86, 2, 4, 4, 1, -4 },
  { 87, 1, 6, 4, 1, -5 },
  { 88, 2, 2, 4, 1, -4 },
  { 89, 2, 1, 4, 1, 0 },
  { 90, 1, 1, 4, 1, -5 },
  { 91, 2, 3, 4, 1, -3 },
  { 92, 2, 5, 4, 1, -5 },
  { 94, 2, 3, 4, 1, -3 },
  { 95, 2, 5, 4, 1, -5 },
  { 97, 3, 3, 4, 0, -3 },
  { 99, 2, 5, 4, 1, -5 },
  { 101, 2, 4, 4, 1, -3 },
  { 102, 2, 5, 4, 1, -5 },
  { 104, 2, 4, 4, 1, -4 },
  { 105, 1, 5, 4, 1, -4 },
  { 106, 2, 5, 4, 1, -5 },
  { 108, 2, 5, 4, 1, -5 },
  { 110, 3, 3, 4, 0, -3 },
  { 112, 2, 3, 4, 1, -3 },
  { 113, 3, 3, 4, 0, -3 },
  { 115, 2, 4, 4, 1, -3 },
  { 116, 2, 4, 4, 1, -3 },
  { 117, 2, 3, 4, 1, -3 },
  { 118, 2, 3, 4, 1, -3 },
  { 119, 2, 4, 4, 1, -4 },
  { 120, 2, 3, 4, 1, -3 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 3, 4, 0, -3 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 3, 4, 4, 0, -3 },
  { 129, 3, 3, 4, 0, -3 },
  { 131, 2, 6, 4, 1, -5 },
  { 133, 1, 5, 4, 1, -4 },
  { 134, 2, 6, 4, 1, -5 },
  { 136, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_Thin6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin6pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_THIN6PT7B_H_
