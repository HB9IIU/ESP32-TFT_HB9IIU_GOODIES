#ifndef _JETBRAINSMONO_BOLD39PT7B_H_
#define _JETBRAINSMONO_BOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFD,
  0xFB, 0xE0, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1E, 0x01, 0xE0, 0xE0, 0x0E,
  0x07, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC1, 0xE0,
  0xF0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x0F, 0x07, 0x80, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C,
  0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF9, 0xFB, 0x9F,
  0x3E, 0x71, 0xF7, 0xCE, 0x3E, 0xF9, 0xC0, 0x1F, 0x38, 0x03, 0xF7, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0x3F, 0x00, 0xE3, 0xE0, 0x1C, 0x7F,
  0xE3, 0x8F, 0xFC, 0x71, 0xFF, 0xCE, 0x3E, 0xFD, 0xCF, 0xDF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x3F, 0xC0,
  0x1E, 0x7F, 0xE0, 0x1C, 0x79, 0xE0, 0x38, 0x70, 0xF0, 0x78, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xE0, 0xF0, 0xF1, 0xE0, 0xF0, 0xF3, 0xC0, 0x70, 0xF3,
  0x80, 0x7F, 0xE7, 0x00, 0x3F, 0xEF, 0x00, 0x1F, 0xCE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x71, 0xF0, 0x00, 0xF7,
  0xF8, 0x01, 0xEF, 0xFC, 0x01, 0xCF, 0x1E, 0x03, 0x8E, 0x1E, 0x07, 0x8E,
  0x1E, 0x0F, 0x0E, 0x1E, 0x0E, 0x0E, 0x1E, 0x1E, 0x0E, 0x1E, 0x3C, 0x0F,
  0x1E, 0x38, 0x0F, 0xFC, 0x70, 0x07, 0xFC, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x1F, 0x03, 0xE0,
  0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x1F, 0xF9, 0xF1, 0xEF, 0x1F, 0x3E, 0xF0, 0xFB, 0xCF, 0x07, 0xFC,
  0xF0, 0x7F, 0x8F, 0x03, 0xF8, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xBE, 0x1F, 0xE1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x10, 0x0F, 0x01, 0xF0, 0x7F,
  0x0F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F,
  0x00, 0xF0, 0x01, 0x80, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x81,
  0xF8, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x20, 0x3C, 0x09, 0xE1, 0xC3, 0xCF,
  0xCE, 0x3F, 0xFF, 0x37, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0xFC, 0x3E, 0x07, 0xC1, 0xF8, 0x0C, 0x07, 0x00, 0x20, 0x20,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x8F, 0xCF, 0xC7,
  0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0x3F, 0xBF, 0x03, 0xEF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF1, 0xC7, 0xFC, 0xF9, 0xFF, 0x3E, 0x7F,
  0xCF, 0x9F, 0xF1, 0xE7, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3E, 0xFC, 0x1F, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xEF, 0x81, 0xF1, 0xF0, 0x3C, 0x3E,
  0x07, 0x07, 0xC0, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0xFB, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x1C, 0x0F, 0xBF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0x8F, 0xEF, 0xC0, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xF0,
  0x7E, 0x7F, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x40,
  0x1F, 0x7F, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC7, 0xF3, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xDF, 0x01, 0xFB, 0xF0, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xFC,
  0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0xF8,
  0xF8, 0x1F, 0x1F, 0x87, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xF8, 0x1F, 0xBF, 0x87, 0xC1, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7,
  0x80, 0x3F, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xF8, 0x0F, 0xBF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F, 0xDF, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xEF, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF,
  0xEF, 0x80, 0x0F, 0x0F, 0xCF, 0xE7, 0xF3, 0xF8, 0xFC, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xC7,
  0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x00, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x0F,
  0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x1F, 0x1E, 0x00, 0x7D, 0xF0,
  0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xDF,
  0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x7C, 0x7F, 0xC3, 0xC1, 0xFE, 0x1E,
  0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xFF,
  0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1F, 0x1F, 0xF0, 0x7F,
  0xBF, 0x83, 0xF9, 0xFC, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x7C,
  0x00, 0x7B, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xE0, 0x0F,
  0x1F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x03,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x7F, 0xBF, 0x03,
  0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE3, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0x7F, 0xBF, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x01, 0xFB, 0xF0,
  0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xF8,
  0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0,
  0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE3,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xC7,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0xFC, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x07, 0x7F, 0xE0, 0xEF, 0xEE, 0x1F, 0xFD, 0xC7, 0xFF, 0xB8,
  0xEF, 0xF7, 0x9D, 0xFE, 0x73, 0xBF, 0xCE, 0xE7, 0xF9, 0xFC, 0xFF, 0x1F,
  0x9F, 0xF3, 0xF3, 0xFE, 0x7C, 0x7F, 0xCF, 0x8F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xF0, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xDE, 0x1F, 0xF7, 0x87, 0xFD, 0xE1, 0xFF,
  0x3C, 0x7F, 0xCF, 0x1F, 0xF3, 0xC7, 0xFC, 0x79, 0xFF, 0x1E, 0x7F, 0xC7,
  0x9F, 0xF0, 0xF7, 0xFC, 0x3D, 0xFF, 0x0F, 0x7F, 0xC1, 0xFF, 0xF0, 0x7B,
  0xFC, 0x1E, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0x7F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xFC, 0x1F,
  0x9F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x80, 0xFD, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x03, 0xEF, 0x81, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0x7F, 0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xFC,
  0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xFC, 0xF8,
  0x0F, 0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFB, 0xFC, 0xFC, 0x0F, 0x9F,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7E, 0x07, 0xEF, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0xFC, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0,
  0x3E, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF1,
  0xF0, 0x07, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00,
  0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xF0, 0x78, 0x3F,
  0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E, 0xF0, 0xF8, 0x7B, 0xC3,
  0x61, 0xEF, 0x0D, 0xC7, 0xBE, 0x37, 0x1E, 0x78, 0xDC, 0x79, 0xE3, 0x71,
  0xE7, 0x9D, 0xC7, 0x9E, 0x73, 0x1C, 0x79, 0xCC, 0xF1, 0xE7, 0x33, 0xC7,
  0x9C, 0xCF, 0x1E, 0x63, 0xBC, 0x79, 0x8E, 0xF1, 0xE6, 0x3B, 0xC3, 0xB8,
  0xEF, 0x0F, 0xE3, 0xBC, 0x3F, 0x86, 0xF0, 0xFE, 0x1B, 0x83, 0xF8, 0x6E,
  0x0F, 0xE1, 0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x7E, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3F, 0x3E, 0x00, 0xFB, 0xF0, 0x07,
  0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0x00,
  0x7F, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF7,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0x78, 0x03, 0xDF, 0x01, 0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0xBE, 0x01, 0xEF, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0x0F, 0xDF, 0x81, 0xF7, 0xC0, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x7F, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7E, 0x03,
  0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xF7,
  0xE1, 0xFD, 0xFF, 0xEF, 0x3F, 0xFB, 0xC7, 0xF8, 0xF0, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x8F,
  0x83, 0xEF, 0xF8, 0xFB, 0xFF, 0x3F, 0xFF, 0xEF, 0xF3, 0xFB, 0xF0, 0x3E,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xBF, 0xE3, 0xE7, 0xF0,
  0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x7F, 0xBF,
  0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFF, 0x07, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x1E, 0x1E, 0x3F, 0xCF, 0x3F, 0xF7, 0xBF, 0xFB, 0xFF,
  0xDF, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7F, 0xF7, 0xBF, 0xFB, 0xCF, 0xF9, 0xE3,
  0xF8, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C,
  0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xFF, 0x03, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFE, 0xFF, 0xF7, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0x7F, 0xBF,
  0xFB, 0xCF, 0xFD, 0xE3, 0xFC, 0xF0, 0x78, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE3, 0xE1, 0xF7, 0xFC, 0xFB, 0xFF, 0x7F, 0xFF, 0xBF, 0xDF,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7D, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF,
  0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xF8, 0x0F,
  0xDF, 0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0xFC,
  0x3E, 0x1F, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0xC7, 0xC0, 0xFC,
  0xF8, 0x0F, 0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0x87, 0x9E, 0xF9, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1F,
  0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F,
  0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F,
  0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF,
  0x0E, 0x1F, 0xE1, 0xC3, 0xC0, 0x00, 0xF8, 0x7D, 0xFF, 0x3E, 0xFF, 0xDF,
  0xFF, 0xEF, 0xF7, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3C, 0x03, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0x7F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBF, 0x07, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x3E, 0xFF, 0x8F, 0xBF,
  0xF3, 0xFF, 0xFE, 0xFF, 0x3F, 0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBF, 0x07, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFB, 0xFE, 0x3E, 0x7F, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFE, 0xFF, 0xF7, 0x7F, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xDF, 0xFD, 0xEF, 0xFE, 0xF3, 0xFE, 0x78, 0xFE, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xDF, 0xFE, 0xFE,
  0x3F, 0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xFE, 0xFC, 0x1F, 0xBE, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C,
  0x1F, 0xBF, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0xF8, 0x01,
  0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x0F, 0xBE, 0x00,
  0x7B, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE1, 0xEF, 0x0F, 0x87, 0xBC,
  0x3E, 0x1E, 0x78, 0xF8, 0x79, 0xE3, 0x71, 0xE7, 0x8D, 0xC7, 0x9E, 0x37,
  0x1C, 0x79, 0xDC, 0xF1, 0xE7, 0x33, 0xC7, 0x9C, 0xCF, 0x0E, 0x63, 0x3C,
  0x3D, 0x8E, 0xF0, 0xF6, 0x3B, 0x83, 0xD8, 0xEE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x07,
  0xC0, 0x7E, 0x03, 0xF9, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x1F, 0x1F, 0x80,
  0xFC, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x87, 0xC0, 0xF8, 0x3F,
  0x0F, 0xC0, 0xF8, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xFB,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xEF, 0xF8, 0x3F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFF, 0x1F, 0x9F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFE,
  0x00, 0x0F, 0x00,
};

const GFXglyph JetBrainsMono_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 13, 11, 23, 5, -28 },
  { 44, 21, 28, 23, 1, -28 },
  { 118, 19, 39, 23, 2, -34 },
  { 211, 24, 29, 23, 0, -29 },
  { 298, 20, 29, 23, 2, -29 },
  { 371, 5, 11, 23, 9, -28 },
  { 378, 12, 38, 23, 7, -33 },
  { 435, 13, 38, 23, 4, -33 },
  { 497, 21, 21, 23, 1, -24 },
  { 553, 19, 18, 23, 2, -22 },
  { 596, 9, 12, 23, 6, -6 },
  { 610, 13, 4, 23, 5, -15 },
  { 617, 7, 7, 23, 8, -7 },
  { 624, 19, 36, 23, 2, -32 },
  { 710, 18, 29, 23, 3, -29 },
  { 776, 19, 28, 23, 3, -28 },
  { 843, 19, 29, 23, 2, -29 },
  { 912, 19, 28, 23, 2, -28 },
  { 979, 17, 28, 23, 3, -28 },
  { 1039, 18, 28, 23, 3, -28 },
  { 1102, 19, 28, 23, 2, -28 },
  { 1169, 19, 28, 23, 2, -28 },
  { 1236, 19, 29, 23, 2, -29 },
  { 1305, 19, 29, 23, 2, -29 },
  { 1374, 7, 22, 23, 8, -22 },
  { 1394, 9, 28, 23, 6, -22 },
  { 1426, 17, 22, 23, 3, -24 },
  { 1473, 17, 14, 23, 3, -20 },
  { 1503, 17, 22, 23, 3, -24 },
  { 1550, 15, 28, 23, 5, -28 },
  { 1603, 21, 36, 23, 1, -29 },
  { 1698, 21, 28, 23, 1, -28 },
  { 1772, 18, 28, 23, 3, -28 },
  { 1835, 18, 29, 23, 3, -29 },
  { 1901, 18, 28, 23, 3, -28 },
  { 1964, 18, 28, 23, 3, -28 },
  { 2027, 18, 28, 23, 3, -28 },
  { 2090, 18, 29, 23, 3, -29 },
  { 2156, 17, 28, 23, 3, -28 },
  { 2216, 16, 28, 23, 4, -28 },
  { 2272, 19, 28, 23, 1, -28 },
  { 2339, 19, 28, 23, 3, -28 },
  { 2406, 17, 28, 23, 4, -28 },
  { 2466, 19, 28, 23, 2, -28 },
  { 2533, 18, 28, 23, 3, -28 },
  { 2596, 18, 29, 23, 3, -29 },
  { 2662, 19, 28, 23, 3, -28 },
  { 2729, 18, 36, 23, 3, -29 },
  { 2810, 19, 28, 23, 3, -28 },
  { 2877, 19, 29, 23, 2, -29 },
  { 2946, 20, 28, 23, 2, -28 },
  { 3016, 18, 28, 23, 3, -28 },
  { 3079, 21, 28, 23, 1, -28 },
  { 3153, 22, 28, 23, 1, -28 },
  { 3230, 21, 28, 23, 1, -28 },
  { 3304, 22, 28, 23, 1, -28 },
  { 3381, 17, 28, 23, 3, -28 },
  { 3441, 11, 36, 23, 7, -32 },
  { 3491, 19, 36, 23, 2, -32 },
  { 3577, 11, 36, 23, 5, -32 },
  { 3627, 18, 15, 23, 3, -28 },
  { 3661, 19, 4, 23, 2, 1 },
  { 3671, 10, 6, 23, 6, -31 },
  { 3679, 18, 22, 23, 2, -22 },
  { 3729, 18, 28, 23, 3, -28 },
  { 3792, 18, 22, 23, 3, -22 },
  { 3842, 17, 28, 23, 3, -28 },
  { 3902, 18, 22, 23, 3, -22 },
  { 3952, 19, 28, 23, 2, -28 },
  { 4019, 17, 29, 23, 3, -22 },
  { 4081, 17, 28, 23, 3, -28 },
  { 4141, 19, 31, 23, 3, -31 },
  { 4215, 15, 38, 23, 3, -31 },
  { 4287, 19, 28, 23, 3, -28 },
  { 4354, 21, 28, 23, 1, -28 },
  { 4428, 19, 22, 23, 2, -22 },
  { 4481, 17, 22, 23, 3, -22 },
  { 4528, 18, 22, 23, 3, -22 },
  { 4578, 18, 29, 23, 3, -22 },
  { 4644, 17, 29, 23, 3, -22 },
  { 4706, 18, 22, 23, 4, -22 },
  { 4756, 18, 22, 23, 3, -22 },
  { 4806, 19, 28, 23, 2, -28 },
  { 4873, 17, 21, 23, 3, -21 },
  { 4918, 20, 21, 23, 2, -21 },
  { 4971, 22, 21, 23, 1, -21 },
  { 5029, 21, 21, 23, 1, -21 },
  { 5085, 21, 28, 23, 1, -21 },
  { 5159, 17, 21, 23, 3, -21 },
  { 5204, 17, 36, 23, 3, -32 },
  { 5281, 5, 36, 23, 9, -32 },
  { 5304, 17, 36, 23, 3, -32 },
  { 5381, 19, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_Bold39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_BOLD39PT7B_H_
