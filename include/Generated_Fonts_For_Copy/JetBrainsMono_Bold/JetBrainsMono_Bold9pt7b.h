#ifndef _JETBRAINSMONO_BOLD9PT7B_H_
#define _JETBRAINSMONO_BOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x29, 0x5E, 0xAF, 0xA9, 0x40, 0x46, 0xFC, 0xE7,
  0xDE, 0x40, 0x4D, 0x6C, 0xC3, 0xAE, 0x60, 0x22, 0x90, 0xCA, 0xC9, 0xE0,
  0xE0, 0x2D, 0x2D, 0x92, 0x20, 0x99, 0x92, 0x4A, 0x80, 0x27, 0xCC, 0xB0,
  0x44, 0xF4, 0x78, 0xE0, 0xB0, 0x32, 0x24, 0x4C, 0x88, 0x6B, 0x9D, 0x99,
  0xE0, 0x6E, 0xE6, 0x66, 0xF0, 0x6B, 0x12, 0x6C, 0xF0, 0xF2, 0x46, 0x19,
  0xE0, 0x26, 0x49, 0x9F, 0x10, 0xF8, 0x8F, 0x19, 0xE0, 0x11, 0x18, 0xEC,
  0xA5, 0xC0, 0xF9, 0x22, 0x64, 0xC0, 0x6B, 0x96, 0xB9, 0xE0, 0x32, 0xF2,
  0xB3, 0x18, 0x80, 0xC0, 0xC0, 0x60, 0x15, 0x80, 0x3C, 0xC3, 0x10, 0xF0,
  0x0F, 0xC3, 0x3C, 0x80, 0xC2, 0x36, 0x40, 0xC0, 0x32, 0x67, 0x5A, 0xD6,
  0x48, 0x30, 0x21, 0x94, 0xA7, 0x27, 0x20, 0xCB, 0x9E, 0x99, 0xE0, 0x6B,
  0x88, 0x89, 0xE0, 0xCB, 0x99, 0x99, 0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8,
  0x8F, 0x88, 0x80, 0x6B, 0x88, 0xB9, 0xE0, 0x99, 0x9F, 0x99, 0x90, 0xF4,
  0x44, 0x44, 0xF0, 0x38, 0xC6, 0x31, 0xCD, 0xC0, 0x9B, 0xAE, 0xAA, 0x90,
  0x88, 0x88, 0x88, 0xF0, 0xCE, 0xEF, 0xDC, 0xE7, 0x20, 0x99, 0xDD, 0xDB,
  0xB0, 0x6B, 0x99, 0x99, 0xE0, 0xCB, 0x9F, 0x88, 0x80, 0x6B, 0x99, 0x99,
  0xE2, 0x10, 0xCB, 0x9F, 0xAA, 0x90, 0x6B, 0x8E, 0x39, 0xE0, 0xF9, 0x08,
  0x42, 0x10, 0x80, 0x99, 0x99, 0x99, 0xE0, 0x8A, 0x56, 0xA5, 0x18, 0xC0,
  0xAD, 0x6B, 0x75, 0xAD, 0x60, 0xCA, 0x9C, 0x43, 0x2B, 0x20, 0x8A, 0x54,
  0x62, 0x10, 0x80, 0xF3, 0x24, 0x48, 0xF0, 0xEA, 0xAB, 0x88, 0x44, 0x62,
  0x21, 0xE4, 0x92, 0x4F, 0x46, 0xA9, 0xF0, 0xE0, 0x70, 0x5F, 0x97, 0x80,
  0x88, 0xE9, 0x99, 0xE0, 0xE9, 0x89, 0xE0, 0x11, 0xDB, 0x99, 0xF0, 0xE9,
  0xF9, 0xE0, 0x19, 0x09, 0xF2, 0x10, 0x80, 0xDB, 0x9B, 0xD3, 0xE0, 0x88,
  0xE9, 0x99, 0x90, 0x60, 0xC4, 0x44, 0xF0, 0x23, 0x92, 0x49, 0xC0, 0x88,
  0x9A, 0xEA, 0x90, 0xE1, 0x08, 0x42, 0x10, 0xE0, 0xFD, 0x6B, 0x5A, 0x80,
  0xE9, 0x99, 0x90, 0xE9, 0x99, 0xE0, 0xE9, 0x99, 0xE8, 0x80, 0xDB, 0x99,
  0xF1, 0x10, 0xF9, 0x88, 0x80, 0xF8, 0xE1, 0xF0, 0x27, 0xC8, 0x42, 0x1C,
  0x99, 0x99, 0xE0, 0xCA, 0xD4, 0xE3, 0x00, 0xAD, 0x6E, 0xB5, 0x80, 0xDB,
  0x88, 0xED, 0x80, 0xCA, 0xD4, 0x62, 0x11, 0x80, 0xF2, 0x48, 0xF0, 0x76,
  0x2C, 0x66, 0x63, 0xFF, 0xC4, 0x47, 0x44, 0x4C, 0x6C, 0xC0,
};

const GFXglyph JetBrainsMono_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 7, 5, 2, -7 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 5, 1, -8 },
  { 14, 5, 7, 5, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 3, 5, 2, -7 },
  { 25, 3, 9, 5, 1, -8 },
  { 29, 3, 9, 5, 1, -8 },
  { 33, 5, 4, 5, 0, -5 },
  { 36, 4, 4, 5, 1, -5 },
  { 38, 3, 2, 5, 1, -1 },
  { 39, 3, 1, 5, 1, -3 },
  { 40, 2, 2, 5, 2, -2 },
  { 41, 4, 8, 5, 1, -7 },
  { 45, 4, 7, 5, 1, -7 },
  { 49, 4, 7, 5, 1, -7 },
  { 53, 4, 7, 5, 1, -7 },
  { 57, 4, 7, 5, 1, -7 },
  { 61, 4, 7, 5, 1, -7 },
  { 65, 4, 7, 5, 1, -7 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 4, 7, 5, 1, -7 },
  { 78, 4, 7, 5, 1, -7 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 2, 5, 5, 2, -5 },
  { 89, 3, 6, 5, 1, -5 },
  { 92, 4, 5, 5, 1, -5 },
  { 95, 4, 4, 5, 1, -5 },
  { 97, 4, 5, 5, 1, -5 },
  { 100, 4, 7, 5, 1, -7 },
  { 104, 5, 9, 5, 0, -7 },
  { 110, 5, 7, 5, 0, -7 },
  { 115, 4, 7, 5, 1, -7 },
  { 119, 4, 7, 5, 1, -7 },
  { 123, 4, 7, 5, 1, -7 },
  { 127, 4, 7, 5, 1, -7 },
  { 131, 4, 7, 5, 1, -7 },
  { 135, 4, 7, 5, 1, -7 },
  { 139, 4, 7, 5, 1, -7 },
  { 143, 4, 7, 5, 1, -7 },
  { 147, 5, 7, 5, 0, -7 },
  { 152, 4, 7, 5, 1, -7 },
  { 156, 4, 7, 5, 1, -7 },
  { 160, 5, 7, 5, 0, -7 },
  { 165, 4, 7, 5, 1, -7 },
  { 169, 4, 7, 5, 1, -7 },
  { 173, 4, 7, 5, 1, -7 },
  { 177, 4, 9, 5, 1, -7 },
  { 182, 4, 7, 5, 1, -7 },
  { 186, 4, 7, 5, 1, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 4, 7, 5, 1, -7 },
  { 199, 5, 7, 5, 0, -7 },
  { 204, 5, 7, 5, 0, -7 },
  { 209, 5, 7, 5, 0, -7 },
  { 214, 5, 7, 5, 0, -7 },
  { 219, 4, 7, 5, 1, -7 },
  { 223, 2, 8, 5, 2, -7 },
  { 225, 4, 8, 5, 1, -7 },
  { 229, 3, 8, 5, 1, -7 },
  { 232, 4, 4, 5, 1, -7 },
  { 234, 4, 1, 5, 1, 0 },
  { 235, 3, 1, 5, 1, -7 },
  { 236, 5, 5, 5, 0, -5 },
  { 240, 4, 7, 5, 1, -7 },
  { 244, 4, 5, 5, 1, -5 },
  { 247, 4, 7, 5, 1, -7 },
  { 251, 4, 5, 5, 1, -5 },
  { 254, 5, 7, 5, 0, -7 },
  { 259, 4, 7, 5, 1, -5 },
  { 263, 4, 7, 5, 1, -7 },
  { 267, 4, 7, 5, 1, -7 },
  { 271, 3, 9, 5, 1, -7 },
  { 275, 4, 7, 5, 1, -7 },
  { 279, 5, 7, 5, 0, -7 },
  { 284, 5, 5, 5, 0, -5 },
  { 288, 4, 5, 5, 1, -5 },
  { 291, 4, 5, 5, 1, -5 },
  { 294, 4, 7, 5, 1, -5 },
  { 298, 4, 7, 5, 1, -5 },
  { 302, 4, 5, 5, 1, -5 },
  { 305, 4, 5, 5, 1, -5 },
  { 308, 5, 6, 5, 0, -6 },
  { 312, 4, 5, 5, 1, -5 },
  { 315, 5, 5, 5, 0, -5 },
  { 319, 5, 5, 5, 0, -5 },
  { 323, 5, 5, 5, 0, -5 },
  { 327, 5, 7, 5, 0, -5 },
  { 332, 4, 5, 5, 1, -5 },
  { 335, 4, 8, 5, 1, -7 },
  { 339, 1, 8, 5, 2, -7 },
  { 340, 4, 8, 5, 1, -7 },
  { 344, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_Bold9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_BOLD9PT7B_H_
