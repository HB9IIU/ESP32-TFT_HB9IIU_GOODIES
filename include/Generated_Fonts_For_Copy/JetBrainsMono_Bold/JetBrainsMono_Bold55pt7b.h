#ifndef _JETBRAINSMONO_BOLD55PT7B_H_
#define _JETBRAINSMONO_BOLD55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3E,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xE3,
  0x8F, 0xF3, 0xFC, 0x70, 0xFE, 0x7F, 0x0E, 0x1F, 0xCF, 0xE1, 0xC3, 0xF9,
  0xFC, 0x38, 0x00, 0x3F, 0x87, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0xFF, 0x1C,
  0x00, 0x0F, 0xF3, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0E, 0x7F, 0xC0, 0x01, 0xC7, 0xF8, 0x00, 0x38, 0x7F, 0x80, 0x07, 0x07,
  0xF0, 0x00, 0xE0, 0xFF, 0xFC, 0x1C, 0x1F, 0xFF, 0x83, 0x83, 0xFF, 0xF8,
  0x70, 0x7F, 0x7F, 0x0E, 0x1F, 0xCF, 0xF1, 0xC7, 0xF9, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0x8F, 0xFE, 0x00, 0x0F, 0x8F, 0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0xE0, 0x07,
  0xC7, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC3,
  0xE0, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xF1, 0xF0, 0x07, 0xC1, 0xF1,
  0xF0, 0x03, 0xF1, 0xF8, 0xF8, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0xFC,
  0xF8, 0x00, 0x0F, 0xFC, 0xF8, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x3E, 0x3F, 0xF8, 0x00,
  0x1F, 0x3F, 0xFE, 0x00, 0x1F, 0x3F, 0xFF, 0x00, 0x1F, 0x1F, 0x8F, 0xC0,
  0x0F, 0x9F, 0x83, 0xE0, 0x0F, 0x8F, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0xF8,
  0x07, 0xC3, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xE3, 0xE0, 0x07, 0xFF, 0xE1, 0xF0, 0x01, 0xFF, 0xF1, 0xF0, 0x00, 0x7F,
  0xF1, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x0F, 0xE7, 0xF7, 0xF0, 0x3F, 0x9F, 0x8F, 0xE1, 0xFC, 0xFE,
  0x1F, 0xC7, 0xF3, 0xF8, 0x3F, 0xBF, 0x8F, 0xE0, 0xFE, 0xFE, 0x3F, 0x81,
  0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0x83, 0xF8, 0x0F, 0xFE, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xF8, 0x1F, 0xE1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xF0, 0xFE, 0x03,
  0xFF, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0x00, 0x01, 0xC0,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x70, 0x0F, 0x80, 0x73, 0xF0, 0x7C, 0x1F, 0x9F, 0xE3, 0xE3,
  0xFD, 0xFF, 0x8E, 0x3F, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF,
  0x8F, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x0E, 0x0F,
  0xFF, 0x0F, 0x87, 0xFF, 0x8F, 0xE3, 0xFF, 0xC7, 0xF1, 0xFF, 0xE3, 0xF8,
  0xFF, 0xF1, 0xFC, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x08, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFE,
  0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7C, 0x1F, 0xC0, 0x3C,
  0x0F, 0xE0, 0x1C, 0x07, 0xF0, 0x08, 0x03, 0xF8, 0x04, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0xF9, 0xFF, 0x01, 0xFE, 0x7F,
  0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xE0,
  0x1F, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x14, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x3F, 0xC0, 0x7F, 0x7F, 0x80,
  0x7F, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0xC0,
  0xFC, 0xFF, 0xF0, 0x7E, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFC, 0x7F, 0xE7, 0xF8, 0x07, 0xFB, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x7F, 0x9F,
  0xFD, 0xFF, 0xCF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x1E, 0x00, 0x1F, 0xCF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0xFF,
  0x9F, 0xE0, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFB, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC1,
  0xFE, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x7F, 0xC7, 0xFC, 0x7F,
  0x80, 0xFF, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xEF, 0xFC, 0x7F,
  0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F,
  0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0x00, 0x04, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF,
  0xF3, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xFC,
  0x7F, 0xCF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0x8F, 0xE0, 0x60, 0x07,
  0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0x7F, 0xC3, 0xFE,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x21, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0,
  0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xE3, 0xFF, 0x80, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xFB,
  0xFF, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x1F, 0xFE,
  0x0F, 0x80, 0x7F, 0xF0, 0x7C, 0x03, 0xFF, 0x83, 0xE0, 0x1F, 0xFC, 0x1F,
  0x00, 0xFF, 0xE0, 0xF8, 0x07, 0xFF, 0x07, 0xC0, 0x3F, 0xF8, 0x3E, 0x01,
  0xFF, 0xC1, 0xF0, 0x0F, 0xFE, 0x0F, 0x80, 0x7F, 0xF0, 0x7C, 0x03, 0xFF,
  0x83, 0xF0, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x03,
  0xFF, 0xDF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xCF, 0xFE, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x0F, 0xFB,
  0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x8F, 0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xFF, 0xCF, 0xFC, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F,
  0xEF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xF8, 0x0F, 0xFD, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF9, 0xFF, 0xCF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F, 0xEF, 0xFE,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0xE7,
  0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0,
  0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0xF0,
  0x1E, 0xFF, 0xDF, 0x03, 0xDF, 0xFB, 0xE0, 0xFB, 0xFF, 0x3C, 0x1E, 0xFF,
  0xF7, 0x83, 0xDF, 0xFE, 0xF8, 0xFB, 0xFF, 0xDF, 0x1F, 0x7F, 0xF9, 0xE3,
  0xCF, 0xFF, 0x3E, 0xF9, 0xFF, 0xE7, 0xDF, 0x3F, 0xFC, 0x7B, 0xC7, 0xFF,
  0x8F, 0x78, 0xFF, 0xF1, 0xFF, 0x1F, 0xFE, 0x3F, 0xE3, 0xFF, 0xC3, 0xF8,
  0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0x7C, 0x07, 0xFF, 0xBE, 0x03, 0xFF, 0xDF, 0x81, 0xFF, 0xE7, 0xC0,
  0xFF, 0xF3, 0xE0, 0x7F, 0xF9, 0xF8, 0x3F, 0xFC, 0x7C, 0x1F, 0xFE, 0x3E,
  0x0F, 0xFF, 0x1F, 0x87, 0xFF, 0x87, 0xC3, 0xFF, 0xC3, 0xE1, 0xFF, 0xE1,
  0xF8, 0xFF, 0xF0, 0x7C, 0x7F, 0xF8, 0x3F, 0x3F, 0xFC, 0x1F, 0x9F, 0xFE,
  0x07, 0xCF, 0xFF, 0x03, 0xF7, 0xFF, 0x81, 0xFB, 0xFF, 0xC0, 0x7D, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0xFF, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0xF7, 0xF0, 0x01,
  0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xFB, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xF1,
  0xFE, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0xC0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0xE7, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xF3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF7, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC,
  0x7F, 0xE1, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0xC0,
  0x7F, 0x9F, 0xFD, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81,
  0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xDC, 0x0F,
  0xDF, 0x03, 0xB8, 0x1F, 0x3E, 0x07, 0x70, 0x3E, 0x7E, 0x0E, 0xE0, 0xFC,
  0xFC, 0x1D, 0xE1, 0xF9, 0xF8, 0x7B, 0xC3, 0xF3, 0xF0, 0xF7, 0x87, 0xE7,
  0xE1, 0xEF, 0x0F, 0xCF, 0xC3, 0xDE, 0x1F, 0x9F, 0x87, 0x9C, 0x3F, 0x3F,
  0x0E, 0x38, 0x7C, 0x3E, 0x1C, 0x70, 0xF8, 0x7C, 0x38, 0xE1, 0xF0, 0xF8,
  0xF1, 0xE3, 0xE1, 0xF9, 0xE3, 0xC7, 0xC3, 0xF3, 0xC7, 0x9F, 0x87, 0xE7,
  0x8F, 0x3F, 0x0F, 0xCF, 0x1E, 0x7E, 0x1F, 0x9E, 0x3C, 0xFC, 0x3F, 0x38,
  0x39, 0xF0, 0x3E, 0x70, 0x73, 0xE0, 0x7C, 0xE0, 0xE7, 0xC0, 0xFB, 0xC1,
  0xEF, 0x81, 0xF7, 0x83, 0xDF, 0x03, 0xEF, 0x07, 0xBE, 0x07, 0xDE, 0x0F,
  0x7C, 0x0F, 0xBC, 0x1E, 0xF8, 0x1F, 0xF8, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80,
  0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE3, 0xFE, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xF7, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF, 0xDF, 0xC7, 0xFF,
  0xE7, 0xF0, 0x7F, 0xE1, 0xFC, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x03, 0xE0, 0x3F, 0x8F, 0xFC, 0x1F, 0xCF, 0xFF, 0x8F, 0xEF, 0xFF,
  0xE7, 0xF7, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xC3, 0xFE, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFD, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xEF, 0xFF, 0xE7, 0xF7, 0xFF, 0xE3, 0xF9, 0xFF, 0xE1, 0xFC, 0x3F,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9,
  0xFF, 0x87, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF,
  0xFB, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0xF8, 0x1F, 0xC1, 0xFF, 0x8F, 0xE3, 0xFF, 0xE7, 0xF3, 0xFF,
  0xFB, 0xF9, 0xFF, 0xFD, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFB, 0xF8, 0xFF, 0xFD, 0xFC, 0x3F, 0xFC, 0xFE, 0x0F,
  0xF8, 0x7F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x3F, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xC7, 0xFF, 0xCF, 0xE3, 0xFF,
  0xF7, 0xF3, 0xFF, 0xFB, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFD, 0xFE, 0x07,
  0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xDF, 0xC7, 0xFF,
  0xCF, 0xE1, 0xFF, 0xC7, 0xF0, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x03, 0xE0, 0x3F, 0x8F, 0xFC, 0x1F, 0xCF, 0xFF, 0x8F,
  0xEF, 0xFF, 0xC7, 0xF7, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0x83, 0xFE,
  0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF,
  0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F,
  0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x78,
  0x1E, 0x1F, 0x3F, 0x87, 0xF3, 0xE7, 0xF9, 0xFF, 0x7D, 0xFF, 0x7F, 0xEF,
  0xBF, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8,
  0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE,
  0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1,
  0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0,
  0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F,
  0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83,
  0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F,
  0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x1F,
  0xF8, 0x3F, 0x9F, 0xFF, 0x1F, 0xDF, 0xFF, 0x8F, 0xEF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFB, 0xFF, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xC0, 0x7F, 0x1F, 0xF8, 0x3F, 0x9F, 0xFF, 0x1F, 0xDF, 0xFF,
  0xCF, 0xEF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0x87, 0xFD, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xDF, 0xFF, 0xCF, 0xEF, 0xFF, 0xC7, 0xF3, 0xFF, 0xC3, 0xF8, 0x7F,
  0xC1, 0xFC, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0x1F, 0xC7, 0xFF, 0xCF, 0xE3, 0xFF, 0xF7, 0xF3, 0xFF, 0xFB,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0xFF, 0xBF, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF7,
  0xF1, 0xFF, 0xFB, 0xF8, 0x7F, 0xF9, 0xFC, 0x1F, 0xF0, 0xFE, 0x00, 0xC0,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x8F, 0xFE,
  0x0F, 0xE7, 0xFF, 0xC3, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFC, 0x1F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xF8, 0x07, 0xF9, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0xE0, 0x1F, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0xF7,
  0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x07, 0xC0,
  0x7F, 0xF8, 0x0F, 0x80, 0xFD, 0xF0, 0x3F, 0x81, 0xF3, 0xE0, 0x7F, 0x03,
  0xE7, 0xC0, 0xFE, 0x07, 0xCF, 0xC1, 0xDC, 0x0F, 0x9F, 0x83, 0xB8, 0x3F,
  0x3F, 0x07, 0x70, 0x7E, 0x7E, 0x1E, 0xF0, 0xFC, 0x7C, 0x3D, 0xE1, 0xF0,
  0xF8, 0x7B, 0xC3, 0xE1, 0xF0, 0xF7, 0x87, 0xC3, 0xF1, 0xC7, 0x0F, 0x87,
  0xE3, 0x8E, 0x3F, 0x0F, 0xC7, 0x1C, 0x7E, 0x0F, 0x9E, 0x3C, 0xF8, 0x1F,
  0x3C, 0x79, 0xF0, 0x3E, 0x78, 0xF3, 0xE0, 0x7C, 0xF1, 0xE7, 0xC0, 0xF9,
  0xC1, 0xCF, 0x81, 0xFB, 0x83, 0xBF, 0x03, 0xF7, 0x07, 0x7E, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0xFC, 0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE0, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0x7E, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_Bold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 9, 40, 33, 12, -40 },
  { 46, 19, 16, 33, 7, -40 },
  { 84, 31, 40, 33, 1, -40 },
  { 239, 27, 56, 33, 3, -48 },
  { 428, 33, 40, 33, 0, -40 },
  { 593, 30, 42, 33, 2, -41 },
  { 751, 7, 16, 33, 13, -40 },
  { 765, 18, 53, 33, 9, -46 },
  { 885, 18, 53, 33, 6, -46 },
  { 1005, 29, 29, 33, 2, -34 },
  { 1111, 27, 26, 33, 3, -31 },
  { 1199, 13, 17, 33, 8, -8 },
  { 1227, 17, 6, 33, 8, -21 },
  { 1240, 11, 11, 33, 11, -10 },
  { 1256, 27, 52, 33, 3, -46 },
  { 1432, 25, 42, 33, 4, -41 },
  { 1564, 25, 40, 33, 5, -40 },
  { 1689, 26, 41, 33, 3, -41 },
  { 1823, 26, 41, 33, 3, -40 },
  { 1957, 24, 40, 33, 4, -40 },
  { 2077, 25, 41, 33, 4, -40 },
  { 2206, 27, 41, 33, 3, -40 },
  { 2345, 27, 40, 33, 3, -40 },
  { 2480, 25, 42, 33, 4, -41 },
  { 2612, 27, 41, 33, 3, -41 },
  { 2751, 11, 32, 33, 11, -31 },
  { 2795, 13, 40, 33, 9, -31 },
  { 2860, 25, 30, 33, 4, -33 },
  { 2954, 23, 20, 33, 5, -28 },
  { 3012, 25, 30, 33, 4, -33 },
  { 3106, 21, 40, 33, 7, -40 },
  { 3211, 29, 51, 33, 2, -41 },
  { 3396, 29, 40, 33, 2, -40 },
  { 3541, 26, 40, 33, 4, -40 },
  { 3671, 25, 42, 33, 4, -41 },
  { 3803, 25, 40, 33, 4, -40 },
  { 3928, 24, 40, 33, 5, -40 },
  { 4048, 25, 40, 33, 4, -40 },
  { 4173, 25, 42, 33, 4, -41 },
  { 4305, 25, 40, 33, 4, -40 },
  { 4430, 23, 40, 33, 5, -40 },
  { 4545, 26, 41, 33, 2, -40 },
  { 4679, 27, 40, 33, 4, -40 },
  { 4814, 24, 40, 33, 6, -40 },
  { 4934, 27, 40, 33, 3, -40 },
  { 5069, 25, 40, 33, 4, -40 },
  { 5194, 25, 42, 33, 4, -41 },
  { 5326, 27, 40, 33, 4, -40 },
  { 5461, 26, 51, 33, 4, -41 },
  { 5627, 27, 40, 33, 4, -40 },
  { 5762, 27, 42, 33, 3, -41 },
  { 5904, 27, 40, 33, 3, -40 },
  { 6039, 25, 41, 33, 4, -40 },
  { 6168, 29, 40, 33, 2, -40 },
  { 6313, 31, 40, 33, 1, -40 },
  { 6468, 29, 40, 33, 2, -40 },
  { 6613, 31, 40, 33, 1, -40 },
  { 6768, 25, 40, 33, 4, -40 },
  { 6893, 16, 52, 33, 10, -46 },
  { 6997, 27, 52, 33, 3, -46 },
  { 7173, 16, 52, 33, 7, -46 },
  { 7277, 25, 21, 33, 4, -40 },
  { 7343, 27, 7, 33, 3, 1 },
  { 7367, 13, 8, 33, 9, -43 },
  { 7380, 26, 32, 33, 3, -31 },
  { 7484, 25, 41, 33, 4, -40 },
  { 7613, 25, 32, 33, 4, -31 },
  { 7713, 25, 41, 33, 4, -40 },
  { 7842, 25, 32, 33, 4, -31 },
  { 7942, 27, 40, 33, 3, -40 },
  { 8077, 25, 41, 33, 4, -31 },
  { 8206, 25, 40, 33, 4, -40 },
  { 8331, 27, 43, 33, 4, -43 },
  { 8477, 21, 53, 33, 5, -43 },
  { 8617, 27, 40, 33, 4, -40 },
  { 8752, 30, 40, 33, 1, -40 },
  { 8902, 27, 31, 33, 3, -31 },
  { 9007, 25, 31, 33, 4, -31 },
  { 9104, 25, 32, 33, 4, -31 },
  { 9204, 25, 41, 33, 4, -31 },
  { 9333, 25, 41, 33, 4, -31 },
  { 9462, 26, 31, 33, 5, -31 },
  { 9563, 26, 32, 33, 4, -31 },
  { 9667, 27, 39, 33, 2, -39 },
  { 9799, 25, 31, 33, 4, -30 },
  { 9896, 29, 30, 33, 2, -30 },
  { 10005, 31, 30, 33, 1, -30 },
  { 10122, 29, 30, 33, 2, -30 },
  { 10231, 29, 40, 33, 2, -30 },
  { 10376, 25, 30, 33, 4, -30 },
  { 10470, 25, 52, 33, 4, -46 },
  { 10633, 7, 52, 33, 13, -46 },
  { 10679, 25, 52, 33, 4, -46 },
  { 10842, 27, 13, 33, 3, -26 },
};

const GFXfont JetBrainsMono_Bold55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_BOLD55PT7B_H_
