#ifndef _JETBRAINSMONO_BOLD48PT7B_H_
#define _JETBRAINSMONO_BOLD48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xBF, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E,
  0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x3C, 0x07,
  0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xF3, 0x9F, 0xCF, 0xC7, 0x1F, 0x9F, 0x8E, 0x3F,
  0x7E, 0x1C, 0x7F, 0xFC, 0x38, 0x00, 0xFC, 0x70, 0x01, 0xF8, 0xE0, 0x03,
  0xF9, 0xC0, 0x07, 0xFB, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x03, 0x9F, 0xC0, 0x07, 0x1F, 0xC0, 0x0E, 0x1F, 0x80, 0x1C,
  0x3F, 0x00, 0x38, 0x7F, 0xF8, 0x70, 0xFF, 0xF0, 0xE1, 0xFF, 0xF1, 0xC7,
  0xFF, 0xF3, 0x9F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0xFF, 0xC0, 0x07, 0x8F, 0xFF, 0x00,
  0x78, 0xFD, 0xF8, 0x07, 0x87, 0x83, 0xC0, 0x7C, 0x3C, 0x1F, 0x03, 0xC1,
  0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x1E, 0x03, 0xC1,
  0xF1, 0xE0, 0x1E, 0x0F, 0x1E, 0x00, 0xF8, 0x79, 0xF0, 0x07, 0xFF, 0xCF,
  0x00, 0x1F, 0xFC, 0xF0, 0x00, 0x7F, 0xCF, 0x80, 0x00, 0x70, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC7, 0xFC, 0x00, 0x3E, 0x7F, 0xF0, 0x01, 0xE7,
  0xFF, 0xC0, 0x1E, 0x3C, 0x3E, 0x01, 0xF3, 0xE0, 0xF0, 0x0F, 0x1E, 0x07,
  0x80, 0xF0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07,
  0x81, 0xF0, 0x78, 0x78, 0x0F, 0x83, 0xC7, 0xC0, 0x3F, 0xFE, 0x3C, 0x01,
  0xFF, 0xE3, 0xC0, 0x07, 0xFE, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFB, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x7E, 0xFC, 0xFE, 0x1F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xE3,
  0xF0, 0x7F, 0xF8, 0xFC, 0x1F, 0xFC, 0x3F, 0x03, 0xFF, 0x0F, 0xC0, 0x7F,
  0x83, 0xF0, 0x1F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0,
  0x7F, 0xC1, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xEF, 0xC1,
  0xFF, 0xE3, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xDF, 0x7D, 0xF0, 0x00, 0x06, 0x00, 0x7C, 0x01, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x03, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x40, 0xC0, 0x01, 0xE0, 0x03,
  0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x7F, 0xE0, 0xFF,
  0x81, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x01, 0xF0, 0x18, 0xF8, 0x78,
  0x3E, 0x7F, 0x0E, 0x3F, 0x9F, 0xF3, 0x9F, 0xFF, 0xFE, 0xEF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7C,
  0x07, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x80, 0x20, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x08, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x1C, 0x3F, 0xFC, 0x7C,
  0x7F, 0xF9, 0xF8, 0xFF, 0xF3, 0xF9, 0xFF, 0xE7, 0xE3, 0xFF, 0xC7, 0xC7,
  0xFF, 0x86, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xDF, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xE0, 0xFC,
  0x03, 0x01, 0xF8, 0x04, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0x7F, 0x00, 0xFE,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x3F, 0x80, 0xFD, 0xFC, 0x03, 0xF7,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x81, 0xFB,
  0xFF, 0x87, 0xEF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFE, 0x0F,
  0xF7, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x80, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xCF,
  0xE0, 0x3F, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFE, 0xFF, 0x07, 0xF0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F,
  0x9F, 0xC0, 0x7F, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xC0, 0x7F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFE, 0xFF, 0x07, 0xF9, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0x80, 0xFF, 0x7F, 0x00, 0x30, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x3C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x07, 0xF7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x80, 0x07, 0xC0, 0xFE,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x07, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE1, 0xFC, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x30, 0xFF, 0xC0, 0x7F, 0x3F, 0xE0, 0x7F, 0xDF, 0xF0,
  0x7F, 0xEF, 0xF8, 0x7E, 0x1F, 0xFC, 0x3E, 0x07, 0xFE, 0x1F, 0x03, 0xFF,
  0x0F, 0x81, 0xFF, 0x87, 0xC0, 0xFF, 0xC3, 0xE0, 0x7F, 0xE1, 0xF0, 0x3F,
  0xF0, 0xF8, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x1F, 0x03,
  0xFF, 0x0F, 0x81, 0xFF, 0x87, 0xE0, 0xFF, 0xC1, 0xF9, 0xFF, 0xE0, 0xFF,
  0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xE7, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x78, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x0F,
  0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xE0, 0x0F,
  0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0,
  0x0F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x3F, 0x03, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0xE0, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0xFF,
  0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x03, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xE0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0xE0, 0x7F, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xF0,
  0x0F, 0xEF, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1,
  0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F,
  0x87, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x7B, 0xFD, 0xE0, 0xF7, 0xFB, 0xC1, 0xFF, 0xF7, 0x87,
  0xBF, 0xE7, 0x8F, 0x7F, 0xEF, 0x1E, 0xFF, 0xDE, 0x3D, 0xFF, 0x9E, 0xF3,
  0xFF, 0x3D, 0xE7, 0xFE, 0x7B, 0xCF, 0xFC, 0xF7, 0x1F, 0xF8, 0xFE, 0x3F,
  0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC3, 0xE1, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xF8, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFE,
  0xF0, 0x1F, 0xFB, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xDE, 0x07, 0xFF, 0x7C,
  0x1F, 0xFD, 0xF0, 0x7F, 0xF3, 0xC1, 0xFF, 0xCF, 0x87, 0xFF, 0x3E, 0x1F,
  0xFC, 0x78, 0x7F, 0xF1, 0xF1, 0xFF, 0xC7, 0xC7, 0xFF, 0x0F, 0x9F, 0xFC,
  0x3E, 0x7F, 0xF0, 0xF9, 0xFF, 0xC1, 0xF7, 0xFF, 0x07, 0xDF, 0xFC, 0x1F,
  0x7F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F,
  0xDF, 0x80, 0x7F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFD, 0xF8, 0x07, 0xF7, 0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x81,
  0xFF, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0x7E, 0x01, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0x00, 0xFE,
  0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x9F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0x81, 0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x03, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xFB, 0xF0, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xFE, 0x0F,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F,
  0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x83, 0xF0, 0x7F, 0xF0, 0x77,
  0x0F, 0xBF, 0x0E, 0xE1, 0xF3, 0xE1, 0xDC, 0x3E, 0x7C, 0x3B, 0x87, 0xCF,
  0x87, 0x70, 0xF9, 0xF0, 0xEE, 0x1F, 0x3E, 0x1D, 0xC3, 0xE7, 0xC7, 0xB8,
  0x7C, 0xF8, 0xF7, 0x0F, 0x9F, 0x1C, 0xF1, 0xE3, 0xE3, 0x8E, 0x3C, 0x7C,
  0x71, 0xCF, 0x87, 0x8E, 0x39, 0xF0, 0xF9, 0xC7, 0x3E, 0x1F, 0x38, 0xE7,
  0xC3, 0xE7, 0x1C, 0xF8, 0x7D, 0xE3, 0x9F, 0x0F, 0xB8, 0x73, 0xE1, 0xF7,
  0x0F, 0x78, 0x3E, 0xE0, 0xEF, 0x07, 0xDC, 0x1D, 0xE0, 0xFB, 0x83, 0xBC,
  0x0F, 0x70, 0x77, 0x81, 0xEE, 0x0E, 0xF0, 0x3D, 0xC1, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3,
  0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xE0, 0x07,
  0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFE, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFC, 0xFF, 0xFB, 0xF0,
  0xFF, 0x8F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x3E, 0x07, 0xE7, 0xFC, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xC7, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFD, 0xFF, 0xE7, 0xEF, 0xFE, 0x3F, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xFC, 0xFF, 0x9F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xCF,
  0xFF, 0xBF, 0x3F, 0xFF, 0xFD, 0xFF, 0x3F, 0xF7, 0xF0, 0x1F, 0xDF, 0x80,
  0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x01,
  0xFD, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFE, 0xFC,
  0x7F, 0xF3, 0xF0, 0x7F, 0x8F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFC, 0x0F, 0xE7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF3, 0xFC, 0x3F, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x3F, 0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x7F,
  0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xC3, 0xFF, 0xBF, 0x07, 0xF8, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x3E, 0x07, 0xE7, 0xFC, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7E, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x3F,
  0x01, 0xFC, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x7F,
  0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFE,
  0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF8,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x78, 0xF9, 0xF8, 0xFE,
  0xFB, 0xFD, 0xFE, 0xFB, 0xFD, 0xFF, 0xFE, 0x7F, 0x3F, 0xFC, 0x3E, 0x1F,
  0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F,
  0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F,
  0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F,
  0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F,
  0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F,
  0xFC, 0x3E, 0x1F, 0x00, 0x3E, 0x07, 0xE7, 0xFC, 0x3F, 0x7F, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xBF, 0xE7, 0xF0, 0x1F, 0xDF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFD,
  0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xE7, 0xFC, 0x3F, 0x7F,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFD, 0xFF, 0xE7, 0xEF,
  0xFE, 0x3F, 0x1F, 0xE1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF,
  0xCF, 0xFF, 0xBF, 0x3F, 0xFF, 0xFD, 0xFF, 0x3F, 0xF7, 0xF0, 0x1F, 0xDF,
  0x80, 0x7F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFE,
  0xFC, 0x7F, 0xF3, 0xF0, 0x7F, 0x8F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3E, 0x03, 0xE3, 0xFF,
  0x0F, 0x9F, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFC, 0x3F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xCF, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xDF, 0xF1, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0x3C,
  0x1F, 0x83, 0xE7, 0xC3, 0xF0, 0x7C, 0xF8, 0x77, 0x0F, 0x9F, 0x0E, 0xE1,
  0xF3, 0xE1, 0xDC, 0x3E, 0x7C, 0x3B, 0x87, 0x8F, 0x87, 0x70, 0xF0, 0xF1,
  0xCE, 0x3E, 0x1F, 0x39, 0xE7, 0xC3, 0xE7, 0x1C, 0xF8, 0x7C, 0xE3, 0x9F,
  0x0F, 0x9C, 0x73, 0xE1, 0xF3, 0x8E, 0x78, 0x1E, 0xF1, 0xCF, 0x03, 0xDC,
  0x3B, 0xE0, 0x7B, 0x87, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0,
  0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x9F, 0x80, 0x3F, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7F, 0x1F, 0xC0,
  0x1F, 0x9F, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x03, 0xFB,
  0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xE0, 0x1F, 0x3F, 0xF8, 0x1F, 0x7F, 0xF8, 0x1F, 0x7F, 0xFC,
  0x1F, 0x7C, 0xFE, 0x1F, 0xFC, 0x3F, 0x1F, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFE, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xE0,
};

const GFXglyph JetBrainsMono_Bold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 35, 29, 10, -35 },
  { 36, 17, 14, 29, 6, -35 },
  { 66, 27, 35, 29, 1, -35 },
  { 185, 23, 49, 29, 3, -42 },
  { 326, 29, 35, 29, 0, -35 },
  { 453, 26, 36, 29, 2, -36 },
  { 570, 6, 14, 29, 11, -35 },
  { 581, 15, 46, 29, 8, -40 },
  { 668, 15, 46, 29, 6, -40 },
  { 755, 26, 25, 29, 1, -29 },
  { 837, 23, 23, 29, 3, -27 },
  { 904, 12, 15, 29, 7, -7 },
  { 927, 15, 6, 29, 7, -19 },
  { 939, 9, 9, 29, 10, -9 },
  { 950, 23, 45, 29, 3, -40 },
  { 1080, 23, 36, 29, 3, -36 },
  { 1184, 23, 35, 29, 4, -35 },
  { 1285, 23, 36, 29, 3, -36 },
  { 1389, 22, 35, 29, 3, -35 },
  { 1486, 22, 35, 29, 3, -35 },
  { 1583, 22, 35, 29, 3, -35 },
  { 1680, 23, 35, 29, 3, -35 },
  { 1781, 23, 35, 29, 3, -35 },
  { 1882, 23, 36, 29, 3, -36 },
  { 1986, 23, 36, 29, 3, -36 },
  { 2090, 9, 27, 29, 10, -27 },
  { 2121, 12, 35, 29, 7, -27 },
  { 2174, 21, 26, 29, 4, -29 },
  { 2243, 21, 17, 29, 4, -24 },
  { 2288, 21, 26, 29, 4, -29 },
  { 2357, 18, 35, 29, 6, -35 },
  { 2436, 25, 45, 29, 2, -36 },
  { 2577, 25, 35, 29, 2, -35 },
  { 2687, 22, 35, 29, 4, -35 },
  { 2784, 23, 36, 29, 3, -36 },
  { 2888, 22, 35, 29, 4, -35 },
  { 2985, 21, 35, 29, 4, -35 },
  { 3077, 22, 35, 29, 4, -35 },
  { 3174, 23, 36, 29, 3, -36 },
  { 3278, 21, 35, 29, 4, -35 },
  { 3370, 20, 35, 29, 4, -35 },
  { 3458, 23, 36, 29, 1, -35 },
  { 3562, 23, 35, 29, 4, -35 },
  { 3663, 21, 35, 29, 5, -35 },
  { 3755, 23, 35, 29, 3, -35 },
  { 3856, 22, 35, 29, 3, -35 },
  { 3953, 22, 36, 29, 3, -36 },
  { 4052, 23, 35, 29, 4, -35 },
  { 4153, 23, 45, 29, 3, -36 },
  { 4283, 23, 35, 29, 4, -35 },
  { 4384, 23, 36, 29, 3, -36 },
  { 4488, 25, 35, 29, 2, -35 },
  { 4598, 22, 35, 29, 3, -35 },
  { 4695, 25, 35, 29, 2, -35 },
  { 4805, 27, 35, 29, 1, -35 },
  { 4924, 26, 35, 29, 1, -35 },
  { 5038, 27, 35, 29, 1, -35 },
  { 5157, 21, 35, 29, 4, -35 },
  { 5249, 13, 45, 29, 9, -40 },
  { 5323, 23, 45, 29, 3, -40 },
  { 5453, 14, 45, 29, 6, -40 },
  { 5532, 23, 19, 29, 3, -35 },
  { 5587, 23, 6, 29, 3, 1 },
  { 5605, 12, 7, 29, 8, -38 },
  { 5616, 22, 27, 29, 3, -27 },
  { 5691, 21, 35, 29, 4, -35 },
  { 5783, 23, 27, 29, 3, -27 },
  { 5861, 22, 35, 29, 3, -35 },
  { 5958, 22, 27, 29, 3, -27 },
  { 6033, 23, 35, 29, 3, -35 },
  { 6134, 22, 36, 29, 3, -27 },
  { 6233, 21, 35, 29, 4, -35 },
  { 6325, 23, 38, 29, 4, -38 },
  { 6435, 19, 47, 29, 4, -38 },
  { 6547, 23, 35, 29, 4, -35 },
  { 6648, 26, 35, 29, 1, -35 },
  { 6762, 24, 27, 29, 2, -27 },
  { 6843, 21, 27, 29, 4, -27 },
  { 6914, 22, 27, 29, 3, -27 },
  { 6989, 21, 36, 29, 4, -27 },
  { 7084, 22, 36, 29, 3, -27 },
  { 7183, 22, 27, 29, 5, -27 },
  { 7258, 23, 27, 29, 3, -27 },
  { 7336, 23, 34, 29, 2, -34 },
  { 7434, 21, 26, 29, 4, -26 },
  { 7503, 25, 26, 29, 2, -26 },
  { 7585, 27, 26, 29, 1, -26 },
  { 7673, 25, 26, 29, 2, -26 },
  { 7755, 25, 35, 29, 2, -26 },
  { 7865, 21, 26, 29, 4, -26 },
  { 7934, 21, 45, 29, 4, -40 },
  { 8053, 6, 45, 29, 11, -40 },
  { 8087, 21, 45, 29, 4, -40 },
  { 8206, 24, 12, 29, 2, -23 },
};

const GFXfont JetBrainsMono_Bold48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_BOLD48PT7B_H_
