#ifndef _JETBRAINSMONO_BOLD45PT7B_H_
#define _JETBRAINSMONO_BOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0x7C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x1E, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFC, 0xE7,
  0xEF, 0xC7, 0x1F, 0xFE, 0x38, 0xFF, 0xF1, 0xC7, 0xFF, 0x8E, 0x00, 0xFC,
  0x70, 0x03, 0xF3, 0x80, 0x1F, 0xDC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x1C, 0xFE, 0x00, 0xE3, 0xF0, 0x07, 0x1F, 0x80, 0x38, 0x7F,
  0xE1, 0xC3, 0xFF, 0x0E, 0x1F, 0xFC, 0x71, 0xFF, 0xF3, 0x9F, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xE7, 0xFE, 0x00, 0x78, 0xFF,
  0xE0, 0x1E, 0x3E, 0x7C, 0x03, 0xC7, 0x87, 0x80, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x3C, 0x78, 0x0F, 0x07,
  0x9F, 0x01, 0xE1, 0xE3, 0xC0, 0x3F, 0xFC, 0xF0, 0x03, 0xFF, 0xBC, 0x00,
  0x3F, 0xE7, 0x80, 0x03, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7F, 0x80,
  0x07, 0x9F, 0xF8, 0x01, 0xE7, 0xFF, 0x80, 0x78, 0xF0, 0xF0, 0x0F, 0x3C,
  0x1E, 0x03, 0xC7, 0x83, 0xC0, 0xF0, 0xF0, 0x78, 0x3E, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xE0, 0x7C, 0x3C, 0x78, 0x07, 0xCF, 0x8F, 0x00, 0xFF,
  0xF3, 0xC0, 0x0F, 0xFC, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x3E, 0xFC, 0xFC, 0x7E, 0xF8, 0x7C, 0x7C, 0xF8, 0x7E, 0xFC, 0xF8,
  0x3F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFE, 0x7E, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0xF0,
  0x0F, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0,
  0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0x01, 0xF0, 0x10, 0xE0,
  0xF8, 0x38, 0xFC, 0x38, 0x7E, 0x7F, 0x9C, 0xFF, 0x7F, 0xEE, 0xFF, 0xDF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x07,
  0x80, 0x04, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0x9F, 0xDF,
  0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x01, 0xFB,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x10, 0x7F, 0xE3, 0xE3, 0xFF,
  0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF0, 0x41,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xFD, 0xFF,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x1F, 0x80, 0xF0, 0xFC, 0x06, 0x07,
  0xE0, 0x20, 0x3F, 0x01, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFD, 0xFC, 0x07, 0xE7, 0xF9, 0xFF, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x81, 0xF3, 0xF0, 0x1F,
  0x7F, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x30, 0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1, 0xF7, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xFD, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF7, 0xF0, 0x0F, 0xDF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF,
  0x07, 0xF1, 0xFC, 0x07, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xFC, 0x7F, 0x83, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFD,
  0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0xE7,
  0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x0F,
  0xF7, 0xF8, 0xFE, 0x0F, 0xE7, 0xE0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xF7, 0xFD, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFB, 0xE0,
  0x03, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0xC1,
  0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xF7, 0xE0, 0x3F, 0xDF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFB, 0xF8, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x9F,
  0xF3, 0xFE, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xE1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x3F, 0x07, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x81, 0xF8, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDE, 0x00, 0x03,
  0xEF, 0x01, 0xF9, 0xFF, 0x81, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xE0, 0xFC,
  0xFF, 0xF0, 0x7C, 0x3F, 0xF8, 0x7C, 0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x1F,
  0x03, 0xFF, 0x0F, 0x81, 0xFF, 0x87, 0xC0, 0xFF, 0xC3, 0xE0, 0x7F, 0xE1,
  0xF0, 0x3F, 0xF0, 0xF8, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x3E, 0x07, 0xFE,
  0x0F, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x7B, 0xC0, 0x7F, 0x7D,
  0xE0, 0x04, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x3F,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xC0, 0xFF, 0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x0F, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x1F, 0xEF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x81,
  0xF9, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xFD,
  0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x1F,
  0xDF, 0xC0, 0x7E, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0xFD, 0xF8,
  0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80,
  0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFE, 0xE0, 0xEF, 0xF7,
  0x8F, 0x7F, 0xBC, 0x7B, 0xFC, 0xE3, 0x9F, 0xE7, 0xBC, 0xFF, 0x3D, 0xE7,
  0xF9, 0xEF, 0x3F, 0xC7, 0x71, 0xFF, 0x3F, 0x9F, 0xF9, 0xFC, 0xFF, 0xC7,
  0xE7, 0xFE, 0x3E, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xF8, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xFB, 0xC0, 0xFF, 0xDE, 0x07, 0xFE, 0xF8, 0x3F, 0xF3, 0xC1,
  0xFF, 0x9E, 0x0F, 0xFC, 0xF8, 0x7F, 0xE3, 0xC3, 0xFF, 0x1E, 0x1F, 0xF8,
  0xF8, 0xFF, 0xC3, 0xC7, 0xFE, 0x1E, 0x3F, 0xF0, 0xF9, 0xFF, 0x83, 0xCF,
  0xFC, 0x1E, 0x7F, 0xE0, 0xFB, 0xFF, 0x03, 0xDF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xF0, 0x1F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x01, 0xFB, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x7F, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF,
  0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xFD, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F,
  0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE,
  0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xB8, 0x7F,
  0xE1, 0xDC, 0x3F, 0xF0, 0xEE, 0x1F, 0x78, 0x77, 0x0F, 0x3C, 0x3B, 0x87,
  0x9E, 0x1D, 0xC3, 0xCF, 0x8E, 0xE3, 0xE7, 0xC7, 0x71, 0xF3, 0xE3, 0xB8,
  0xF9, 0xF3, 0x8E, 0x7C, 0xF9, 0xC7, 0x3E, 0x7C, 0xE3, 0x9F, 0x3E, 0x71,
  0xCF, 0x0F, 0x38, 0xE7, 0x87, 0x9C, 0x73, 0xC3, 0xCE, 0x39, 0xE1, 0xE7,
  0x1C, 0xF0, 0xFB, 0x8E, 0x78, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFD, 0xFF, 0x3F, 0x01, 0xF9,
  0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F,
  0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xF7, 0xE7, 0xFF, 0xBF, 0x1F,
  0xF1, 0xF8, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x7F, 0x07, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xEF, 0xFD, 0xFF, 0x7F, 0xFF, 0xFB, 0xF7, 0xFF, 0x9F,
  0x9F, 0xF8, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xFD, 0xFF,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xF1, 0xF8, 0xFF,
  0xCF, 0xCF, 0xFF, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFE, 0xFC, 0x07,
  0xF7, 0xFD, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xF7, 0xE3, 0xFF, 0x3F, 0x0F,
  0xF1, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xF8, 0x7F, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x7E, 0xFC, 0x03, 0xE7, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0xFF, 0xCF, 0xCF, 0xFF, 0x7E, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFB,
  0xF0, 0x1F, 0xDF, 0xE3, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0x8F, 0xFE,
  0xFC, 0x3F, 0xE7, 0xE0, 0x10, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x07, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFC, 0x7F, 0xFC, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xEF, 0x80, 0x3F,
  0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x81, 0xFC, 0x3E,
  0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xE1, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x3F, 0x83, 0xE0, 0x7E, 0x0F, 0x81, 0xFC, 0x3E, 0x03, 0xF0, 0xF8,
  0x07, 0xE3, 0xE0, 0x1F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFE, 0xF8, 0x01,
  0xFC, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF9, 0xF1, 0xF1, 0xF7, 0xE7, 0xF3, 0xFF, 0xEF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xC7, 0xC7, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F,
  0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF,
  0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC,
  0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3,
  0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E,
  0x1F, 0xF8, 0x7C, 0x3E, 0xFC, 0x7F, 0x07, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xDF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0x83, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E,
  0xFC, 0x07, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x7F, 0x07, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xEF, 0xFD, 0xFF, 0x7F,
  0xFF, 0xFB, 0xF7, 0xFF, 0x9F, 0x9F, 0xF8, 0xFC, 0x7F, 0x87, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0xFF, 0xCF,
  0xCF, 0xFF, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFE, 0xFC, 0x07, 0xF7,
  0xFD, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xF7, 0xE3, 0xFF, 0x3F, 0x0F, 0xF1,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x7F,
  0x07, 0xEF, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0x3F, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xBF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFE, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xDF, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xFD, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x3E, 0x03,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0x80,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xF8, 0x3E, 0x07, 0xFC,
  0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xF7, 0x83, 0x60, 0xF3,
  0xC1, 0xB0, 0x79, 0xE1, 0xDC, 0x3C, 0xF8, 0xEE, 0x1E, 0x7C, 0x77, 0x1F,
  0x3E, 0x3B, 0x8F, 0x9F, 0x1D, 0xC7, 0xC7, 0x8C, 0x63, 0xC3, 0xCE, 0x39,
  0xE1, 0xE7, 0x1C, 0xF0, 0xFB, 0x8E, 0x78, 0x7D, 0xC7, 0x7C, 0x3E, 0xE3,
  0xBE, 0x0F, 0x71, 0xDE, 0x07, 0xB0, 0xEF, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE1,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03,
  0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x1F, 0x80, 0xFE, 0x1F,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x7D, 0xFF, 0xC0, 0xFB, 0xFF, 0xC1,
  0xFF, 0xCF, 0xC3, 0xFF, 0x0F, 0xCF, 0xFE, 0x0F, 0xFF, 0x7C, 0x1F, 0xFE,
  0xF8, 0x1F, 0xF9, 0xF0, 0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 33, 27, 10, -33 },
  { 30, 15, 14, 27, 6, -33 },
  { 57, 25, 33, 27, 1, -33 },
  { 161, 21, 45, 27, 3, -39 },
  { 280, 27, 33, 27, 0, -33 },
  { 392, 24, 33, 27, 2, -33 },
  { 491, 5, 14, 27, 11, -33 },
  { 500, 14, 43, 27, 8, -38 },
  { 576, 14, 43, 27, 5, -38 },
  { 652, 25, 23, 27, 1, -27 },
  { 724, 21, 22, 27, 3, -26 },
  { 782, 11, 14, 27, 7, -7 },
  { 802, 15, 5, 27, 6, -17 },
  { 812, 9, 8, 27, 9, -8 },
  { 821, 21, 42, 27, 3, -37 },
  { 932, 21, 33, 27, 3, -33 },
  { 1019, 21, 33, 27, 4, -33 },
  { 1106, 21, 33, 27, 3, -33 },
  { 1193, 21, 33, 27, 3, -33 },
  { 1280, 20, 33, 27, 3, -33 },
  { 1363, 21, 33, 27, 3, -33 },
  { 1450, 23, 33, 27, 2, -33 },
  { 1545, 21, 33, 27, 3, -33 },
  { 1632, 21, 33, 27, 3, -33 },
  { 1719, 23, 33, 27, 2, -33 },
  { 1814, 9, 25, 27, 9, -25 },
  { 1843, 11, 32, 27, 7, -25 },
  { 1887, 21, 24, 27, 3, -27 },
  { 1950, 19, 16, 27, 4, -23 },
  { 1988, 21, 24, 27, 3, -27 },
  { 2051, 18, 33, 27, 5, -33 },
  { 2126, 25, 41, 27, 1, -33 },
  { 2255, 23, 33, 27, 2, -33 },
  { 2350, 22, 33, 27, 3, -33 },
  { 2441, 21, 33, 27, 3, -33 },
  { 2528, 21, 33, 27, 3, -33 },
  { 2615, 20, 33, 27, 4, -33 },
  { 2698, 20, 33, 27, 4, -33 },
  { 2781, 21, 33, 27, 3, -33 },
  { 2868, 21, 33, 27, 3, -33 },
  { 2955, 19, 33, 27, 4, -33 },
  { 3034, 22, 34, 27, 1, -33 },
  { 3128, 23, 33, 27, 3, -33 },
  { 3223, 19, 33, 27, 5, -33 },
  { 3302, 21, 33, 27, 3, -33 },
  { 3389, 21, 33, 27, 3, -33 },
  { 3476, 21, 33, 27, 3, -33 },
  { 3563, 22, 33, 27, 3, -33 },
  { 3654, 21, 41, 27, 3, -33 },
  { 3762, 22, 33, 27, 3, -33 },
  { 3853, 21, 33, 27, 3, -33 },
  { 3940, 23, 33, 27, 2, -33 },
  { 4035, 21, 33, 27, 3, -33 },
  { 4122, 23, 33, 27, 2, -33 },
  { 4217, 25, 33, 27, 1, -33 },
  { 4321, 25, 33, 27, 1, -33 },
  { 4425, 25, 33, 27, 1, -33 },
  { 4529, 19, 33, 27, 4, -33 },
  { 4608, 13, 42, 27, 8, -37 },
  { 4677, 21, 42, 27, 3, -37 },
  { 4788, 13, 42, 27, 6, -37 },
  { 4857, 21, 18, 27, 3, -33 },
  { 4905, 21, 5, 27, 3, 1 },
  { 4919, 11, 6, 27, 7, -35 },
  { 4928, 21, 25, 27, 3, -25 },
  { 4994, 21, 33, 27, 3, -33 },
  { 5081, 21, 25, 27, 3, -25 },
  { 5147, 21, 33, 27, 3, -33 },
  { 5234, 21, 25, 27, 3, -25 },
  { 5300, 22, 33, 27, 2, -33 },
  { 5391, 21, 33, 27, 3, -25 },
  { 5478, 21, 33, 27, 3, -33 },
  { 5565, 22, 35, 27, 3, -35 },
  { 5662, 17, 43, 27, 4, -35 },
  { 5754, 22, 33, 27, 4, -33 },
  { 5845, 24, 33, 27, 1, -33 },
  { 5944, 23, 25, 27, 2, -25 },
  { 6016, 21, 25, 27, 3, -25 },
  { 6082, 21, 25, 27, 3, -25 },
  { 6148, 21, 33, 27, 3, -25 },
  { 6235, 21, 33, 27, 3, -25 },
  { 6322, 21, 25, 27, 4, -25 },
  { 6388, 21, 25, 27, 3, -25 },
  { 6454, 22, 32, 27, 2, -32 },
  { 6542, 21, 25, 27, 3, -25 },
  { 6608, 23, 25, 27, 2, -25 },
  { 6680, 25, 25, 27, 1, -25 },
  { 6759, 23, 25, 27, 2, -25 },
  { 6831, 23, 33, 27, 2, -25 },
  { 6926, 19, 25, 27, 4, -25 },
  { 6986, 19, 42, 27, 4, -37 },
  { 7086, 5, 42, 27, 11, -37 },
  { 7113, 19, 42, 27, 4, -37 },
  { 7213, 23, 10, 27, 2, -21 },
};

const GFXfont JetBrainsMono_Bold45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_BOLD45PT7B_H_
