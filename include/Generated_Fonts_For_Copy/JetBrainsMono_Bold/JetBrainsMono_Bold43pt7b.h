#ifndef _JETBRAINSMONO_BOLD43PT7B_H_
#define _JETBRAINSMONO_BOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C,
  0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xC1, 0xF7, 0x83, 0xE0, 0x00, 0xF0, 0x7C,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x07, 0x81, 0xC0, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x00,
  0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xCC, 0xFC, 0xFC,
  0x63, 0xF7, 0xE3, 0x1F, 0xBE, 0x18, 0xFD, 0xF8, 0xC0, 0x0F, 0xC6, 0x00,
  0x7E, 0x30, 0x01, 0xFD, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x37, 0xF8,
  0x01, 0x8F, 0xC0, 0x0C, 0x7E, 0x00, 0x61, 0xF0, 0x03, 0x0F, 0xFE, 0x18,
  0x7D, 0xF0, 0xC3, 0xEF, 0xC6, 0x3F, 0x7F, 0xB7, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x00, 0x47, 0xF8, 0x01, 0xE3, 0xFF, 0x00, 0x79, 0xFF, 0xC0, 0x3C,
  0x78, 0x78, 0x1E, 0x1C, 0x1E, 0x07, 0x07, 0x07, 0x83, 0xC1, 0xC1, 0xE1,
  0xE0, 0x70, 0x78, 0xF0, 0x1C, 0x1E, 0x3C, 0x07, 0x87, 0x9E, 0x01, 0xFF,
  0xEF, 0x00, 0x3F, 0xF3, 0xC0, 0x07, 0xF9, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x8F,
  0xC0, 0x01, 0xEF, 0xFC, 0x00, 0xF3, 0xFF, 0x00, 0x79, 0xF3, 0xE0, 0x1C,
  0x78, 0x78, 0x0F, 0x1E, 0x1E, 0x07, 0x87, 0x87, 0x83, 0xC1, 0xE1, 0xE0,
  0xF0, 0x78, 0x78, 0x78, 0x1E, 0x1E, 0x3C, 0x07, 0xCF, 0x8F, 0x00, 0xFF,
  0xC7, 0x80, 0x3F, 0xF3, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0xFB, 0xE3,
  0xE3, 0xE7, 0xC7, 0xE7, 0xCF, 0x87, 0xFF, 0x1F, 0x07, 0xFE, 0x3E, 0x07,
  0xF8, 0x7C, 0x0F, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F,
  0x87, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF, 0x0F, 0xFF, 0x3F,
  0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0x9E,
  0x78, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1,
  0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x0C, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x81, 0xFF, 0x01,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x20, 0x3C, 0x04, 0x38, 0x3C, 0x1C, 0x7E, 0x3C,
  0x7E, 0x7F, 0x99, 0xFE, 0xFF, 0xDB, 0xFF, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xE7,
  0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81,
  0xF8, 0x07, 0x01, 0xE0, 0x03, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x86, 0x1F, 0xF8, 0xF1, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xFF,
  0x9F, 0x1F, 0xF8, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xC0, 0xF8, 0x08,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xE0, 0xFE, 0xFC, 0x07,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0xFE, 0x0F, 0xE7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x18, 0x07, 0xCF, 0xF0, 0x7D, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7E, 0x7F, 0x1F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF3, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xF0,
  0x0F, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC3, 0xF9, 0xFC, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x9F, 0xC7, 0xE0, 0x7E, 0xFC,
  0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xEF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xF0, 0xFF, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFE, 0xF8, 0x07, 0xCF, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7E,
  0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8,
  0x0F, 0x9F, 0xF8, 0x3F, 0xDF, 0xF8, 0x3F, 0xEF, 0xF8, 0x7E, 0x3F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x78, 0x1F, 0xF8,
  0x78, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x78, 0x1F, 0xF8,
  0x78, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xEF, 0xF8, 0x1F, 0xCF, 0x78, 0x02, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF3,
  0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0x80, 0x7C, 0x3E,
  0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xE0,
  0x07, 0xEF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE, 0x7E, 0x03, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC3, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03,
  0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0xFC,
  0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x0F, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E,
  0x07, 0xF7, 0xF9, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xF7,
  0xF8, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0xE3, 0xFC, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0x7F, 0x70, 0x3F, 0xFB,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0x70, 0xEF, 0xFB, 0x8F, 0x7F, 0xDE, 0x7B,
  0xFE, 0xF3, 0x9F, 0xF3, 0x9C, 0xFF, 0x9F, 0xE7, 0xFC, 0xFF, 0x3F, 0xE3,
  0xF1, 0xFF, 0x1F, 0x8F, 0xF8, 0xFC, 0xFF, 0xC7, 0xC7, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xBC, 0x1F, 0xFB, 0xC1, 0xFF,
  0xBE, 0x1F, 0xF9, 0xE1, 0xFF, 0x9E, 0x1F, 0xF9, 0xF1, 0xFF, 0x8F, 0x1F,
  0xF8, 0xF1, 0xFF, 0x87, 0x9F, 0xF8, 0x79, 0xFF, 0x87, 0xDF, 0xF8, 0x3D,
  0xFF, 0x83, 0xDF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xE0, 0xFE, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xF9, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0x7E,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0xFE, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x07, 0xE7, 0xF9, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xC1,
  0xFE, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7,
  0xE0, 0x0F, 0xFF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x7E, 0x07,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E,
  0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0x81, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x7E, 0xFF, 0x0F, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xF0,
  0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1E, 0xF8, 0x7E, 0x1E, 0x78, 0x7E, 0x1E,
  0x78, 0x6E, 0x1E, 0x78, 0x66, 0x1E, 0x78, 0xE6, 0x1E, 0x78, 0xE7, 0x3E,
  0x78, 0xE7, 0x3E, 0x7C, 0xE7, 0x3E, 0x7C, 0xE7, 0x3E, 0x7C, 0xE7, 0x3C,
  0x7C, 0xE7, 0x3C, 0x3C, 0xC7, 0x3C, 0x3D, 0xC7, 0x3C, 0x3D, 0xC3, 0x3C,
  0x3D, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC, 0x3D, 0xC3, 0xFC,
  0x3D, 0xC3, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x83, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xEF, 0xC0,
  0x07, 0xE7, 0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x1F, 0x0F, 0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0x3E, 0x07,
  0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFC, 0xFF, 0x1F, 0x81, 0xF8, 0xF8, 0x07,
  0xC8, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x80, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFE, 0xFC, 0x0F, 0xF7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xF7, 0xE1, 0xFE, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7E, 0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xDF, 0xF8,
  0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x7E, 0x07, 0xF7, 0xF0, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x1F, 0x1F, 0xF3,
  0xE7, 0xFF, 0x7D, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xFC, 0x7F, 0xBF, 0xFF, 0xF3, 0xFF, 0xBE,
  0x3F, 0xF7, 0xC3, 0xFC, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x01, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE3, 0xE3, 0xFF, 0x7C, 0xFF, 0xEF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xBE, 0x1F, 0xE7, 0xC0, 0xF0, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFF, 0xF0, 0x07, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xF9,
  0xE1, 0xE3, 0xEF, 0xCF, 0xCF, 0xFF, 0x7F, 0xBF, 0xFF, 0xFE, 0xF8, 0x78,
  0xFB, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F,
  0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1,
  0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1,
  0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF,
  0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xFC, 0x7E, 0x0F, 0xDF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x7E, 0x07, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xFC, 0x7E, 0x0F, 0xDF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xEF, 0xF0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFD, 0xFF, 0x8F, 0xCF, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE3, 0xE3, 0xFE, 0x7C, 0xFF, 0xEF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xBF, 0x8F,
  0xF7, 0xFF, 0xFE, 0x7F, 0xF7, 0xC7, 0xFE, 0xF8, 0x7F, 0x9F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0xFE, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF,
  0xCF, 0xBF, 0xFE, 0xFF, 0xBF, 0xEF, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0x7E, 0x07, 0xE7,
  0xF1, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x01, 0xF9, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xFC, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x7E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x1F,
  0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1E, 0xF8, 0x7E, 0x1E, 0x78, 0x7E, 0x1E,
  0x78, 0x7E, 0x1E, 0x78, 0x6E, 0x1E, 0x78, 0x6E, 0x3E, 0x7C, 0xE6, 0x3E,
  0x7C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C,
  0x3C, 0xC7, 0x3C, 0x3D, 0xC7, 0x7C, 0x3F, 0xC3, 0x78, 0x3F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8,
  0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF0, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xFC,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xDF, 0x80, 0x3F, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x3E, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x81, 0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xF8,
  0xF8, 0x7F, 0xE1, 0xFB, 0xFF, 0x87, 0xFF, 0xBE, 0x0F, 0xFE, 0xF8, 0x1F,
  0xF0, 0x00, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_Bold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 31, 26, 9, -31 },
  { 32, 15, 13, 26, 5, -31 },
  { 57, 24, 31, 26, 1, -31 },
  { 150, 21, 43, 26, 2, -37 },
  { 263, 26, 32, 26, 0, -32 },
  { 367, 23, 32, 26, 2, -32 },
  { 459, 6, 13, 26, 10, -31 },
  { 469, 14, 41, 26, 7, -36 },
  { 541, 14, 41, 26, 5, -36 },
  { 613, 24, 22, 26, 1, -26 },
  { 679, 20, 20, 26, 3, -24 },
  { 729, 11, 14, 26, 6, -7 },
  { 749, 14, 5, 26, 6, -17 },
  { 758, 8, 8, 26, 9, -8 },
  { 766, 20, 41, 26, 3, -36 },
  { 869, 20, 32, 26, 3, -32 },
  { 949, 20, 31, 26, 4, -31 },
  { 1027, 20, 32, 26, 3, -32 },
  { 1107, 20, 31, 26, 3, -31 },
  { 1185, 19, 31, 26, 3, -31 },
  { 1259, 20, 31, 26, 3, -31 },
  { 1337, 21, 31, 26, 2, -31 },
  { 1419, 20, 31, 26, 3, -31 },
  { 1497, 20, 32, 26, 3, -32 },
  { 1577, 21, 32, 26, 2, -32 },
  { 1661, 8, 24, 26, 9, -24 },
  { 1685, 10, 31, 26, 7, -24 },
  { 1724, 20, 24, 26, 3, -26 },
  { 1784, 18, 16, 26, 4, -22 },
  { 1820, 20, 24, 26, 3, -26 },
  { 1880, 17, 31, 26, 5, -31 },
  { 1946, 24, 40, 26, 1, -32 },
  { 2066, 23, 31, 26, 1, -31 },
  { 2156, 21, 31, 26, 3, -31 },
  { 2238, 20, 32, 26, 3, -32 },
  { 2318, 20, 31, 26, 3, -31 },
  { 2396, 19, 31, 26, 4, -31 },
  { 2470, 20, 31, 26, 3, -31 },
  { 2548, 20, 32, 26, 3, -32 },
  { 2628, 19, 31, 26, 3, -31 },
  { 2702, 18, 31, 26, 4, -31 },
  { 2772, 21, 31, 26, 1, -31 },
  { 2854, 21, 31, 26, 3, -31 },
  { 2936, 19, 31, 26, 4, -31 },
  { 3010, 21, 31, 26, 2, -31 },
  { 3092, 20, 31, 26, 3, -31 },
  { 3170, 20, 32, 26, 3, -32 },
  { 3250, 21, 31, 26, 3, -31 },
  { 3332, 20, 40, 26, 3, -32 },
  { 3432, 21, 31, 26, 3, -31 },
  { 3514, 21, 32, 26, 2, -32 },
  { 3598, 22, 31, 26, 2, -31 },
  { 3684, 20, 31, 26, 3, -31 },
  { 3762, 23, 31, 26, 1, -31 },
  { 3852, 24, 31, 26, 1, -31 },
  { 3945, 24, 31, 26, 1, -31 },
  { 4038, 24, 31, 26, 1, -31 },
  { 4131, 19, 31, 26, 3, -31 },
  { 4205, 12, 41, 26, 8, -36 },
  { 4267, 20, 41, 26, 3, -36 },
  { 4370, 12, 41, 26, 6, -36 },
  { 4432, 20, 16, 26, 3, -31 },
  { 4472, 20, 5, 26, 3, 1 },
  { 4485, 11, 6, 26, 7, -34 },
  { 4494, 21, 24, 26, 2, -24 },
  { 4557, 20, 31, 26, 3, -31 },
  { 4635, 20, 24, 26, 3, -24 },
  { 4695, 19, 31, 26, 3, -31 },
  { 4769, 20, 24, 26, 3, -24 },
  { 4829, 21, 31, 26, 2, -31 },
  { 4911, 19, 32, 26, 3, -24 },
  { 4987, 20, 31, 26, 3, -31 },
  { 5065, 21, 34, 26, 3, -34 },
  { 5155, 16, 42, 26, 4, -34 },
  { 5239, 21, 31, 26, 3, -31 },
  { 5321, 23, 31, 26, 1, -31 },
  { 5411, 22, 24, 26, 2, -24 },
  { 5477, 20, 24, 26, 3, -24 },
  { 5537, 20, 24, 26, 3, -24 },
  { 5597, 20, 32, 26, 3, -24 },
  { 5677, 19, 32, 26, 3, -24 },
  { 5753, 20, 24, 26, 4, -24 },
  { 5813, 20, 24, 26, 3, -24 },
  { 5873, 21, 30, 26, 2, -30 },
  { 5952, 20, 24, 26, 3, -24 },
  { 6012, 22, 24, 26, 2, -24 },
  { 6078, 24, 24, 26, 1, -24 },
  { 6150, 22, 24, 26, 2, -24 },
  { 6216, 22, 32, 26, 2, -24 },
  { 6304, 19, 24, 26, 3, -24 },
  { 6361, 19, 41, 26, 3, -36 },
  { 6459, 6, 41, 26, 10, -36 },
  { 6490, 19, 41, 26, 3, -36 },
  { 6588, 22, 10, 26, 2, -20 },
};

const GFXfont JetBrainsMono_Bold43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_BOLD43PT7B_H_
