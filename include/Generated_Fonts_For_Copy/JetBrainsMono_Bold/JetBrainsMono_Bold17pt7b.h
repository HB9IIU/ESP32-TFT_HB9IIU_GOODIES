#ifndef _JETBRAINSMONO_BOLD17PT7B_H_
#define _JETBRAINSMONO_BOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x03, 0xE0, 0xCF, 0x3C, 0xF3, 0xCC, 0x19, 0x86,
  0x61, 0x11, 0xFF, 0x11, 0x0C, 0xC3, 0x33, 0xFE, 0xFF, 0x88, 0x82, 0x61,
  0x98, 0x08, 0x08, 0x18, 0x7E, 0xEF, 0xCB, 0xC8, 0x78, 0x7E, 0x1F, 0x0B,
  0x0B, 0xCB, 0xFF, 0x7E, 0x08, 0x08, 0x20, 0x1E, 0x3C, 0x9B, 0x24, 0xCA,
  0x1F, 0x80, 0x40, 0x24, 0x1F, 0xCD, 0xB2, 0x6D, 0x9B, 0xC3, 0x80, 0x18,
  0x3F, 0x19, 0x8C, 0xC6, 0x03, 0x03, 0xC1, 0xB7, 0xDF, 0x67, 0x31, 0x9F,
  0xE7, 0xB8, 0xFF, 0xC0, 0x19, 0xDD, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x86,
  0x38, 0xE1, 0xC7, 0x1C, 0x71, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xBB, 0x90,
  0x18, 0x0C, 0x36, 0xDD, 0xF1, 0x81, 0xE1, 0x98, 0xCE, 0x24, 0x00, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x76, 0xEC, 0xCC, 0xFF, 0xF0,
  0x6F, 0x60, 0x03, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0x18, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3,
  0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0x7F, 0x3E, 0x3C, 0x7C, 0xCC, 0x8C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0xFF, 0xFF, 0x18, 0x7E, 0xE7, 0xC3, 0x03,
  0x07, 0x06, 0x0C, 0x1C, 0x38, 0x60, 0xFF, 0xFF, 0x7F, 0x07, 0x0C, 0x18,
  0x1C, 0x1E, 0x03, 0x03, 0x03, 0xC3, 0x7E, 0x7C, 0x0E, 0x0C, 0x18, 0x38,
  0x70, 0x63, 0xC3, 0xC3, 0xFF, 0xFF, 0x03, 0x03, 0x7F, 0x7F, 0x60, 0x60,
  0x7E, 0xFF, 0x03, 0x03, 0x03, 0xC3, 0x7F, 0x3E, 0x1C, 0x18, 0x30, 0x30,
  0x6C, 0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0x7F, 0x3E, 0xFF, 0xFF, 0xC3, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x18, 0x7E, 0xE7, 0xC3,
  0xE3, 0x66, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0x7F, 0x3E, 0x18, 0x7E, 0xE7,
  0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x5F, 0x80,
  0x06, 0xF8, 0x2F, 0x70, 0x00, 0x07, 0x6E, 0xCC, 0xC0, 0x03, 0x0F, 0x3C,
  0xF0, 0xC0, 0xF8, 0x3E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x0F, 0x3C, 0xF0, 0x80, 0xF9, 0xF8, 0x38,
  0x70, 0xCF, 0x9E, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x18, 0x3F, 0x30, 0xD8,
  0x38, 0x1C, 0xFE, 0x67, 0x33, 0x99, 0xCC, 0xE6, 0x71, 0xFC, 0x06, 0x01,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x86, 0x63, 0x31, 0x98, 0xFC, 0xFF,
  0x61, 0xB0, 0xD8, 0x70, 0xFE, 0xC7, 0xC3, 0xC3, 0xC6, 0xFC, 0xC7, 0xC3,
  0xC3, 0xC3, 0xFF, 0xFE, 0x18, 0x7E, 0x67, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC3, 0xE3, 0x7F, 0x3E, 0xFE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x7E, 0x67, 0xC3, 0xC0, 0xC0, 0xCF,
  0xCF, 0xC3, 0xC3, 0xE3, 0x7F, 0x3E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x63, 0xFF, 0xF0, 0x1F, 0x1F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xC3, 0xC7, 0xFE, 0x7C, 0xC3, 0xE3, 0xB1, 0x99, 0xCC, 0xC7, 0xE3,
  0xF1, 0x9C, 0xC6, 0x63, 0xB0, 0xD8, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xE7, 0xE7, 0xE5, 0xF7, 0xDF, 0xDB,
  0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB,
  0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0xC7, 0x18, 0x7E, 0x67, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7E, 0x3E, 0xFE, 0x7F, 0xB0, 0xD8, 0x7C,
  0x37, 0xFB, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x18, 0x7E, 0xE7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3E, 0x0E, 0x06,
  0x03, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0xCC, 0xC6, 0xC6, 0xC7,
  0xC3, 0x18, 0x7E, 0xE7, 0xC3, 0xC0, 0x70, 0x7E, 0x1F, 0x03, 0x03, 0xC3,
  0xFF, 0x7E, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3,
  0x7E, 0x3E, 0xC3, 0xE1, 0xB0, 0xCC, 0x66, 0x63, 0x31, 0x98, 0x6C, 0x3C,
  0x1E, 0x0F, 0x03, 0x80, 0xCC, 0xF3, 0x34, 0xCD, 0x32, 0x6E, 0x9A, 0xA7,
  0xA9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71, 0xCC, 0xC3, 0xB0, 0x78,
  0x1E, 0x03, 0x01, 0xE0, 0x78, 0x3B, 0x0C, 0xC7, 0x1B, 0x87, 0xE1, 0xD8,
  0x63, 0x30, 0xCC, 0x1F, 0x07, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xFF,
  0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0,
  0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x06,
  0x06, 0x07, 0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F,
  0xFF, 0x1C, 0x3C, 0x34, 0x66, 0x66, 0xC3, 0xFF, 0xFF, 0xE7, 0x08, 0x7E,
  0x67, 0x83, 0x1F, 0x7F, 0xC3, 0xC3, 0xEF, 0x7B, 0xC0, 0xC0, 0xC8, 0xDE,
  0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0xDE, 0x08, 0x7E, 0x67, 0xC3,
  0xC0, 0xC0, 0xC0, 0xE3, 0x7F, 0x3E, 0x03, 0x03, 0x13, 0x7B, 0xE7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x7B, 0x08, 0x7E, 0x67, 0xC3, 0xCF, 0xFF,
  0xC0, 0xC0, 0x7F, 0x3E, 0x1F, 0x18, 0x38, 0x38, 0xFF, 0xFF, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x10, 0x7B, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7,
  0x7B, 0x03, 0x03, 0x3F, 0x3E, 0xC0, 0xC0, 0xC8, 0xDE, 0xE7, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x1C, 0x1C, 0x00, 0x00, 0x7C, 0x7C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0xFF, 0xFF, 0x0E, 0x1C, 0x00, 0x07, 0xEF, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xFF, 0x7C, 0xC0, 0x60, 0x30, 0x38,
  0x6C, 0x66, 0x73, 0xF1, 0xF8, 0xCE, 0x63, 0x31, 0xD8, 0x70, 0xFC, 0x3F,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xFC,
  0x1F, 0x12, 0xFF, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0x08,
  0xDE, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x08, 0x7E, 0x67,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7E, 0x3E, 0x08, 0xDE, 0xE7, 0xE3, 0xC3,
  0xC3, 0xC3, 0xE3, 0xFF, 0xDE, 0xC0, 0xC0, 0xC0, 0x10, 0x7B, 0xE7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x7B, 0x03, 0x03, 0x03, 0x09, 0xFF, 0x3E,
  0x3C, 0x78, 0x30, 0x60, 0xC1, 0x80, 0x08, 0x7E, 0xE3, 0xC0, 0x78, 0x3F,
  0x03, 0xC3, 0xFF, 0x7E, 0x30, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x1F, 0x1F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7E,
  0x3C, 0xC3, 0xE1, 0x99, 0xCC, 0xC6, 0x61, 0xB0, 0xF0, 0x78, 0x1C, 0x00,
  0xCC, 0xD3, 0x34, 0xC9, 0xBA, 0x6B, 0x9C, 0xE7, 0x38, 0xCE, 0x33, 0x00,
  0xE7, 0x33, 0x0F, 0x07, 0x81, 0xC1, 0xE1, 0xD8, 0xCE, 0xC3, 0x80, 0xC3,
  0xF1, 0x99, 0xCC, 0xC3, 0x61, 0xE0, 0xF0, 0x38, 0x18, 0x0C, 0x0E, 0x06,
  0x00, 0xFF, 0xFF, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x07, 0x0F,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0xF8, 0xF8, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x38, 0x38, 0x38, 0x30,
  0x38, 0x1F, 0x1F, 0x38, 0x30, 0x38, 0x38, 0x38, 0xF0, 0xE0, 0x71, 0xF9,
  0xDF, 0xCF,
};

const GFXglyph JetBrainsMono_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 4, -12 },
  { 6, 6, 5, 10, 2, -12 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 8, 17, 10, 1, -15 },
  { 42, 10, 13, 10, 0, -13 },
  { 59, 9, 13, 10, 1, -13 },
  { 74, 2, 5, 10, 4, -12 },
  { 76, 5, 16, 10, 3, -14 },
  { 86, 5, 16, 10, 2, -14 },
  { 96, 9, 9, 10, 1, -10 },
  { 107, 8, 8, 10, 1, -10 },
  { 115, 4, 6, 10, 3, -3 },
  { 118, 6, 2, 10, 2, -7 },
  { 120, 4, 3, 10, 3, -3 },
  { 122, 8, 16, 10, 1, -14 },
  { 138, 8, 13, 10, 1, -13 },
  { 151, 8, 12, 10, 1, -12 },
  { 163, 8, 13, 10, 1, -13 },
  { 176, 8, 12, 10, 1, -12 },
  { 188, 8, 12, 10, 1, -12 },
  { 200, 8, 12, 10, 1, -12 },
  { 212, 8, 12, 10, 1, -12 },
  { 224, 8, 12, 10, 1, -12 },
  { 236, 8, 13, 10, 1, -13 },
  { 249, 8, 13, 10, 1, -13 },
  { 262, 3, 10, 10, 4, -10 },
  { 266, 4, 13, 10, 3, -10 },
  { 273, 8, 9, 10, 1, -10 },
  { 282, 8, 6, 10, 1, -9 },
  { 288, 8, 9, 10, 1, -10 },
  { 297, 7, 12, 10, 2, -12 },
  { 308, 9, 16, 10, 1, -13 },
  { 326, 9, 12, 10, 1, -12 },
  { 340, 8, 12, 10, 1, -12 },
  { 352, 8, 13, 10, 1, -13 },
  { 365, 8, 12, 10, 1, -12 },
  { 377, 8, 12, 10, 1, -12 },
  { 389, 8, 12, 10, 1, -12 },
  { 401, 8, 13, 10, 1, -13 },
  { 414, 8, 12, 10, 1, -12 },
  { 426, 7, 12, 10, 2, -12 },
  { 437, 8, 12, 10, 1, -12 },
  { 449, 9, 12, 10, 1, -12 },
  { 463, 7, 12, 10, 2, -12 },
  { 474, 8, 12, 10, 1, -12 },
  { 486, 8, 12, 10, 1, -12 },
  { 498, 8, 13, 10, 1, -13 },
  { 511, 9, 12, 10, 1, -12 },
  { 525, 8, 16, 10, 1, -13 },
  { 541, 8, 12, 10, 1, -12 },
  { 553, 8, 13, 10, 1, -13 },
  { 566, 8, 12, 10, 1, -12 },
  { 578, 8, 12, 10, 1, -12 },
  { 590, 9, 12, 10, 1, -12 },
  { 604, 10, 12, 10, 0, -12 },
  { 619, 10, 12, 10, 0, -12 },
  { 634, 10, 12, 10, 0, -12 },
  { 649, 8, 12, 10, 1, -12 },
  { 661, 5, 16, 10, 3, -14 },
  { 671, 8, 16, 10, 1, -14 },
  { 687, 5, 16, 10, 2, -14 },
  { 697, 8, 6, 10, 1, -12 },
  { 703, 8, 2, 10, 1, 0 },
  { 705, 4, 2, 10, 3, -13 },
  { 706, 8, 10, 10, 1, -10 },
  { 716, 8, 12, 10, 1, -12 },
  { 728, 8, 10, 10, 1, -10 },
  { 738, 8, 12, 10, 1, -12 },
  { 750, 8, 10, 10, 1, -10 },
  { 760, 8, 12, 10, 1, -12 },
  { 772, 8, 13, 10, 1, -10 },
  { 785, 8, 12, 10, 1, -12 },
  { 797, 8, 13, 10, 1, -13 },
  { 810, 7, 16, 10, 1, -13 },
  { 824, 9, 12, 10, 1, -12 },
  { 838, 10, 12, 10, 0, -12 },
  { 853, 8, 10, 10, 1, -10 },
  { 863, 8, 10, 10, 1, -10 },
  { 873, 8, 10, 10, 1, -10 },
  { 883, 8, 13, 10, 1, -10 },
  { 896, 8, 13, 10, 1, -10 },
  { 909, 7, 10, 10, 2, -10 },
  { 918, 8, 10, 10, 1, -10 },
  { 928, 8, 12, 10, 1, -12 },
  { 940, 8, 9, 10, 1, -9 },
  { 949, 9, 9, 10, 1, -9 },
  { 960, 10, 9, 10, 0, -9 },
  { 972, 9, 9, 10, 1, -9 },
  { 983, 9, 12, 10, 1, -9 },
  { 997, 8, 9, 10, 1, -9 },
  { 1006, 8, 16, 10, 1, -14 },
  { 1022, 2, 16, 10, 4, -14 },
  { 1026, 8, 16, 10, 1, -14 },
  { 1042, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_Bold17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_BOLD17PT7B_H_
