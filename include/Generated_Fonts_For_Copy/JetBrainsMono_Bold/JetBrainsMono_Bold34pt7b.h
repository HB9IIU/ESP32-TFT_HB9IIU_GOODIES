#ifndef _JETBRAINSMONO_BOLD34PT7B_H_
#define _JETBRAINSMONO_BOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold34pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x8E, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x78, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x03,
  0x83, 0x80, 0x70, 0x70, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E,
  0x0E, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE1, 0xC1, 0xC0, 0x38,
  0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x3C, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x0E, 0x1C, 0x03, 0x83,
  0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x79, 0x9F, 0x79, 0x8F, 0xF9, 0x8F, 0xF9,
  0x80, 0x79, 0x80, 0x7D, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x01, 0x9F, 0x01, 0x8F, 0x01, 0x8F, 0xF1, 0x8F, 0xF1,
  0x8F, 0xF9, 0x9F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x79,
  0xFC, 0x07, 0x9F, 0xF0, 0x39, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x1C, 0x1E, 0x39, 0xC0, 0x7B, 0xCE, 0x03, 0xFE, 0xE0, 0x0F,
  0xCE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x3F,
  0x00, 0x3B, 0xFC, 0x03, 0xBE, 0xF0, 0x39, 0xC3, 0x83, 0xCE, 0x1C, 0x1C,
  0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x1C, 0x38, 0xE0, 0xFF, 0xCE, 0x03, 0xFC,
  0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBF,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x87,
  0x9E, 0x79, 0xE7, 0xCF, 0xBC, 0xF8, 0xFF, 0x1F, 0x0F, 0xE3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xBC,
  0x1F, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x30, 0x3C,
  0x3F, 0x1F, 0xCF, 0xC3, 0xE1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7C, 0x0F,
  0x00, 0x40, 0x80, 0x1C, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x3E, 0x0F, 0x87, 0xF1, 0xFC, 0x3F, 0x07, 0x80, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x1C,
  0x38, 0x67, 0xCC, 0x7F, 0xFB, 0x7F, 0x7F, 0xFF, 0xC3, 0xFF, 0x00, 0x1E,
  0x00, 0x0E, 0xC0, 0x07, 0xB8, 0x03, 0xCF, 0x01, 0xF1, 0xE0, 0xF8, 0x7C,
  0x1E, 0x0E, 0x01, 0x01, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x1F, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x78, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF1, 0x8F,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7E, 0x7E, 0x3F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE0, 0xF3, 0xE0, 0xE3, 0xE0, 0xC3, 0xE0, 0x83, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7C, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x1F, 0x7C, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7B, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0x7E, 0x3E, 0x78, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7E, 0x7E, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x7E, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xFB, 0xE0, 0x7D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x81, 0xF3, 0xF1,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xE0,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7E, 0x7C, 0x1F,
  0x78, 0x1F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7E, 0x3F, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xEF,
  0xCF, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8,
  0x07, 0xBE, 0x03, 0xCF, 0x83, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x7B, 0xFF,
  0xFF, 0x7C, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF7,
  0xC0, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78,
  0xF0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x07, 0xF0, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xF0, 0x7F,
  0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00,
  0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC8, 0x7E, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xF8, 0x3E, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x39, 0xFC, 0x3F, 0x7F, 0x1F, 0xFF, 0xC7, 0x8F, 0xF1, 0xC1, 0xFC, 0x70,
  0x7F, 0x1C, 0x1F, 0xC7, 0x07, 0xF1, 0xC1, 0xFC, 0x70, 0x7F, 0x1C, 0x1F,
  0xC7, 0x87, 0xF1, 0xF7, 0xFC, 0x3F, 0xFF, 0x07, 0xDF, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xF0, 0x78, 0x3C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x1E,
  0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x7D, 0xE0, 0x0F, 0xF8, 0x03, 0xC0,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1F,
  0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7F, 0x7E, 0x3F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F,
  0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7E, 0x7E, 0x3F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xF0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0x7E, 0x7F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x7C,
  0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0x71, 0xFF, 0xB8, 0xDF, 0xDC, 0xEF, 0xE6, 0x77, 0xFB, 0xBB, 0xFD, 0xF9,
  0xFE, 0xFC, 0xFF, 0x3E, 0x7F, 0x9E, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F, 0xF7,
  0x8F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1,
  0xEF, 0xF0, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0x07, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78,
  0x1F, 0x78, 0x1F, 0x7F, 0x7E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xF7,
  0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x03,
  0xDF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8,
  0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xE7, 0x81, 0xF3, 0xFB, 0xF0,
  0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0,
  0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0x07, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x78, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0x7F, 0x7F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E,
  0x7E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF8, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x7D, 0xE0, 0x1E, 0x7C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xF0,
  0x3C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xE1, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF8,
  0xF0, 0xFF, 0x1F, 0x1D, 0xE3, 0xE3, 0xBC, 0x6C, 0x77, 0x8D, 0x8E, 0xF3,
  0xB3, 0xCE, 0x76, 0x79, 0xCE, 0xCF, 0x39, 0x99, 0xE7, 0x33, 0x3C, 0xE6,
  0x67, 0x1C, 0xCE, 0xE3, 0xD9, 0xDC, 0x7B, 0x1B, 0x8F, 0xE3, 0x71, 0xFC,
  0x6E, 0x1F, 0x0D, 0xC3, 0xE1, 0xB8, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x00, 0xF8, 0x07, 0xDF, 0x01, 0xE3, 0xC0, 0xF8, 0xF8,
  0x3C, 0x1E, 0x1F, 0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x3E, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0x78,
  0x7C, 0x3E, 0x1F, 0x0F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x1F, 0xF8, 0x07,
  0xC0, 0xF0, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0,
  0xF8, 0x7C, 0x1E, 0x07, 0x87, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x01, 0xE7,
  0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x38,
  0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7E, 0x7C, 0x1F, 0x78, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xEF, 0x7F, 0xEF, 0x3F,
  0xCF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0xF8, 0x7B, 0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xE0, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x83, 0xFF, 0x9F, 0xBF, 0xFF, 0x7B, 0xFC, 0xF3, 0xF0,
  0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1F, 0x78, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x0F, 0x78, 0x1F, 0x7E, 0x7E, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x0F, 0x8F, 0x3F, 0xCF, 0x3F, 0xEF, 0x7F, 0xEF, 0x7C, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7E, 0x7F, 0x7F, 0xEF,
  0x3F, 0xEF, 0x1F, 0xCF, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x3E,
  0x78, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x7C, 0x3E,
  0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x8F, 0x1F, 0xEF,
  0x3F, 0xEF, 0x7F, 0xEF, 0x7C, 0x3F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F,
  0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x07, 0x8F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x7E, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8, 0x7B,
  0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x01, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xE7, 0x1E, 0x77, 0xDF,
  0xBF, 0xEF, 0xDE, 0x78, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3,
  0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0x71, 0xFE, 0x38, 0xFF, 0x1C, 0x7F,
  0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0x71,
  0xE0, 0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x83, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x78, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7F, 0x7E, 0x3F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xF0, 0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x83,
  0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x7E, 0xFF, 0xFD, 0xEF,
  0xF3, 0xCF, 0xC7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x0F, 0x8F, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xEF, 0x7C, 0x3F,
  0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7E, 0x7F, 0x7F, 0xEF,
  0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0xF1, 0xF0, 0xF7, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7E, 0x7F, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x0F,
  0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xF8, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xFE, 0x0F, 0x7E, 0x7E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0xF8,
  0x03, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03,
  0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xE0, 0xE1, 0xFC, 0x3C, 0x3F, 0xC7,
  0x87, 0x78, 0xF0, 0xEF, 0x1E, 0x1D, 0xE3, 0xE3, 0x9C, 0x6C, 0xF3, 0x9D,
  0x9E, 0x73, 0x33, 0x8E, 0x66, 0x71, 0xEC, 0xCE, 0x3D, 0x9D, 0xC3, 0xB3,
  0xB8, 0x76, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x00, 0x7C, 0x07, 0xDF, 0x03, 0xE3, 0xE0, 0xF0, 0x78,
  0x7C, 0x0F, 0x3E, 0x03, 0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xEF, 0x01,
  0xF1, 0xE0, 0x78, 0x7C, 0x3E, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0x7C, 0xF8,
  0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x83,
  0xC1, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xFB, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x3F, 0xF0,
  0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x3F, 0x83, 0xFF, 0xE1, 0xFE, 0xF8, 0xFE, 0x3E, 0xFF, 0x0F,
  0xFB, 0x83, 0xFC, 0x00, 0xF8,
};

const GFXglyph JetBrainsMono_Bold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 25, 20, 7, -25 },
  { 20, 12, 10, 20, 4, -25 },
  { 35, 19, 25, 20, 1, -25 },
  { 95, 16, 35, 20, 2, -30 },
  { 165, 21, 25, 20, 0, -25 },
  { 231, 19, 25, 20, 1, -25 },
  { 291, 4, 10, 20, 8, -25 },
  { 296, 10, 33, 20, 6, -29 },
  { 338, 11, 33, 20, 4, -29 },
  { 384, 18, 18, 20, 1, -21 },
  { 425, 16, 16, 20, 2, -19 },
  { 457, 8, 10, 20, 5, -5 },
  { 467, 11, 4, 20, 5, -13 },
  { 473, 6, 6, 20, 7, -6 },
  { 478, 16, 32, 20, 2, -28 },
  { 542, 16, 25, 20, 2, -25 },
  { 592, 16, 25, 20, 3, -25 },
  { 642, 16, 25, 20, 2, -25 },
  { 692, 16, 25, 20, 2, -25 },
  { 742, 16, 25, 20, 2, -25 },
  { 792, 16, 25, 20, 2, -25 },
  { 842, 17, 25, 20, 2, -25 },
  { 896, 17, 25, 20, 2, -25 },
  { 950, 16, 25, 20, 2, -25 },
  { 1000, 17, 25, 20, 2, -25 },
  { 1054, 6, 19, 20, 7, -19 },
  { 1069, 8, 24, 20, 5, -19 },
  { 1093, 15, 19, 20, 3, -21 },
  { 1129, 15, 12, 20, 3, -17 },
  { 1152, 15, 19, 20, 3, -21 },
  { 1188, 13, 25, 20, 4, -25 },
  { 1229, 18, 31, 20, 1, -25 },
  { 1299, 18, 25, 20, 1, -25 },
  { 1356, 16, 25, 20, 3, -25 },
  { 1406, 16, 25, 20, 2, -25 },
  { 1456, 15, 25, 20, 3, -25 },
  { 1503, 15, 25, 20, 3, -25 },
  { 1550, 15, 25, 20, 3, -25 },
  { 1597, 16, 25, 20, 2, -25 },
  { 1647, 15, 25, 20, 3, -25 },
  { 1694, 14, 25, 20, 3, -25 },
  { 1738, 16, 25, 20, 1, -25 },
  { 1788, 16, 25, 20, 3, -25 },
  { 1838, 15, 25, 20, 3, -25 },
  { 1885, 17, 25, 20, 2, -25 },
  { 1939, 16, 25, 20, 2, -25 },
  { 1989, 16, 25, 20, 2, -25 },
  { 2039, 16, 25, 20, 3, -25 },
  { 2089, 17, 31, 20, 2, -25 },
  { 2155, 16, 25, 20, 3, -25 },
  { 2205, 16, 25, 20, 2, -25 },
  { 2255, 17, 25, 20, 2, -25 },
  { 2309, 16, 25, 20, 2, -25 },
  { 2359, 18, 25, 20, 1, -25 },
  { 2416, 19, 25, 20, 1, -25 },
  { 2476, 18, 25, 20, 1, -25 },
  { 2533, 19, 25, 20, 1, -25 },
  { 2593, 15, 25, 20, 3, -25 },
  { 2640, 10, 32, 20, 6, -28 },
  { 2680, 16, 32, 20, 2, -28 },
  { 2744, 9, 32, 20, 5, -28 },
  { 2780, 16, 13, 20, 2, -25 },
  { 2806, 16, 4, 20, 2, 1 },
  { 2814, 8, 5, 20, 6, -27 },
  { 2819, 16, 19, 20, 2, -19 },
  { 2857, 15, 25, 20, 3, -25 },
  { 2904, 16, 19, 20, 2, -19 },
  { 2942, 16, 25, 20, 2, -25 },
  { 2992, 16, 19, 20, 2, -19 },
  { 3030, 16, 25, 20, 2, -25 },
  { 3080, 16, 25, 20, 2, -19 },
  { 3130, 15, 25, 20, 3, -25 },
  { 3177, 16, 27, 20, 3, -27 },
  { 3231, 13, 33, 20, 3, -27 },
  { 3285, 16, 25, 20, 3, -25 },
  { 3335, 18, 25, 20, 1, -25 },
  { 3392, 17, 19, 20, 2, -19 },
  { 3433, 15, 19, 20, 3, -19 },
  { 3469, 16, 19, 20, 2, -19 },
  { 3507, 15, 25, 20, 3, -19 },
  { 3554, 16, 25, 20, 2, -19 },
  { 3604, 16, 19, 20, 3, -19 },
  { 3642, 16, 19, 20, 2, -19 },
  { 3680, 17, 24, 20, 1, -24 },
  { 3731, 15, 19, 20, 3, -19 },
  { 3767, 18, 19, 20, 1, -19 },
  { 3810, 19, 19, 20, 1, -19 },
  { 3856, 18, 19, 20, 1, -19 },
  { 3899, 18, 25, 20, 1, -19 },
  { 3956, 15, 19, 20, 3, -19 },
  { 3992, 15, 32, 20, 3, -28 },
  { 4052, 4, 32, 20, 8, -28 },
  { 4068, 15, 32, 20, 3, -28 },
  { 4128, 17, 8, 20, 2, -16 },
};

const GFXfont JetBrainsMono_Bold34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_BOLD34PT7B_H_
