#ifndef _JETBRAINSMONO_BOLD7PT7B_H_
#define _JETBRAINSMONO_BOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x5F, 0x6F, 0xA0, 0x27, 0xA6, 0xB6, 0x20, 0xDE, 0x27,
  0xB0, 0x64, 0xDA, 0xF0, 0xC0, 0x5A, 0x94, 0x95, 0x58, 0x2F, 0x70, 0x2F,
  0x20, 0xE0, 0xC0, 0xC0, 0x12, 0x22, 0x44, 0x80, 0x69, 0xB9, 0x60, 0xD9,
  0x2E, 0x69, 0x24, 0x70, 0x72, 0x79, 0x60, 0x24, 0x5F, 0x10, 0x74, 0x79,
  0x60, 0x24, 0x79, 0x60, 0xF1, 0x22, 0x40, 0x65, 0x69, 0x60, 0x79, 0x72,
  0x40, 0xC3, 0xC3, 0x80, 0x73, 0x10, 0xE3, 0x80, 0x8F, 0x40, 0xC7, 0x08,
  0x7B, 0xDD, 0xB6, 0x66, 0x67, 0x90, 0xF7, 0x5C, 0x78, 0x88, 0x70, 0xD6,
  0xDC, 0xF3, 0x4E, 0xF3, 0xC8, 0x78, 0xB9, 0x60, 0xB7, 0xDA, 0xE9, 0x2E,
  0x71, 0x19, 0x60, 0xBB, 0x6A, 0x92, 0x4E, 0xDF, 0xB9, 0x90, 0xDD, 0xBB,
  0xB0, 0x69, 0x99, 0x60, 0xF7, 0xC8, 0x69, 0x99, 0x63, 0xF7, 0x6A, 0x78,
  0x69, 0x60, 0xF2, 0x22, 0x20, 0x99, 0x99, 0x60, 0x95, 0x66, 0x60, 0xBB,
  0xFF, 0x50, 0xD6, 0x26, 0x90, 0x96, 0x62, 0x20, 0xE9, 0x4E, 0xEA, 0xAC,
  0x84, 0x42, 0x22, 0x10, 0xD5, 0x5C, 0x66, 0x90, 0xF0, 0xC0, 0x63, 0xD7,
  0x9A, 0xDC, 0x69, 0x87, 0x17, 0x99, 0x70, 0x69, 0xE7, 0x3F, 0x44, 0x40,
  0x79, 0x97, 0x70, 0x9A, 0xDA, 0x4B, 0x25, 0xC0, 0x5D, 0x5C, 0x97, 0x6A,
  0xC4, 0x44, 0x30, 0xFB, 0xBB, 0xD6, 0xD0, 0x69, 0x96, 0xD6, 0xE8, 0x79,
  0x97, 0x10, 0xF6, 0x40, 0x74, 0x3F, 0x4F, 0x44, 0x30, 0xB6, 0xE0, 0x95,
  0x66, 0xBB, 0x77, 0xD6, 0x6D, 0x96, 0x62, 0x40, 0xEA, 0x70, 0x69, 0x44,
  0x98, 0xFE, 0x92, 0x39, 0x20, 0xF0,
};

const GFXglyph JetBrainsMono_Bold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 2, 7, 4, 1, -6 },
  { 19, 2, 7, 4, 1, -6 },
  { 21, 4, 3, 4, 0, -4 },
  { 23, 4, 3, 4, 0, -4 },
  { 25, 2, 2, 4, 1, -1 },
  { 26, 2, 1, 4, 1, -3 },
  { 27, 2, 1, 4, 1, -1 },
  { 28, 4, 7, 4, 0, -6 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 1, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 2, 4, 4, 1, -4 },
  { 62, 2, 5, 4, 1, -4 },
  { 64, 3, 4, 4, 1, -4 },
  { 66, 3, 3, 4, 1, -4 },
  { 68, 3, 4, 4, 1, -4 },
  { 70, 3, 5, 4, 1, -5 },
  { 72, 4, 6, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 3, 5, 4, 1, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 3, 5, 4, 1, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 3, 5, 4, 1, -5 },
  { 94, 3, 5, 4, 1, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 3, 5, 4, 1, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 3, 5, 4, 1, -5 },
  { 114, 4, 6, 4, 0, -5 },
  { 117, 3, 5, 4, 1, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 4, 5, 4, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 3, 5, 4, 1, -5 },
  { 142, 2, 7, 4, 1, -6 },
  { 144, 4, 7, 4, 0, -6 },
  { 148, 2, 7, 4, 1, -6 },
  { 150, 4, 3, 4, 0, -5 },
  { 152, 4, 1, 4, 0, 0 },
  { 153, 2, 1, 4, 1, -6 },
  { 154, 4, 4, 4, 0, -4 },
  { 156, 3, 5, 4, 1, -5 },
  { 158, 4, 4, 4, 0, -4 },
  { 160, 4, 5, 4, 0, -5 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 4, 5, 4, 0, -4 },
  { 171, 3, 5, 4, 1, -5 },
  { 173, 3, 6, 4, 1, -6 },
  { 176, 2, 7, 4, 1, -6 },
  { 178, 3, 5, 4, 1, -5 },
  { 180, 4, 5, 4, 0, -5 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 4, 4, 1, -4 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 3, 5, 4, 1, -4 },
  { 191, 4, 5, 4, 0, -4 },
  { 194, 3, 4, 4, 1, -4 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 4, 5, 4, 0, -5 },
  { 201, 3, 4, 4, 1, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 5, 4, 0, -4 },
  { 212, 3, 4, 4, 1, -4 },
  { 214, 3, 7, 4, 1, -6 },
  { 217, 1, 7, 4, 2, -6 },
  { 218, 3, 7, 4, 1, -6 },
  { 221, 4, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_Bold7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_BOLD7PT7B_H_
