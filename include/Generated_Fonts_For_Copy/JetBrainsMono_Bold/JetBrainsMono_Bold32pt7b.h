#ifndef _JETBRAINSMONO_BOLD32PT7B_H_
#define _JETBRAINSMONO_BOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xE0, 0x07, 0x07, 0x03, 0x83, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0x70, 0xE3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x87, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE1, 0xC3, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x1C, 0x1C, 0x0E, 0x0C, 0x07, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0x81, 0xC1, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x3C, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x79, 0xBF, 0xE3,
  0x3F, 0xC6, 0x7F, 0x8C, 0x0F, 0x98, 0x0F, 0xB0, 0x1F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x0D, 0xF0, 0x19, 0xE0, 0x33, 0xFC,
  0x67, 0xF8, 0xCF, 0xFD, 0xBE, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x07, 0xE0, 0x1D, 0xFE,
  0x07, 0x39, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x8E, 0x38, 0x73, 0x87, 0x0E,
  0x60, 0x73, 0x9C, 0x0F, 0xF7, 0x00, 0xFD, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x84, 0x00, 0x77, 0xE0, 0x1D, 0xFE, 0x07, 0x38, 0xE1, 0xCE,
  0x1C, 0x39, 0xC3, 0x8E, 0x38, 0x73, 0x83, 0x0E, 0x70, 0x7B, 0xDC, 0x0F,
  0xF7, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x83,
  0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x08, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x7B, 0xDE, 0x3F, 0xC7, 0xBD, 0xE3,
  0xDE, 0xF0, 0xFE, 0x78, 0x3F, 0x3C, 0x1F, 0x1E, 0x07, 0x87, 0x87, 0xE3,
  0xFF, 0xF8, 0xFF, 0xBC, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xB9, 0xCE, 0x70,
  0x00, 0x60, 0x3C, 0x1F, 0x87, 0xF1, 0xF8, 0x7C, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x18, 0x80, 0x38, 0x0F, 0x83, 0xF0,
  0x7E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x07, 0xC7, 0xE3, 0xF0, 0xF8, 0x38, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x8E, 0x1B, 0xE7,
  0x3F, 0xFD, 0x7F, 0x7F, 0xFF, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0xEE, 0x00,
  0xF7, 0x80, 0xF1, 0xE0, 0x78, 0xF8, 0x78, 0x3C, 0x0C, 0x08, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x1E, 0x78, 0xF1,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x33, 0xEF, 0xFF, 0xFB, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xCE, 0x7F, 0x9E, 0xFF, 0x7D, 0xFE, 0x73,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7,
  0xC7, 0xCF, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xFF,
  0x07, 0xDE, 0x0F, 0x3C, 0x1C, 0x78, 0x20, 0xF0, 0x41, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x83,
  0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0xC3, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC3, 0xDE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7B, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xE1, 0xF7,
  0x81, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0xFB, 0xE3, 0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xF1, 0xFF, 0xF7, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xE3, 0xF7, 0xFF,
  0xC7, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDF, 0x03,
  0xFC, 0x07, 0xB8, 0x0F, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x81,
  0xFF, 0x07, 0xFF, 0x1F, 0x1F, 0x3C, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xF7, 0xC7, 0xEF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x03, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE1, 0xF7, 0xFF, 0xE7, 0xFF,
  0x87, 0xDF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x73, 0xEF, 0xFE, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xBF, 0xFB, 0xE0, 0x1C, 0x3E, 0x3F,
  0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E,
  0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x00, 0x06, 0x00, 0x3C,
  0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0x80, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0x00, 0x0E, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0xFF,
  0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x3F,
  0xE3, 0xFC, 0x3F, 0x83, 0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xC3, 0xE7, 0x80, 0x7B, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x73, 0xF0, 0xFD, 0xF8, 0x7F, 0xFC, 0x78, 0xFE, 0x3C, 0x3F, 0x1E,
  0x1F, 0x8F, 0x0F, 0xC7, 0x87, 0xE3, 0xC3, 0xF1, 0xE1, 0xF8, 0xF0, 0xFC,
  0x3C, 0xFE, 0x1F, 0xFF, 0x07, 0xDF, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0E, 0x38, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE1, 0xC0, 0xE0, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF7, 0xC0, 0x3F, 0xC0, 0x1E,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x7B, 0xC0, 0xF7,
  0xC7, 0xEF, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0x83, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7B, 0xC0, 0xF7, 0xC7, 0xEF, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7B, 0xE3, 0xF7, 0xFF, 0xC7,
  0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xDF, 0xE1, 0xFF, 0xC7, 0xFD, 0x8F, 0xFB, 0x9B, 0xF7, 0x77, 0xE6, 0xEF,
  0xCD, 0x9F, 0x9F, 0x3F, 0x3E, 0x7E, 0x3C, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0x80, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0xC7, 0xFB, 0x8F, 0xF7, 0x1F, 0xEF, 0x3F, 0xCE, 0x7F,
  0x9C, 0xFF, 0x3D, 0xFE, 0x3B, 0xFC, 0x77, 0xF8, 0xFF, 0xF0, 0xEF, 0xE1,
  0xDF, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0x80, 0x03,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDF, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC1,
  0xF7, 0xC7, 0xCF, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC7, 0xCF, 0xFF, 0x8F,
  0xFE, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1F, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0xC7, 0xEF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0xFB, 0xE3,
  0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xF0, 0x07, 0xBC, 0x03, 0xDE,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0x71,
  0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xBC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0xE1, 0xC3, 0xF8, 0x78,
  0xFE, 0x1E, 0x3B, 0x8F, 0x8E, 0xE3, 0x63, 0xB8, 0xD8, 0xEF, 0x36, 0x3B,
  0xCD, 0x8E, 0xF3, 0x67, 0x9C, 0xD9, 0xE7, 0x37, 0x79, 0xCC, 0xDC, 0x77,
  0x37, 0x1D, 0x8D, 0xC7, 0x63, 0x71, 0xD8, 0xDC, 0x76, 0x37, 0x1D, 0x8D,
  0xC7, 0xE3, 0x70, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0x87, 0x83, 0xC1, 0xE0,
  0xF8, 0x0F, 0xBE, 0x07, 0x8F, 0x07, 0x87, 0xC3, 0xC1, 0xE3, 0xC0, 0xF9,
  0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x3C,
  0x0F, 0x1E, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0,
  0x1E, 0xF0, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1,
  0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x77, 0x00,
  0xEF, 0x03, 0xCE, 0x07, 0x1E, 0x1E, 0x3C, 0x38, 0x38, 0xF0, 0x79, 0xE0,
  0x77, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3C, 0x3E,
  0x1F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF3, 0xE7, 0x83, 0xEF, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x3F, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0x7F, 0xDE, 0x7F, 0x3C, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x3C, 0x3D, 0xFE,
  0x7B, 0xFE, 0xFF, 0xFD, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xEF, 0x7F, 0xDE, 0xFF, 0x3C, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0x83, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x01, 0xFF, 0x03, 0xDF, 0x1F, 0xBF,
  0xFE, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE1, 0xE3, 0xCF, 0xF7, 0xBF, 0xEF, 0x7F, 0xFF, 0xF0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0xFB, 0xE3, 0xF7, 0xFF, 0xE7, 0xFB, 0xC7, 0xE7,
  0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x03, 0xDE, 0x0F, 0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xE0, 0x01,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x1E, 0x7F, 0xBD, 0xFF,
  0x7B, 0xFF, 0xF7, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x83, 0xEF, 0xDF, 0xDF, 0xF7, 0x9F,
  0xEF, 0x0F, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFE, 0x0F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x3C, 0x3D, 0xFE, 0x7B, 0xFE, 0xFF, 0xFD, 0xF0, 0x7F, 0xE0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFC,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x03,
  0xFC, 0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xE1, 0xF3, 0xC7, 0xC7, 0x8F, 0x0F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3,
  0xE7, 0x83, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0xEE, 0x3C,
  0xFF, 0x7E, 0xFF, 0xFE, 0xE3, 0x8E, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F,
  0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F,
  0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xF1, 0xE1,
  0xEF, 0xF3, 0xDF, 0xF7, 0xFF, 0xEF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xDF, 0x1F,
  0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0xF1, 0xE1, 0xEF, 0xF3, 0xDF, 0xF7,
  0xFF, 0xEF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x1F, 0x7B, 0xFE,
  0xF7, 0xF9, 0xE7, 0xE3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x0F, 0x1E, 0x7F, 0xBD, 0xFF, 0x7B, 0xFF, 0xF7, 0x83,
  0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0x07, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xDE, 0x3F,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xF7, 0xEF, 0x83, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0xE0,
  0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xF7, 0x81, 0xEF, 0x00, 0x1E, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xFE, 0x03,
  0xFE, 0x0F, 0xBF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xEF, 0x07, 0xDF, 0x1F, 0x1F, 0xFE,
  0x3F, 0xF8, 0x1F, 0xC0, 0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01,
  0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F,
  0x1E, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x3B, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xE1, 0xC3, 0xF8, 0x70, 0xEE,
  0x1C, 0x3B, 0x87, 0x8E, 0xF3, 0x63, 0xBC, 0xD8, 0xE7, 0x36, 0x79, 0xCD,
  0x9C, 0x73, 0x67, 0x1C, 0xDD, 0xC7, 0x33, 0x71, 0xD8, 0xDC, 0x7E, 0x37,
  0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0x80,
  0x78, 0x0F, 0xBE, 0x0F, 0x8F, 0x07, 0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0xF7, 0x80, 0xF9, 0xE0, 0x78, 0xF8, 0x78, 0x3C, 0x7C, 0x0F,
  0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x81, 0xE3,
  0xC1, 0xF1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1F, 0x3C, 0x07, 0x9E,
  0x03, 0xDE, 0x00, 0xEF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0x80, 0x3F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0xFF, 0x0F, 0xFC, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x0C, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0x0F, 0xFF, 0x8F, 0xE7, 0x8F, 0xE3, 0xFE, 0xE1, 0xFE, 0xE0, 0xFC,
};

const GFXglyph JetBrainsMono_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 11, 9, 19, 4, -23 },
  { 29, 17, 23, 19, 1, -23 },
  { 78, 15, 32, 19, 2, -28 },
  { 138, 19, 24, 19, 0, -24 },
  { 195, 17, 24, 19, 1, -24 },
  { 246, 5, 9, 19, 7, -23 },
  { 252, 11, 31, 19, 5, -27 },
  { 295, 10, 31, 19, 4, -27 },
  { 334, 17, 17, 19, 1, -20 },
  { 371, 15, 15, 19, 2, -18 },
  { 400, 7, 10, 19, 5, -5 },
  { 409, 11, 3, 19, 4, -12 },
  { 414, 6, 6, 19, 7, -6 },
  { 419, 15, 31, 19, 2, -27 },
  { 478, 15, 24, 19, 2, -24 },
  { 523, 15, 23, 19, 3, -23 },
  { 567, 15, 24, 19, 2, -24 },
  { 612, 15, 23, 19, 2, -23 },
  { 656, 14, 23, 19, 2, -23 },
  { 697, 15, 23, 19, 2, -23 },
  { 741, 15, 23, 19, 2, -23 },
  { 785, 15, 23, 19, 2, -23 },
  { 829, 15, 24, 19, 2, -24 },
  { 874, 15, 24, 19, 2, -24 },
  { 919, 6, 18, 19, 7, -18 },
  { 933, 8, 23, 19, 5, -18 },
  { 956, 15, 17, 19, 2, -19 },
  { 988, 14, 11, 19, 3, -16 },
  { 1008, 15, 17, 19, 2, -19 },
  { 1040, 12, 23, 19, 4, -23 },
  { 1075, 17, 30, 19, 1, -24 },
  { 1139, 17, 23, 19, 1, -23 },
  { 1188, 16, 23, 19, 2, -23 },
  { 1234, 15, 24, 19, 2, -24 },
  { 1279, 15, 23, 19, 2, -23 },
  { 1323, 14, 23, 19, 3, -23 },
  { 1364, 14, 23, 19, 3, -23 },
  { 1405, 15, 24, 19, 2, -24 },
  { 1450, 15, 23, 19, 2, -23 },
  { 1494, 13, 23, 19, 3, -23 },
  { 1532, 15, 23, 19, 1, -23 },
  { 1576, 16, 23, 19, 2, -23 },
  { 1622, 14, 23, 19, 3, -23 },
  { 1663, 15, 23, 19, 2, -23 },
  { 1707, 15, 23, 19, 2, -23 },
  { 1751, 15, 24, 19, 2, -24 },
  { 1796, 16, 23, 19, 2, -23 },
  { 1842, 15, 30, 19, 2, -24 },
  { 1899, 16, 23, 19, 2, -23 },
  { 1945, 15, 24, 19, 2, -24 },
  { 1990, 17, 23, 19, 1, -23 },
  { 2039, 15, 23, 19, 2, -23 },
  { 2083, 17, 23, 19, 1, -23 },
  { 2132, 18, 23, 19, 1, -23 },
  { 2184, 17, 23, 19, 1, -23 },
  { 2233, 17, 23, 19, 1, -23 },
  { 2282, 14, 23, 19, 3, -23 },
  { 2323, 9, 31, 19, 6, -27 },
  { 2358, 15, 31, 19, 2, -27 },
  { 2417, 9, 31, 19, 4, -27 },
  { 2452, 15, 12, 19, 2, -23 },
  { 2475, 15, 3, 19, 2, 1 },
  { 2481, 8, 4, 19, 5, -25 },
  { 2485, 15, 18, 19, 2, -18 },
  { 2519, 15, 23, 19, 2, -23 },
  { 2563, 15, 18, 19, 2, -18 },
  { 2597, 15, 23, 19, 2, -23 },
  { 2641, 15, 18, 19, 2, -18 },
  { 2675, 15, 23, 19, 2, -23 },
  { 2719, 15, 24, 19, 2, -18 },
  { 2764, 15, 23, 19, 2, -23 },
  { 2808, 16, 25, 19, 2, -25 },
  { 2858, 12, 31, 19, 3, -25 },
  { 2905, 15, 23, 19, 3, -23 },
  { 2949, 17, 23, 19, 1, -23 },
  { 2998, 16, 18, 19, 2, -18 },
  { 3034, 15, 18, 19, 2, -18 },
  { 3068, 15, 18, 19, 2, -18 },
  { 3102, 15, 24, 19, 2, -18 },
  { 3147, 15, 24, 19, 2, -18 },
  { 3192, 15, 18, 19, 3, -18 },
  { 3226, 15, 18, 19, 2, -18 },
  { 3260, 16, 23, 19, 1, -23 },
  { 3306, 15, 18, 19, 2, -18 },
  { 3340, 17, 18, 19, 1, -18 },
  { 3379, 18, 18, 19, 1, -18 },
  { 3420, 17, 18, 19, 1, -18 },
  { 3459, 17, 24, 19, 1, -18 },
  { 3510, 15, 18, 19, 2, -18 },
  { 3544, 14, 31, 19, 3, -27 },
  { 3599, 4, 31, 19, 8, -27 },
  { 3615, 14, 31, 19, 3, -27 },
  { 3670, 16, 7, 19, 2, -15 },
};

const GFXfont JetBrainsMono_Bold32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_BOLD32PT7B_H_
