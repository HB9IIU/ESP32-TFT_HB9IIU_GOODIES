#ifndef _JETBRAINSMONO_BOLD18PT7B_H_
#define _JETBRAINSMONO_BOLD18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0x40, 0x7E, 0xEF, 0xDF, 0xB6, 0x6C, 0xC0, 0x08,
  0x86, 0x21, 0x99, 0xFF, 0x7F, 0xC4, 0x41, 0x10, 0xCC, 0xFF, 0xFF, 0xF2,
  0x30, 0x88, 0x66, 0x00, 0x08, 0x04, 0x02, 0x07, 0xC7, 0xF7, 0x5F, 0xA1,
  0xD0, 0x7C, 0x1F, 0x83, 0xC1, 0x7C, 0x9F, 0x5D, 0xFC, 0x7C, 0x08, 0x04,
  0x02, 0x00, 0x78, 0x79, 0x1B, 0x26, 0x64, 0x8F, 0xB0, 0xEC, 0x01, 0x00,
  0x5E, 0x1B, 0xC6, 0xCC, 0x99, 0xB3, 0x2C, 0x3C, 0x3E, 0x3F, 0x18, 0xCC,
  0x06, 0x03, 0x83, 0xE1, 0xB3, 0xCF, 0x63, 0xB1, 0xDF, 0xE7, 0x98, 0xFF,
  0xEC, 0x0C, 0xF7, 0x98, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xE1, 0x87,
  0x8F, 0x0C, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xC3, 0x0C, 0x30, 0xC7, 0x18,
  0xE7, 0x38, 0xC0, 0x18, 0x0C, 0x22, 0x3D, 0x7F, 0xF8, 0xC0, 0xD8, 0xEC,
  0x63, 0x00, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0xE0, 0x70, 0x38, 0x77,
  0x6E, 0xCC, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60,
  0x70, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0xE0, 0x00, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C, 0x3E, 0x5F, 0x7F, 0x97, 0xC3,
  0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0x1C, 0x3E, 0x3B, 0x19, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF7, 0xF8, 0x3E, 0x3F, 0xB8, 0xD8,
  0x60, 0x30, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0xFF, 0xF8, 0x7F,
  0x3F, 0x81, 0x81, 0x81, 0x80, 0xF0, 0x7C, 0x06, 0x03, 0xE1, 0xB8, 0xCF,
  0xE3, 0xE0, 0x07, 0x0E, 0x1C, 0x18, 0x38, 0x73, 0x63, 0xC3, 0xFF, 0xFF,
  0x03, 0x03, 0x03, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0xC3, 0xF9, 0x8C, 0x07,
  0x03, 0x81, 0xF8, 0xCF, 0xE3, 0xE0, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x03,
  0x73, 0xFD, 0xC7, 0xC1, 0xE0, 0xF8, 0xEF, 0xE3, 0xE0, 0xFF, 0xFF, 0xF0,
  0xF8, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x00,
  0x3E, 0x3F, 0xB8, 0xDC, 0x66, 0x33, 0xF0, 0xF8, 0xEE, 0xE3, 0x61, 0xF8,
  0xEF, 0xE3, 0xE0, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C, 0x1F, 0x1D, 0xFC, 0x76,
  0x06, 0x07, 0x03, 0x03, 0x03, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x77, 0x70,
  0x00, 0x07, 0x76, 0xEC, 0xC0, 0x01, 0x03, 0x1F, 0x7C, 0xE0, 0xE0, 0x78,
  0x1F, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78,
  0x1F, 0x07, 0x03, 0x1F, 0x7C, 0xF0, 0x80, 0xF9, 0xF8, 0x38, 0x30, 0x6F,
  0xDF, 0x30, 0x60, 0x00, 0x03, 0x87, 0x00, 0x3F, 0x31, 0xF0, 0x78, 0x38,
  0xFC, 0xFE, 0x67, 0x33, 0x99, 0xCC, 0xE7, 0x71, 0xDC, 0x06, 0x01, 0xE0,
  0x78, 0x1C, 0x0E, 0x0D, 0x86, 0xC3, 0x61, 0xB1, 0x9C, 0xC6, 0x7F, 0x3F,
  0xB8, 0xF8, 0x3C, 0x18, 0xFE, 0x7F, 0xB8, 0xDC, 0x7E, 0x37, 0xFB, 0xF9,
  0xC6, 0xE1, 0xF0, 0xF8, 0xFF, 0xEF, 0xE0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0xF8, 0xCF, 0xE3, 0xE0, 0xFE, 0x7F,
  0xB8, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xDF, 0xEF,
  0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0xFB, 0xFD, 0xFE, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x00, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x07, 0x03, 0xBF,
  0xDF, 0xE3, 0xF1, 0xF8, 0xCF, 0xE3, 0xE0, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xFF, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFC, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE7, 0xFF, 0xE0, 0x1F, 0x1F, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xC3, 0xFF, 0x7E, 0xE3, 0xF1, 0xB9,
  0xDC, 0xCE, 0xE7, 0xE3, 0xF1, 0xDC, 0xE6, 0x73, 0xB8, 0xDC, 0x7E, 0x18,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xE3, 0xF1, 0xF9, 0xFE, 0xFD, 0x5E, 0xAF, 0x77, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x18, 0xE3, 0xF9, 0xFC, 0xFA, 0x7D, 0xBE, 0xDF, 0x2F,
  0x9F, 0xCD, 0xE2, 0xF1, 0xF8, 0xFC, 0x38, 0x3E, 0x3F, 0xB8, 0xDC, 0x6E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xB8, 0xCF, 0xE3, 0xE0, 0xFE, 0x7F,
  0xB8, 0xFC, 0x3E, 0x1F, 0x1F, 0xFD, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x00, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF8, 0xCF, 0xE3, 0xE0, 0x30, 0x1C, 0x07, 0xFE, 0x7F, 0xB8, 0xFC, 0x3E,
  0x3F, 0x1B, 0xFD, 0xF8, 0xE6, 0x73, 0x39, 0xDC, 0x6E, 0x38, 0x3E, 0x3F,
  0xB8, 0xFC, 0x0E, 0x03, 0xE0, 0xFC, 0x1E, 0x03, 0xE0, 0xF8, 0xEF, 0xE3,
  0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xB8, 0xCF, 0xE3, 0xE0, 0xC1, 0xE0, 0xF8, 0xEC, 0x66,
  0x33, 0x19, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x03, 0x81, 0xC0, 0xCC, 0x79,
  0xD9, 0x2B, 0x35, 0x66, 0xAC, 0xD5, 0x9A, 0xB3, 0x56, 0x7A, 0xCF, 0x51,
  0xCE, 0x39, 0xC3, 0x18, 0x71, 0xCC, 0x63, 0xB8, 0x6C, 0x1F, 0x03, 0x80,
  0xE0, 0x78, 0x1B, 0x0E, 0xC3, 0x19, 0xC6, 0xE0, 0xC0, 0xE0, 0xDC, 0x73,
  0x18, 0xCE, 0x1B, 0x06, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x00, 0x7F, 0x7F, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0x70,
  0x60, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9F, 0xF8, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x1C, 0x0E, 0x0D,
  0x86, 0xC6, 0x33, 0x1B, 0x0E, 0xFF, 0xFF, 0xC0, 0xE7, 0x3E, 0x7F, 0xE3,
  0x03, 0x3F, 0xFF, 0xC3, 0xC3, 0xFF, 0x7F, 0xE0, 0x70, 0x38, 0x1F, 0xCF,
  0xF7, 0x1B, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xDF, 0xEF, 0xE0, 0x3E, 0x3F,
  0xB8, 0xDC, 0x7E, 0x07, 0x03, 0x81, 0xC7, 0x7F, 0x1F, 0x00, 0x03, 0x03,
  0x03, 0x3B, 0x7F, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x3B, 0x3E,
  0x3F, 0xB8, 0xD8, 0x7F, 0xFF, 0xFF, 0x01, 0xC6, 0x7F, 0x1F, 0x00, 0x0F,
  0x8F, 0xC6, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x3B, 0x7F, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x7F, 0x03,
  0x03, 0x3F, 0x3E, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x06, 0x07, 0x00, 0x00,
  0x7E, 0x7E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0xFE,
  0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x7E, 0x37, 0x3B, 0x99, 0xF8, 0xFE, 0x73,
  0x39, 0xDC, 0x6E, 0x38, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0x07, 0xC0, 0xFB, 0x7F, 0xF2,
  0x79, 0x3C, 0x9E, 0x4F, 0x27, 0x93, 0xC9, 0xE4, 0xC0, 0xFE, 0xFF, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3E, 0x3F, 0xB8, 0xDC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC6, 0x7F, 0x1F, 0x00, 0xFE, 0x7F, 0xB8, 0xDC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC6, 0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x00, 0x3B, 0x7F,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x3B, 0x03, 0x03, 0x03, 0xDE,
  0xFE, 0xC7, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x3F, 0xB8,
  0xEC, 0x07, 0xE0, 0xF8, 0x0F, 0x87, 0x7F, 0x3F, 0x80, 0x38, 0x1C, 0x0E,
  0x1F, 0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0xE0, 0xF0,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x3E, 0xC1, 0xE1,
  0xF8, 0xCC, 0x66, 0x73, 0xB0, 0xD8, 0x6C, 0x3C, 0x0E, 0x00, 0xCC, 0x53,
  0x36, 0xAD, 0xAB, 0x6A, 0xDA, 0xB6, 0xA9, 0xEA, 0x33, 0x8C, 0xE0, 0xE3,
  0xB3, 0x9D, 0x87, 0xC1, 0xC0, 0xE0, 0xF8, 0xEC, 0x63, 0x71, 0xC0, 0xC1,
  0xF1, 0xD8, 0xCC, 0x67, 0x71, 0xB0, 0xD8, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x03, 0x80, 0x7F, 0x7F, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xFF, 0xFF,
  0x07, 0x0F, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0xFC, 0xF0, 0xFC, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0xF8, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1F, 0x0F, 0x1F, 0x18, 0x18,
  0x18, 0x18, 0x38, 0xF8, 0xF0, 0xF9, 0xEC, 0xF3, 0xE0, 0xE0,
};

const GFXglyph JetBrainsMono_Bold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 7, 5, 11, 2, -13 },
  { 11, 10, 13, 11, 0, -13 },
  { 28, 9, 19, 11, 1, -16 },
  { 50, 11, 13, 11, 0, -13 },
  { 68, 9, 13, 11, 1, -13 },
  { 83, 3, 5, 11, 4, -13 },
  { 85, 6, 17, 11, 3, -15 },
  { 98, 6, 17, 11, 2, -15 },
  { 111, 9, 9, 11, 1, -11 },
  { 122, 9, 8, 11, 1, -10 },
  { 131, 4, 6, 11, 3, -3 },
  { 134, 5, 2, 11, 3, -7 },
  { 136, 3, 3, 11, 4, -3 },
  { 138, 9, 17, 11, 1, -15 },
  { 158, 9, 13, 11, 1, -13 },
  { 173, 9, 13, 11, 1, -13 },
  { 188, 9, 13, 11, 1, -13 },
  { 203, 9, 13, 11, 1, -13 },
  { 218, 8, 13, 11, 1, -13 },
  { 231, 9, 13, 11, 1, -13 },
  { 246, 9, 13, 11, 1, -13 },
  { 261, 9, 13, 11, 1, -13 },
  { 276, 9, 13, 11, 1, -13 },
  { 291, 9, 13, 11, 1, -13 },
  { 306, 3, 10, 11, 4, -10 },
  { 310, 4, 13, 11, 3, -10 },
  { 317, 8, 10, 11, 1, -11 },
  { 327, 8, 6, 11, 1, -9 },
  { 333, 8, 10, 11, 1, -11 },
  { 343, 7, 13, 11, 2, -13 },
  { 355, 9, 16, 11, 1, -13 },
  { 373, 9, 13, 11, 1, -13 },
  { 388, 9, 13, 11, 1, -13 },
  { 403, 9, 13, 11, 1, -13 },
  { 418, 9, 13, 11, 1, -13 },
  { 433, 7, 13, 11, 2, -13 },
  { 445, 9, 13, 11, 1, -13 },
  { 460, 9, 13, 11, 1, -13 },
  { 475, 8, 13, 11, 1, -13 },
  { 488, 7, 13, 11, 2, -13 },
  { 500, 8, 13, 11, 1, -13 },
  { 513, 9, 13, 11, 1, -13 },
  { 528, 8, 13, 11, 2, -13 },
  { 541, 9, 13, 11, 1, -13 },
  { 556, 9, 13, 11, 1, -13 },
  { 571, 9, 13, 11, 1, -13 },
  { 586, 9, 13, 11, 1, -13 },
  { 601, 9, 16, 11, 1, -13 },
  { 619, 9, 13, 11, 1, -13 },
  { 634, 9, 13, 11, 1, -13 },
  { 649, 9, 13, 11, 1, -13 },
  { 664, 9, 13, 11, 1, -13 },
  { 679, 9, 13, 11, 1, -13 },
  { 694, 11, 13, 11, 0, -13 },
  { 712, 10, 13, 11, 0, -13 },
  { 729, 10, 13, 11, 0, -13 },
  { 746, 8, 13, 11, 1, -13 },
  { 759, 5, 17, 11, 3, -15 },
  { 770, 9, 17, 11, 1, -15 },
  { 790, 5, 17, 11, 2, -15 },
  { 801, 9, 7, 11, 1, -13 },
  { 809, 9, 2, 11, 1, 0 },
  { 812, 4, 2, 11, 3, -14 },
  { 813, 8, 10, 11, 1, -10 },
  { 823, 9, 13, 11, 1, -13 },
  { 838, 9, 10, 11, 1, -10 },
  { 850, 8, 13, 11, 1, -13 },
  { 863, 9, 10, 11, 1, -10 },
  { 875, 9, 13, 11, 1, -13 },
  { 890, 8, 13, 11, 1, -10 },
  { 903, 8, 13, 11, 1, -13 },
  { 916, 9, 14, 11, 1, -14 },
  { 932, 8, 17, 11, 1, -14 },
  { 949, 9, 13, 11, 1, -13 },
  { 964, 10, 13, 11, 0, -13 },
  { 981, 9, 10, 11, 1, -10 },
  { 993, 8, 10, 11, 1, -10 },
  { 1003, 9, 10, 11, 1, -10 },
  { 1015, 9, 13, 11, 1, -10 },
  { 1030, 8, 13, 11, 1, -10 },
  { 1043, 8, 10, 11, 2, -10 },
  { 1053, 9, 10, 11, 1, -10 },
  { 1065, 9, 13, 11, 1, -13 },
  { 1080, 8, 10, 11, 1, -10 },
  { 1090, 9, 10, 11, 1, -10 },
  { 1102, 10, 10, 11, 0, -10 },
  { 1115, 9, 10, 11, 1, -10 },
  { 1127, 9, 13, 11, 1, -10 },
  { 1142, 8, 10, 11, 1, -10 },
  { 1152, 8, 17, 11, 1, -15 },
  { 1169, 3, 17, 11, 4, -15 },
  { 1176, 8, 17, 11, 1, -15 },
  { 1193, 9, 4, 11, 1, -8 },
};

const GFXfont JetBrainsMono_Bold18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_BOLD18PT7B_H_
