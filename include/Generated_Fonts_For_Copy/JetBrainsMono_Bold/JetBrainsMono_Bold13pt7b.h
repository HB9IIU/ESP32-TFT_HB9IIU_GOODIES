#ifndef _JETBRAINSMONO_BOLD13PT7B_H_
#define _JETBRAINSMONO_BOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0x99, 0x90, 0x36, 0x49, 0xF9, 0x22, 0x44, 0xBF,
  0xA4, 0x48, 0x20, 0xCF, 0xBB, 0xE3, 0x87, 0x8B, 0xAF, 0xB7, 0x88, 0x20,
  0x61, 0xF2, 0x94, 0x94, 0x68, 0x10, 0x3E, 0x2B, 0x4B, 0x8E, 0x33, 0xEC,
  0xB0, 0x63, 0x9B, 0xE6, 0x9B, 0xF0, 0xFC, 0x13, 0x6C, 0xCC, 0xCC, 0xC4,
  0x63, 0x10, 0xC7, 0x0C, 0x21, 0x8C, 0x63, 0x19, 0x8D, 0xC8, 0x00, 0x18,
  0x31, 0xDF, 0xE1, 0x8D, 0x89, 0x80, 0x30, 0xCF, 0xCC, 0x30, 0xC0, 0x6B,
  0x60, 0xF0, 0xF0, 0x0C, 0x31, 0x86, 0x10, 0xC3, 0x08, 0x61, 0x84, 0x30,
  0x33, 0xEC, 0xE3, 0xAE, 0xF8, 0xE3, 0xCD, 0xE0, 0x73, 0x49, 0x04, 0x10,
  0x41, 0x04, 0xFC, 0x33, 0xEC, 0xC3, 0x0C, 0x63, 0x18, 0xC3, 0xF0, 0xFC,
  0x63, 0x0E, 0x0C, 0x38, 0xF3, 0x78, 0x18, 0xC6, 0x18, 0xCE, 0x3F, 0xC3,
  0x0C, 0xFF, 0x0C, 0x3E, 0xCC, 0x30, 0xF3, 0x78, 0x38, 0x86, 0x3E, 0xCE,
  0x38, 0xF3, 0x78, 0xFE, 0x30, 0x86, 0x18, 0x43, 0x08, 0x60, 0x33, 0xEC,
  0xF3, 0x79, 0xEC, 0xE3, 0xCD, 0xE0, 0x33, 0xEC, 0xE3, 0xCF, 0xF1, 0x86,
  0x31, 0x80, 0xF0, 0x3C, 0x6C, 0x00, 0xDE, 0xC0, 0x04, 0x77, 0x30, 0xE0,
  0xE0, 0xC0, 0xFF, 0xF0, 0x00, 0xFC, 0x83, 0x83, 0x83, 0x1D, 0xCC, 0x00,
  0xF0, 0x86, 0x6F, 0x20, 0x18, 0xC0, 0x18, 0xFD, 0x0E, 0x1D, 0xFA, 0x74,
  0xE9, 0xDE, 0x81, 0x01, 0xC0, 0x18, 0x70, 0xF1, 0x62, 0x4F, 0x9F, 0xA3,
  0xC2, 0xFB, 0x3C, 0xFE, 0xFB, 0x3C, 0xF3, 0xF8, 0x33, 0xEC, 0xF0, 0xC3,
  0x0C, 0x33, 0xCD, 0xE0, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xF8, 0xFF,
  0x0C, 0x3E, 0xFB, 0x0C, 0x30, 0xFC, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30,
  0xC0, 0x33, 0xEC, 0xF0, 0xC3, 0x7C, 0xF3, 0xCD, 0xE0, 0xCF, 0x3C, 0xFF,
  0xFF, 0x3C, 0xF3, 0xCC, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x1E,
  0x0C, 0x18, 0x30, 0x60, 0xF1, 0xB6, 0x7C, 0xCF, 0x2D, 0xBC, 0xF3, 0x6D,
  0xB3, 0xCC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0xCF, 0x3F, 0x6D,
  0xB6, 0x18, 0x61, 0x84, 0xCF, 0xBA, 0xEB, 0xBE, 0x79, 0x67, 0x8C, 0x33,
  0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCD, 0xE0, 0xFF, 0x3C, 0x73, 0xFB, 0x0C,
  0x30, 0xC0, 0x33, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCD, 0xE1, 0x83, 0xFB,
  0x3C, 0xF3, 0xFB, 0x6D, 0xB3, 0xCC, 0x33, 0xEC, 0xF0, 0xE1, 0xE0, 0xE3,
  0xCD, 0xE0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0x78, 0xC6, 0xCD, 0x9B, 0x22, 0x47, 0x8F, 0x1C, 0x18,
  0xDB, 0xDA, 0x5A, 0x5A, 0x5A, 0x6A, 0x6A, 0x66, 0x66, 0x66, 0x58, 0xF0,
  0xC1, 0x87, 0x8B, 0x33, 0xC6, 0xC7, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFC, 0x21, 0x8C, 0x31, 0x84, 0x3F, 0xFC, 0xFF, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCF, 0xC3, 0x04, 0x18, 0x60, 0x83, 0x0C, 0x18, 0x60, 0x83,
  0xFC, 0x92, 0x49, 0x24, 0xF0, 0x31, 0xE4, 0xB2, 0x8C, 0xFF, 0xF0, 0xC4,
  0x7B, 0x30, 0xFF, 0x8F, 0x3F, 0xC0, 0xC3, 0x0F, 0xB3, 0xCF, 0x3C, 0xF3,
  0xF8, 0x7B, 0x3C, 0x30, 0xC3, 0x37, 0x80, 0x0C, 0x37, 0xF3, 0xCF, 0x3C,
  0xF3, 0x7C, 0x7B, 0x38, 0xFF, 0x83, 0x37, 0x80, 0x3C, 0x82, 0x3F, 0x20,
  0x82, 0x08, 0x20, 0x7F, 0x3C, 0xF3, 0xCF, 0xF2, 0xC3, 0x78, 0xC3, 0x0F,
  0xB3, 0xCF, 0x3C, 0xF3, 0xCC, 0x30, 0xC0, 0x3C, 0x30, 0xC3, 0x0C, 0x33,
  0xF0, 0x18, 0xC1, 0xF1, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0xC3, 0x0C, 0xF2,
  0xDB, 0xCD, 0xB3, 0xCC, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x1E,
  0xEE, 0xDA, 0x69, 0xA6, 0x9A, 0x40, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0,
  0x7B, 0x3C, 0xF3, 0xCF, 0x37, 0x80, 0xFB, 0x3C, 0xF3, 0xCF, 0x3F, 0xB0,
  0xC0, 0x7F, 0x3C, 0xF3, 0xCF, 0x37, 0xC3, 0x0C, 0xFF, 0x3C, 0x70, 0xC3,
  0x0C, 0x00, 0x7B, 0x3C, 0x1E, 0x0F, 0x37, 0x80, 0x61, 0x8F, 0xD8, 0x61,
  0x86, 0x0C, 0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0x37, 0x80, 0xC6, 0xCD, 0x91,
  0x23, 0xC7, 0x06, 0x00, 0xDB, 0x5A, 0x5A, 0x5A, 0x6A, 0x66, 0x66, 0x66,
  0x78, 0xE0, 0xC3, 0xCC, 0xB9, 0x80, 0xE6, 0xCC, 0x91, 0xE3, 0xC3, 0x06,
  0x0C, 0x30, 0xFC, 0x21, 0x8C, 0x63, 0x0F, 0xC0, 0x0C, 0x71, 0x04, 0x10,
  0xCE, 0x04, 0x10, 0x41, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0x82, 0x08, 0x20,
  0xC3, 0xC8, 0x20, 0x82, 0x38, 0xE6, 0xD9, 0xC0,
};

const GFXglyph JetBrainsMono_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 2, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 13, 8, 1, -11 },
  { 24, 8, 10, 8, 0, -10 },
  { 34, 6, 10, 8, 1, -10 },
  { 42, 2, 3, 8, 3, -9 },
  { 43, 4, 13, 8, 2, -11 },
  { 50, 5, 13, 8, 1, -11 },
  { 59, 7, 7, 8, 0, -8 },
  { 66, 6, 6, 8, 1, -7 },
  { 71, 3, 4, 8, 2, -2 },
  { 73, 4, 1, 8, 2, -5 },
  { 74, 2, 2, 8, 3, -2 },
  { 75, 6, 12, 8, 1, -11 },
  { 84, 6, 10, 8, 1, -10 },
  { 92, 6, 9, 8, 1, -9 },
  { 99, 6, 10, 8, 1, -10 },
  { 107, 6, 9, 8, 1, -9 },
  { 114, 6, 9, 8, 1, -9 },
  { 121, 6, 9, 8, 1, -9 },
  { 128, 6, 9, 8, 1, -9 },
  { 135, 6, 9, 8, 1, -9 },
  { 142, 6, 10, 8, 1, -10 },
  { 150, 6, 10, 8, 1, -10 },
  { 158, 2, 7, 8, 3, -7 },
  { 160, 3, 9, 8, 2, -7 },
  { 164, 6, 7, 8, 1, -8 },
  { 170, 6, 5, 8, 1, -7 },
  { 174, 6, 7, 8, 1, -8 },
  { 180, 5, 9, 8, 2, -9 },
  { 186, 7, 12, 8, 0, -10 },
  { 197, 7, 9, 8, 0, -9 },
  { 205, 6, 9, 8, 1, -9 },
  { 212, 6, 10, 8, 1, -10 },
  { 220, 6, 9, 8, 1, -9 },
  { 227, 6, 9, 8, 1, -9 },
  { 234, 6, 9, 8, 1, -9 },
  { 241, 6, 10, 8, 1, -10 },
  { 249, 6, 9, 8, 1, -9 },
  { 256, 6, 9, 8, 1, -9 },
  { 263, 7, 9, 8, 0, -9 },
  { 271, 6, 9, 8, 1, -9 },
  { 278, 6, 9, 8, 1, -9 },
  { 285, 6, 9, 8, 1, -9 },
  { 292, 6, 9, 8, 1, -9 },
  { 299, 6, 10, 8, 1, -10 },
  { 307, 6, 9, 8, 1, -9 },
  { 314, 6, 12, 8, 1, -10 },
  { 323, 6, 9, 8, 1, -9 },
  { 330, 6, 10, 8, 1, -10 },
  { 338, 6, 9, 8, 1, -9 },
  { 345, 6, 9, 8, 1, -9 },
  { 352, 7, 9, 8, 0, -9 },
  { 360, 8, 9, 8, 0, -9 },
  { 369, 7, 9, 8, 0, -9 },
  { 377, 8, 9, 8, 0, -9 },
  { 386, 6, 9, 8, 1, -9 },
  { 393, 4, 12, 8, 2, -11 },
  { 399, 6, 12, 8, 1, -11 },
  { 408, 3, 12, 8, 2, -11 },
  { 413, 6, 5, 8, 1, -9 },
  { 417, 6, 2, 8, 1, 0 },
  { 419, 3, 2, 8, 2, -10 },
  { 420, 6, 7, 8, 1, -7 },
  { 426, 6, 9, 8, 1, -9 },
  { 433, 6, 7, 8, 1, -7 },
  { 439, 6, 9, 8, 1, -9 },
  { 446, 6, 7, 8, 1, -7 },
  { 452, 6, 9, 8, 1, -9 },
  { 459, 6, 9, 8, 1, -7 },
  { 466, 6, 9, 8, 1, -9 },
  { 473, 6, 10, 8, 1, -10 },
  { 481, 5, 12, 8, 1, -10 },
  { 489, 6, 9, 8, 1, -9 },
  { 496, 7, 9, 8, 0, -9 },
  { 504, 6, 7, 8, 1, -7 },
  { 510, 6, 7, 8, 1, -7 },
  { 516, 6, 7, 8, 1, -7 },
  { 522, 6, 9, 8, 1, -7 },
  { 529, 6, 9, 8, 1, -7 },
  { 536, 6, 7, 8, 1, -7 },
  { 542, 6, 7, 8, 1, -7 },
  { 548, 6, 9, 8, 1, -9 },
  { 555, 6, 7, 8, 1, -7 },
  { 561, 7, 7, 8, 0, -7 },
  { 568, 8, 7, 8, 0, -7 },
  { 575, 7, 7, 8, 0, -7 },
  { 582, 7, 9, 8, 0, -7 },
  { 590, 6, 7, 8, 1, -7 },
  { 596, 6, 12, 8, 1, -11 },
  { 605, 2, 12, 8, 3, -11 },
  { 608, 6, 12, 8, 1, -11 },
  { 617, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Bold13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_BOLD13PT7B_H_
