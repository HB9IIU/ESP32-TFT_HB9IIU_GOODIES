#ifndef _JETBRAINSMONO_BOLD25PT7B_H_
#define _JETBRAINSMONO_BOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x00, 0x0E, 0xFB,
  0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0x0C, 0x30, 0x61,
  0x83, 0x1C, 0x38, 0xCF, 0xFF, 0xFF, 0xFC, 0x61, 0x83, 0x1C, 0x18, 0xE1,
  0xC6, 0x0C, 0x31, 0xFF, 0xFF, 0xFF, 0x98, 0xE1, 0xC7, 0x0E, 0x30, 0x61,
  0x83, 0x0C, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x01, 0xFC, 0x1F,
  0xF1, 0xEB, 0xCE, 0x4E, 0x72, 0x73, 0x90, 0x1E, 0x80, 0x7E, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x4E, 0x02, 0x7F, 0x93, 0xDC, 0x9C, 0xFF, 0xE3,
  0xFE, 0x0F, 0xE0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x7E, 0x0E,
  0xFC, 0x1B, 0x9C, 0x67, 0x39, 0x8E, 0x77, 0x1C, 0xCC, 0x1F, 0xB0, 0x1E,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x19, 0xE0, 0x37, 0xE0, 0xDC, 0xE3, 0x39,
  0xCE, 0x73, 0x98, 0xE7, 0x60, 0xFD, 0xC0, 0xF0, 0x02, 0x00, 0xFC, 0x0F,
  0xF0, 0x73, 0xC7, 0x0E, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xF0,
  0x3F, 0x8F, 0xCE, 0xEE, 0x3F, 0x71, 0xF3, 0x87, 0x9C, 0x3C, 0xF3, 0xF3,
  0xFF, 0x8F, 0xCE, 0xFF, 0xFF, 0xF8, 0x01, 0x07, 0x1F, 0x3E, 0x38, 0x78,
  0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x38, 0x3E, 0x1F, 0x07, 0x01, 0x80, 0xE0, 0xF8, 0x7C, 0x1C, 0x1E,
  0x0E, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E,
  0x1E, 0x1C, 0x7C, 0xF8, 0xE0, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E,
  0x2F, 0x27, 0xFF, 0xFC, 0x7F, 0x00, 0xE0, 0x0D, 0x80, 0xEE, 0x0E, 0x38,
  0xF1, 0xE1, 0x04, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x3D, 0xE7, 0x9C, 0x73, 0xCE, 0x38, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFE,
  0xE0, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE4, 0xFD, 0xDF, 0xBB, 0xF2, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xFB, 0xEF, 0xF8, 0xFE, 0x00, 0x1F, 0x03, 0xF0, 0xFF, 0x0F,
  0x70, 0xC7, 0x08, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x01,
  0xFC, 0x3F, 0xE7, 0x8F, 0x70, 0x7F, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x7F, 0x07,
  0x70, 0x77, 0xDF, 0x3F, 0xE1, 0xFC, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x38, 0x0F, 0x03, 0xC7, 0x70, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFE, 0xFF, 0xFC, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xF8, 0x3F, 0xDF, 0x7F, 0xC7, 0xF0, 0x03, 0xC0, 0x3C, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xF8, 0x7F, 0xE3, 0xC7,
  0x9C, 0x1D, 0xE0, 0xFE, 0x03, 0xF8, 0x3D, 0xC1, 0xCF, 0xBE, 0x3F, 0xE0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xEF, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x04, 0x07, 0xF1, 0xFF,
  0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xC3, 0xE1, 0xFF, 0x78,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFB, 0xEF, 0xF8, 0xFE, 0x00, 0x02,
  0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0x80, 0xFE, 0x0F,
  0x70, 0x73, 0xEF, 0x8F, 0xDC, 0x3D, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00,
  0x1D, 0xFF, 0xB8, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCE,
  0x79, 0xE7, 0x3C, 0xE3, 0x80, 0x00, 0x20, 0x1C, 0x0F, 0x8F, 0xE7, 0xE1,
  0xF0, 0x38, 0x07, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xF0, 0x06, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x38,
  0x0F, 0x07, 0xE3, 0xF3, 0xF8, 0x78, 0x0C, 0x01, 0x00, 0x00, 0xFE, 0x3F,
  0xCF, 0xF8, 0x0E, 0x03, 0xC0, 0xF0, 0x38, 0x3E, 0x3F, 0x8F, 0x83, 0x80,
  0xE0, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x02, 0x00, 0xFF,
  0x0F, 0xFC, 0xE0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x78, 0x7B, 0xC7, 0xFE,
  0x39, 0xF1, 0x87, 0x8C, 0x3C, 0x61, 0xE3, 0x0F, 0x18, 0x78, 0xE7, 0xC7,
  0xDF, 0x0C, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x01, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x18,
  0x38, 0xE1, 0xC7, 0x0E, 0x38, 0xFF, 0xC7, 0xFF, 0x3F, 0xF9, 0xC1, 0xDE,
  0x0E, 0xE0, 0x3F, 0x01, 0xC0, 0xFF, 0x8F, 0xFC, 0xE3, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEF, 0xFC, 0xFF, 0x0F, 0xFC, 0xE0, 0xEE, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x04, 0x07, 0xF1, 0xFF,
  0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x3F, 0x07, 0xFF, 0xEF, 0xF8, 0xFE, 0x00, 0xFF,
  0x9F, 0xFB, 0xFF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0xFF, 0xFF, 0xDF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF,
  0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x07,
  0x00, 0xE0, 0x1C, 0xFF, 0x9F, 0xF3, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xFB, 0xEF, 0xF8, 0xFE, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x7E, 0x07, 0xE0, 0xFF, 0xFE, 0x7F, 0xC3, 0xF8, 0xE0, 0xFE,
  0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x8F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0xFE,
  0x07, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x7F, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xDF, 0xF6, 0xDF, 0xB6, 0xFD,
  0xB7, 0xE7, 0x3F, 0x39, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x7D,
  0x8F, 0xB9, 0xFF, 0x3F, 0x67, 0xEE, 0xFD, 0xDF, 0x9B, 0xF3, 0xFE, 0x77,
  0xC6, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3C, 0x04, 0x07, 0xF1, 0xFF, 0x78,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xEF, 0xF8, 0xFE, 0x00, 0xFF, 0x8F,
  0xFE, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF,
  0xFC, 0xFF, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x04, 0x03, 0xF8, 0x7F, 0xCF, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xFF, 0xE7, 0xFC, 0x3F, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x0E, 0x38, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE,
  0x1E, 0xE0, 0xEE, 0x0F, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07,
  0x38, 0x39, 0xC0, 0x0F, 0x00, 0x3F, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xE0,
  0x07, 0x00, 0x3F, 0xC1, 0xEE, 0x0E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0xDF, 0x7F, 0xC7, 0xF0, 0xE0, 0x3F, 0x81, 0xDC, 0x1C, 0xE0,
  0xE7, 0x07, 0x38, 0x38, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x36, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0xE3, 0x8E, 0xC7, 0x19, 0x8A, 0x33, 0x14, 0x67, 0x28, 0xCE, 0x53, 0x9D,
  0xB7, 0x3B, 0x6E, 0x76, 0xDC, 0xED, 0xB8, 0xDB, 0x61, 0xB6, 0xC3, 0x45,
  0x86, 0x8B, 0x0F, 0x16, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF0, 0x7B,
  0x83, 0x9E, 0x3C, 0x71, 0xC1, 0xDC, 0x0E, 0xE0, 0x3E, 0x01, 0xF0, 0x07,
  0x00, 0x7C, 0x03, 0xE0, 0x3B, 0x81, 0xDC, 0x1C, 0x70, 0xE3, 0x8E, 0x0E,
  0xF0, 0x7F, 0x01, 0xC0, 0xE0, 0x3F, 0x83, 0xDC, 0x1C, 0xF0, 0xE3, 0x8E,
  0x1C, 0x70, 0x77, 0x03, 0xB8, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0,
  0x70, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xF8, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0xE0, 0x6C, 0x1D, 0xC3, 0xB8,
  0xE3, 0x9C, 0x73, 0x06, 0xE0, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1,
  0xC3, 0x87, 0x0F, 0x83, 0xFE, 0x3F, 0xF7, 0x07, 0x00, 0x70, 0x07, 0x1F,
  0xF7, 0xFF, 0x70, 0x7F, 0x07, 0xF0, 0x77, 0x0F, 0x7F, 0xF3, 0xF7, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x79, 0xDF, 0xBF, 0xFF, 0x87, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xDF, 0xFF, 0xDD, 0xF0,
  0x1F, 0x0F, 0xFB, 0xFF, 0xF8, 0x7E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x1F, 0x83, 0xFD, 0xF7, 0xFC, 0x7F, 0x00, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x73, 0xCE, 0xFD, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xDF, 0x7F, 0xE7, 0xDC, 0x1F, 0x0F, 0xFB,
  0xEF, 0x70, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x83,
  0xF8, 0xF7, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x1C, 0x00,
  0xE0, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0xEF, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0xFF, 0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x38, 0x0F, 0x3F, 0xC7, 0xF0,
  0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x79, 0xFF, 0xBF, 0xFF,
  0x8F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1C, 0x06, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0xF0,
  0x3C, 0x0E, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x7F, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x83,
  0xEF, 0xF3, 0xF8, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xFE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x78, 0xFF, 0x0F, 0xF0, 0xE7,
  0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0x07, 0xF8,
  0x1F, 0xC0, 0xEE, 0xE7, 0xF7, 0xBD, 0xDF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F,
  0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3,
  0x9C, 0xE7, 0x9F, 0xFB, 0xFF, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x1F, 0x0F, 0xFB,
  0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xFF, 0xF7, 0xFC, 0x7F, 0x00, 0xE7, 0x9D, 0xFB, 0xFF, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFD, 0xFF, 0xFD, 0xDF,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0xEF, 0xDF, 0xFF,
  0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFD,
  0xF7, 0xFE, 0x7D, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE7,
  0x8E, 0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3F, 0x8F, 0xFB, 0xFF,
  0xF0, 0x7E, 0x01, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xE0, 0x1F, 0x83, 0xF8,
  0xF7, 0xFE, 0x7F, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFD, 0xF7,
  0xFC, 0x7F, 0x00, 0xE0, 0x3F, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x87, 0x1C,
  0x70, 0xE3, 0x87, 0x1C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0xE3, 0x8E, 0xC7, 0x19, 0x8E, 0x33, 0x94, 0x67, 0x29, 0xCE,
  0xDB, 0x9D, 0xB7, 0x1B, 0x6C, 0x36, 0xD8, 0x6D, 0xB0, 0xD1, 0x61, 0xE3,
  0xC3, 0xC7, 0x83, 0x8E, 0x00, 0xF0, 0x7B, 0xC7, 0x8E, 0x38, 0x7B, 0xC1,
  0xDC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xEE, 0x0F, 0x78, 0x71,
  0xC7, 0x07, 0x78, 0x3C, 0xE0, 0x3F, 0x83, 0xDC, 0x1C, 0xF0, 0xE3, 0x8F,
  0x1C, 0x70, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x7C, 0x1F, 0x83,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x7F, 0x0F,
  0xE0, 0x3E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x0F, 0xC0, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x03, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x7C, 0x07, 0xF0, 0xFE, 0x3E, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC1, 0xF8, 0x3E, 0x07, 0x00, 0x38, 0x03,
  0xF1, 0xFF, 0xCF, 0xCF, 0x7E, 0x3F, 0x70, 0xF0,
};

const GFXglyph JetBrainsMono_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 9, 7, 15, 3, -18 },
  { 21, 13, 18, 15, 1, -18 },
  { 51, 13, 26, 15, 1, -22 },
  { 94, 15, 18, 15, 0, -18 },
  { 128, 13, 19, 15, 1, -19 },
  { 159, 3, 7, 15, 6, -18 },
  { 162, 8, 24, 15, 4, -21 },
  { 186, 8, 24, 15, 3, -21 },
  { 210, 13, 13, 15, 1, -15 },
  { 232, 13, 12, 15, 1, -14 },
  { 252, 6, 8, 15, 4, -4 },
  { 258, 9, 3, 15, 3, -10 },
  { 262, 5, 4, 15, 5, -4 },
  { 265, 13, 24, 15, 1, -21 },
  { 304, 11, 19, 15, 2, -19 },
  { 331, 12, 18, 15, 2, -18 },
  { 358, 12, 19, 15, 1, -19 },
  { 387, 12, 18, 15, 1, -18 },
  { 414, 11, 18, 15, 2, -18 },
  { 439, 11, 18, 15, 2, -18 },
  { 464, 13, 18, 15, 1, -18 },
  { 494, 13, 18, 15, 1, -18 },
  { 524, 11, 19, 15, 2, -19 },
  { 551, 13, 19, 15, 1, -19 },
  { 582, 5, 14, 15, 5, -14 },
  { 591, 6, 18, 15, 4, -14 },
  { 605, 11, 14, 15, 2, -15 },
  { 625, 11, 9, 15, 2, -13 },
  { 638, 11, 14, 15, 2, -15 },
  { 658, 10, 18, 15, 3, -18 },
  { 681, 13, 23, 15, 1, -19 },
  { 719, 13, 18, 15, 1, -18 },
  { 749, 12, 18, 15, 2, -18 },
  { 776, 11, 19, 15, 2, -19 },
  { 803, 11, 18, 15, 2, -18 },
  { 828, 11, 18, 15, 2, -18 },
  { 853, 11, 18, 15, 2, -18 },
  { 878, 11, 19, 15, 2, -19 },
  { 905, 11, 18, 15, 2, -18 },
  { 930, 11, 18, 15, 2, -18 },
  { 955, 12, 18, 15, 1, -18 },
  { 982, 12, 18, 15, 2, -18 },
  { 1009, 10, 18, 15, 3, -18 },
  { 1032, 13, 18, 15, 1, -18 },
  { 1062, 11, 18, 15, 2, -18 },
  { 1087, 11, 19, 15, 2, -19 },
  { 1114, 12, 18, 15, 2, -18 },
  { 1141, 12, 24, 15, 2, -19 },
  { 1177, 12, 18, 15, 2, -18 },
  { 1204, 13, 19, 15, 1, -19 },
  { 1235, 13, 18, 15, 1, -18 },
  { 1265, 11, 18, 15, 2, -18 },
  { 1290, 13, 18, 15, 1, -18 },
  { 1320, 15, 18, 15, 0, -18 },
  { 1354, 13, 18, 15, 1, -18 },
  { 1384, 13, 18, 15, 1, -18 },
  { 1414, 11, 18, 15, 2, -18 },
  { 1439, 7, 24, 15, 5, -21 },
  { 1460, 12, 24, 15, 1, -21 },
  { 1496, 7, 24, 15, 3, -21 },
  { 1517, 11, 10, 15, 2, -18 },
  { 1531, 13, 2, 15, 1, 1 },
  { 1535, 6, 4, 15, 4, -20 },
  { 1538, 12, 14, 15, 1, -14 },
  { 1559, 11, 18, 15, 2, -18 },
  { 1584, 11, 14, 15, 2, -14 },
  { 1604, 11, 18, 15, 2, -18 },
  { 1629, 11, 14, 15, 2, -14 },
  { 1649, 13, 18, 15, 1, -18 },
  { 1679, 11, 19, 15, 2, -14 },
  { 1706, 11, 18, 15, 2, -18 },
  { 1731, 12, 20, 15, 2, -20 },
  { 1761, 10, 25, 15, 2, -20 },
  { 1793, 12, 18, 15, 2, -18 },
  { 1820, 13, 18, 15, 1, -18 },
  { 1850, 13, 14, 15, 1, -14 },
  { 1873, 11, 14, 15, 2, -14 },
  { 1893, 11, 14, 15, 2, -14 },
  { 1913, 11, 19, 15, 2, -14 },
  { 1940, 11, 19, 15, 2, -14 },
  { 1967, 12, 14, 15, 2, -14 },
  { 1988, 11, 14, 15, 2, -14 },
  { 2008, 12, 18, 15, 1, -18 },
  { 2035, 11, 14, 15, 2, -14 },
  { 2055, 13, 14, 15, 1, -14 },
  { 2078, 15, 14, 15, 0, -14 },
  { 2105, 13, 14, 15, 1, -14 },
  { 2128, 13, 19, 15, 1, -14 },
  { 2159, 11, 14, 15, 2, -14 },
  { 2179, 11, 24, 15, 2, -21 },
  { 2212, 3, 24, 15, 6, -21 },
  { 2221, 11, 24, 15, 2, -21 },
  { 2254, 13, 6, 15, 1, -12 },
};

const GFXfont JetBrainsMono_Bold25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_BOLD25PT7B_H_
