#ifndef _JETBRAINSMONO_BOLD42PT7B_H_
#define _JETBRAINSMONO_BOLD42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF7, 0xFF, 0xFF, 0xDF, 0x00, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0x78, 0x3E, 0xF0, 0x7D,
  0xE0, 0xFB, 0xC1, 0xE7, 0x83, 0xC0, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0,
  0x07, 0x81, 0xE0, 0x0F, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0F,
  0x00, 0x78, 0x1E, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1C, 0x00,
  0xF0, 0x78, 0x01, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFC, 0xE7, 0xE7, 0xE7, 0x1F, 0x3E, 0x38,
  0xF9, 0xF1, 0xC0, 0x0F, 0x8E, 0x00, 0x7E, 0x70, 0x03, 0xFB, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0x9F, 0x80, 0x1C, 0x7E, 0x00,
  0xE3, 0xF0, 0x07, 0x0F, 0xFE, 0x38, 0x7D, 0xF1, 0xC7, 0xEF, 0xCE, 0x3E,
  0x7F, 0x77, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0x9F, 0xF0, 0x03, 0xDF,
  0xFC, 0x03, 0xCF, 0x9E, 0x03, 0xC7, 0x07, 0x81, 0xC7, 0x83, 0xC1, 0xE3,
  0xC1, 0xE1, 0xE1, 0xE0, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x38, 0x3C, 0xF0,
  0x1E, 0x3C, 0xF0, 0x0F, 0xFE, 0x70, 0x03, 0xFE, 0x78, 0x00, 0xFE, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x1E, 0xFF, 0x80, 0x1E, 0xFF, 0xE0, 0x1E, 0x7D, 0xF0, 0x0E,
  0x38, 0x3C, 0x0F, 0x3C, 0x1E, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x07, 0x87,
  0x87, 0x83, 0xC7, 0x81, 0xC1, 0xE7, 0x80, 0xF1, 0xE3, 0x80, 0x7F, 0xF3,
  0xC0, 0x1F, 0xF3, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xE7, 0xE3, 0xEF, 0x8F, 0x9F, 0xBE, 0x1F,
  0x7C, 0xF8, 0x7F, 0xE3, 0xE0, 0xFF, 0x8F, 0x81, 0xFC, 0x3E, 0x03, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xE3, 0xE0, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x07, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7E, 0x03,
  0xC0, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0C, 0x0F, 0x07, 0x3E,
  0x1C, 0x3E, 0x7F, 0x39, 0xFD, 0xFF, 0x77, 0xFD, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF7,
  0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x0F, 0x80, 0xFC, 0x1F,
  0x80, 0xF0, 0x1E, 0x00, 0x60, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xFB,
  0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF1, 0xE7, 0xFE, 0x7C,
  0xFF, 0xCF, 0x9F, 0xF9, 0xF3, 0xFF, 0x3E, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0xFD, 0xF8, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xF7, 0xC0, 0xFE, 0x7C, 0x0F, 0x87, 0xC0, 0xF0,
  0x7C, 0x0C, 0x07, 0xC0, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE0, 0x7F,
  0x7E, 0x03, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xCF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x7F, 0x07, 0xDF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8,
  0x7F, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0xFD, 0xF8, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF3, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFB, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x87, 0xF3, 0xF0, 0x1F,
  0x9F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0xC1, 0xFC,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xBF, 0xC7, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0xFC, 0x3F,
  0x1F, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03,
  0xFB, 0xF8, 0x7E, 0x0F, 0xCF, 0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0xFE, 0x0F,
  0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFD, 0xFE,
  0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBF, 0x00, 0xFD,
  0xFC, 0x1F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xDF, 0x01, 0xFD,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x7C, 0xFE,
  0xFE, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x04, 0x07, 0xE3,
  0xF8, 0xFE, 0x3F, 0xCF, 0xE1, 0xF8, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7F, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x0F,
  0x3E, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x18, 0x7F,
  0xC0, 0xFC, 0xFF, 0x83, 0xFD, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0x0F, 0xFC,
  0x3C, 0x1F, 0xF8, 0x78, 0x1F, 0xF0, 0xF0, 0x3F, 0xE1, 0xE0, 0x7F, 0xC3,
  0xC0, 0xFF, 0x87, 0x81, 0xFF, 0x0F, 0x03, 0xFE, 0x1E, 0x07, 0xFC, 0x3C,
  0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0x7F, 0xC0, 0xFE,
  0xF7, 0x80, 0x60, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x05, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07,
  0xCF, 0x00, 0x0F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0x81, 0xFC,
  0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x1F, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E,
  0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFD, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0x7F, 0x0F,
  0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xE0, 0x3F,
  0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF,
  0x80, 0x7E, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F,
  0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x3E, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0,
  0x7E, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF9,
  0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFB, 0x83, 0xFF, 0xDC, 0x1D, 0xFE, 0xF0, 0xEF, 0xFB, 0x8F,
  0x7F, 0xDC, 0x73, 0xFE, 0xF3, 0xBF, 0xF7, 0xBD, 0xFF, 0x9D, 0xEF, 0xFC,
  0xEE, 0x7F, 0xE7, 0xF3, 0xFF, 0x1F, 0x9F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xBC, 0x1F, 0xF7, 0x83, 0xFF, 0xF8, 0x7F, 0xEF,
  0x0F, 0xFD, 0xE1, 0xFF, 0xBE, 0x3F, 0xF3, 0xC7, 0xFE, 0x78, 0xFF, 0xCF,
  0x9F, 0xF8, 0xF3, 0xFF, 0x1E, 0x7F, 0xE3, 0xEF, 0xFC, 0x3C, 0xFF, 0x87,
  0x9F, 0xF0, 0x7B, 0xFE, 0x0F, 0x7F, 0xC1, 0xEF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0xFD, 0xFC, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7C, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x01, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0x7F, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0xFE, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80,
  0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x01,
  0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0x9F, 0xE1, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xFC, 0x7F, 0x3F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C,
  0x1E, 0xF8, 0x7C, 0x1E, 0xF8, 0x6C, 0x1E, 0xF8, 0x6E, 0x3E, 0xF8, 0x6E,
  0x3E, 0x78, 0xEE, 0x3E, 0x78, 0xEE, 0x3E, 0x78, 0xEE, 0x3C, 0x78, 0xEE,
  0x3C, 0x78, 0xEE, 0x3C, 0x78, 0xE6, 0x3C, 0x78, 0xE6, 0x3C, 0x7C, 0xC7,
  0x3C, 0x7C, 0xC7, 0x3C, 0x7D, 0xC7, 0x3C, 0x3D, 0xC7, 0x7C, 0x3D, 0xC7,
  0x78, 0x3D, 0xC7, 0x78, 0x3D, 0xC7, 0x78, 0x3D, 0xC3, 0x78, 0x3D, 0xC3,
  0x78, 0x3D, 0x83, 0xF8, 0x3D, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x00,
  0x7E, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD,
  0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0x83, 0xF0, 0x3F, 0x07,
  0xE0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xBF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0x78, 0x03, 0xEF, 0x80, 0x7C, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xE0, 0x78,
  0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x9F, 0x00, 0xF7, 0xC0,
  0x1F, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83,
  0xF0, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xF0, 0x7F, 0x3E, 0x03, 0xF7, 0xE0, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xF7, 0xE0, 0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xDF, 0x3F, 0xFD, 0xF0, 0xFF,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x80, 0xF8, 0xFF, 0x1F, 0x3F,
  0xF3, 0xEF, 0xFF, 0x7D, 0xFF, 0xEF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xEF, 0xBF, 0xFD, 0xF3, 0xFF,
  0x3E, 0x3F, 0x80, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xBF, 0x87, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x08, 0x1F, 0x0F, 0xE3, 0xE7, 0xFF, 0x7C,
  0xFF, 0xEF, 0xBF, 0xFF, 0xF7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0xFD, 0xF8, 0x7F, 0xBF, 0xFF, 0xF3, 0xFF, 0xBE, 0x7F, 0xE7, 0xC3,
  0xF8, 0xF8, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFC, 0x0F, 0xBF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xBF,
  0x03, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x00, 0x01,
  0xFC, 0x7C, 0xFF, 0xEF, 0x9F, 0xFD, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xEF, 0xC1, 0xFD, 0xFF, 0xFF, 0xBF, 0xFD, 0xF3, 0xFF, 0xBE, 0x3F,
  0xE7, 0xC0, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x80, 0xF8, 0xFE, 0x1F, 0x3F,
  0xF3, 0xEF, 0xFF, 0x7D, 0xFF, 0xEF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0,
  0xFC, 0x3E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01,
  0xFB, 0xF0, 0x07, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x87, 0x9F, 0x1F, 0x3D,
  0xFD, 0xFD, 0xEF, 0xEF, 0xFF, 0xCF, 0x8F, 0xFC, 0x3C, 0x7F, 0xE1, 0xC3,
  0xFF, 0x0E, 0x1F, 0xF8, 0x70, 0xFF, 0xC3, 0x87, 0xFE, 0x1C, 0x3F, 0xF0,
  0xE1, 0xFF, 0x87, 0x0F, 0xFC, 0x38, 0x7F, 0xE1, 0xC3, 0xFF, 0x0E, 0x1F,
  0xF8, 0x70, 0xFF, 0xC3, 0x87, 0xFE, 0x1C, 0x3F, 0xF0, 0xE1, 0xFF, 0x87,
  0x0F, 0xFC, 0x38, 0x7F, 0xE1, 0xC3, 0xFF, 0x0E, 0x1F, 0x00, 0x10, 0x1F,
  0x1F, 0xC3, 0xE7, 0xFE, 0x7D, 0xFF, 0xEF, 0xBF, 0xFD, 0xFE, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xF0, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0xFD, 0xFC, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x10, 0x1F, 0x1F, 0xE3, 0xE7, 0xFE, 0x7D, 0xFF, 0xEF, 0xBF,
  0xFD, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x87,
  0xFF, 0xBF, 0xFD, 0xF7, 0xFF, 0xBE, 0x7F, 0xE7, 0xC7, 0xF0, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x7C, 0xFF, 0xEF,
  0x9F, 0xFD, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xBF, 0x0F, 0xF7, 0xFF, 0xBE, 0x7F, 0xF7, 0xCF, 0xFC, 0xF8,
  0x7F, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x10, 0x1F,
  0x3F, 0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7C, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xEF,
  0x80, 0xFD, 0xFC, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0x9F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3F, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xE1, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F,
  0xE1, 0xF0, 0x7F, 0xC3, 0xE0, 0xF7, 0x87, 0xC3, 0xEF, 0x0D, 0xC7, 0x9E,
  0x1B, 0x8F, 0x3C, 0x77, 0x1E, 0x78, 0xEE, 0x3C, 0xF9, 0xDC, 0x79, 0xF3,
  0x98, 0xF1, 0xE7, 0x33, 0xE3, 0xCC, 0x77, 0x87, 0xB8, 0xEF, 0x0F, 0x71,
  0xDE, 0x1E, 0xE3, 0xBC, 0x3D, 0xC7, 0x78, 0x3F, 0x86, 0xF0, 0x7E, 0x0D,
  0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3E, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0xCF, 0x80,
  0x7E, 0x3F, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xF1, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xC0,
  0x1F, 0x9F, 0x80, 0x7C, 0x7E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3E,
  0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0xFC, 0x03,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xC0,
  0x00, 0x07, 0x00, 0x01, 0xFE, 0x03, 0xDF, 0xF8, 0x1E, 0xFF, 0xE0, 0xFF,
  0xDF, 0x87, 0xFC, 0x7E, 0x7F, 0xE1, 0xFF, 0xFF, 0x07, 0xFE, 0xF8, 0x1F,
  0xF0, 0x00, 0x7E, 0x00,
};

const GFXglyph JetBrainsMono_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -31 },
  { 29, 15, 13, 25, 5, -31 },
  { 54, 23, 31, 25, 1, -31 },
  { 144, 21, 43, 25, 2, -37 },
  { 257, 25, 31, 25, 0, -31 },
  { 354, 22, 31, 25, 2, -31 },
  { 440, 5, 13, 25, 10, -31 },
  { 449, 13, 40, 25, 7, -35 },
  { 514, 13, 40, 25, 5, -35 },
  { 579, 23, 22, 25, 1, -26 },
  { 643, 21, 20, 25, 2, -24 },
  { 696, 10, 13, 25, 6, -6 },
  { 713, 13, 5, 25, 6, -16 },
  { 722, 8, 7, 25, 9, -7 },
  { 729, 20, 40, 25, 3, -35 },
  { 829, 19, 31, 25, 3, -31 },
  { 903, 20, 31, 25, 3, -31 },
  { 981, 20, 31, 25, 2, -31 },
  { 1059, 20, 31, 25, 2, -31 },
  { 1137, 19, 31, 25, 3, -31 },
  { 1211, 19, 31, 25, 3, -31 },
  { 1285, 21, 31, 25, 2, -31 },
  { 1367, 20, 31, 25, 3, -31 },
  { 1445, 20, 31, 25, 3, -31 },
  { 1523, 21, 31, 25, 2, -31 },
  { 1605, 8, 24, 25, 9, -24 },
  { 1629, 10, 31, 25, 7, -24 },
  { 1668, 19, 23, 25, 3, -25 },
  { 1723, 19, 15, 25, 3, -21 },
  { 1759, 19, 23, 25, 3, -25 },
  { 1814, 16, 31, 25, 5, -31 },
  { 1876, 23, 39, 25, 1, -31 },
  { 1989, 23, 31, 25, 1, -31 },
  { 2079, 20, 31, 25, 3, -31 },
  { 2157, 20, 31, 25, 3, -31 },
  { 2235, 19, 31, 25, 3, -31 },
  { 2309, 18, 31, 25, 4, -31 },
  { 2379, 19, 31, 25, 3, -31 },
  { 2453, 20, 31, 25, 3, -31 },
  { 2531, 19, 31, 25, 3, -31 },
  { 2605, 17, 31, 25, 4, -31 },
  { 2671, 20, 31, 25, 1, -31 },
  { 2749, 21, 31, 25, 3, -31 },
  { 2831, 19, 31, 25, 4, -31 },
  { 2905, 21, 31, 25, 2, -31 },
  { 2987, 19, 31, 25, 3, -31 },
  { 3061, 19, 31, 25, 3, -31 },
  { 3135, 21, 31, 25, 3, -31 },
  { 3217, 20, 39, 25, 3, -31 },
  { 3315, 20, 31, 25, 3, -31 },
  { 3393, 21, 31, 25, 2, -31 },
  { 3475, 21, 31, 25, 2, -31 },
  { 3557, 19, 31, 25, 3, -31 },
  { 3631, 23, 31, 25, 1, -31 },
  { 3721, 24, 31, 25, 1, -31 },
  { 3814, 23, 31, 25, 1, -31 },
  { 3904, 23, 31, 25, 1, -31 },
  { 3994, 19, 31, 25, 3, -31 },
  { 4068, 12, 40, 25, 8, -35 },
  { 4128, 20, 40, 25, 3, -35 },
  { 4228, 11, 40, 25, 6, -35 },
  { 4283, 19, 17, 25, 3, -31 },
  { 4324, 20, 5, 25, 3, 1 },
  { 4337, 10, 6, 25, 7, -33 },
  { 4345, 20, 24, 25, 2, -24 },
  { 4405, 19, 31, 25, 3, -31 },
  { 4479, 19, 24, 25, 3, -24 },
  { 4536, 19, 31, 25, 3, -31 },
  { 4610, 19, 24, 25, 3, -24 },
  { 4667, 21, 31, 25, 2, -31 },
  { 4749, 19, 32, 25, 3, -24 },
  { 4825, 19, 31, 25, 3, -31 },
  { 4899, 20, 33, 25, 3, -33 },
  { 4982, 17, 41, 25, 3, -33 },
  { 5070, 21, 31, 25, 3, -31 },
  { 5152, 22, 31, 25, 1, -31 },
  { 5238, 21, 24, 25, 2, -24 },
  { 5301, 19, 24, 25, 3, -24 },
  { 5358, 19, 23, 25, 3, -23 },
  { 5413, 19, 32, 25, 3, -24 },
  { 5489, 19, 32, 25, 3, -24 },
  { 5565, 19, 24, 25, 4, -24 },
  { 5622, 20, 23, 25, 3, -23 },
  { 5680, 20, 30, 25, 2, -30 },
  { 5755, 19, 23, 25, 3, -23 },
  { 5810, 22, 23, 25, 2, -23 },
  { 5874, 23, 23, 25, 1, -23 },
  { 5941, 22, 23, 25, 2, -23 },
  { 6005, 22, 31, 25, 2, -23 },
  { 6091, 19, 23, 25, 3, -23 },
  { 6146, 19, 40, 25, 3, -35 },
  { 6241, 5, 40, 25, 10, -35 },
  { 6266, 19, 40, 25, 3, -35 },
  { 6361, 21, 10, 25, 2, -20 },
};

const GFXfont JetBrainsMono_Bold42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_BOLD42PT7B_H_
