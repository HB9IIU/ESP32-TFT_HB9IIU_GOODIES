#ifndef _JETBRAINSMONO_BOLD44PT7B_H_
#define _JETBRAINSMONO_BOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xF7, 0xC1, 0xEF, 0x83, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x03, 0xC0,
  0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x03,
  0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x1F, 0xDF, 0xFC, 0xFC, 0xE7, 0xEF, 0xC7, 0x1F, 0x7E, 0x38, 0xFB, 0xF1,
  0xC0, 0x1F, 0x8E, 0x00, 0xFC, 0x70, 0x03, 0xF3, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xBF, 0x80, 0x1C, 0xFE, 0x00, 0xE3, 0xF0,
  0x07, 0x1F, 0xFC, 0x38, 0xFF, 0xE1, 0xC7, 0xFF, 0x8E, 0x3F, 0xFC, 0x73,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xE7, 0xFE, 0x00,
  0xF1, 0xFF, 0xE0, 0x1E, 0x3C, 0x3C, 0x07, 0x87, 0x87, 0x81, 0xE0, 0xE0,
  0xF0, 0x3C, 0x1C, 0x1E, 0x0F, 0x03, 0x83, 0xC3, 0xC0, 0x70, 0x78, 0xF0,
  0x0F, 0x0F, 0x1E, 0x01, 0xE1, 0xE7, 0x80, 0x3F, 0xFD, 0xE0, 0x03, 0xFF,
  0x3C, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x82, 0x00, 0x01, 0xE3, 0xF8, 0x00, 0x3D,
  0xFF, 0x80, 0x0F, 0x3F, 0xF8, 0x03, 0xCF, 0x8F, 0x80, 0x79, 0xE0, 0xF0,
  0x1E, 0x3C, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0x03, 0xC1, 0xE3, 0xC0, 0x7C, 0x7C, 0x78, 0x07, 0xFF, 0x1E,
  0x00, 0x7F, 0xC7, 0x80, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF7, 0xE1,
  0xF7, 0xC7, 0xE7, 0xEF, 0x87, 0xCF, 0x9F, 0x07, 0xFF, 0x3E, 0x0F, 0xFC,
  0x7C, 0x0F, 0xF8, 0xF8, 0x0F, 0xE1, 0xF0, 0x1F, 0xC3, 0xE0, 0x1F, 0x87,
  0xE0, 0x7F, 0x0F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBE, 0x1F,
  0xFE, 0x3E, 0x0F, 0xF8, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xF7, 0xDF, 0x78, 0x00, 0x04, 0x00, 0xF0, 0x07, 0xC0, 0x7F, 0x03, 0xFC,
  0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0,
  0x3F, 0x00, 0x3C, 0x00, 0x30, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x30, 0x3C, 0x06, 0x7C, 0x3C, 0x3E, 0x7F, 0x1C, 0xFE, 0x7F, 0x99,
  0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF7, 0x00, 0x01, 0xF7, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE3,
  0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0x80,
  0xE0, 0x03, 0x00, 0x40, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE7, 0xF0, 0xFE, 0x7E, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x9F, 0xF9, 0xF9, 0xFF, 0x9F, 0x9F, 0xF8,
  0xF9, 0xFF, 0x87, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF7, 0xE0, 0x3F,
  0x7F, 0x9F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0x0F, 0xC0, 0xE0, 0xFC, 0x0C,
  0x0F, 0xC0, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xCF,
  0xF3, 0xF8, 0x1F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF7, 0xF0, 0x3F,
  0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0xF0, 0x7D, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF9, 0xFF, 0x7E, 0x03, 0xF7, 0xC0,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7,
  0xF9, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x9F, 0x00,
  0x7D, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xEF, 0xF9, 0xFC,
  0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xE7,
  0xF0, 0x1F, 0x8F, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00,
  0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0xF8, 0x07, 0xE7,
  0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x1F, 0xC7, 0xE0, 0x7E, 0x7E,
  0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7D, 0xFC, 0x07, 0xE7, 0xF8, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x1F,
  0xDF, 0xC0, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0x01,
  0xFE, 0xFC, 0x00, 0xE7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x06, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFC,
  0x3F, 0x80, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF8, 0x03, 0x0F, 0xF8, 0x1F, 0xCF,
  0xF8, 0x3F, 0xEF, 0xF8, 0x3F, 0xEF, 0xF8, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F,
  0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F,
  0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F,
  0xF8, 0x7C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xEF,
  0xF8, 0x1F, 0xCF, 0x78, 0x02, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0xFC,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x83,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7E, 0x00, 0xF8,
  0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xC3, 0xFF, 0x7E, 0x03, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00,
  0x7D, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x00, 0xFD, 0xF8, 0x03,
  0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xFD, 0xFF,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7E, 0x07, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x03, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0xC7, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0xFC, 0x07,
  0xE7, 0xF9, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFF, 0x9F, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xF7, 0x03, 0xFF, 0xFE, 0x0E, 0xFF, 0xF8,
  0x7B, 0xFE, 0xE1, 0xEF, 0xFB, 0xC7, 0xFF, 0xEF, 0x1D, 0xFF, 0xBC, 0xF7,
  0xFE, 0x7B, 0xDF, 0xF9, 0xEE, 0x7F, 0xE7, 0xB9, 0xFF, 0x8F, 0xE7, 0xFE,
  0x3F, 0x9F, 0xF8, 0xFC, 0x7F, 0xE1, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xBC, 0x1F, 0xFB,
  0xE1, 0xFF, 0x9E, 0x1F, 0xF9, 0xE1, 0xFF, 0x9F, 0x1F, 0xF8, 0xF1, 0xFF,
  0x8F, 0x1F, 0xF8, 0xF9, 0xFF, 0x87, 0x9F, 0xF8, 0x79, 0xFF, 0x87, 0xDF,
  0xF8, 0x3D, 0xFF, 0x83, 0xDF, 0xF8, 0x3E, 0xFF, 0x81, 0xEF, 0xF8, 0x1E,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF8, 0xFE, 0x7E, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0xDF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7,
  0xF1, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0xFC, 0x0F, 0xE7, 0xFD,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0,
  0x1F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7F, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0x87, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01,
  0xF7, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xEF, 0xFD, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x7E, 0x07, 0xF7, 0xF9, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x01,
  0xF7, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xC1,
  0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F,
  0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xDF, 0x07, 0xC1,
  0xEF, 0x87, 0xE0, 0xF7, 0xC3, 0xF0, 0xFB, 0xE1, 0xF8, 0x7D, 0xF0, 0xEC,
  0x3E, 0x78, 0x77, 0x1F, 0x3C, 0x3B, 0x8F, 0x9E, 0x1D, 0xC7, 0xCF, 0x0E,
  0xE3, 0xC7, 0xCE, 0x71, 0xE3, 0xE7, 0x38, 0xF1, 0xF3, 0x9C, 0x78, 0xF9,
  0xCE, 0x3C, 0x7C, 0xE3, 0x1E, 0x1E, 0x71, 0xDF, 0x0F, 0x38, 0xEF, 0x87,
  0x9C, 0x77, 0xC3, 0xCC, 0x3B, 0xC1, 0xEE, 0x1D, 0xE0, 0xF7, 0x0E, 0xF0,
  0x7B, 0x87, 0x78, 0x3F, 0xC3, 0xBC, 0x1F, 0xE1, 0xDE, 0x0F, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3,
  0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xF7,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xE0,
  0x07, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x07,
  0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xC1, 0xFC, 0xFC, 0x07, 0xE7, 0xC0,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF,
  0xFF, 0x7C, 0xFF, 0xFB, 0xE3, 0xFF, 0x9F, 0x0F, 0xF8, 0xF8, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC1, 0xC0, 0xFC, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF,
  0xFC, 0xFD, 0xFF, 0xCF, 0xCF, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x87, 0xF9, 0xF8, 0x0F,
  0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xF9,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x18, 0x1F, 0x0F, 0xF1, 0xF1, 0xFF,
  0x9F, 0x3F, 0xFD, 0xF7, 0xFF, 0xDF, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xF9, 0xFF, 0x7F, 0xFD,
  0xF3, 0xFF, 0xDF, 0x1F, 0xF9, 0xF0, 0xFF, 0x1F, 0x00, 0x70, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7C,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x7F, 0x07,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x1F, 0x1F, 0xF9, 0xF3, 0xFF,
  0xDF, 0x7F, 0xFD, 0xF7, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7F,
  0x7F, 0x0F, 0xF7, 0xFF, 0xDF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x0F, 0xF1,
  0xF0, 0x18, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC1, 0xC0, 0xFC, 0xFF,
  0x0F, 0xDF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x30,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xF9,
  0xF0, 0x1F, 0xCF, 0x80, 0xFC, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x07,
  0xE0, 0xF8, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F,
  0x87, 0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x7C,
  0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xC0, 0xC3, 0xEF, 0xCF,
  0xCF, 0xFF, 0x3F, 0xBF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFF, 0xE1, 0xE1, 0xFF,
  0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87,
  0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87,
  0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE,
  0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E,
  0x1F, 0xF8, 0x78, 0x7C, 0x00, 0x1C, 0x0F, 0xCF, 0xF0, 0xFD, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x00, 0x60, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0xFE, 0x7E, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0xDF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x1C,
  0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFD, 0xFF, 0xCF, 0xDF, 0xFC, 0xFC, 0xFF,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0x1F, 0x1F, 0xF9, 0xF3, 0xFF, 0xDF, 0x7F, 0xFD, 0xF7, 0xF0, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x7F,
  0x9D, 0xF7, 0xFF, 0xDF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x0F, 0xF1, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x0F, 0x8F,
  0xF8, 0xF9, 0xFF, 0xCF, 0xBF, 0xFE, 0xFB, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F,
  0x7E, 0x07, 0xF7, 0xF9, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3,
  0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F,
  0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7C,
  0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7,
  0xE0, 0x07, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0xF8, 0x3C, 0x0F, 0xFC, 0x1F, 0x07, 0xBE, 0x0F, 0x83, 0xDF, 0x07, 0xC1,
  0xE7, 0x87, 0xE1, 0xF3, 0xC3, 0xF0, 0xF9, 0xE1, 0xD8, 0x78, 0xF8, 0xEE,
  0x3C, 0x7C, 0x77, 0x1E, 0x3E, 0x33, 0x8F, 0x0F, 0x39, 0xC7, 0x87, 0x9C,
  0xE7, 0xC3, 0xCE, 0x73, 0xE1, 0xE7, 0x19, 0xE0, 0xF3, 0x8E, 0xF0, 0x7D,
  0xC7, 0x78, 0x3E, 0xC3, 0xBC, 0x0F, 0xE1, 0xDE, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F,
  0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xC3,
  0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C,
  0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0x80, 0xF7, 0xFF, 0x03, 0xDF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xE3, 0xF1, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFB, 0xE0,
  0x3F, 0xC0, 0x00, 0x38, 0x00,
};

const GFXglyph JetBrainsMono_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 32, 26, 9, -32 },
  { 33, 15, 13, 26, 6, -32 },
  { 58, 24, 32, 26, 1, -32 },
  { 154, 21, 44, 26, 3, -38 },
  { 270, 27, 32, 26, 0, -32 },
  { 378, 23, 33, 26, 2, -33 },
  { 473, 6, 13, 26, 10, -32 },
  { 483, 14, 42, 26, 7, -37 },
  { 557, 14, 42, 26, 5, -37 },
  { 631, 24, 23, 26, 1, -27 },
  { 700, 21, 21, 26, 3, -25 },
  { 756, 10, 14, 26, 7, -7 },
  { 774, 14, 5, 26, 6, -17 },
  { 783, 8, 8, 26, 9, -8 },
  { 791, 21, 42, 26, 3, -37 },
  { 902, 20, 33, 26, 3, -33 },
  { 985, 20, 32, 26, 4, -32 },
  { 1065, 21, 33, 26, 3, -33 },
  { 1152, 20, 32, 26, 3, -32 },
  { 1232, 20, 32, 26, 3, -32 },
  { 1312, 20, 32, 26, 3, -32 },
  { 1392, 22, 32, 26, 2, -32 },
  { 1480, 21, 32, 26, 3, -32 },
  { 1564, 21, 33, 26, 3, -33 },
  { 1651, 22, 33, 26, 2, -33 },
  { 1742, 8, 25, 26, 9, -25 },
  { 1767, 10, 32, 26, 7, -25 },
  { 1807, 20, 25, 26, 3, -27 },
  { 1870, 19, 15, 26, 4, -22 },
  { 1906, 20, 25, 26, 3, -27 },
  { 1969, 17, 32, 26, 5, -32 },
  { 2037, 24, 41, 26, 1, -33 },
  { 2160, 23, 32, 26, 2, -32 },
  { 2252, 21, 32, 26, 3, -32 },
  { 2336, 21, 33, 26, 3, -33 },
  { 2423, 21, 32, 26, 3, -32 },
  { 2507, 19, 32, 26, 4, -32 },
  { 2583, 20, 32, 26, 4, -32 },
  { 2663, 21, 33, 26, 3, -33 },
  { 2750, 20, 32, 26, 3, -32 },
  { 2830, 18, 32, 26, 4, -32 },
  { 2902, 21, 32, 26, 1, -32 },
  { 2986, 22, 32, 26, 3, -32 },
  { 3074, 19, 32, 26, 5, -32 },
  { 3150, 22, 32, 26, 2, -32 },
  { 3238, 20, 32, 26, 3, -32 },
  { 3318, 20, 33, 26, 3, -33 },
  { 3401, 22, 32, 26, 3, -32 },
  { 3489, 21, 41, 26, 3, -33 },
  { 3597, 22, 32, 26, 3, -32 },
  { 3685, 21, 33, 26, 3, -33 },
  { 3772, 22, 32, 26, 2, -32 },
  { 3860, 20, 32, 26, 3, -32 },
  { 3940, 23, 32, 26, 2, -32 },
  { 4032, 25, 32, 26, 1, -32 },
  { 4132, 24, 32, 26, 1, -32 },
  { 4228, 24, 32, 26, 1, -32 },
  { 4324, 20, 32, 26, 3, -32 },
  { 4404, 12, 42, 26, 8, -37 },
  { 4467, 21, 42, 26, 3, -37 },
  { 4578, 12, 42, 26, 6, -37 },
  { 4641, 20, 17, 26, 3, -32 },
  { 4684, 21, 5, 26, 3, 1 },
  { 4698, 11, 7, 26, 7, -35 },
  { 4708, 21, 25, 26, 2, -25 },
  { 4774, 20, 32, 26, 3, -32 },
  { 4854, 21, 25, 26, 3, -25 },
  { 4920, 20, 32, 26, 3, -32 },
  { 5000, 20, 25, 26, 3, -25 },
  { 5063, 22, 32, 26, 2, -32 },
  { 5151, 20, 33, 26, 3, -25 },
  { 5234, 20, 32, 26, 3, -32 },
  { 5314, 22, 35, 26, 3, -35 },
  { 5411, 17, 43, 26, 4, -35 },
  { 5503, 21, 32, 26, 4, -32 },
  { 5587, 24, 32, 26, 1, -32 },
  { 5683, 22, 25, 26, 2, -25 },
  { 5752, 20, 25, 26, 3, -25 },
  { 5815, 20, 25, 26, 3, -25 },
  { 5878, 20, 33, 26, 3, -25 },
  { 5961, 20, 33, 26, 3, -25 },
  { 6044, 20, 25, 26, 4, -25 },
  { 6107, 21, 25, 26, 3, -25 },
  { 6173, 21, 31, 26, 2, -31 },
  { 6255, 20, 24, 26, 3, -24 },
  { 6315, 23, 24, 26, 2, -24 },
  { 6384, 25, 24, 26, 1, -24 },
  { 6459, 23, 24, 26, 2, -24 },
  { 6528, 23, 32, 26, 2, -24 },
  { 6620, 20, 24, 26, 3, -24 },
  { 6680, 20, 42, 26, 3, -37 },
  { 6785, 6, 42, 26, 10, -37 },
  { 6817, 20, 42, 26, 3, -37 },
  { 6922, 22, 11, 26, 2, -21 },
};

const GFXfont JetBrainsMono_Bold44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_BOLD44PT7B_H_
