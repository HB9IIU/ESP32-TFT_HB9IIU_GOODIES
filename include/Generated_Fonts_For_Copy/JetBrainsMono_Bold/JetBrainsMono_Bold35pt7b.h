#ifndef _JETBRAINSMONO_BOLD35PT7B_H_
#define _JETBRAINSMONO_BOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7D, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9C, 0x1C,
  0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x78,
  0x0E, 0x0E, 0x01, 0xC1, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x3C, 0x3C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80,
  0xF0, 0x70, 0x1C, 0x1E, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE1,
  0xC1, 0xC0, 0x78, 0x78, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3E,
  0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFE, 0x7D, 0xDF, 0x3C, 0xE7, 0x9E,
  0x73, 0xEF, 0x38, 0x07, 0x9C, 0x03, 0xEE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1D, 0xF8, 0x0E,
  0x7C, 0x07, 0x1F, 0xE3, 0x8F, 0xF9, 0xCF, 0xFC, 0xE7, 0xDF, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x39, 0xFC, 0x03, 0x9F, 0xF0,
  0x3C, 0xE3, 0x81, 0xCF, 0x1E, 0x1C, 0x78, 0x71, 0xE3, 0xC3, 0x8E, 0x1E,
  0x1C, 0xE0, 0x71, 0xCE, 0x03, 0xFE, 0x70, 0x0F, 0xE7, 0x00, 0x3E, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x84, 0x00, 0x39, 0xFC, 0x01,
  0xDF, 0xF0, 0x1C, 0xE3, 0x81, 0xCF, 0x1E, 0x1E, 0x70, 0xF0, 0xE3, 0x87,
  0x8E, 0x1C, 0x3C, 0xF0, 0xF1, 0xC7, 0x03, 0xFE, 0x70, 0x1F, 0xF7, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xE1, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x83, 0xDE,
  0x78, 0xF3, 0xCF, 0x9E, 0xF8, 0xF7, 0x9F, 0x0F, 0xF3, 0xE1, 0xFC, 0x7C,
  0x1F, 0x87, 0x81, 0xE0, 0xF0, 0x7E, 0x1F, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F,
  0xF3, 0xC3, 0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x9C, 0x00,
  0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0x00, 0x60, 0xE0, 0x1F, 0x03,
  0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0xC7,
  0xF1, 0xFC, 0x3F, 0x07, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x04, 0x0E, 0x04, 0xF1, 0xC7, 0x9F, 0x3B, 0xF7,
  0xFA, 0xFF, 0x3F, 0xFF, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00,
  0x7B, 0xC0, 0x1E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x0E, 0x0E, 0x00,
  0x80, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0,
  0x78, 0x3C, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0xFB,
  0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x39, 0xFF, 0xBE, 0xFF, 0xDF, 0x7F, 0xE7, 0x3F, 0xF1,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xF3,
  0xE0, 0xF9, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x03,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFD, 0xE0, 0xF9, 0xE0, 0xF1,
  0xE0, 0xC1, 0xE0, 0x81, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xC3, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7E, 0x7F, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x0F, 0x3E, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x78, 0x1E, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xE0,
  0xF9, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF7, 0x80, 0xF3, 0xE0, 0xF9, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x9C, 0x0F, 0xBF, 0x87, 0xFF, 0xE3, 0xFF, 0xFB, 0xF0, 0x7D, 0xF0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFB,
  0xC0, 0xF9, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xC0, 0x3D, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3E, 0x0F, 0x8F, 0x8F, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0xF8, 0xFC, 0x7E, 0x78, 0x1F, 0x7C, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x79, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xE3, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xBC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x10,
  0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x3E, 0xFF, 0xFF, 0xFB, 0xE0, 0x04, 0x0F, 0x8F, 0xE7, 0xF3, 0xF8, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F,
  0x1F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x00, 0x00,
  0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0,
  0x7F, 0x80, 0xF8, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x1C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00,
  0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x87, 0xFE, 0x1F, 0xF0, 0x7F,
  0x81, 0xFC, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xC7, 0xE3, 0xC0, 0x3C, 0xF0, 0x03,
  0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0x9F, 0xC3, 0xFB,
  0xF8, 0xFF, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x8F, 0x0F,
  0xF1, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F,
  0xE1, 0xFF, 0xFC, 0x3F, 0xBF, 0x83, 0xE7, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3B, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x1E, 0x78,
  0x03, 0xDF, 0x00, 0x7C, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFE, 0xF8, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF1, 0xFE, 0xF0, 0x3E,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xF8, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xFF, 0xF1,
  0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3E, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFB,
  0xE0, 0xF9, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xF0,
  0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0xDE, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE3,
  0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x1F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xE3, 0xE0, 0xF0, 0xF8, 0x78,
  0x7C, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x03, 0xC7, 0x81, 0xF3, 0xC0, 0xF9,
  0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x71, 0xDF, 0xB8, 0xEF, 0xDC,
  0x7F, 0xF7, 0x77, 0xFB, 0xBB, 0xFD, 0xDD, 0xFE, 0x6E, 0xFF, 0x3E, 0x7F,
  0x9F, 0x3F, 0xCF, 0x9F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xC0, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xF7, 0x0F, 0xEF, 0x1F, 0xCE, 0x3F, 0x9C,
  0x7F, 0x3C, 0xFE, 0x39, 0xFE, 0x73, 0xFC, 0xF3, 0xF8, 0xE7, 0xF1, 0xCF,
  0xE3, 0xDF, 0xC3, 0xBF, 0x87, 0x7F, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0x7C, 0x07, 0xC0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF,
  0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xFF,
  0xBF, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x07, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC1,
  0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xF3, 0xE0,
  0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x07, 0xE7, 0x80, 0xFB, 0xC0,
  0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0xDE, 0x07, 0xCF,
  0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF1, 0xF0, 0x78, 0x7C,
  0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0xC7, 0x81, 0xE3, 0xC0, 0xF9, 0xE0,
  0x7C, 0xF0, 0x1F, 0x78, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3E, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFF, 0x07, 0xFF, 0xBF, 0xBF, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0xF8,
  0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x78,
  0x3C, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0xE0, 0xE0, 0xFC, 0x1E, 0x1F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFF, 0x1B,
  0x1F, 0xE3, 0x63, 0xFC, 0x6C, 0x7F, 0x8D, 0x8F, 0xF1, 0xB1, 0xFE, 0x36,
  0x39, 0xC6, 0xC7, 0x39, 0xDC, 0xE7, 0x3B, 0x9C, 0xE7, 0x33, 0x9E, 0xC6,
  0xF3, 0xD8, 0xDE, 0x7B, 0x1B, 0xCF, 0x63, 0x79, 0xEC, 0x6F, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07,
  0xC1, 0xE0, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x7D, 0xF0, 0x07, 0xBC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF8,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x3E,
  0x7C, 0x07, 0xDF, 0x00, 0x7C, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x0F,
  0x3E, 0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8, 0x78,
  0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0x78,
  0x1E, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0x80, 0xF7, 0xC0,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x01, 0x80, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x1F,
  0x78, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x1F, 0xFF, 0x7F, 0xFF,
  0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F,
  0x7F, 0xFF, 0x7F, 0xEF, 0x1F, 0xCF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x40, 0xF3, 0xF8, 0xF7, 0xFC,
  0xFF, 0xFE, 0xFC, 0x7E, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF8, 0x3E, 0xFE, 0xFE, 0xFF, 0xFC, 0xF7, 0xFC, 0xF3, 0xF0, 0x00, 0x80,
  0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0x79, 0xE0,
  0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x3E, 0x7F, 0x7F, 0x1F, 0xFF,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x02, 0x0F, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F,
  0xFF, 0x7E, 0x3F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x7C,
  0x1F, 0x7F, 0x7F, 0x3F, 0xFF, 0x3F, 0xEF, 0x0F, 0xCF, 0x00, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3D,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x7E, 0x1F, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x06, 0x00, 0x7F, 0x3D, 0xFF, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0x7F, 0xDE, 0x7F, 0xBC, 0x3C, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x10, 0x79, 0xFC, 0xF7, 0xFD, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3C, 0x00, 0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x20, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3,
  0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0xF0, 0x1F, 0x78, 0x1F, 0x3C,
  0x0F, 0x1E, 0x0F, 0x8F, 0x0F, 0x87, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3C, 0x7C, 0x1E, 0x1F, 0x0F, 0x07, 0xC7, 0x83,
  0xE3, 0xC0, 0xF9, 0xE0, 0x7C, 0xF0, 0x1F, 0x78, 0x07, 0xC0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x03, 0x0C, 0x77, 0xCF, 0xBB, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x7F, 0x8E,
  0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0x71, 0xFE,
  0x38, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7,
  0xF8, 0xE3, 0xFC, 0x71, 0xFE, 0x38, 0xF0, 0x00, 0x41, 0xE7, 0xF3, 0xDF,
  0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0x01, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x3D,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7D, 0xE0, 0x3C, 0xF8, 0x3E, 0x7F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x40, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE,
  0xFC, 0x7E, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E,
  0xFE, 0xFE, 0xFF, 0xFC, 0xF7, 0xFC, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x7F, 0x3D,
  0xFF, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x1F, 0xFE, 0xFE, 0xFF, 0xFD, 0xFF, 0x78, 0xFC, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x40, 0xF3,
  0xFC, 0xF7, 0xFE, 0xF7, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF3,
  0xC0, 0x7D, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x1F, 0x7C,
  0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0x7F, 0x7F,
  0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x1F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0xCF, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xE0, 0xE0, 0xFE, 0x1C, 0x1F, 0xC7, 0xC7, 0xF8, 0xD8,
  0xFF, 0x1B, 0x1E, 0xE3, 0x63, 0x9C, 0x6C, 0x73, 0x8D, 0x8E, 0x7B, 0xBB,
  0xCF, 0x77, 0x79, 0xEC, 0x6F, 0x3D, 0x8D, 0xC3, 0xB1, 0xB8, 0x76, 0x37,
  0x0E, 0xC6, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x3C,
  0x00, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x8F, 0x80, 0xFB,
  0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x7C, 0x07, 0xC7,
  0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x8F, 0x80, 0xFB, 0xF0, 0x1F, 0x80, 0xF8,
  0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0xF8, 0x0F, 0x1F, 0x01, 0xF3, 0xC0, 0x1E,
  0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x3F, 0x80, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8, 0x00,
  0x3F, 0x03, 0xBF, 0xC1, 0xFF, 0xF0, 0xFE, 0x7C, 0xFE, 0x1F, 0xFF, 0x07,
  0xFF, 0x81, 0xFC, 0x00, 0x38,
};

const GFXglyph JetBrainsMono_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 26, 21, 8, -26 },
  { 18, 13, 11, 21, 4, -26 },
  { 36, 19, 26, 21, 1, -26 },
  { 98, 17, 35, 21, 2, -30 },
  { 173, 21, 26, 21, 0, -26 },
  { 242, 19, 26, 21, 1, -26 },
  { 304, 5, 11, 21, 8, -26 },
  { 311, 11, 33, 21, 6, -29 },
  { 357, 11, 33, 21, 4, -29 },
  { 403, 19, 18, 21, 1, -21 },
  { 446, 17, 17, 21, 2, -20 },
  { 483, 9, 11, 21, 5, -5 },
  { 496, 11, 4, 21, 5, -14 },
  { 502, 7, 6, 21, 7, -6 },
  { 508, 17, 33, 21, 2, -29 },
  { 579, 17, 26, 21, 2, -26 },
  { 635, 16, 26, 21, 3, -26 },
  { 687, 17, 26, 21, 2, -26 },
  { 743, 16, 26, 21, 2, -26 },
  { 795, 16, 26, 21, 2, -26 },
  { 847, 17, 26, 21, 2, -26 },
  { 903, 17, 26, 21, 2, -26 },
  { 959, 17, 26, 21, 2, -26 },
  { 1015, 17, 26, 21, 2, -26 },
  { 1071, 17, 26, 21, 2, -26 },
  { 1127, 7, 20, 21, 7, -20 },
  { 1145, 9, 26, 21, 5, -20 },
  { 1175, 15, 19, 21, 3, -21 },
  { 1211, 15, 13, 21, 3, -18 },
  { 1236, 15, 19, 21, 3, -21 },
  { 1272, 14, 26, 21, 4, -26 },
  { 1318, 19, 32, 21, 1, -26 },
  { 1394, 19, 26, 21, 1, -26 },
  { 1456, 16, 26, 21, 3, -26 },
  { 1508, 16, 26, 21, 3, -26 },
  { 1560, 16, 26, 21, 3, -26 },
  { 1612, 15, 26, 21, 3, -26 },
  { 1661, 16, 26, 21, 3, -26 },
  { 1713, 16, 26, 21, 3, -26 },
  { 1765, 15, 26, 21, 3, -26 },
  { 1814, 15, 26, 21, 3, -26 },
  { 1863, 17, 26, 21, 1, -26 },
  { 1919, 17, 26, 21, 3, -26 },
  { 1975, 15, 26, 21, 4, -26 },
  { 2024, 17, 26, 21, 2, -26 },
  { 2080, 15, 26, 21, 3, -26 },
  { 2129, 15, 26, 21, 3, -26 },
  { 2178, 17, 26, 21, 3, -26 },
  { 2234, 17, 32, 21, 2, -26 },
  { 2302, 17, 26, 21, 3, -26 },
  { 2358, 17, 26, 21, 2, -26 },
  { 2414, 17, 26, 21, 2, -26 },
  { 2470, 15, 26, 21, 3, -26 },
  { 2519, 19, 26, 21, 1, -26 },
  { 2581, 19, 26, 21, 1, -26 },
  { 2643, 19, 26, 21, 1, -26 },
  { 2705, 19, 26, 21, 1, -26 },
  { 2767, 15, 26, 21, 3, -26 },
  { 2816, 10, 33, 21, 6, -29 },
  { 2858, 17, 33, 21, 2, -29 },
  { 2929, 10, 33, 21, 5, -29 },
  { 2971, 17, 14, 21, 2, -26 },
  { 3001, 17, 4, 21, 2, 1 },
  { 3010, 8, 4, 21, 6, -27 },
  { 3014, 16, 20, 21, 2, -20 },
  { 3054, 16, 26, 21, 3, -26 },
  { 3106, 17, 20, 21, 2, -20 },
  { 3149, 16, 26, 21, 2, -26 },
  { 3201, 17, 20, 21, 2, -20 },
  { 3244, 17, 26, 21, 2, -26 },
  { 3300, 15, 26, 21, 3, -20 },
  { 3349, 15, 26, 21, 3, -26 },
  { 3398, 17, 28, 21, 3, -28 },
  { 3458, 14, 34, 21, 3, -28 },
  { 3518, 17, 26, 21, 3, -26 },
  { 3574, 19, 26, 21, 1, -26 },
  { 3636, 17, 20, 21, 2, -20 },
  { 3679, 15, 20, 21, 3, -20 },
  { 3717, 17, 20, 21, 2, -20 },
  { 3760, 16, 26, 21, 3, -20 },
  { 3812, 15, 26, 21, 3, -20 },
  { 3861, 16, 20, 21, 3, -20 },
  { 3901, 17, 20, 21, 2, -20 },
  { 3944, 18, 25, 21, 1, -25 },
  { 4001, 15, 19, 21, 3, -19 },
  { 4037, 19, 19, 21, 1, -19 },
  { 4083, 19, 19, 21, 1, -19 },
  { 4129, 19, 19, 21, 1, -19 },
  { 4175, 19, 25, 21, 1, -19 },
  { 4235, 15, 19, 21, 3, -19 },
  { 4271, 15, 33, 21, 3, -29 },
  { 4333, 5, 33, 21, 8, -29 },
  { 4354, 15, 33, 21, 3, -29 },
  { 4416, 17, 8, 21, 2, -16 },
};

const GFXfont JetBrainsMono_Bold35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_BOLD35PT7B_H_
