#ifndef _JETBRAINSMONO_BOLD46PT7B_H_
#define _JETBRAINSMONO_BOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0x0F,
  0x03, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x03,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x83, 0xC0, 0xF8, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xDD, 0xFE, 0x7E,
  0x71, 0xFB, 0xF1, 0xC7, 0xEF, 0xC7, 0x0F, 0xBF, 0x1C, 0x00, 0xFC, 0x70,
  0x03, 0xF9, 0xC0, 0x07, 0xF7, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1C, 0x7F, 0x00, 0x71, 0xFC, 0x01, 0xC3,
  0xF0, 0x07, 0x0F, 0xFE, 0x1C, 0x3F, 0xFC, 0x70, 0xFF, 0xF1, 0xC3, 0xFF,
  0xE7, 0x1F, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0xF1, 0xFF, 0x00, 0x1E, 0x3F, 0xF8, 0x03, 0xC7, 0xFF, 0x80, 0x7C, 0x78,
  0x7C, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x3C, 0x07, 0x83, 0xC7, 0x80, 0x78, 0x3C, 0xF8, 0x07,
  0x87, 0xCF, 0x00, 0x7F, 0xF9, 0xE0, 0x03, 0xFF, 0x3C, 0x00, 0x1F, 0xE3,
  0xC0, 0x00, 0x10, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x7C, 0xFF, 0x80, 0x07,
  0x9F, 0xFC, 0x00, 0xF3, 0xE7, 0xE0, 0x1E, 0x3C, 0x1E, 0x01, 0xE3, 0xC1,
  0xE0, 0x3C, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x03, 0xC1, 0xE1, 0xE0, 0x3C, 0x1E, 0x3C, 0x03, 0xE7, 0xE3, 0xC0, 0x1F,
  0xFC, 0x78, 0x01, 0xFF, 0x8F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0x83, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0xF8, 0x3F, 0xFC, 0xFC, 0x3E, 0xFC, 0x7E, 0x7E, 0xF8,
  0x3F, 0xFC, 0xF8, 0x3F, 0xFC, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8,
  0x07, 0xF0, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0x7F,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0x7E, 0x1F, 0xFE, 0x3E, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB,
  0xE0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xF0,
  0xFF, 0x87, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x04, 0x80, 0x01, 0xE0, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x81, 0xFC, 0x03, 0xF0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0xC0, 0x78, 0x0C, 0x78, 0x3C, 0x3E, 0x7F, 0x1C,
  0x7F, 0x3F, 0xEE, 0x7F, 0xFF, 0xFB, 0x7F, 0xE7, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x01,
  0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xC0, 0x0E, 0x01, 0xC0, 0x02, 0x00, 0xC0,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFB, 0xFD, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF1, 0xE3, 0xFF, 0x9F, 0x1F, 0xFC, 0xFC, 0xFF,
  0xE7, 0xE7, 0xFF, 0x3F, 0x3F, 0xF8, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xF9, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0x03, 0xE0, 0x30,
  0x1F, 0x01, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0xEF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x3F,
  0x7F, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0x1F,
  0xDF, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x30, 0x03, 0xF7, 0xFC,
  0x1F, 0xBF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xBF,
  0x80, 0x7E, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E,
  0x7E, 0x03, 0xF9, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00,
  0x7E, 0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7F, 0x03, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xF3, 0xF8, 0x7F, 0x03,
  0xF1, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFE, 0x03, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFE, 0x7F, 0xCF, 0xF9,
  0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0x07, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x07, 0x83, 0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFC, 0x7F, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x02, 0x0F, 0xF0, 0x1F, 0xCF, 0xF0, 0x3F, 0xEF, 0xF0, 0x7F,
  0xEF, 0xF0, 0x7C, 0x3F, 0xF0, 0x7C, 0x1F, 0xF0, 0x78, 0x1F, 0xF0, 0xF8,
  0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8,
  0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x1F, 0xF0, 0x78, 0x1F, 0xF0, 0x7C,
  0x1F, 0xF0, 0x7E, 0x3F, 0xF0, 0x7F, 0xEF, 0xF0, 0x3F, 0xEF, 0xF0, 0x1F,
  0xCF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xEF,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC7,
  0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83,
  0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7C, 0x07, 0xFB, 0xE0, 0x1F, 0xDF, 0x00,
  0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0x7C, 0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xF0, 0x0F, 0xEF, 0x80, 0x3F, 0x7C,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFE, 0x1F, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0xFE, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF9, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7F, 0x01, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xE1,
  0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F,
  0x87, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0E, 0xFF, 0xF0, 0x7B, 0xFD, 0xE1, 0xEF, 0xF7,
  0x87, 0xFF, 0xDE, 0x1D, 0xFF, 0x38, 0xF7, 0xFC, 0xF3, 0xDF, 0xF3, 0xCE,
  0x7F, 0xEF, 0x79, 0xFF, 0x9F, 0xE7, 0xFE, 0x7F, 0x9F, 0xF9, 0xFC, 0x7F,
  0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3E, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFB, 0xC0, 0xFF, 0xDE,
  0x07, 0xFE, 0xF8, 0x3F, 0xF3, 0xC1, 0xFF, 0x9F, 0x0F, 0xFC, 0xF8, 0x7F,
  0xE3, 0xC3, 0xFF, 0x9F, 0x1F, 0xFC, 0xF8, 0xFF, 0xE3, 0xC7, 0xFF, 0x1F,
  0x3F, 0xF8, 0xF9, 0xFF, 0xC3, 0xCF, 0xFE, 0x1F, 0x7F, 0xF0, 0xFB, 0xFF,
  0x83, 0xDF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xDF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xF8, 0x07, 0xEF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0x80, 0x3F, 0xBE, 0x00, 0x7E, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xBE, 0x01, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC,
  0x1F, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03,
  0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0,
  0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F,
  0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7F, 0x03, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0x3F, 0x00,
  0xFE, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7E,
  0x7E, 0x07, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xE7,
  0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0xBF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00,
  0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x81,
  0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xE7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x3E, 0x07, 0xFE, 0x0F,
  0x81, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xBE,
  0x0F, 0xC3, 0xEF, 0x83, 0xF0, 0xFB, 0xE0, 0xFC, 0x3E, 0x78, 0x77, 0x0F,
  0x9E, 0x1D, 0xC3, 0xE7, 0xC7, 0x70, 0xF9, 0xF1, 0xDE, 0x3E, 0x7C, 0x73,
  0x8F, 0x9F, 0x1C, 0xE3, 0xC7, 0xC7, 0x38, 0xF1, 0xF1, 0xCE, 0x3C, 0x7C,
  0x73, 0x8F, 0x1F, 0x3C, 0xE7, 0xC3, 0xCE, 0x39, 0xF0, 0xF3, 0x8E, 0x7C,
  0x3C, 0xE3, 0x9F, 0x0F, 0xB8, 0x77, 0xC3, 0xEE, 0x1D, 0xE0, 0xFB, 0x87,
  0x78, 0x3E, 0xE1, 0xDE, 0x0F, 0xF8, 0x77, 0x83, 0xFC, 0x1D, 0xE0, 0x7F,
  0x07, 0x78, 0x1F, 0xC1, 0xDE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC1, 0xF8,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xF9, 0xF0,
  0x0F, 0xCF, 0x80, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xFF,
  0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFB, 0xEF, 0xFF, 0xDF, 0x3F, 0xFC, 0xF8, 0xFF, 0x87, 0xC0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x0F, 0x8F, 0xF8,
  0xF9, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xBF, 0xFC, 0xF9, 0xFF, 0x8F, 0x8F, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFE, 0x1F, 0xE7, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xC1, 0xF8,
  0x7F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xC7,
  0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x1F, 0xFD, 0xF8, 0x3F, 0xCF, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0xBF, 0xC3, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xCF, 0xC7, 0xFF,
  0x7E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xC7, 0xFD, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFF, 0xBF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x7F, 0xF7, 0xE1, 0xFF, 0x3F, 0x00, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x0F, 0x8F, 0xF8,
  0xFB, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x07,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xBE, 0x00, 0xFC, 0xF8, 0x07, 0xF3, 0xE0,
  0x1F, 0x8F, 0x80, 0xFC, 0x3E, 0x07, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0xFE,
  0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xF8, 0x3F, 0x83, 0xE0, 0x7E, 0x0F, 0x81,
  0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x1F, 0xCF, 0x80, 0x3F,
  0x3E, 0x00, 0xFE, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xF0, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x61, 0xF7,
  0xE3, 0xF3, 0xEF, 0xEF, 0xF7, 0xFF, 0xDF, 0xFF, 0xE7, 0xE7, 0xFF, 0x8F,
  0x87, 0xFE, 0x0F, 0x0F, 0xFC, 0x1E, 0x1F, 0xF8, 0x3C, 0x3F, 0xF0, 0x78,
  0x7F, 0xE0, 0xF0, 0xFF, 0xC1, 0xE1, 0xFF, 0x83, 0xC3, 0xFF, 0x07, 0x87,
  0xFE, 0x0F, 0x0F, 0xFC, 0x1E, 0x1F, 0xF8, 0x3C, 0x3F, 0xF0, 0x78, 0x7F,
  0xE0, 0xF0, 0xFF, 0xC1, 0xE1, 0xFF, 0x83, 0xC3, 0xFF, 0x07, 0x87, 0xFE,
  0x0F, 0x0F, 0xFC, 0x1E, 0x1F, 0xF8, 0x3C, 0x3F, 0xF0, 0x78, 0x7C, 0x00,
  0x3C, 0x0F, 0x8F, 0xF8, 0xFB, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xE7, 0xF9, 0xF8, 0x0F, 0xEF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0xBF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x00, 0x3C, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xBF,
  0xFC, 0xF9, 0xFF, 0x8F, 0x8F, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xC7, 0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xBF, 0x1F, 0xFD, 0xF8, 0x3F, 0xCF, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF3,
  0xFF, 0x0F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F,
  0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFC, 0x0F,
  0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFD, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF,
  0x80, 0x7E, 0xFE, 0x07, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0,
  0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x3E, 0x07,
  0xFE, 0x0F, 0x81, 0xEF, 0x83, 0xE0, 0x7B, 0xE0, 0xFC, 0x1E, 0x78, 0x3F,
  0x0F, 0x9E, 0x0F, 0xC3, 0xE7, 0xC3, 0x70, 0xF9, 0xF1, 0xDC, 0x3C, 0x7C,
  0x77, 0x0F, 0x1F, 0x1C, 0xE3, 0xC3, 0xC7, 0x38, 0xF0, 0xF1, 0xCE, 0x7C,
  0x3C, 0x73, 0x9F, 0x0F, 0xB8, 0xE7, 0xC3, 0xEE, 0x39, 0xE0, 0xFB, 0x8E,
  0x78, 0x3E, 0xE1, 0xDE, 0x07, 0xB8, 0x77, 0x81, 0xEE, 0x1F, 0xE0, 0x7B,
  0x87, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xE7,
  0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x01,
  0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x7C, 0xFF, 0xC0, 0xFB, 0xFF, 0xC1,
  0xF7, 0xFF, 0xC3, 0xFF, 0x9F, 0xC7, 0xFE, 0x1F, 0xDF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFD, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 34, 28, 10, -34 },
  { 35, 16, 14, 28, 6, -34 },
  { 63, 25, 34, 28, 1, -34 },
  { 170, 22, 46, 28, 3, -40 },
  { 297, 28, 34, 28, 0, -34 },
  { 416, 24, 34, 28, 2, -34 },
  { 518, 6, 14, 28, 11, -34 },
  { 529, 14, 45, 28, 8, -39 },
  { 608, 15, 45, 28, 5, -39 },
  { 693, 25, 24, 28, 1, -28 },
  { 768, 22, 22, 28, 3, -26 },
  { 829, 11, 14, 28, 7, -7 },
  { 849, 15, 5, 28, 6, -18 },
  { 859, 9, 8, 28, 9, -8 },
  { 868, 22, 43, 28, 3, -38 },
  { 987, 21, 34, 28, 3, -34 },
  { 1077, 21, 34, 28, 4, -34 },
  { 1167, 22, 34, 28, 3, -34 },
  { 1261, 21, 34, 28, 3, -34 },
  { 1351, 21, 34, 28, 3, -34 },
  { 1441, 21, 34, 28, 3, -34 },
  { 1531, 22, 34, 28, 3, -34 },
  { 1625, 22, 34, 28, 3, -34 },
  { 1719, 22, 34, 28, 3, -34 },
  { 1813, 22, 34, 28, 3, -34 },
  { 1907, 8, 26, 28, 10, -26 },
  { 1933, 11, 33, 28, 7, -26 },
  { 1979, 21, 25, 28, 3, -28 },
  { 2045, 20, 16, 28, 4, -23 },
  { 2085, 21, 25, 28, 3, -28 },
  { 2151, 17, 34, 28, 6, -34 },
  { 2224, 24, 42, 28, 2, -34 },
  { 2350, 24, 34, 28, 2, -34 },
  { 2452, 21, 34, 28, 4, -34 },
  { 2542, 22, 34, 28, 3, -34 },
  { 2636, 22, 34, 28, 3, -34 },
  { 2730, 20, 34, 28, 4, -34 },
  { 2815, 21, 34, 28, 4, -34 },
  { 2905, 22, 34, 28, 3, -34 },
  { 2999, 20, 34, 28, 4, -34 },
  { 3084, 19, 34, 28, 4, -34 },
  { 3165, 22, 35, 28, 1, -34 },
  { 3262, 23, 34, 28, 3, -34 },
  { 3360, 20, 34, 28, 5, -34 },
  { 3445, 22, 34, 28, 3, -34 },
  { 3539, 21, 34, 28, 3, -34 },
  { 3629, 21, 34, 28, 3, -34 },
  { 3719, 22, 34, 28, 4, -34 },
  { 3813, 22, 42, 28, 3, -34 },
  { 3929, 23, 34, 28, 3, -34 },
  { 4027, 22, 34, 28, 3, -34 },
  { 4121, 23, 34, 28, 2, -34 },
  { 4219, 21, 34, 28, 3, -34 },
  { 4309, 24, 34, 28, 2, -34 },
  { 4411, 26, 34, 28, 1, -34 },
  { 4522, 25, 34, 28, 1, -34 },
  { 4629, 26, 34, 28, 1, -34 },
  { 4740, 20, 34, 28, 4, -34 },
  { 4825, 12, 43, 28, 9, -38 },
  { 4890, 22, 43, 28, 3, -38 },
  { 5009, 13, 43, 28, 6, -38 },
  { 5079, 21, 18, 28, 3, -34 },
  { 5127, 22, 5, 28, 3, 1 },
  { 5141, 12, 6, 28, 7, -36 },
  { 5150, 21, 26, 28, 3, -26 },
  { 5219, 20, 34, 28, 4, -34 },
  { 5304, 22, 26, 28, 3, -26 },
  { 5376, 21, 34, 28, 3, -34 },
  { 5466, 21, 26, 28, 3, -26 },
  { 5535, 23, 34, 28, 2, -34 },
  { 5633, 21, 34, 28, 3, -26 },
  { 5723, 20, 34, 28, 4, -34 },
  { 5808, 23, 36, 28, 3, -36 },
  { 5912, 18, 44, 28, 4, -36 },
  { 6011, 22, 34, 28, 4, -34 },
  { 6105, 25, 34, 28, 1, -34 },
  { 6212, 23, 26, 28, 2, -26 },
  { 6287, 20, 26, 28, 4, -26 },
  { 6352, 21, 26, 28, 3, -26 },
  { 6421, 20, 34, 28, 4, -26 },
  { 6506, 21, 34, 28, 3, -26 },
  { 6596, 22, 26, 28, 4, -26 },
  { 6668, 22, 26, 28, 3, -26 },
  { 6740, 22, 32, 28, 2, -32 },
  { 6828, 21, 25, 28, 3, -25 },
  { 6894, 24, 25, 28, 2, -25 },
  { 6969, 26, 25, 28, 1, -25 },
  { 7051, 24, 25, 28, 2, -25 },
  { 7126, 24, 33, 28, 2, -25 },
  { 7225, 20, 25, 28, 4, -25 },
  { 7288, 20, 43, 28, 4, -38 },
  { 7396, 6, 43, 28, 11, -38 },
  { 7429, 20, 43, 28, 4, -38 },
  { 7537, 23, 11, 28, 2, -22 },
};

const GFXfont JetBrainsMono_Bold46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_BOLD46PT7B_H_
