#ifndef _JETBRAINSMONO_BOLD36PT7B_H_
#define _JETBRAINSMONO_BOLD36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xC0, 0x00, 0x00, 0xCF, 0xBF, 0xFF, 0xE0, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x38, 0x38,
  0x07, 0x83, 0x80, 0x78, 0x38, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x70, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0E, 0x0F, 0x00, 0xE0,
  0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE1, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03,
  0x83, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0xFF, 0x1F, 0x33, 0xE7, 0x8C, 0xF9, 0xE3, 0x1E, 0x78, 0xC0,
  0x1F, 0x30, 0x07, 0xEC, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x33, 0xE0, 0x0C, 0x78, 0x03,
  0x1F, 0xF8, 0xC7, 0xFE, 0x31, 0xEF, 0xCC, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x3F, 0x80, 0x3D, 0xFF, 0x01, 0xC7, 0x9E, 0x0F,
  0x3C, 0x38, 0x38, 0xF0, 0xE1, 0xC3, 0xC3, 0x8F, 0x0F, 0x0E, 0x38, 0x3C,
  0x39, 0xC0, 0x71, 0xEF, 0x01, 0xFF, 0x38, 0x03, 0xF9, 0xC0, 0x01, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x7B, 0xFC,
  0x01, 0xDF, 0xF8, 0x0E, 0x70, 0xE0, 0x71, 0xC3, 0x83, 0xC7, 0x0E, 0x0E,
  0x1C, 0x38, 0x70, 0x70, 0xE3, 0xC1, 0xC3, 0x8E, 0x07, 0xFE, 0x70, 0x0F,
  0xF3, 0x80, 0x1F, 0x80, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x03, 0xE3, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0xF7, 0x9F, 0x3E, 0xF1, 0xE7, 0x9E, 0x3F, 0xF3, 0xC3,
  0xFC, 0x78, 0x3F, 0x8F, 0x03, 0xE1, 0xE0, 0x7C, 0x3C, 0x1F, 0x87, 0xE7,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFE, 0xF8, 0x7F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFD, 0xEF, 0x7B, 0xDE, 0x00, 0x60, 0x3C, 0x0F, 0x87, 0xF1, 0xFC, 0x3E,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F,
  0x01, 0xE0, 0x0C, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x87, 0xF0,
  0xFE, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x0E, 0x0C, 0x7C, 0xE3, 0xEF,
  0xE6, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0x80,
  0x03, 0xBC, 0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x01, 0xF1, 0xF0, 0x1F, 0x0F,
  0x80, 0xE0, 0x70, 0x04, 0x04, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x8F, 0x87, 0xC7, 0xC3,
  0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0x7D, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x18, 0xFF, 0x9E,
  0x7F, 0xDF, 0x3F, 0xE7, 0x9F, 0xF3, 0xCF, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x7D, 0xF0, 0x3E, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xDE, 0x07, 0x8F, 0x03, 0x87, 0x81, 0x83, 0xC0,
  0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7,
  0xF7, 0xF3, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0xFD,
  0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC1, 0xF3, 0xE0,
  0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFB,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0xFE, 0xF8, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xEF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0x8F, 0xEF, 0xC0, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1E, 0xF8, 0x07, 0x9F, 0x03, 0xE7, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0x7D, 0xE0, 0x3E, 0xF0, 0x1F,
  0x78, 0x0F, 0xBE, 0x07, 0x8F, 0x87, 0xC7, 0xEF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xC0, 0x7F, 0xF0, 0x7E, 0xFC, 0x7C, 0x1F, 0x3C, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xF0, 0x3E, 0xFF, 0xFF, 0x3F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7E, 0x1F, 0x1F, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0x9F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x3F, 0x7F, 0xFD, 0xFB, 0xE0,
  0x1E, 0x3F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xF8,
  0xF0, 0xF0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F,
  0x81, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x03, 0xC7, 0xC0,
  0x1E, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x01, 0x8F, 0xF0,
  0x7E, 0xFF, 0x0F, 0xFF, 0xF0, 0xF1, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF,
  0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F,
  0xF1, 0xE0, 0xFF, 0x1F, 0x1F, 0xF0, 0xFF, 0xFF, 0x0F, 0xEF, 0xF0, 0x3C,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xC0, 0x7C, 0xF8,
  0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x3C, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x1F, 0xCF, 0x01, 0xF7, 0x80, 0xFB,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x3F, 0x9F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xC0, 0xF9, 0xE0, 0x3E, 0xF0, 0x0F, 0x78,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0xFE, 0x7F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFE, 0x7F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF1, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0, 0x7D, 0xFF,
  0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xF0, 0x0F, 0xF8, 0x0F,
  0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xF3, 0xC1, 0xF1, 0xE0,
  0xF8, 0xF0, 0xF8, 0x78, 0x7C, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x83, 0xC7, 0xC1, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x3E, 0x3C, 0x1F,
  0x1E, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0,
  0x0F, 0xF8, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xEE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xBF, 0xDC, 0xEF, 0xF7,
  0x3B, 0xFD, 0xDC, 0xFF, 0x3F, 0x3F, 0xCF, 0xCF, 0xF3, 0xF3, 0xFC, 0xF9,
  0xFF, 0x1E, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xF0, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xEE, 0x0F, 0xEE, 0x0F, 0xEF, 0x0F, 0xF7, 0x0F, 0xF7, 0x0F,
  0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF,
  0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0x80, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0xFE, 0x7E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x07, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x03, 0xE7,
  0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0,
  0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07,
  0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0x9E, 0x03, 0xE7,
  0xC1, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x01, 0xF7,
  0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07,
  0xDE, 0x0F, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF0,
  0xF8, 0x78, 0x7C, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x03, 0xC7, 0x81, 0xF3,
  0xC0, 0xF9, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x07, 0xC0, 0x01, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x3F, 0x9F, 0x03, 0xE7, 0x80,
  0xF9, 0xE0, 0x1E, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0xC0,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xF0, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0,
  0x3C, 0x78, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x3E, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7,
  0xC0, 0x7C, 0xF0, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDE,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x1F,
  0x0F, 0xF1, 0xF0, 0xFF, 0x1F, 0x0E, 0xF1, 0xF0, 0xEF, 0x1B, 0x9E, 0xF1,
  0xB9, 0xE7, 0x1B, 0x9E, 0x71, 0x99, 0xE7, 0x19, 0x9E, 0x7B, 0x99, 0xE7,
  0xB9, 0x9E, 0x7B, 0x99, 0xC7, 0xB9, 0x9C, 0x7B, 0x1D, 0xC7, 0xB1, 0xDC,
  0x3B, 0x1D, 0xC3, 0xB0, 0xFC, 0x3B, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0xFC, 0x03, 0xE7, 0xC0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F,
  0x9F, 0x00, 0x7B, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7B, 0xE0, 0x0F, 0x9F, 0x00, 0xF1, 0xF0, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x1F, 0x00,
  0xF9, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x77, 0x80,
  0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0x78, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x03,
  0xCF, 0x81, 0xE7, 0x80, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x07, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7, 0xC0, 0xFB, 0xC0, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x03, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0x81, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xBF, 0xFB,
  0xCF, 0xFD, 0xE3, 0xF8, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xF7, 0xFE, 0xFF,
  0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFE, 0xF7, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0x0F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x1F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7E,
  0x7E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x0F, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7,
  0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x0F,
  0x9E, 0x0F, 0x8F, 0x0F, 0x87, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3C, 0x3E, 0x1E, 0x0F, 0x8F, 0x07, 0xC7, 0x81, 0xF3,
  0xC0, 0xF9, 0xE0, 0x3E, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0xF7,
  0x8F, 0x3F, 0xF7, 0xEF, 0xFF, 0xFB, 0xC7, 0x9F, 0xF1, 0xC3, 0xFC, 0x70,
  0xFF, 0x1C, 0x3F, 0xC7, 0x0F, 0xF1, 0xC3, 0xFC, 0x70, 0xFF, 0x1C, 0x3F,
  0xC7, 0x0F, 0xF1, 0xC3, 0xFC, 0x70, 0xFF, 0x1C, 0x3F, 0xC7, 0x0F, 0xF1,
  0xC3, 0xFC, 0x70, 0xFF, 0x1C, 0x3F, 0xC7, 0x0F, 0xF1, 0xF0, 0xF7, 0xFC,
  0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0x7F, 0xFE,
  0x3F, 0xF8, 0x0F, 0xF0, 0xF1, 0xF0, 0xF7, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFE, 0xF7, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x9F, 0x3F, 0xDF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xF9, 0xF8, 0x7D, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xC0, 0xFB, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0xF0, 0x0F, 0x7E, 0x1F, 0xBF, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0,
  0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x3E, 0x01, 0xE3, 0xC0, 0x7C,
  0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0,
  0x3C, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x80,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0E, 0xF1, 0xF0,
  0xE7, 0x1F, 0x1E, 0x71, 0xB9, 0xE7, 0x1B, 0x9E, 0x79, 0xB9, 0xE7, 0x99,
  0x9C, 0x7B, 0x99, 0xC7, 0xB9, 0x9C, 0x3B, 0x9B, 0xC3, 0xB1, 0xFC, 0x3B,
  0x1F, 0xC3, 0xB1, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xE0, 0xF8, 0x7C, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0xC0,
  0xF9, 0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x7C, 0x03,
  0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x87, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E,
  0x01, 0xF0, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0x1E, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x0F, 0x0F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xF1, 0xE3, 0xFC, 0x7F, 0xEF, 0x0F, 0xFB, 0xC1, 0xFC, 0x00,
  0x0C, 0x00,
};

const GFXglyph JetBrainsMono_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 12, 11, 22, 5, -26 },
  { 38, 20, 26, 22, 1, -26 },
  { 103, 18, 36, 22, 2, -31 },
  { 184, 22, 26, 22, 0, -26 },
  { 256, 19, 27, 22, 2, -27 },
  { 321, 5, 11, 22, 8, -26 },
  { 328, 11, 34, 22, 6, -30 },
  { 375, 12, 34, 22, 4, -30 },
  { 426, 20, 19, 22, 1, -22 },
  { 474, 17, 17, 22, 2, -20 },
  { 511, 9, 11, 22, 5, -5 },
  { 524, 12, 4, 22, 5, -14 },
  { 530, 7, 6, 22, 7, -6 },
  { 536, 17, 34, 22, 2, -30 },
  { 609, 17, 27, 22, 2, -27 },
  { 667, 17, 26, 22, 3, -26 },
  { 723, 17, 27, 22, 2, -27 },
  { 781, 17, 26, 22, 2, -26 },
  { 837, 17, 26, 22, 2, -26 },
  { 893, 16, 26, 22, 3, -26 },
  { 945, 18, 26, 22, 2, -26 },
  { 1004, 18, 26, 22, 2, -26 },
  { 1063, 17, 27, 22, 2, -27 },
  { 1121, 18, 27, 22, 2, -27 },
  { 1182, 7, 20, 22, 7, -20 },
  { 1200, 8, 26, 22, 6, -20 },
  { 1226, 16, 20, 22, 3, -22 },
  { 1266, 16, 13, 22, 3, -18 },
  { 1292, 16, 20, 22, 3, -22 },
  { 1332, 14, 26, 22, 4, -26 },
  { 1378, 20, 33, 22, 1, -27 },
  { 1461, 19, 26, 22, 1, -26 },
  { 1523, 17, 26, 22, 3, -26 },
  { 1579, 16, 27, 22, 3, -27 },
  { 1633, 16, 26, 22, 3, -26 },
  { 1685, 16, 26, 22, 3, -26 },
  { 1737, 16, 26, 22, 3, -26 },
  { 1789, 16, 27, 22, 3, -27 },
  { 1843, 16, 26, 22, 3, -26 },
  { 1895, 15, 26, 22, 3, -26 },
  { 1944, 17, 26, 22, 1, -26 },
  { 2000, 17, 26, 22, 3, -26 },
  { 2056, 15, 26, 22, 4, -26 },
  { 2105, 18, 26, 22, 2, -26 },
  { 2164, 16, 26, 22, 3, -26 },
  { 2216, 16, 27, 22, 3, -27 },
  { 2270, 17, 26, 22, 3, -26 },
  { 2326, 18, 33, 22, 2, -27 },
  { 2401, 17, 26, 22, 3, -26 },
  { 2457, 18, 27, 22, 2, -27 },
  { 2518, 18, 26, 22, 2, -26 },
  { 2577, 16, 26, 22, 3, -26 },
  { 2629, 19, 26, 22, 1, -26 },
  { 2691, 20, 26, 22, 1, -26 },
  { 2756, 20, 26, 22, 1, -26 },
  { 2821, 20, 26, 22, 1, -26 },
  { 2886, 16, 26, 22, 3, -26 },
  { 2938, 10, 34, 22, 7, -30 },
  { 2981, 17, 34, 22, 2, -30 },
  { 3054, 10, 34, 22, 5, -30 },
  { 3097, 17, 14, 22, 2, -26 },
  { 3127, 17, 4, 22, 2, 1 },
  { 3136, 9, 5, 22, 6, -28 },
  { 3142, 17, 20, 22, 2, -20 },
  { 3185, 16, 26, 22, 3, -26 },
  { 3237, 16, 20, 22, 3, -20 },
  { 3277, 16, 26, 22, 3, -26 },
  { 3329, 16, 20, 22, 3, -20 },
  { 3369, 17, 26, 22, 2, -26 },
  { 3425, 16, 26, 22, 3, -20 },
  { 3477, 16, 26, 22, 3, -26 },
  { 3529, 17, 28, 22, 3, -28 },
  { 3589, 14, 34, 22, 3, -28 },
  { 3649, 17, 26, 22, 3, -26 },
  { 3705, 19, 26, 22, 1, -26 },
  { 3767, 18, 20, 22, 2, -20 },
  { 3812, 16, 20, 22, 3, -20 },
  { 3852, 16, 20, 22, 3, -20 },
  { 3892, 16, 26, 22, 3, -20 },
  { 3944, 16, 26, 22, 3, -20 },
  { 3996, 17, 20, 22, 3, -20 },
  { 4039, 17, 20, 22, 2, -20 },
  { 4082, 17, 25, 22, 2, -25 },
  { 4136, 16, 20, 22, 3, -20 },
  { 4176, 19, 20, 22, 1, -20 },
  { 4224, 20, 20, 22, 1, -20 },
  { 4274, 19, 20, 22, 1, -20 },
  { 4322, 19, 26, 22, 1, -20 },
  { 4384, 16, 20, 22, 3, -20 },
  { 4424, 16, 34, 22, 3, -30 },
  { 4492, 4, 34, 22, 9, -30 },
  { 4509, 16, 34, 22, 3, -30 },
  { 4577, 18, 9, 22, 2, -17 },
};

const GFXfont JetBrainsMono_Bold36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_BOLD36PT7B_H_
