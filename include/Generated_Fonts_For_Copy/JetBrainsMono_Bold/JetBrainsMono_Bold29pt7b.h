#ifndef _JETBRAINSMONO_BOLD29PT7B_H_
#define _JETBRAINSMONO_BOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold29pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x03,
  0xBF, 0xF7, 0x80, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8E, 0xE3, 0x80, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E,
  0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x30, 0x18, 0x30, 0x18, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x38,
  0x60, 0x30, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBC, 0xDE, 0xF3,
  0x3B, 0xCC, 0x0F, 0x30, 0x3E, 0xC0, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xF8, 0x0D, 0xF0, 0x33, 0xF8, 0xCF, 0xF3, 0x3F, 0xCD, 0xE7,
  0xFF, 0x9F, 0xFC, 0x1F, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x3E, 0x03, 0xBF, 0x81, 0xB8, 0xE1, 0xDC, 0x71, 0xCE, 0x38, 0xC7, 0x1C,
  0xC3, 0x8E, 0xE0, 0xFE, 0xE0, 0x3E, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x31, 0x00, 0x3B, 0xF0, 0x3B, 0xFC, 0x39, 0x8E, 0x18, 0xC7, 0x1C, 0x63,
  0x9C, 0x31, 0xCC, 0x1C, 0xEE, 0x0F, 0xEE, 0x03, 0xE0, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x38, 0x78, 0x38, 0x38, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x01, 0xF7, 0x9E, 0xF3, 0xDC, 0xF1,
  0xFC, 0xF1, 0xF8, 0xF0, 0xF8, 0xF0, 0x70, 0xF0, 0xF8, 0x7F, 0xFC, 0x7F,
  0xDE, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x83, 0xC3, 0xE3, 0xE3,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x7E, 0x1F, 0x83,
  0xC0, 0xE0, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x83, 0xC1, 0xF1, 0xF8, 0xFC, 0x3E, 0x0E, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x43, 0x86, 0xF1, 0x9E,
  0xFD, 0xFE, 0x7F, 0xFD, 0x03, 0x80, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0x70,
  0x1C, 0x78, 0x3C, 0x7C, 0x18, 0x30, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x7C, 0xF1, 0xE7, 0x8F, 0x1C, 0x38,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0xE1, 0xFF,
  0x9F, 0xFF, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE2, 0x3F,
  0x39, 0xF9, 0xEF, 0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x3F, 0xC3, 0xDF, 0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x03,
  0xFC, 0x3E, 0xF0, 0xF3, 0xC3, 0x8F, 0x08, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF,
  0xC7, 0xFF, 0x3C, 0x1E, 0xF0, 0x7B, 0x80, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0xE0, 0x7F, 0x83, 0xFE, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x07,
  0xF0, 0x7F, 0x83, 0xDF, 0xFC, 0xFF, 0xE1, 0xFC, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03,
  0xC3, 0xDE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x78, 0x7F, 0xF3, 0xFF,
  0xDE, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x7F,
  0xC3, 0xDF, 0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7B, 0xE1, 0xDF,
  0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3B, 0x81, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0xE1, 0xFF,
  0xC7, 0xFF, 0xBC, 0x1E, 0xF0, 0x7B, 0xC0, 0xEF, 0x07, 0x9E, 0x1E, 0x3D,
  0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xFC, 0x78, 0x7B, 0xC1, 0xEF, 0x03, 0xB8,
  0x0F, 0xF0, 0x3B, 0xC1, 0xE7, 0xFF, 0x9F, 0xFC, 0x1F, 0xE0, 0x1F, 0xE1,
  0xFF, 0xC7, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE1, 0xE7, 0xFF, 0x8F, 0xFE, 0x1E, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x7F,
  0xFF, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFF, 0xEF, 0x1E, 0x7C, 0xF9,
  0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xCF, 0x1E, 0x38,
  0xF1, 0xE3, 0x8F, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xE1, 0xFC,
  0x7F, 0x03, 0xE0, 0x1C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0,
  0x07, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xE0, 0x07,
  0x00, 0xF8, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xC0, 0x78, 0x03, 0x00, 0x00,
  0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0x3E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xE1, 0xFE, 0x1F, 0xC1, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0xF0, 0x3F, 0xFC,
  0x3C, 0x3C, 0x78, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE1, 0xF7,
  0xE3, 0xF7, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x87, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0xFF, 0xE1, 0xF7, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x03,
  0xBC, 0x0F, 0x38, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xE1, 0xE1, 0xC3, 0xC3,
  0x87, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0x78, 0x1C, 0xF0, 0x3D, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0,
  0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xF1, 0xF3, 0xFF, 0x8F, 0xFE, 0x3C,
  0x7E, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF,
  0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBE, 0x1E,
  0xF0, 0x3B, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0xF0, 0x39, 0xE1,
  0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C,
  0x3E, 0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B,
  0xC3, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBE, 0x1E, 0xF0, 0x3B, 0xC0,
  0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x39, 0xE1, 0xE7, 0xFF, 0x8F,
  0xFC, 0x1F, 0xC0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x78,
  0x78, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0xF3, 0xC1, 0xE7, 0x81,
  0xEF, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xF6, 0x3F, 0xD8, 0xDF, 0xF3,
  0x7F, 0xCD, 0xFB, 0x77, 0xEF, 0x9F, 0xBE, 0x7E, 0x7B, 0xF9, 0xEF, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3C, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xF6,
  0x1F, 0xB8, 0xFD, 0xC7, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xC7, 0x7E, 0x3B,
  0xF1, 0xDF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x07, 0x80, 0x1F, 0xE1, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xC3, 0xDF, 0xFC, 0x7F, 0xE1, 0xFC,
  0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC3,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBC, 0x1E, 0xF0, 0x3B, 0xC0,
  0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0,
  0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xE1, 0xE7, 0xFF, 0x0F,
  0xFC, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x7B, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x3C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0x3C, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBC, 0x1E, 0xF0, 0x3B, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xE7, 0xFF, 0x9F, 0xFC,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xC3, 0xDF,
  0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0xF0, 0x0F, 0xE0, 0x3D, 0xC0, 0x7B, 0xC0,
  0xE7, 0x81, 0xCF, 0x07, 0x8E, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0,
  0x71, 0xE0, 0xE3, 0x81, 0xE7, 0x03, 0xCE, 0x03, 0xBC, 0x07, 0x70, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF1, 0xC3, 0xB8,
  0xE1, 0xDC, 0x78, 0xEE, 0x3C, 0x77, 0x1E, 0x73, 0x8B, 0x39, 0xCD, 0x9C,
  0xE6, 0xCE, 0x73, 0x67, 0x39, 0xB3, 0x8E, 0xC9, 0xC7, 0x66, 0xE3, 0xB3,
  0x71, 0xD9, 0xB0, 0xF8, 0xD8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x8F, 0x87, 0xC7, 0xC1, 0xE1, 0xE0, 0xF8, 0x1E, 0x78, 0x3C, 0x3C, 0x3C,
  0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0,
  0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78,
  0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x7C, 0x03, 0xF0, 0x3B, 0x81, 0xDE, 0x1E, 0x70, 0xE3, 0x87, 0x0E,
  0x70, 0x73, 0x83, 0xFC, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0xF0, 0xE1, 0xF0, 0x1F, 0xC1, 0xFF, 0x9F, 0xFE, 0xF0, 0xFF, 0x07, 0x80,
  0x1C, 0x00, 0xE7, 0xFF, 0x7F, 0xFF, 0x81, 0xF8, 0x0F, 0xC0, 0xFF, 0x07,
  0xFE, 0xFD, 0xFE, 0xE7, 0xE7, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7B, 0xF3, 0xFF, 0xDF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF,
  0xFF, 0xEF, 0x7E, 0x00, 0x1F, 0xC1, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x7F,
  0x87, 0xBF, 0xFC, 0xFF, 0xC3, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x8F, 0x9D, 0xFE, 0xEF, 0xF7, 0xF8, 0xFF, 0x83, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xC3, 0xDF,
  0xEE, 0xFF, 0x73, 0xF3, 0x80, 0x1F, 0xC1, 0xFF, 0x9F, 0xFD, 0xE0, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x07, 0xBF, 0xFC, 0xFF, 0xC3, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0x3B, 0xFD, 0xDF,
  0xEF, 0xF1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x1F, 0xF1, 0xF7, 0xFB, 0x9F, 0xDC, 0x7C, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xCF, 0xFE, 0x7F, 0xE3, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7B, 0xF3, 0xFF, 0xDF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x7F,
  0xE7, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x03,
  0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x07, 0xBC, 0x1F, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC7, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3C, 0x78, 0x78, 0xF0, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xE0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xE0, 0xDE, 0x7B, 0x7F, 0xEF, 0xFB, 0xF9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E,
  0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x1F,
  0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xF7, 0xE7, 0xFF, 0xBF, 0xFF, 0xF0, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x1F, 0xC1, 0xFF, 0x9F, 0xFD,
  0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFF, 0x87, 0xBF, 0xF8, 0xFF, 0xC3, 0xF8, 0xF7, 0xE7, 0xFF,
  0xBF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xDE, 0xFC, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x3B, 0xFD, 0xDF,
  0xEF, 0xF1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0xFF, 0x87, 0xBF, 0xDD, 0xFE, 0xE7, 0xE7, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xE7, 0xE7, 0x7F, 0xBF, 0xFD,
  0xE1, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1F, 0xE1, 0xFF,
  0xC7, 0xFF, 0xBC, 0x1E, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xFF, 0xE7, 0xFF, 0x8F,
  0xF8, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xF7, 0x87, 0xBF, 0xF8, 0xFF,
  0xC3, 0xF8, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0x73, 0xC0, 0xE3, 0x83, 0xC7,
  0x87, 0x8F, 0x0E, 0x0E, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x3B, 0xC0, 0x77,
  0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x86, 0xE3, 0xCE, 0xE2, 0xCE, 0xE6, 0xCE, 0x66, 0xCE, 0x76, 0xCE,
  0x76, 0x4E, 0x76, 0x6C, 0x76, 0x7C, 0x74, 0x7C, 0x7C, 0x7C, 0x3C, 0x7C,
  0x3C, 0x7C, 0x3C, 0x78, 0xF8, 0x1E, 0xF0, 0x78, 0xF1, 0xE0, 0xF3, 0xC1,
  0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0xF7, 0x83, 0xC7, 0x87, 0x87, 0x9E, 0x0F, 0x78, 0x0F, 0xF0, 0x1E,
  0xF0, 0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0xC3, 0xC7, 0x87, 0x07, 0x1E, 0x0F,
  0x3C, 0x1E, 0x70, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x8F,
  0xF8, 0x7F, 0x03, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xF8, 0x0F, 0xC0, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7F, 0x80,
  0xFC, 0x1F, 0xE1, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0xFE, 0x07, 0xF0, 0x3E, 0x00, 0x08, 0x00,
  0x7E, 0x1D, 0xFE, 0x3F, 0xBC, 0x7F, 0x3F, 0xFE, 0x3F, 0xBC, 0x3E, 0x00,
};

const GFXglyph JetBrainsMono_Bold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 10, 9, 17, 4, -21 },
  { 27, 16, 21, 17, 1, -21 },
  { 69, 14, 29, 17, 2, -25 },
  { 120, 17, 21, 17, 0, -21 },
  { 165, 16, 21, 17, 1, -21 },
  { 207, 3, 9, 17, 7, -21 },
  { 211, 9, 27, 17, 5, -24 },
  { 242, 10, 27, 17, 3, -24 },
  { 276, 16, 15, 17, 1, -18 },
  { 306, 14, 13, 17, 2, -16 },
  { 329, 7, 9, 17, 4, -4 },
  { 337, 9, 3, 17, 4, -11 },
  { 341, 5, 5, 17, 6, -5 },
  { 345, 14, 27, 17, 2, -24 },
  { 393, 13, 21, 17, 2, -21 },
  { 428, 14, 21, 17, 2, -21 },
  { 465, 14, 21, 17, 2, -21 },
  { 502, 13, 21, 17, 2, -21 },
  { 537, 13, 21, 17, 2, -21 },
  { 572, 13, 21, 17, 2, -21 },
  { 607, 14, 21, 17, 2, -21 },
  { 644, 14, 21, 17, 2, -21 },
  { 681, 14, 21, 17, 2, -21 },
  { 718, 14, 21, 17, 2, -21 },
  { 755, 5, 16, 17, 6, -16 },
  { 765, 7, 21, 17, 4, -16 },
  { 784, 13, 15, 17, 2, -17 },
  { 809, 13, 11, 17, 2, -15 },
  { 827, 13, 15, 17, 2, -17 },
  { 852, 12, 21, 17, 3, -21 },
  { 884, 16, 26, 17, 1, -21 },
  { 936, 15, 21, 17, 1, -21 },
  { 976, 14, 21, 17, 2, -21 },
  { 1013, 14, 21, 17, 2, -21 },
  { 1050, 14, 21, 17, 2, -21 },
  { 1087, 12, 21, 17, 3, -21 },
  { 1119, 13, 21, 17, 2, -21 },
  { 1154, 14, 21, 17, 2, -21 },
  { 1191, 13, 21, 17, 2, -21 },
  { 1226, 12, 21, 17, 3, -21 },
  { 1258, 14, 21, 17, 1, -21 },
  { 1295, 15, 21, 17, 2, -21 },
  { 1335, 13, 21, 17, 3, -21 },
  { 1370, 14, 21, 17, 2, -21 },
  { 1407, 13, 21, 17, 2, -21 },
  { 1442, 13, 21, 17, 2, -21 },
  { 1477, 14, 21, 17, 2, -21 },
  { 1514, 14, 26, 17, 2, -21 },
  { 1560, 14, 21, 17, 2, -21 },
  { 1597, 14, 21, 17, 2, -21 },
  { 1634, 15, 21, 17, 1, -21 },
  { 1674, 13, 21, 17, 2, -21 },
  { 1709, 15, 21, 17, 1, -21 },
  { 1749, 17, 21, 17, 0, -21 },
  { 1794, 16, 21, 17, 1, -21 },
  { 1836, 16, 21, 17, 1, -21 },
  { 1878, 13, 21, 17, 2, -21 },
  { 1913, 8, 27, 17, 5, -24 },
  { 1940, 14, 27, 17, 2, -24 },
  { 1988, 8, 27, 17, 4, -24 },
  { 2015, 13, 11, 17, 2, -21 },
  { 2033, 14, 3, 17, 2, 1 },
  { 2039, 7, 4, 17, 5, -23 },
  { 2043, 13, 16, 17, 2, -16 },
  { 2069, 13, 21, 17, 2, -21 },
  { 2104, 13, 16, 17, 2, -16 },
  { 2130, 13, 21, 17, 2, -21 },
  { 2165, 13, 16, 17, 2, -16 },
  { 2191, 14, 21, 17, 2, -21 },
  { 2228, 13, 21, 17, 2, -16 },
  { 2263, 13, 21, 17, 2, -21 },
  { 2298, 14, 23, 17, 2, -23 },
  { 2339, 12, 28, 17, 2, -23 },
  { 2381, 15, 21, 17, 2, -21 },
  { 2421, 15, 21, 17, 1, -21 },
  { 2461, 14, 16, 17, 2, -16 },
  { 2489, 13, 16, 17, 2, -16 },
  { 2515, 13, 16, 17, 2, -16 },
  { 2541, 13, 21, 17, 2, -16 },
  { 2576, 13, 21, 17, 2, -16 },
  { 2611, 13, 16, 17, 3, -16 },
  { 2637, 14, 16, 17, 2, -16 },
  { 2665, 14, 20, 17, 1, -20 },
  { 2700, 13, 16, 17, 2, -16 },
  { 2726, 15, 16, 17, 1, -16 },
  { 2756, 16, 16, 17, 1, -16 },
  { 2788, 15, 16, 17, 1, -16 },
  { 2818, 15, 21, 17, 1, -16 },
  { 2858, 13, 16, 17, 2, -16 },
  { 2884, 13, 27, 17, 2, -24 },
  { 2928, 4, 27, 17, 7, -24 },
  { 2942, 13, 27, 17, 2, -24 },
  { 2986, 15, 7, 17, 1, -14 },
};

const GFXfont JetBrainsMono_Bold29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_BOLD29PT7B_H_
