#ifndef _JETBRAINSMONO_BOLD41PT7B_H_
#define _JETBRAINSMONO_BOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFB,
  0xFF, 0xFF, 0xEF, 0x80, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xE0, 0xF7, 0x83, 0xDE,
  0x0F, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07,
  0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0xF0,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x3C, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x0F,
  0x03, 0xC0, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x07, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x0F, 0x03, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x7F, 0xE7, 0xE7, 0x3E, 0x7C, 0x73,
  0xF7, 0xC7, 0x1F, 0x7C, 0x70, 0x07, 0xC7, 0x00, 0x7E, 0x70, 0x03, 0xF7,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x77, 0xF0, 0x07, 0x3F, 0x00, 0x71, 0xF0,
  0x07, 0x1F, 0xF8, 0x71, 0xFF, 0xC7, 0x1F, 0x7C, 0x73, 0xF7, 0xF7, 0x7E,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x1F, 0x80, 0x07, 0x9F, 0xF0, 0x07, 0x9F, 0xFC, 0x07, 0x8F, 0x1E,
  0x03, 0x87, 0x07, 0x03, 0xC7, 0x83, 0x83, 0xC3, 0xC1, 0xC3, 0xC1, 0xE0,
  0xE1, 0xC0, 0xF0, 0x71, 0xE0, 0x38, 0x79, 0xE0, 0x1F, 0xFC, 0xE0, 0x07,
  0xFC, 0xF0, 0x01, 0xFC, 0xF0, 0x00, 0x10, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x60, 0x00, 0x39, 0xFE, 0x00, 0x3D, 0xFF,
  0x80, 0x3C, 0xFF, 0xE0, 0x1C, 0xF0, 0xF0, 0x1E, 0x78, 0x78, 0x1E, 0x3C,
  0x3C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0x87, 0x8F, 0x03,
  0xE3, 0xC7, 0x00, 0xFF, 0xC7, 0x80, 0x3F, 0xE7, 0x80, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0x0F,
  0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x3E, 0xF9, 0xF0, 0xFB, 0xE7, 0xE7,
  0xCF, 0x8F, 0x9F, 0x3E, 0x1F, 0xF8, 0xF8, 0x3F, 0xE3, 0xE0, 0xFF, 0x0F,
  0x81, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0xC3, 0xF0, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0x7C, 0x3F, 0xF9, 0xF0, 0x7F, 0xC3, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x38, 0x07, 0xC0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x8F, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x83, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0xE0, 0x07,
  0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0x80, 0x78, 0x02,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x81, 0xE0, 0x27, 0x83, 0x87, 0x9F, 0x8E, 0x3F,
  0x7F, 0x3B, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xB8, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC7,
  0xC0, 0x3E, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xC0, 0xF8, 0x06, 0x01, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE1, 0xFD, 0xF8,
  0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x8E, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xCF,
  0x9F, 0xF9, 0xF3, 0xFF, 0x18, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xCF, 0xC1,
  0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x0F, 0x80, 0xE0, 0xF8, 0x0C, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0x8F, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xF0, 0x7E, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC1, 0xF7, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF1, 0xE0, 0x3E, 0xFF, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF3, 0xE0, 0x7E, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xDF, 0xC3, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x7F,
  0x03, 0xEF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x07, 0xF7, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF7, 0xF0, 0x7E, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE0, 0xFD, 0xF8, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x3F,
  0x3F, 0x0F, 0xC3, 0xFB, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0x0F, 0xC3, 0xF1, 0xF0, 0x3F, 0x7C, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xF9,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x07, 0xE7, 0xE0,
  0x3F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0xDF, 0xF3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x3C, 0x7F, 0x7F, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E,
  0x0F, 0x07, 0xF1, 0xFC, 0xFF, 0x1F, 0xC7, 0xF0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x78,
  0x3E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xF1, 0xFE, 0x3F, 0x00, 0xF8, 0xF8, 0x01,
  0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x81, 0xF3, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xF1, 0xFF, 0x8F,
  0x83, 0xFE, 0x3E, 0x0F, 0xF8, 0xF8, 0x3F, 0xE3, 0xE0, 0xFF, 0x8F, 0x83,
  0xFE, 0x3E, 0x0F, 0xF8, 0xF8, 0x3F, 0xE3, 0xE0, 0xFF, 0x8F, 0x83, 0xFE,
  0x1E, 0x0F, 0xF8, 0x7E, 0xFF, 0xE1, 0xFF, 0x7F, 0x83, 0xF9, 0xFE, 0x03,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0,
  0x03, 0xEF, 0x80, 0x0F, 0x3E, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x07,
  0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF0, 0x0F, 0x83,
  0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF0, 0x01,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x83,
  0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF1,
  0xFD, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xEF, 0xC1, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF1, 0xFD, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC1, 0xF9, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7,
  0xF0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F,
  0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x83,
  0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F,
  0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x7F,
  0x70, 0x7F, 0xF7, 0x0F, 0xFF, 0x78, 0xEF, 0xF7, 0x8E, 0xFF, 0xB9, 0xEF,
  0xFB, 0xDE, 0xFF, 0xBD, 0xCF, 0xF9, 0xDC, 0xFF, 0x9F, 0xCF, 0xF9, 0xF8,
  0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xBC, 0x1F, 0xF7, 0x83, 0xFE,
  0xF0, 0x7F, 0xCF, 0x0F, 0xFD, 0xE1, 0xFF, 0xBE, 0x3F, 0xF3, 0xC7, 0xFE,
  0x78, 0xFF, 0xCF, 0x9F, 0xF8, 0xF3, 0xFF, 0x1E, 0x7F, 0xE3, 0xEF, 0xFC,
  0x3D, 0xFF, 0x87, 0xBF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xE1, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xFC,
  0x07, 0xCF, 0xC3, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xE1, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xCF, 0xC3, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0x7E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x83, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x3F,
  0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x0F,
  0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0x7C, 0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xCF, 0xC3, 0xF9,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFC, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xF0, 0x7C, 0x1F,
  0xE0, 0xF8, 0x7F, 0xC1, 0xF0, 0xFF, 0x83, 0xE1, 0xFF, 0x07, 0xC3, 0xDF,
  0x0F, 0x87, 0xBE, 0x3B, 0x0F, 0x7C, 0x76, 0x1E, 0x78, 0xEC, 0x3C, 0xF1,
  0xDC, 0x79, 0xE3, 0xB8, 0xF3, 0xC7, 0x71, 0xE7, 0x8C, 0xE3, 0xCF, 0x19,
  0xCF, 0x9E, 0x33, 0x9E, 0x3C, 0xE3, 0x3C, 0x79, 0xC6, 0x78, 0xFB, 0x8C,
  0xF0, 0xF7, 0x1D, 0xE1, 0xEE, 0x3B, 0xC3, 0xDC, 0x77, 0x87, 0xB0, 0xEF,
  0x0F, 0x61, 0xDE, 0x1F, 0xC3, 0xB8, 0x3F, 0x87, 0x70, 0x7F, 0x07, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xFC, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3F,
  0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC3,
  0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0,
  0x1F, 0x87, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0xC0,
  0x1F, 0x78, 0x03, 0xCF, 0x80, 0x78, 0xF0, 0x1F, 0x1F, 0x03, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1E, 0x07, 0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0x8F, 0xE3,
  0xE0, 0x3E, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xE0, 0x3F, 0x7C, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xFB,
  0xDF, 0x7F, 0xFD, 0xF3, 0xFF, 0x9F, 0x0F, 0xF1, 0xF0, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0xF9, 0xFF, 0x1F, 0x7F, 0xF3, 0xEF, 0xFE, 0x7F,
  0xDF, 0xEF, 0xE0, 0xFD, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xDF, 0xC1, 0xFB, 0xFF,
  0xFF, 0x7D, 0xFF, 0xCF, 0xBF, 0xF1, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFD, 0xF8, 0x0F, 0xBF,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0xFD, 0xF8, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x1F, 0x1F, 0xF7,
  0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7, 0xC3, 0xF9, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFD,
  0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFD, 0xF0, 0x1F, 0x3F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xC7,
  0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x1F, 0xE7, 0xC1, 0xE1, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0xF9, 0xFF, 0x1F, 0x7F, 0xF3, 0xEF, 0xFE, 0x7F, 0xDF, 0xEF, 0xC0,
  0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x01, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x07, 0xCF,
  0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80,
  0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0xF3, 0xC3,
  0xC7, 0xBF, 0x3F, 0x3D, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x8F, 0x8F, 0x7C,
  0x78, 0x7F, 0xE3, 0xC3, 0xFF, 0x1E, 0x1F, 0xF8, 0xF0, 0xFF, 0xC7, 0x87,
  0xFE, 0x3C, 0x3F, 0xF1, 0xE1, 0xFF, 0x8F, 0x0F, 0xFC, 0x78, 0x7F, 0xE3,
  0xC3, 0xFF, 0x1E, 0x1F, 0xF8, 0xF0, 0xFF, 0xC7, 0x87, 0xFE, 0x3C, 0x3F,
  0xF1, 0xE1, 0xFF, 0x8F, 0x0F, 0xFC, 0x78, 0x7F, 0xE3, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xCF, 0xFB, 0xFD, 0xF8,
  0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x80,
  0xF9, 0xF8, 0x7F, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0x00, 0xF8, 0x7C, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xCF, 0xFB,
  0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFB, 0xF8, 0x3F, 0x7F, 0xFF,
  0xEF, 0xBF, 0xF9, 0xF7, 0xFE, 0x3E, 0x3F, 0x87, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xF7, 0xE1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFD, 0xF0, 0xFE, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0xFC, 0x1F,
  0x7F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xF3, 0xFD, 0xF8, 0x1F, 0xBE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xE0, 0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xF9, 0xF8, 0x7F, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x78, 0x1F, 0xE0,
  0xF0, 0x3F, 0xC1, 0xF0, 0xF7, 0x83, 0xE1, 0xEF, 0x87, 0xC3, 0xCF, 0x0F,
  0x87, 0x9E, 0x3B, 0x0F, 0x3C, 0x76, 0x1E, 0x78, 0xEE, 0x7C, 0xF1, 0xDC,
  0xF1, 0xE3, 0x39, 0xE1, 0xE6, 0x73, 0xC3, 0xDC, 0xE7, 0x87, 0xB8, 0xCF,
  0x0F, 0x71, 0x9E, 0x1E, 0xE3, 0xB8, 0x3D, 0xC7, 0xF0, 0x7B, 0x0F, 0xE0,
  0x76, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x07,
  0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0x7E, 0xFC, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x07,
  0xCF, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x01,
  0xF1, 0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0xDF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0x8F, 0x8F, 0xF8, 0x7F, 0xFB, 0xC1, 0xFF, 0xDE, 0x07, 0xFC,
  0xF0, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 30, 25, 9, -30 },
  { 28, 14, 12, 25, 5, -30 },
  { 49, 23, 30, 25, 1, -30 },
  { 136, 20, 42, 25, 2, -36 },
  { 241, 25, 30, 25, 0, -30 },
  { 335, 22, 30, 25, 2, -30 },
  { 418, 5, 12, 25, 10, -30 },
  { 426, 13, 39, 25, 7, -34 },
  { 490, 13, 39, 25, 5, -34 },
  { 554, 22, 21, 25, 1, -25 },
  { 612, 20, 19, 25, 2, -23 },
  { 660, 10, 13, 25, 6, -6 },
  { 677, 13, 5, 25, 6, -16 },
  { 686, 8, 7, 25, 8, -7 },
  { 693, 20, 39, 25, 2, -34 },
  { 791, 19, 30, 25, 3, -30 },
  { 863, 20, 30, 25, 3, -30 },
  { 938, 20, 30, 25, 2, -30 },
  { 1013, 20, 30, 25, 2, -30 },
  { 1088, 18, 30, 25, 3, -30 },
  { 1156, 19, 30, 25, 3, -30 },
  { 1228, 20, 30, 25, 2, -30 },
  { 1303, 20, 30, 25, 2, -30 },
  { 1378, 19, 30, 25, 3, -30 },
  { 1450, 20, 30, 25, 2, -30 },
  { 1525, 8, 23, 25, 8, -23 },
  { 1548, 10, 30, 25, 6, -23 },
  { 1586, 18, 23, 25, 3, -25 },
  { 1638, 18, 15, 25, 3, -21 },
  { 1672, 18, 23, 25, 3, -25 },
  { 1724, 16, 30, 25, 5, -30 },
  { 1784, 22, 37, 25, 1, -30 },
  { 1886, 22, 30, 25, 1, -30 },
  { 1969, 19, 30, 25, 3, -30 },
  { 2041, 19, 30, 25, 3, -30 },
  { 2113, 19, 30, 25, 3, -30 },
  { 2185, 18, 30, 25, 4, -30 },
  { 2253, 19, 30, 25, 3, -30 },
  { 2325, 19, 30, 25, 3, -30 },
  { 2397, 18, 30, 25, 3, -30 },
  { 2465, 17, 30, 25, 4, -30 },
  { 2529, 20, 30, 25, 1, -30 },
  { 2604, 20, 30, 25, 3, -30 },
  { 2679, 18, 30, 25, 4, -30 },
  { 2747, 20, 30, 25, 2, -30 },
  { 2822, 19, 30, 25, 3, -30 },
  { 2894, 19, 30, 25, 3, -30 },
  { 2966, 20, 30, 25, 3, -30 },
  { 3041, 19, 37, 25, 3, -30 },
  { 3129, 20, 30, 25, 3, -30 },
  { 3204, 20, 30, 25, 2, -30 },
  { 3279, 21, 30, 25, 2, -30 },
  { 3358, 19, 30, 25, 3, -30 },
  { 3430, 22, 30, 25, 1, -30 },
  { 3513, 23, 30, 25, 1, -30 },
  { 3600, 22, 30, 25, 1, -30 },
  { 3683, 23, 30, 25, 1, -30 },
  { 3770, 18, 30, 25, 3, -30 },
  { 3838, 11, 39, 25, 8, -34 },
  { 3892, 20, 39, 25, 2, -34 },
  { 3990, 11, 39, 25, 6, -34 },
  { 4044, 19, 16, 25, 3, -30 },
  { 4082, 20, 5, 25, 2, 1 },
  { 4095, 10, 6, 25, 7, -32 },
  { 4103, 20, 23, 25, 2, -23 },
  { 4161, 19, 30, 25, 3, -30 },
  { 4233, 19, 23, 25, 3, -23 },
  { 4288, 18, 30, 25, 3, -30 },
  { 4356, 19, 23, 25, 3, -23 },
  { 4411, 20, 30, 25, 2, -30 },
  { 4486, 18, 30, 25, 3, -23 },
  { 4554, 19, 30, 25, 3, -30 },
  { 4626, 20, 32, 25, 3, -32 },
  { 4706, 16, 39, 25, 3, -32 },
  { 4784, 20, 30, 25, 3, -30 },
  { 4859, 22, 30, 25, 1, -30 },
  { 4942, 21, 23, 25, 2, -23 },
  { 5003, 19, 23, 25, 3, -23 },
  { 5058, 19, 23, 25, 3, -23 },
  { 5113, 19, 30, 25, 3, -23 },
  { 5185, 18, 30, 25, 3, -23 },
  { 5253, 19, 23, 25, 4, -23 },
  { 5308, 19, 23, 25, 3, -23 },
  { 5363, 20, 29, 25, 2, -29 },
  { 5436, 19, 23, 25, 3, -23 },
  { 5491, 21, 23, 25, 2, -23 },
  { 5552, 23, 23, 25, 1, -23 },
  { 5619, 22, 23, 25, 1, -23 },
  { 5683, 21, 30, 25, 2, -23 },
  { 5762, 18, 23, 25, 3, -23 },
  { 5814, 18, 39, 25, 3, -34 },
  { 5902, 5, 39, 25, 10, -34 },
  { 5927, 18, 39, 25, 3, -34 },
  { 6015, 21, 9, 25, 2, -19 },
};

const GFXfont JetBrainsMono_Bold41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_BOLD41PT7B_H_
