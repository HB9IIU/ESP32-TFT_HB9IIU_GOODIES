#ifndef _JETBRAINSMONO_BOLD60PT7B_H_
#define _JETBRAINSMONO_BOLD60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold60pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x7B, 0xFF, 0x0F, 0xF1, 0xE3,
  0xFC, 0x3F, 0xC7, 0x87, 0xF9, 0xFE, 0x1E, 0x1F, 0xE7, 0xF8, 0x78, 0x7F,
  0x9F, 0xE1, 0xE1, 0xFE, 0x7F, 0x87, 0x80, 0x01, 0xFE, 0x1E, 0x00, 0x03,
  0xFC, 0x78, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x3F, 0xE7, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xE3, 0xFE, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x1E, 0x1F, 0xE0,
  0x00, 0x78, 0x3F, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0x07, 0x83, 0xFF, 0xFC,
  0x1E, 0x0F, 0xF7, 0xF0, 0x78, 0x3F, 0x9F, 0xE1, 0xE1, 0xFE, 0x7F, 0xC7,
  0x8F, 0xF8, 0xFF, 0xDE, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0xFF, 0xE0, 0x00, 0x3E, 0x1F, 0xFF, 0x00, 0x07, 0xE3,
  0xFF, 0xF8, 0x00, 0xFC, 0x7F, 0xFF, 0xC0, 0x0F, 0x87, 0xE0, 0xFC, 0x01,
  0xF0, 0x7C, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC1, 0xF8, 0x07,
  0xC0, 0x7C, 0x1F, 0x00, 0x7C, 0x07, 0xC3, 0xF0, 0x07, 0xC0, 0x7C, 0x7E,
  0x00, 0x7E, 0x0F, 0xC7, 0xC0, 0x07, 0xFF, 0xF8, 0xF8, 0x00, 0x3F, 0xFF,
  0x9F, 0x80, 0x01, 0xFF, 0xF1, 0xF0, 0x00, 0x0F, 0xFE, 0x3E, 0x00, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x7F, 0xF0, 0x00, 0x0F, 0xCF, 0xFF, 0x80,
  0x01, 0xF9, 0xFF, 0xFC, 0x00, 0x1F, 0x1F, 0xFF, 0xC0, 0x03, 0xE3, 0xF0,
  0x7E, 0x00, 0x7E, 0x3E, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0xF8,
  0x3E, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0xFC, 0x03, 0xE0,
  0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xE1, 0xF0, 0x03, 0xFD, 0xFE, 0x3F, 0x00,
  0x1F, 0xFF, 0xC3, 0xE0, 0x00, 0xFF, 0xF8, 0x7C, 0x00, 0x07, 0xFF, 0x0F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x3F, 0xC1, 0xFD, 0xFC, 0x3F, 0x87, 0xFB, 0xF8, 0x7F, 0x8F,
  0xE7, 0xF0, 0x7F, 0xBF, 0x8F, 0xE0, 0x7F, 0x7F, 0x1F, 0xC0, 0x7F, 0xFC,
  0x3F, 0x80, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xC1,
  0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xF8, 0x3F,
  0xFF, 0x07, 0xF0, 0x3F, 0xF8, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x07, 0xE0,
  0x04, 0x3C, 0x07, 0xE0, 0x3C, 0x7F, 0x03, 0xC0, 0xFE, 0x7F, 0xC3, 0xC3,
  0xFE, 0x7F, 0xE3, 0xC7, 0xFE, 0xFF, 0xFB, 0xDF, 0xFF, 0xFF, 0xFD, 0xBF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xC0, 0x60, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x0F, 0x07, 0xFF,
  0xE1, 0xF8, 0x7F, 0xFE, 0x3F, 0xC7, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x3F,
  0xC7, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE0, 0xF0, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x1F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0x9F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0x81, 0xFE,
  0x00, 0xF0, 0x1F, 0xE0, 0x0E, 0x01, 0xFE, 0x00, 0x80, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x7F, 0xF9, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x1E, 0x00, 0x7F, 0x9F, 0xFC, 0x07, 0xFB, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0x9F, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x01, 0xFE, 0x7F, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xF7, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0,
  0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x06, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF,
  0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x06, 0x00, 0x00, 0xC0, 0x0F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x87, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xBF, 0xFC,
  0x07, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xDF, 0xFC, 0x0F, 0xF0, 0xFF, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC,
  0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC,
  0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC,
  0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC,
  0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0xFC,
  0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xEF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F,
  0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x3F,
  0xEF, 0xE0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0,
  0xFF, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xE7, 0xFE,
  0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x0F, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xE7,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xE7, 0xFE, 0x07, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x01,
  0xFF, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFD, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x03,
  0xFE, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF0,
  0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0xFF, 0x80, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F,
  0xC0, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xFC, 0x7F, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xF7,
  0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFD, 0xF0, 0x3E, 0xFF, 0xF7, 0xC0, 0xFB, 0xFF,
  0xDF, 0x03, 0xEF, 0xFF, 0x3E, 0x1F, 0x3F, 0xFC, 0xF8, 0x7C, 0xFF, 0xFB,
  0xE1, 0xF7, 0xFF, 0xE7, 0xC7, 0xDF, 0xFF, 0x9F, 0x3E, 0x7F, 0xFE, 0x7C,
  0xF9, 0xFF, 0xF9, 0xF3, 0xE7, 0xFF, 0xE3, 0xEF, 0x1F, 0xFF, 0x8F, 0xFC,
  0x7F, 0xFE, 0x3F, 0xF1, 0xFF, 0xF8, 0x7F, 0xC7, 0xFF, 0xE1, 0xFE, 0x1F,
  0xFF, 0x87, 0xF8, 0x7F, 0xFE, 0x1F, 0xE1, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFE, 0xFC, 0x07, 0xFF, 0xEF, 0xC0, 0x7F, 0xFE, 0xFC, 0x07, 0xFF,
  0xE7, 0xE0, 0x7F, 0xFE, 0x7E, 0x07, 0xFF, 0xE7, 0xE0, 0x7F, 0xFE, 0x3F,
  0x07, 0xFF, 0xE3, 0xF0, 0x7F, 0xFE, 0x3F, 0x07, 0xFF, 0xE1, 0xF8, 0x7F,
  0xFE, 0x1F, 0x87, 0xFF, 0xE0, 0xFC, 0x7F, 0xFE, 0x0F, 0xC7, 0xFF, 0xE0,
  0xFC, 0x7F, 0xFE, 0x07, 0xE7, 0xFF, 0xE0, 0x7E, 0x7F, 0xFE, 0x07, 0xE7,
  0xFF, 0xE0, 0x3F, 0x7F, 0xFE, 0x03, 0xF7, 0xFF, 0xE0, 0x3F, 0x7F, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x0F, 0xFC,
  0xFE, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFD, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0xBF, 0x80, 0x07, 0xFD, 0xFC, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01,
  0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x07, 0xFE, 0xFE,
  0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x3F, 0xEF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xDF, 0x81,
  0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x81, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E,
  0x07, 0xF8, 0x1F, 0x9F, 0x81, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x81, 0xF9,
  0xF8, 0x1E, 0xE0, 0x7E, 0x7F, 0x0F, 0x3C, 0x1F, 0x9F, 0xC3, 0xCF, 0x0F,
  0xE7, 0xF0, 0xF3, 0xC3, 0xF8, 0xFC, 0x3C, 0xF0, 0xFC, 0x3F, 0x0F, 0x3C,
  0x3F, 0x0F, 0xC3, 0xCF, 0x0F, 0xC3, 0xF0, 0xF3, 0xC3, 0xF0, 0xFC, 0x3C,
  0xF0, 0xFC, 0x3F, 0x0F, 0x1C, 0x3F, 0x0F, 0xC7, 0x87, 0x8F, 0xC3, 0xF1,
  0xE1, 0xE3, 0xF0, 0xFC, 0x78, 0x78, 0xFC, 0x3F, 0x9E, 0x1E, 0x3E, 0x07,
  0xE7, 0x87, 0x9F, 0x81, 0xF9, 0xE1, 0xE7, 0xE0, 0x7E, 0x78, 0x79, 0xF8,
  0x1F, 0x9E, 0x1E, 0x7E, 0x07, 0xEF, 0x07, 0x9F, 0x81, 0xFB, 0xC0, 0xF7,
  0xE0, 0x7E, 0xF0, 0x3D, 0xF8, 0x1F, 0xBC, 0x0F, 0x7E, 0x07, 0xEF, 0x03,
  0xDF, 0x01, 0xFB, 0xC0, 0xF7, 0xC0, 0x3E, 0xF0, 0x3D, 0xF0, 0x0F, 0xBC,
  0x0F, 0x7C, 0x03, 0xFF, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0,
  0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xE3, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xC7,
  0xF8, 0x1F, 0xFC, 0x3F, 0xC0, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x06, 0x00, 0x7F, 0x0F, 0xFC,
  0x0F, 0xE3, 0xFF, 0xC1, 0xFC, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x03,
  0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xF7, 0xFF, 0xFC, 0xFE,
  0xFF, 0xFF, 0x1F, 0xCF, 0xFF, 0xE3, 0xF8, 0xFF, 0xF0, 0x7F, 0x0F, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0xC0, 0x1F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x3F, 0x81, 0xFF, 0x87, 0xF0,
  0x7F, 0xF8, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xFF, 0xFB, 0xF9, 0xFF, 0xFF,
  0x7F, 0x7F, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0xBF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFE,
  0xFF, 0xC0, 0xFF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF,
  0xEF, 0xE1, 0xFF, 0xF9, 0xFC, 0x1F, 0xFE, 0x3F, 0x81, 0xFF, 0x87, 0xF0,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF0,
  0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xE7, 0xFC, 0x01, 0xFE, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xE1, 0xFC, 0x1F, 0xFF, 0x3F, 0x87, 0xFF, 0xE7, 0xF1,
  0xFF, 0xFE, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x03,
  0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xFF,
  0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFE, 0xFE,
  0x1F, 0xFF, 0x9F, 0xC1, 0xFF, 0xE3, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x06, 0x00, 0x7F, 0x0F, 0xFC, 0x0F, 0xE3,
  0xFF, 0xC1, 0xFC, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x1F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0xFF, 0x9F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0xC7, 0xF0, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC0, 0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0x80,
  0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0x3F,
  0xC3, 0xF8, 0x01, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xE7,
  0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x08, 0x01, 0x03, 0xF1,
  0xF8, 0x3F, 0x8F, 0xCF, 0xF1, 0xFF, 0x3F, 0x7F, 0xEF, 0xFE, 0xFD, 0xFF,
  0xBF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0x83, 0xF0,
  0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF,
  0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8,
  0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F,
  0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0,
  0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF,
  0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8,
  0x3F, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x1F, 0xC3, 0xFF, 0x03, 0xF8, 0xFF,
  0xF0, 0x7F, 0x3F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x07,
  0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xFE,
  0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x07, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x1F, 0xC3, 0xFF, 0x03, 0xF8, 0xFF, 0xF0, 0x7F,
  0x3F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFD, 0xFF, 0xFF, 0x3F, 0xBF, 0xFF, 0xC7, 0xF3, 0xFF,
  0xF0, 0xFE, 0x3F, 0xFC, 0x1F, 0xC3, 0xFF, 0x03, 0xF8, 0x06, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xE1, 0xFC, 0x1F, 0xFE, 0x3F, 0x87, 0xFF, 0xE7, 0xF1, 0xFF,
  0xFE, 0xFE, 0x7F, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x03, 0xFF,
  0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xDF, 0xC7, 0xFF, 0xFB, 0xF8, 0x7F, 0xFE, 0x7F, 0x07, 0xFF, 0x8F,
  0xE0, 0x7F, 0xE1, 0xFC, 0x01, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x1F, 0xC3, 0xFF, 0x03,
  0xF9, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0x8F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFE,
  0x03, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0xC0, 0x7E, 0x7E, 0x07, 0xF8, 0x1F, 0x9F, 0x81, 0xFE, 0x07,
  0xE7, 0xE0, 0x7F, 0x81, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7F, 0x07, 0xF8,
  0x1F, 0x0F, 0xC1, 0xCE, 0x0F, 0xC3, 0xF0, 0xF3, 0xC3, 0xF0, 0xFC, 0x3C,
  0xF0, 0xFC, 0x3F, 0x0F, 0x3C, 0x3F, 0x0F, 0xC3, 0xCF, 0x0F, 0xC3, 0xF0,
  0xF3, 0xC3, 0xF0, 0x7E, 0x3C, 0xF0, 0xF8, 0x1F, 0x8E, 0x1C, 0x7E, 0x07,
  0xE7, 0x87, 0x9F, 0x81, 0xF9, 0xE1, 0xE7, 0xE0, 0x7E, 0x78, 0x79, 0xF8,
  0x1F, 0x9E, 0x1E, 0x7E, 0x07, 0xE7, 0x87, 0x9F, 0x00, 0xF9, 0xE1, 0xE7,
  0xC0, 0x3F, 0x70, 0x3B, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xF3, 0xFF, 0xE0, 0x0F,
  0xDF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xE1, 0xFE, 0x1F, 0xFF, 0x03, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0xBF, 0x00, 0x7F, 0xFC, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_Bold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 10, 44, 36, 13, -44 },
  { 56, 20, 18, 36, 8, -44 },
  { 101, 32, 44, 36, 2, -44 },
  { 277, 30, 60, 36, 3, -52 },
  { 502, 36, 44, 36, 0, -44 },
  { 700, 31, 45, 36, 3, -44 },
  { 875, 8, 18, 36, 14, -44 },
  { 893, 19, 57, 36, 10, -50 },
  { 1029, 19, 57, 36, 7, -50 },
  { 1165, 32, 32, 36, 2, -37 },
  { 1293, 28, 28, 36, 4, -34 },
  { 1391, 14, 19, 36, 9, -9 },
  { 1425, 20, 7, 36, 8, -23 },
  { 1443, 12, 12, 36, 12, -11 },
  { 1461, 28, 57, 36, 4, -50 },
  { 1661, 28, 45, 36, 4, -44 },
  { 1819, 28, 44, 36, 5, -44 },
  { 1973, 28, 44, 36, 4, -44 },
  { 2127, 28, 45, 36, 4, -44 },
  { 2285, 27, 44, 36, 4, -44 },
  { 2434, 28, 45, 36, 4, -44 },
  { 2592, 30, 45, 36, 3, -44 },
  { 2761, 29, 44, 36, 4, -44 },
  { 2921, 28, 45, 36, 4, -44 },
  { 3079, 30, 44, 36, 3, -44 },
  { 3244, 12, 35, 36, 12, -34 },
  { 3297, 15, 44, 36, 9, -34 },
  { 3380, 26, 33, 36, 5, -36 },
  { 3488, 26, 22, 36, 5, -31 },
  { 3560, 26, 33, 36, 5, -36 },
  { 3668, 23, 44, 36, 7, -44 },
  { 3795, 32, 55, 36, 2, -44 },
  { 4015, 32, 44, 36, 2, -44 },
  { 4191, 28, 44, 36, 5, -44 },
  { 4345, 28, 45, 36, 4, -44 },
  { 4503, 28, 44, 36, 4, -44 },
  { 4657, 27, 44, 36, 5, -44 },
  { 4806, 27, 44, 36, 5, -44 },
  { 4955, 28, 45, 36, 4, -44 },
  { 5113, 26, 44, 36, 5, -44 },
  { 5256, 26, 44, 36, 5, -44 },
  { 5399, 29, 45, 36, 2, -44 },
  { 5563, 29, 44, 36, 5, -44 },
  { 5723, 26, 44, 36, 6, -44 },
  { 5866, 30, 44, 36, 3, -44 },
  { 6031, 28, 44, 36, 4, -44 },
  { 6185, 28, 45, 36, 4, -44 },
  { 6343, 29, 44, 36, 5, -44 },
  { 6503, 29, 55, 36, 4, -44 },
  { 6703, 28, 44, 36, 5, -44 },
  { 6857, 30, 45, 36, 3, -44 },
  { 7026, 30, 44, 36, 3, -44 },
  { 7191, 28, 45, 36, 4, -44 },
  { 7349, 32, 44, 36, 2, -44 },
  { 7525, 34, 44, 36, 1, -44 },
  { 7712, 32, 44, 36, 2, -44 },
  { 7888, 34, 44, 36, 1, -44 },
  { 8075, 26, 44, 36, 5, -44 },
  { 8218, 17, 57, 36, 11, -50 },
  { 8340, 28, 57, 36, 4, -50 },
  { 8540, 17, 57, 36, 8, -50 },
  { 8662, 28, 24, 36, 4, -44 },
  { 8746, 28, 7, 36, 4, 1 },
  { 8771, 14, 8, 36, 10, -47 },
  { 8785, 29, 35, 36, 3, -34 },
  { 8912, 27, 45, 36, 5, -44 },
  { 9064, 28, 35, 36, 4, -34 },
  { 9187, 27, 45, 36, 4, -44 },
  { 9339, 28, 35, 36, 4, -34 },
  { 9462, 29, 44, 36, 3, -44 },
  { 9622, 27, 45, 36, 4, -34 },
  { 9774, 27, 44, 36, 5, -44 },
  { 9923, 28, 47, 36, 5, -47 },
  { 10088, 23, 58, 36, 5, -47 },
  { 10255, 29, 44, 36, 5, -44 },
  { 10415, 32, 44, 36, 2, -44 },
  { 10591, 30, 34, 36, 3, -34 },
  { 10719, 27, 34, 36, 5, -34 },
  { 10834, 28, 35, 36, 4, -34 },
  { 10957, 27, 45, 36, 5, -34 },
  { 11109, 27, 45, 36, 4, -34 },
  { 11261, 27, 34, 36, 6, -34 },
  { 11376, 28, 35, 36, 4, -34 },
  { 11499, 29, 42, 36, 3, -42 },
  { 11652, 28, 34, 36, 4, -33 },
  { 11771, 32, 33, 36, 2, -33 },
  { 11903, 34, 33, 36, 1, -33 },
  { 12044, 32, 33, 36, 2, -33 },
  { 12176, 32, 44, 36, 2, -33 },
  { 12352, 26, 33, 36, 5, -33 },
  { 12460, 26, 57, 36, 5, -50 },
  { 12646, 8, 57, 36, 14, -50 },
  { 12703, 26, 57, 36, 5, -50 },
  { 12889, 30, 14, 36, 3, -28 },
};

const GFXfont JetBrainsMono_Bold60pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold60pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _JETBRAINSMONO_BOLD60PT7B_H_
