#ifndef _JETBRAINSMONO_BOLD23PT7B_H_
#define _JETBRAINSMONO_BOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x00, 0xEF, 0xF0, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x0C, 0x61, 0xC6, 0x18, 0x61, 0x8C, 0xFF,
  0xFF, 0xFF, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x31, 0x8F, 0xFE, 0xFF,
  0xE6, 0x18, 0x63, 0x86, 0x30, 0x63, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x0F,
  0xC3, 0xFC, 0xFF, 0xDD, 0xBB, 0xB7, 0x76, 0x0F, 0xC1, 0xFC, 0x1F, 0xE0,
  0xFE, 0x0F, 0xC1, 0xBF, 0x33, 0xE6, 0xEF, 0xFD, 0xFF, 0x0F, 0xC0, 0x60,
  0x0C, 0x01, 0x80, 0x38, 0x0D, 0xF8, 0x6C, 0x63, 0x31, 0x9C, 0xC6, 0x63,
  0x1B, 0x07, 0xD8, 0x0E, 0x60, 0x03, 0x00, 0x19, 0x80, 0x6F, 0x83, 0x66,
  0x19, 0x9C, 0xC6, 0x73, 0x19, 0xD8, 0x7E, 0xC0, 0xF0, 0x1F, 0x03, 0xF8,
  0x7B, 0xC7, 0x1C, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x7C, 0x0E, 0xE7,
  0xE7, 0xEE, 0x7E, 0xE3, 0xCE, 0x1C, 0xE3, 0xC7, 0xFE, 0x3E, 0x70, 0xFF,
  0xFE, 0xD8, 0x06, 0x3C, 0xFB, 0xC7, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0x40, 0xC1, 0xC3,
  0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x1C, 0x79, 0xE7, 0x8E, 0x10, 0x00, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x62,
  0xF6, 0xFF, 0xFF, 0x06, 0x00, 0xF0, 0x1B, 0x83, 0x9C, 0x71, 0xE1, 0x08,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x3C, 0xE3, 0x9C, 0x71, 0x8E, 0x00, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x00, 0x3F, 0x1F,
  0xEF, 0x7F, 0x87, 0xC1, 0xF0, 0x3C, 0x0F, 0x33, 0xDC, 0xF3, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x7F, 0x3D, 0xFE, 0x3F, 0x00, 0x1E, 0x07, 0xC1, 0xF8,
  0x77, 0x0C, 0xE1, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x07, 0xF9, 0xFF,
  0xB8, 0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1F, 0xFB, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFD, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x7E, 0x0F, 0xC0, 0x1C, 0x03, 0x80,
  0x7E, 0x0F, 0xC1, 0xDC, 0x7B, 0xFE, 0x1F, 0x80, 0x01, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC7, 0x70, 0xFE, 0x1F, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0xF3, 0xFE, 0xF3, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xF8, 0x7F, 0x3D, 0xFE, 0x3F, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x7C, 0x7F, 0xE7, 0x0E, 0xE0, 0xEE, 0x07,
  0xE0, 0x66, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0E, 0xE0, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x1F, 0x87,
  0xF9, 0xE7, 0xB8, 0x77, 0x0E, 0xE1, 0xDE, 0x71, 0xFE, 0x1F, 0x87, 0xF9,
  0xC3, 0xB0, 0x7E, 0x0E, 0xE1, 0xDE, 0x7B, 0xFE, 0x1F, 0x80, 0x1F, 0x03,
  0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x67, 0x0E, 0x7F, 0xE3,
  0xEE, 0x09, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x00,
  0x6F, 0xFE, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x73, 0xDE, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0xE7, 0x73, 0x9C, 0xC0, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C,
  0x3C, 0x0C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x38, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0C, 0x1F, 0x1F, 0x9F, 0x8F,
  0x03, 0x00, 0x80, 0x00, 0xF8, 0x7F, 0x3F, 0xC0, 0xE0, 0x38, 0x1C, 0x1C,
  0xFE, 0x7E, 0x3E, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x70, 0x00,
  0x1F, 0x83, 0xFE, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC7, 0xBC, 0x77,
  0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE7, 0xC7, 0xFC, 0x3B,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xF8, 0x1F, 0x81, 0xB8, 0x39, 0x83, 0x9C, 0x39, 0xC3, 0x1C, 0x70,
  0xC7, 0xFE, 0x7F, 0xE7, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x70, 0xFE, 0x1F,
  0xF3, 0xFF, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0xFC, 0xFF, 0x1C, 0x7B,
  0x87, 0x70, 0x7E, 0x0F, 0xC3, 0xB8, 0xF7, 0xFC, 0xFF, 0x00, 0x3F, 0x1F,
  0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0xEF, 0xFF,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7F, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80,
  0xE7, 0xF9, 0xFE, 0x7F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE, 0x3F, 0x00,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE1, 0xFC, 0x3F,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x7E, 0x0F, 0xC1, 0xFC, 0xF3, 0xFE, 0x3F, 0x00, 0xE0, 0xFC, 0x3B, 0x87,
  0x71, 0xCE, 0x39, 0xCE, 0x39, 0xC7, 0xF8, 0xFE, 0x1F, 0xE3, 0x9C, 0x73,
  0xCE, 0x39, 0xC7, 0xB8, 0x77, 0x0E, 0xE0, 0xE0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xFF, 0x0F, 0xF1, 0xFD, 0x9F,
  0xF9, 0xFF, 0x97, 0xEF, 0x7E, 0xF7, 0xEF, 0x7E, 0x67, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xE0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF8, 0xF6, 0x3D, 0x8F, 0x73, 0xCC, 0xF3, 0x3C, 0xEF, 0x1B, 0xC6,
  0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xC0, 0x3F, 0x1F, 0xEF, 0xFF, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F,
  0x3D, 0xFE, 0x3F, 0x00, 0xFE, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x0F, 0xFF, 0xDF, 0xF3, 0xF0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x00, 0x3F, 0x0F, 0xF3, 0xFF, 0x70, 0xEC, 0x1D, 0x83,
  0xB0, 0x76, 0x0E, 0xC1, 0xD8, 0x3B, 0x07, 0x60, 0xEC, 0x1D, 0xC3, 0xBC,
  0xF3, 0xFC, 0x3F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0xFE, 0x1F, 0xF3,
  0xFF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x77, 0x1E, 0xFF, 0x9F, 0xE3, 0x9C,
  0x73, 0x8E, 0x39, 0xC7, 0x38, 0xF7, 0x0E, 0xE1, 0xE0, 0x1F, 0x87, 0xF9,
  0xFF, 0xB8, 0x77, 0x0E, 0xE0, 0x1E, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x07,
  0x80, 0x7E, 0x07, 0xC1, 0xDE, 0x7B, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE, 0x3F, 0x00, 0xE0, 0x7E, 0x07,
  0xE0, 0x67, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xC3, 0x1C, 0x39, 0xC3, 0x9C,
  0x39, 0x81, 0x98, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE3,
  0x1B, 0x18, 0xD9, 0xC6, 0xCF, 0x36, 0x79, 0xB3, 0xCD, 0x96, 0xEC, 0xB7,
  0x74, 0xBB, 0xA5, 0x9D, 0x2C, 0x79, 0x63, 0xCF, 0x1E, 0x78, 0xF3, 0xC7,
  0x1E, 0x38, 0xF0, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x9C, 0x39, 0xC1, 0xF8,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x39, 0xC3, 0x9C,
  0x70, 0xEF, 0x0E, 0xE0, 0x70, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x31,
  0xC3, 0x9C, 0x39, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFF,
  0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0xFF, 0xFF, 0xF8, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1C, 0x07, 0x81, 0xE0, 0xFC, 0x33, 0x1C, 0xE6,
  0x3B, 0x86, 0xE1, 0xC0, 0xFF, 0xFF, 0xFC, 0xE3, 0x8E, 0x0F, 0x07, 0xF9,
  0xFF, 0xB8, 0x70, 0x0E, 0x01, 0xCF, 0xFB, 0x87, 0xE0, 0xFC, 0x1F, 0xC7,
  0xBF, 0xF3, 0xEE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x3F, 0xEF, 0xFF,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3F, 0xFE, 0xEF,
  0x00, 0x1E, 0x1F, 0xEF, 0xFF, 0x87, 0xE1, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x7F, 0x3D, 0xFE, 0x3F, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x3D,
  0xDF, 0xFF, 0xFF, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7F,
  0x3F, 0xFF, 0x7D, 0xC0, 0x1E, 0x1F, 0xEF, 0x3F, 0x87, 0xC1, 0xF0, 0x7F,
  0xFF, 0x00, 0xC0, 0x38, 0x0E, 0x1D, 0xFE, 0x3F, 0x00, 0x03, 0xE0, 0xFC,
  0x3F, 0x87, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x3D, 0xDF, 0xFF,
  0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xFF, 0xFD, 0xF7,
  0x01, 0xC0, 0x70, 0x3D, 0xFE, 0x7F, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xEF, 0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x0E, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x03,
  0xFD, 0xFE, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xDF, 0xEF, 0xE7, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x0F, 0xC3, 0xB8, 0xF7, 0x1C, 0xE7, 0x1F, 0xE3, 0xF8, 0x7F, 0x8E,
  0x71, 0xC7, 0x38, 0xF7, 0x0E, 0xE0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0xEC, 0xCF, 0xFE,
  0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67,
  0xE6, 0x7E, 0x67, 0xE6, 0x70, 0xEF, 0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x1E, 0x1F,
  0xEF, 0xFF, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7F, 0x3D,
  0xFE, 0x3F, 0x00, 0xEF, 0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7F, 0x3F, 0xFE, 0xEF, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x00, 0x3D, 0xDF, 0xFF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7F, 0x3F, 0xFF, 0x7D, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE7,
  0x1F, 0xFB, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x3F, 0x1F, 0xEF, 0x3F, 0x87, 0xE0, 0x3F,
  0x07, 0xF8, 0x3F, 0x01, 0xC0, 0x3E, 0x1F, 0xFF, 0x7F, 0x80, 0x1C, 0x03,
  0x80, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x1F, 0xC3, 0xF8, 0x3F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE, 0x3F,
  0x00, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x70, 0xE3, 0x1C, 0x39, 0xC3,
  0x9C, 0x1B, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xE3, 0x1B, 0x18,
  0xD9, 0xC6, 0xCF, 0x36, 0x7B, 0xBA, 0xDD, 0xD6, 0xC6, 0x96, 0x34, 0xB1,
  0xE5, 0x8F, 0x3C, 0x79, 0xE3, 0x8E, 0x00, 0xE0, 0xF7, 0x0E, 0x39, 0xC3,
  0xBC, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x83, 0xBC, 0x39, 0xC7,
  0x0E, 0xE0, 0xF0, 0xE0, 0x7E, 0x0F, 0x70, 0xE7, 0x0E, 0x39, 0xC3, 0x9C,
  0x39, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03,
  0x81, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC1,
  0xF0, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0x8F, 0xC3,
  0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1F, 0x07,
  0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3E, 0x0F, 0x80, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x18, 0x07, 0xF0,
  0xFC, 0x7F, 0x1C, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x03, 0xC3, 0xE0,
  0xF0, 0x30, 0x00, 0x38, 0x07, 0xC7, 0xEE, 0x7E, 0x7F, 0xE3, 0xE0, 0x18,
};

const GFXglyph JetBrainsMono_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 8, 7, 14, 3, -17 },
  { 17, 12, 17, 14, 1, -17 },
  { 43, 11, 23, 14, 1, -20 },
  { 75, 14, 17, 14, 0, -17 },
  { 105, 12, 17, 14, 1, -17 },
  { 131, 3, 7, 14, 5, -17 },
  { 134, 7, 22, 14, 4, -19 },
  { 154, 7, 22, 14, 3, -19 },
  { 174, 12, 12, 14, 1, -14 },
  { 192, 11, 11, 14, 1, -13 },
  { 208, 6, 7, 14, 3, -3 },
  { 214, 8, 3, 14, 3, -9 },
  { 217, 4, 4, 14, 5, -4 },
  { 219, 11, 22, 14, 1, -19 },
  { 250, 10, 17, 14, 2, -17 },
  { 272, 11, 17, 14, 2, -17 },
  { 296, 11, 17, 14, 1, -17 },
  { 320, 11, 17, 14, 1, -17 },
  { 344, 11, 17, 14, 1, -17 },
  { 368, 10, 17, 14, 2, -17 },
  { 390, 12, 17, 14, 1, -17 },
  { 416, 12, 17, 14, 1, -17 },
  { 442, 11, 17, 14, 1, -17 },
  { 466, 12, 17, 14, 1, -17 },
  { 492, 4, 13, 14, 5, -13 },
  { 499, 5, 17, 14, 4, -13 },
  { 510, 10, 13, 14, 2, -14 },
  { 527, 10, 9, 14, 2, -12 },
  { 539, 10, 13, 14, 2, -14 },
  { 556, 9, 17, 14, 3, -17 },
  { 576, 12, 21, 14, 1, -17 },
  { 608, 12, 17, 14, 1, -17 },
  { 634, 11, 17, 14, 2, -17 },
  { 658, 10, 17, 14, 2, -17 },
  { 680, 10, 17, 14, 2, -17 },
  { 702, 10, 17, 14, 2, -17 },
  { 724, 10, 17, 14, 2, -17 },
  { 746, 10, 17, 14, 2, -17 },
  { 768, 10, 17, 14, 2, -17 },
  { 790, 10, 17, 14, 2, -17 },
  { 812, 11, 17, 14, 1, -17 },
  { 836, 11, 17, 14, 2, -17 },
  { 860, 10, 17, 14, 2, -17 },
  { 882, 12, 17, 14, 1, -17 },
  { 908, 10, 17, 14, 2, -17 },
  { 930, 10, 17, 14, 2, -17 },
  { 952, 11, 17, 14, 2, -17 },
  { 976, 11, 21, 14, 2, -17 },
  { 1005, 11, 17, 14, 2, -17 },
  { 1029, 11, 17, 14, 1, -17 },
  { 1053, 12, 17, 14, 1, -17 },
  { 1079, 10, 17, 14, 2, -17 },
  { 1101, 12, 17, 14, 1, -17 },
  { 1127, 13, 17, 14, 0, -17 },
  { 1155, 12, 17, 14, 1, -17 },
  { 1181, 12, 17, 14, 1, -17 },
  { 1207, 10, 17, 14, 2, -17 },
  { 1229, 7, 22, 14, 4, -19 },
  { 1249, 11, 22, 14, 1, -19 },
  { 1280, 7, 22, 14, 3, -19 },
  { 1300, 10, 9, 14, 2, -17 },
  { 1312, 11, 2, 14, 1, 1 },
  { 1315, 5, 3, 14, 4, -18 },
  { 1317, 11, 13, 14, 1, -13 },
  { 1335, 10, 17, 14, 2, -17 },
  { 1357, 10, 13, 14, 2, -13 },
  { 1374, 10, 17, 14, 2, -17 },
  { 1396, 10, 13, 14, 2, -13 },
  { 1413, 11, 17, 14, 1, -17 },
  { 1437, 10, 17, 14, 2, -13 },
  { 1459, 10, 17, 14, 2, -17 },
  { 1481, 11, 18, 14, 2, -18 },
  { 1506, 9, 22, 14, 2, -18 },
  { 1531, 11, 17, 14, 2, -17 },
  { 1555, 12, 17, 14, 1, -17 },
  { 1581, 12, 13, 14, 1, -13 },
  { 1601, 10, 13, 14, 2, -13 },
  { 1618, 10, 13, 14, 2, -13 },
  { 1635, 10, 17, 14, 2, -13 },
  { 1657, 10, 17, 14, 2, -13 },
  { 1679, 11, 13, 14, 2, -13 },
  { 1697, 10, 13, 14, 2, -13 },
  { 1714, 11, 16, 14, 1, -16 },
  { 1736, 10, 13, 14, 2, -13 },
  { 1753, 12, 13, 14, 1, -13 },
  { 1773, 13, 13, 14, 0, -13 },
  { 1795, 12, 13, 14, 1, -13 },
  { 1815, 12, 17, 14, 1, -13 },
  { 1841, 10, 13, 14, 2, -13 },
  { 1858, 10, 22, 14, 2, -19 },
  { 1886, 3, 22, 14, 5, -19 },
  { 1895, 10, 22, 14, 2, -19 },
  { 1923, 12, 6, 14, 1, -11 },
};

const GFXfont JetBrainsMono_Bold23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_BOLD23PT7B_H_
