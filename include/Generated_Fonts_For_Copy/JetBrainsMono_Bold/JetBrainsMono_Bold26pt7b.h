#ifndef _JETBRAINSMONO_BOLD26PT7B_H_
#define _JETBRAINSMONO_BOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xE6, 0x60, 0x00, 0xFF, 0xF0, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1D, 0x8E, 0xC7, 0x0E, 0x38, 0x30, 0xC0,
  0xC3, 0x03, 0x0C, 0x0C, 0x71, 0xFF, 0xF7, 0xFF, 0xC6, 0x18, 0x18, 0x60,
  0x61, 0x83, 0x8E, 0x0E, 0x38, 0xFF, 0xFB, 0xFF, 0xE3, 0x0C, 0x0C, 0x30,
  0x71, 0xC1, 0xC7, 0x06, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0xFC, 0x1F, 0xF9, 0xFF, 0xCF, 0x6F, 0x73, 0x3B, 0x98, 0x1E, 0xC0,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0x7C, 0x19, 0xDC,
  0xCE, 0xE6, 0xF7, 0xFF, 0x1F, 0xF8, 0x7F, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x3C, 0x07, 0x7E, 0x0E, 0xE7, 0x0C, 0xE3, 0x18, 0xE3, 0x38,
  0xE3, 0x70, 0x7F, 0x60, 0x7E, 0xC0, 0x19, 0xC0, 0x01, 0x80, 0x03, 0x10,
  0x07, 0x7C, 0x06, 0xEE, 0x0C, 0xC6, 0x18, 0xC6, 0x38, 0xC6, 0x30, 0xC6,
  0x60, 0xFE, 0xE0, 0x7C, 0x0F, 0x80, 0xFF, 0x83, 0xDE, 0x1E, 0x3C, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x01, 0xF8, 0x1F, 0x73, 0xB9,
  0xEE, 0xE3, 0xF3, 0x87, 0xCE, 0x1E, 0x38, 0x78, 0xFB, 0xF1, 0xFE, 0xE3,
  0xF3, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x83, 0xC3, 0xE3, 0xE3, 0xC3, 0xC1,
  0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x38, 0x1C, 0x0F, 0x03, 0xC0, 0xF8, 0x7E, 0x0F, 0x01, 0x80, 0x80, 0xE0,
  0xF8, 0xFC, 0x3E, 0x1E, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x1E, 0x7C, 0xF8, 0xF0, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x21, 0xC2, 0xE3, 0x3B, 0xED, 0xFF, 0xFF, 0x80,
  0xC0, 0x07, 0x80, 0x77, 0x01, 0xCE, 0x0E, 0x3C, 0x38, 0x60, 0x41, 0x00,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0xF7, 0x9E, 0x71,
  0xCE, 0x38, 0xFF, 0xFF, 0xFF, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x1F,
  0x87, 0xFC, 0xFF, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xEE,
  0x7E, 0xF7, 0xEE, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xFF,
  0xE7, 0xFC, 0x3F, 0x80, 0x0F, 0x03, 0xF0, 0x7F, 0x0F, 0x70, 0xE7, 0x0C,
  0x70, 0x87, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x87, 0xFC,
  0xFF, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xE0,
  0xFE, 0x0F, 0xFF, 0xE7, 0xFC, 0x3F, 0x80, 0x01, 0xE0, 0x78, 0x1E, 0x03,
  0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0xFE, 0x1F, 0x83, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xFC, 0xFF, 0xEF,
  0x9E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0xE0, 0xFE, 0x0F, 0xFF, 0xE7,
  0xFC, 0x3F, 0x80, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x38, 0x7F, 0xE3, 0xFF, 0x9E, 0x1E, 0xE0, 0x7F, 0x03,
  0xF8, 0x1D, 0xC0, 0xEE, 0x0F, 0x7F, 0xF1, 0xFF, 0x87, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0xFE, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x00, 0x3F, 0x87, 0xFC, 0xFF, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F,
  0xF0, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0x7F, 0xCF, 0x0E, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x0F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x1F, 0xC1, 0xFF, 0x1F,
  0xFC, 0xE0, 0xF7, 0x03, 0xF8, 0x1F, 0xC0, 0xEE, 0x07, 0x78, 0x7B, 0xFF,
  0xCF, 0xFC, 0x19, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x23, 0xFE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD,
  0xE0, 0x10, 0xF7, 0xCF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3D, 0xE7,
  0x9C, 0x73, 0xCE, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7E, 0x1F, 0x87,
  0xE0, 0xF8, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF0,
  0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x0C, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0x01, 0xF0, 0xFE, 0x3F, 0x8F, 0xC0, 0xF0, 0x0C,
  0x00, 0x80, 0x00, 0xFE, 0x3F, 0xCF, 0xF8, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x3F, 0x8F, 0xE3, 0xE0, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x1F, 0x03, 0x80, 0x0F, 0xE0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0xE0, 0x1F,
  0x80, 0x7E, 0x1D, 0xF8, 0xFF, 0xE7, 0x3F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7,
  0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xEF, 0xE3, 0xFF, 0x82, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x0D, 0xC0, 0x77, 0x01, 0xCE, 0x07, 0x38, 0x1C,
  0xE0, 0xE3, 0x83, 0x8F, 0x0E, 0x1C, 0x3F, 0xF1, 0xFF, 0xC7, 0x07, 0x9C,
  0x0E, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x1E, 0xFF, 0xCF, 0xFC, 0xE3, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF, 0xFE, 0xFF, 0x80,
  0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7F, 0x0F,
  0x7F, 0xE7, 0xFE, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x7F,
  0xEF, 0x0F, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xE7, 0xFE, 0x1F,
  0x80, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xF7, 0xFE,
  0x1F, 0x80, 0xE0, 0x7F, 0x07, 0xB8, 0x39, 0xC3, 0xCE, 0x1E, 0x71, 0xE3,
  0x8F, 0x1C, 0x70, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xC7, 0x0E, 0x3C, 0x70,
  0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xF7, 0x03, 0xB8, 0x1E, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xBF, 0xCD, 0xF6, 0x7F, 0xB7, 0xFD,
  0xF7, 0xE7, 0xBF, 0x3D, 0xF9, 0xCF, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xF0, 0x7F, 0x07, 0xF8, 0x7F,
  0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xC7, 0xEE, 0x7E, 0x67, 0xE6, 0x7E,
  0x77, 0xE3, 0x7E, 0x37, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xF0,
  0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0E,
  0x7F, 0xE7, 0xFC, 0x3F, 0x80, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE,
  0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0x1F, 0x87, 0xFC, 0xFF, 0xEF, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0F,
  0xFF, 0xE7, 0xFC, 0x3F, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE1, 0xFF, 0xFE, 0xFF, 0xCE, 0x38, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E,
  0xE0, 0xEE, 0x0F, 0xE0, 0x70, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF0, 0xF7,
  0x03, 0xB8, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1D, 0xC0, 0xEE, 0x0F, 0x7F, 0xF1, 0xFF, 0x87, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0E, 0xFF, 0xE7, 0xFC, 0x3F, 0x80,
  0xE0, 0x3F, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x79, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0xF0, 0xE3, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x77,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0xE3, 0x8E,
  0xC7, 0x1D, 0x8E, 0x3B, 0x9E, 0x77, 0x3C, 0xEE, 0x79, 0xDC, 0xB3, 0xB9,
  0x66, 0x76, 0xCC, 0xEC, 0x99, 0xD9, 0x71, 0xB2, 0xE3, 0x67, 0xC6, 0xCF,
  0x8D, 0x9F, 0x1E, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0xF0, 0x3D,
  0xC1, 0xE7, 0x87, 0x0E, 0x3C, 0x3C, 0xE0, 0x77, 0x81, 0xFC, 0x03, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x83, 0xCE,
  0x0E, 0x3C, 0x78, 0x79, 0xC1, 0xEF, 0x03, 0xC0, 0xE0, 0x3F, 0xC0, 0xE7,
  0x03, 0x9E, 0x1C, 0x38, 0x70, 0xE3, 0x81, 0xCE, 0x07, 0x78, 0x1F, 0xC0,
  0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xFE, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0xFF,
  0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xF8, 0x39, 0x83, 0x9C, 0x71, 0xC7, 0x0E, 0xE0, 0xEE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x70, 0x78, 0x02, 0x00, 0xFF, 0x0F,
  0xFC, 0xF1, 0xE7, 0x07, 0x80, 0x3C, 0x01, 0xE7, 0xFF, 0x7F, 0xFB, 0x83,
  0xFC, 0x1F, 0xE0, 0xF7, 0x8F, 0xBF, 0xFC, 0xFD, 0xE0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE2, 0x0E, 0xFC, 0xFF, 0xEF, 0x9E, 0xF0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0xFF, 0xEE, 0xFE,
  0xE7, 0xC0, 0x04, 0x03, 0xFC, 0x7F, 0xEF, 0x9E, 0xE0, 0xFE, 0x07, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7F, 0x0F, 0xFF, 0xE7, 0xFE, 0x1F,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xF3, 0xEF, 0x7F, 0xFF,
  0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xFF, 0xF7, 0xFF, 0x3E, 0xF0, 0x04, 0x03, 0xFC, 0x7F, 0xEF, 0x0E,
  0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x0F,
  0xF9, 0xE7, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0x00,
  0xF0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0C, 0x03, 0xEF, 0x7F, 0xFF, 0x9F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F,
  0x00, 0xE3, 0xFE, 0x3F, 0xC3, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE2, 0x0E, 0xFC, 0xFF, 0xEF, 0x9E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC1, 0xEF,
  0xFB, 0xFC, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x3B, 0x83, 0xDC, 0x3C, 0xE1, 0xC7, 0x1E, 0x3F, 0xE1, 0xFE, 0x0F,
  0xF8, 0x71, 0xE3, 0x8F, 0x1C, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x1E, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x04, 0x27, 0x77,
  0xFF, 0xFF, 0xCE, 0x7E, 0x33, 0xF1, 0x9F, 0x8C, 0xFC, 0x67, 0xE3, 0x3F,
  0x19, 0xF8, 0xCF, 0xC6, 0x7E, 0x33, 0xF1, 0x9F, 0x8C, 0xE0, 0x02, 0x0E,
  0xFC, 0xFF, 0xEF, 0x9E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x06, 0x03, 0xFC,
  0x7F, 0xEF, 0x9E, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFF, 0x0F, 0xFF, 0xE7, 0xFC, 0x1F, 0x80, 0x02, 0x0E, 0xFC, 0xFF,
  0xEF, 0x9E, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFF, 0x0F, 0xFF, 0xEE, 0xFE, 0xE7, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x08, 0x03, 0xEF, 0x7F, 0xFF, 0x9F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x3E,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0x0F, 0xFE, 0xFF,
  0xFF, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x06, 0x03, 0xFC, 0x7F, 0xEF,
  0x0F, 0xE0, 0x0F, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0x00, 0x7E,
  0x07, 0xF9, 0xF7, 0xFE, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xE7, 0xFE, 0x7F, 0xC3, 0xF8, 0xF0, 0x3D, 0xC0,
  0xE7, 0x07, 0x9E, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x8E, 0x07, 0x38, 0x1C,
  0xE0, 0x77, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xC7, 0x1F,
  0x1C, 0x7E, 0x79, 0xF9, 0xE6, 0xE5, 0x9B, 0x96, 0x66, 0xDB, 0x9B, 0x2E,
  0x6C, 0xB9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x78, 0xF0, 0xE3, 0xC0, 0xF0,
  0x79, 0xE1, 0xC3, 0xCE, 0x07, 0x78, 0x1F, 0xC0, 0x3E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0xC0, 0x77, 0x83, 0xCE, 0x0E, 0x3C, 0x78, 0x7B, 0xC0, 0xF0,
  0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x9E, 0x1C, 0x38, 0x70, 0xF3, 0xC1, 0xCE,
  0x07, 0x38, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x3F, 0x03, 0xF0,
  0x7C, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x0F,
  0xF0, 0xFC, 0x0F, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x0F, 0x80, 0xFC, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0xFF, 0x07, 0xF0, 0xFF, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0xFC, 0x0F, 0xC0, 0xF0, 0x00, 0x3C, 0x1B, 0xF0,
  0xFF, 0xCF, 0xC7, 0xFE, 0x3F, 0x80, 0x70,
};

const GFXglyph JetBrainsMono_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 9, 8, 16, 3, -19 },
  { 20, 14, 19, 16, 1, -19 },
  { 54, 13, 27, 16, 1, -23 },
  { 98, 16, 19, 16, 0, -19 },
  { 136, 14, 19, 16, 1, -19 },
  { 170, 3, 8, 16, 6, -19 },
  { 173, 9, 25, 16, 4, -22 },
  { 202, 8, 25, 16, 3, -22 },
  { 227, 14, 14, 16, 1, -16 },
  { 252, 12, 13, 16, 2, -15 },
  { 272, 6, 8, 16, 4, -4 },
  { 278, 8, 3, 16, 4, -10 },
  { 281, 5, 5, 16, 5, -5 },
  { 285, 12, 25, 16, 2, -22 },
  { 323, 12, 19, 16, 2, -19 },
  { 352, 12, 19, 16, 2, -19 },
  { 381, 12, 19, 16, 2, -19 },
  { 410, 12, 19, 16, 2, -19 },
  { 439, 11, 19, 16, 2, -19 },
  { 466, 12, 19, 16, 2, -19 },
  { 495, 13, 19, 16, 1, -19 },
  { 526, 12, 19, 16, 2, -19 },
  { 555, 12, 19, 16, 2, -19 },
  { 584, 13, 19, 16, 1, -19 },
  { 615, 5, 15, 16, 5, -15 },
  { 625, 6, 19, 16, 4, -15 },
  { 640, 12, 15, 16, 2, -16 },
  { 663, 11, 9, 16, 2, -13 },
  { 676, 12, 15, 16, 2, -16 },
  { 699, 10, 19, 16, 3, -19 },
  { 723, 14, 24, 16, 1, -19 },
  { 765, 14, 19, 16, 1, -19 },
  { 799, 12, 19, 16, 2, -19 },
  { 828, 12, 19, 16, 2, -19 },
  { 857, 12, 19, 16, 2, -19 },
  { 886, 12, 19, 16, 2, -19 },
  { 915, 12, 19, 16, 2, -19 },
  { 944, 12, 19, 16, 2, -19 },
  { 973, 12, 19, 16, 2, -19 },
  { 1002, 11, 19, 16, 2, -19 },
  { 1029, 12, 19, 16, 1, -19 },
  { 1058, 13, 19, 16, 2, -19 },
  { 1089, 11, 19, 16, 3, -19 },
  { 1116, 13, 19, 16, 1, -19 },
  { 1147, 12, 19, 16, 2, -19 },
  { 1176, 12, 19, 16, 2, -19 },
  { 1205, 13, 19, 16, 2, -19 },
  { 1236, 12, 24, 16, 2, -19 },
  { 1272, 12, 19, 16, 2, -19 },
  { 1301, 13, 19, 16, 1, -19 },
  { 1332, 13, 19, 16, 1, -19 },
  { 1363, 12, 19, 16, 2, -19 },
  { 1392, 14, 19, 16, 1, -19 },
  { 1426, 15, 19, 16, 0, -19 },
  { 1462, 14, 19, 16, 1, -19 },
  { 1496, 14, 19, 16, 1, -19 },
  { 1530, 12, 19, 16, 2, -19 },
  { 1559, 7, 25, 16, 5, -22 },
  { 1581, 12, 25, 16, 2, -22 },
  { 1619, 7, 25, 16, 4, -22 },
  { 1641, 12, 10, 16, 2, -19 },
  { 1656, 12, 3, 16, 2, 1 },
  { 1661, 7, 3, 16, 4, -20 },
  { 1664, 13, 15, 16, 1, -15 },
  { 1689, 12, 19, 16, 2, -19 },
  { 1718, 12, 15, 16, 2, -15 },
  { 1741, 12, 19, 16, 2, -19 },
  { 1770, 12, 15, 16, 2, -15 },
  { 1793, 13, 19, 16, 1, -19 },
  { 1824, 12, 20, 16, 2, -15 },
  { 1854, 12, 19, 16, 2, -19 },
  { 1883, 13, 20, 16, 2, -20 },
  { 1916, 10, 25, 16, 2, -20 },
  { 1948, 13, 19, 16, 2, -19 },
  { 1979, 14, 19, 16, 1, -19 },
  { 2013, 13, 15, 16, 1, -15 },
  { 2038, 12, 15, 16, 2, -15 },
  { 2061, 12, 15, 16, 2, -15 },
  { 2084, 12, 20, 16, 2, -15 },
  { 2114, 12, 20, 16, 2, -15 },
  { 2144, 12, 15, 16, 2, -15 },
  { 2167, 12, 15, 16, 2, -15 },
  { 2190, 13, 18, 16, 1, -18 },
  { 2220, 12, 14, 16, 2, -14 },
  { 2241, 14, 14, 16, 1, -14 },
  { 2266, 14, 14, 16, 1, -14 },
  { 2291, 14, 14, 16, 1, -14 },
  { 2316, 14, 19, 16, 1, -14 },
  { 2350, 12, 14, 16, 2, -14 },
  { 2371, 12, 25, 16, 2, -22 },
  { 2409, 3, 25, 16, 6, -22 },
  { 2419, 12, 25, 16, 2, -22 },
  { 2457, 13, 6, 16, 1, -12 },
};

const GFXfont JetBrainsMono_Bold26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_BOLD26PT7B_H_
