#ifndef _JETBRAINSMONO_BOLD8PT7B_H_
#define _JETBRAINSMONO_BOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x57, 0xD4, 0xAF, 0x30, 0x27, 0x76, 0x3B, 0x72,
  0xCD, 0xB8, 0x66, 0xCC, 0x62, 0x91, 0x79, 0x3C, 0xE0, 0x2A, 0x49, 0x11,
  0x95, 0x56, 0x27, 0xC8, 0xA0, 0x22, 0xF2, 0x60, 0xE0, 0x80, 0x11, 0x32,
  0x24, 0x4C, 0xF6, 0xFB, 0xC0, 0x59, 0x25, 0xC0, 0x7D, 0x12, 0x47, 0x73,
  0x21, 0x97, 0x2A, 0x5E, 0x40, 0xF3, 0x93, 0xC0, 0x22, 0x65, 0x97, 0xF9,
  0x12, 0x26, 0xF6, 0xFB, 0xC0, 0x7D, 0xD7, 0x26, 0x90, 0x41, 0x80, 0x3A,
  0x32, 0xE3, 0x80, 0x98, 0xE8, 0xC4, 0xA1, 0x80, 0x74, 0x6F, 0x5A, 0xD9,
  0x80, 0x23, 0x14, 0xA7, 0x4C, 0xF7, 0xDB, 0xC0, 0xF6, 0x4B, 0xC0, 0xF6,
  0xDB, 0xC0, 0xF3, 0xC9, 0xC0, 0xF2, 0x79, 0x00, 0xF6, 0x7B, 0xC0, 0xB7,
  0xDB, 0x40, 0xE9, 0x25, 0xC0, 0x31, 0x11, 0x97, 0xAA, 0xCC, 0xAB, 0x92,
  0x49, 0xC0, 0xDD, 0xB9, 0x99, 0xB7, 0xFF, 0x40, 0xF6, 0xDB, 0xC0, 0xEB,
  0xAE, 0x88, 0xF6, 0xDB, 0xC8, 0xF6, 0xEB, 0x40, 0x75, 0x43, 0x97, 0xF2,
  0x22, 0x22, 0xB6, 0xDB, 0xC0, 0x9A, 0x94, 0xA6, 0x10, 0xAD, 0x7B, 0xE5,
  0x28, 0xD2, 0x88, 0x45, 0x6C, 0x9A, 0x94, 0x42, 0x10, 0xE5, 0x29, 0xC0,
  0xF2, 0x49, 0x27, 0xC4, 0x42, 0x22, 0x11, 0xD5, 0x57, 0x56, 0x80, 0xF0,
  0xC0, 0x77, 0x97, 0x9A, 0xDB, 0xC0, 0xF2, 0xF0, 0x27, 0xDB, 0xC0, 0xFE,
  0x70, 0x32, 0xF2, 0x22, 0xF6, 0xFE, 0x9A, 0xDB, 0x40, 0x43, 0x25, 0xC0,
  0x63, 0x92, 0x78, 0x89, 0xAC, 0xAB, 0xE2, 0x22, 0x23, 0xFB, 0xBB, 0xF6,
  0xD0, 0xF6, 0xF0, 0xF6, 0xF8, 0xF6, 0xF2, 0xF6, 0x40, 0xF8, 0xF0, 0x22,
  0xF2, 0x23, 0xB6, 0xF0, 0xD5, 0x52, 0xAF, 0xB4, 0xA0, 0xD1, 0x1D, 0xB0,
  0xDA, 0x98, 0x46, 0x00, 0xEA, 0x70, 0x29, 0x2C, 0x91, 0xFF, 0x89, 0x26,
  0x94, 0x5B,
};

const GFXglyph JetBrainsMono_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 0, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 3, 5, 2, -6 },
  { 21, 3, 8, 5, 1, -7 },
  { 24, 2, 8, 5, 1, -7 },
  { 26, 5, 4, 5, 0, -5 },
  { 29, 4, 4, 5, 0, -5 },
  { 31, 2, 2, 5, 1, -1 },
  { 32, 3, 1, 5, 1, -3 },
  { 33, 1, 1, 5, 2, -1 },
  { 34, 4, 8, 5, 0, -7 },
  { 38, 3, 6, 5, 1, -6 },
  { 41, 3, 6, 5, 1, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 4, 6, 5, 0, -6 },
  { 50, 3, 6, 5, 1, -6 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 4, 6, 5, 0, -6 },
  { 59, 4, 6, 5, 0, -6 },
  { 62, 3, 6, 5, 1, -6 },
  { 65, 4, 6, 5, 0, -6 },
  { 68, 1, 4, 5, 2, -4 },
  { 69, 2, 5, 5, 1, -4 },
  { 71, 3, 5, 5, 1, -5 },
  { 73, 3, 3, 5, 1, -4 },
  { 75, 3, 5, 5, 1, -5 },
  { 77, 3, 6, 5, 1, -6 },
  { 80, 5, 7, 5, 0, -6 },
  { 85, 5, 6, 5, 0, -6 },
  { 89, 3, 6, 5, 1, -6 },
  { 92, 3, 6, 5, 1, -6 },
  { 95, 3, 6, 5, 1, -6 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 3, 6, 5, 1, -6 },
  { 104, 3, 6, 5, 1, -6 },
  { 107, 3, 6, 5, 1, -6 },
  { 110, 3, 6, 5, 1, -6 },
  { 113, 4, 6, 5, 0, -6 },
  { 116, 4, 6, 5, 1, -6 },
  { 119, 3, 6, 5, 1, -6 },
  { 122, 4, 6, 5, 0, -6 },
  { 125, 3, 6, 5, 1, -6 },
  { 128, 3, 6, 5, 1, -6 },
  { 131, 4, 6, 5, 1, -6 },
  { 134, 3, 7, 5, 1, -6 },
  { 137, 3, 6, 5, 1, -6 },
  { 140, 4, 6, 5, 0, -6 },
  { 143, 4, 6, 5, 0, -6 },
  { 146, 3, 6, 5, 1, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 3, 6, 5, 1, -6 },
  { 168, 3, 8, 5, 1, -7 },
  { 171, 4, 8, 5, 0, -7 },
  { 175, 2, 8, 5, 1, -7 },
  { 177, 3, 3, 5, 1, -6 },
  { 179, 4, 1, 5, 0, 0 },
  { 180, 2, 1, 5, 1, -6 },
  { 181, 4, 4, 5, 0, -4 },
  { 183, 3, 6, 5, 1, -6 },
  { 186, 3, 4, 5, 1, -4 },
  { 188, 3, 6, 5, 1, -6 },
  { 191, 3, 4, 5, 1, -4 },
  { 193, 4, 6, 5, 0, -6 },
  { 196, 3, 5, 5, 1, -4 },
  { 198, 3, 6, 5, 1, -6 },
  { 201, 3, 6, 5, 1, -6 },
  { 204, 3, 7, 5, 1, -6 },
  { 207, 4, 6, 5, 1, -6 },
  { 210, 4, 6, 5, 0, -6 },
  { 213, 4, 4, 5, 0, -4 },
  { 215, 3, 4, 5, 1, -4 },
  { 217, 3, 4, 5, 1, -4 },
  { 219, 3, 5, 5, 1, -4 },
  { 221, 3, 5, 5, 1, -4 },
  { 223, 3, 4, 5, 1, -4 },
  { 225, 3, 4, 5, 1, -4 },
  { 227, 4, 6, 5, 0, -6 },
  { 230, 3, 4, 5, 1, -4 },
  { 232, 4, 4, 5, 0, -4 },
  { 234, 5, 4, 5, 0, -4 },
  { 237, 5, 4, 5, 0, -4 },
  { 240, 5, 5, 5, 0, -4 },
  { 244, 3, 4, 5, 1, -4 },
  { 246, 3, 8, 5, 1, -7 },
  { 249, 1, 8, 5, 2, -7 },
  { 250, 3, 8, 5, 1, -7 },
  { 253, 4, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_Bold8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_BOLD8PT7B_H_
