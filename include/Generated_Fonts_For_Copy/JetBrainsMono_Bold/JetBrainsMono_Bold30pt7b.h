#ifndef _JETBRAINSMONO_BOLD30PT7B_H_
#define _JETBRAINSMONO_BOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xC3,
  0x00, 0x00, 0x07, 0x9E, 0xFD, 0xE0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x07, 0x0E, 0x07, 0x0E, 0x06, 0x0C,
  0x06, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x18,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x30, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x38, 0x70, 0x38, 0x70, 0x30, 0x60, 0x30, 0xE0,
  0x70, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x9E, 0xDF, 0xF3, 0x3F, 0xCC, 0xFF, 0x30, 0x3C, 0xC0, 0x7F,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xF8, 0x0D, 0xF0, 0x33, 0xC0,
  0xCF, 0xE3, 0x1F, 0xCC, 0xFF, 0xB7, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x01, 0xDF, 0xC0, 0xE7,
  0x78, 0x33, 0x8E, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x0E, 0x39, 0xC1, 0xDE,
  0xE0, 0x7F, 0x70, 0x0F, 0x98, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x9E,
  0x00, 0xEF, 0xE0, 0x77, 0xB8, 0x39, 0xC7, 0x0E, 0x71, 0xC7, 0x1C, 0x73,
  0x87, 0x1C, 0xC1, 0xCE, 0x70, 0x3F, 0xB8, 0x07, 0xC0, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x3C, 0x78, 0x38, 0x3C, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x7F, 0x8F, 0xF3, 0xCE, 0xF3,
  0xDE, 0xF1, 0xFC, 0xF0, 0xFC, 0xF0, 0x78, 0xF0, 0x78, 0x70, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0xF0, 0xFC, 0x7F, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x40, 0xE0,
  0x3C, 0x0F, 0xC3, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0xF8, 0x7C, 0x7E, 0x3F, 0x0F, 0x83, 0xC0, 0x80, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x71, 0x8E, 0xF9, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFC, 0x01, 0x80, 0x07, 0xE0, 0x0E, 0x70, 0x1E, 0x78,
  0x1E, 0x78, 0x3C, 0x3C, 0x18, 0x18, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x78, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF,
  0xFF, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xCC, 0xFF, 0x7B, 0xFD, 0xEF,
  0xF3, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x03,
  0xFE, 0x0F, 0xBC, 0x1C, 0x78, 0x30, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0,
  0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBE, 0x3E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x3E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE1, 0xDE, 0x0F,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x77, 0xF1, 0xFF, 0xE7,
  0xFF, 0x9E, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F,
  0xC0, 0xFF, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xFF, 0xC7, 0xFF, 0xBF, 0x3F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xDE, 0x1E, 0x78, 0x78, 0xFF, 0xC1, 0xFE, 0x07, 0xF8,
  0x7C, 0xF9, 0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87,
  0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBE,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0xCF, 0xDF, 0xFE, 0x3F, 0xF8, 0x33, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x33, 0xEF, 0xFF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xEF, 0xFF, 0x78, 0x3C, 0xFD,
  0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0x8F, 0x3E,
  0x78, 0xF3, 0xC7, 0x8F, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xF0, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0x3C, 0x03, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0xFE, 0x1F,
  0xF3, 0xFF, 0x7F, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE7, 0xFC,
  0xFF, 0x1F, 0xC3, 0xE0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x3E, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x78,
  0x1E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x67, 0xE1, 0xFF, 0xE3,
  0xFF, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0xCF, 0xE3, 0xFF, 0xE1, 0xF7, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E,
  0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0x78,
  0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xBC, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xFF,
  0xCF, 0xFC, 0x3F, 0xFC, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFF, 0x07, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x80, 0x0F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x9E, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F,
  0x80, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x1F, 0xBF, 0xFE,
  0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEE,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF,
  0x9E, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xF7, 0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F,
  0x80, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1E,
  0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF9, 0xE0, 0xF3, 0xC1,
  0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3F, 0xE1, 0xFF, 0x87,
  0xF6, 0x1B, 0xF8, 0x7F, 0xF3, 0xFE, 0xCD, 0xFB, 0x37, 0xEF, 0xDF, 0xBF,
  0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0xF8, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xB8, 0xFE, 0xE3, 0xFB, 0x8F,
  0xE7, 0x3F, 0xDC, 0xFF, 0x73, 0xFC, 0xEF, 0xF3, 0xBF, 0xCE, 0x7F, 0x1D,
  0xFC, 0x77, 0xF1, 0xDF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1,
  0xF0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0xFE,
  0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xEF,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xC1,
  0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x78,
  0x0E, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xEF,
  0x03, 0xDE, 0x07, 0xC0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70,
  0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xF1, 0xE3, 0xDC, 0x78, 0xE7, 0x1E, 0x39, 0xC7, 0x8E, 0x71,
  0xE3, 0x9C, 0x78, 0xE7, 0x1E, 0x39, 0xC7, 0x8E, 0x73, 0x33, 0x9E, 0xCC,
  0xE3, 0xB3, 0x70, 0xEC, 0xDC, 0x3B, 0x37, 0x0E, 0xCD, 0xC3, 0xB3, 0x70,
  0xEC, 0xDC, 0x3B, 0x37, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x1E,
  0x1E, 0x07, 0x87, 0x80, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C,
  0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78,
  0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00,
  0xFC, 0x03, 0xF0, 0x1E, 0xE0, 0x73, 0x83, 0xCF, 0x0E, 0x1C, 0x78, 0x79,
  0xC0, 0xE7, 0x03, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0xF0, 0xF1, 0xE1, 0xE0, 0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x70,
  0x3E, 0x00, 0xF0, 0x03, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xDF, 0xEF, 0x3F, 0x3C, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0x0F, 0x7F, 0x3F, 0xFE,
  0xFF, 0xFB, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0xFE, 0xF7, 0xF3, 0xCF,
  0x80, 0x07, 0xC0, 0x7F, 0xC7, 0xFF, 0x9F, 0xFE, 0xF8, 0x3F, 0xC0, 0xFF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0xF0, 0x3D,
  0xE1, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x38, 0xF3, 0xFB, 0xDF, 0xFF, 0x7F, 0xFF, 0xC1,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFF, 0x3F, 0xBC, 0x7C, 0xF0, 0x07, 0x80,
  0x7F, 0x87, 0xFF, 0x1E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0xF7, 0xFF,
  0x8F, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x3C, 0xFE, 0xF7, 0xFF,
  0xDF, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x1F, 0x78, 0xFD, 0xFF, 0xF3, 0xFB, 0xC7, 0xCF, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0x0F, 0x7F, 0x3F, 0xFE,
  0xFF, 0xFB, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xF0, 0x01, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40,
  0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x03, 0xFC, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xE1,
  0xF3, 0xC3, 0xC7, 0x8F, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0x78, 0xF0,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xEE, 0x3B, 0xFD, 0xFF,
  0xFF, 0xF9, 0xE7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F,
  0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7,
  0xE3, 0x1C, 0xF1, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x07, 0x80, 0x7F, 0x87,
  0xFF, 0x1F, 0xFE, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC,
  0x1F, 0xE0, 0xF1, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFF, 0xFF, 0xBD, 0xFC, 0xF3, 0xE3, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF,
  0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xE3, 0xC3, 0xBF, 0xCE,
  0xFF, 0xBF, 0x3E, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0x1F, 0xF0, 0x3F, 0xC0,
  0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0xF7, 0xFF, 0xDF, 0xFE, 0x1F, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1,
  0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x38,
  0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0xE1, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7,
  0xE3, 0xC7, 0xE3, 0xC7, 0x73, 0xC6, 0x76, 0x6E, 0x76, 0x6E, 0x76, 0x6E,
  0x76, 0x6E, 0x76, 0x6E, 0x76, 0x6E, 0x36, 0x6C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0xF8, 0x1F, 0x78, 0x1E, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E, 0x78,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x78, 0x1E, 0xF8, 0x1F,
  0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C,
  0x1C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x0F, 0x7F, 0x0F, 0x7F, 0x8F,
  0x73, 0xCE, 0xF1, 0xFE, 0xF0, 0xFE, 0x00, 0x78,
};

const GFXglyph JetBrainsMono_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 10, 9, 18, 4, -22 },
  { 30, 16, 22, 18, 1, -22 },
  { 74, 14, 30, 18, 2, -26 },
  { 127, 18, 22, 18, 0, -22 },
  { 177, 16, 22, 18, 1, -22 },
  { 221, 4, 9, 18, 7, -22 },
  { 226, 10, 29, 18, 5, -25 },
  { 263, 10, 29, 18, 3, -25 },
  { 300, 16, 15, 18, 1, -18 },
  { 330, 14, 14, 18, 2, -17 },
  { 355, 8, 10, 18, 4, -5 },
  { 365, 10, 4, 18, 4, -12 },
  { 370, 6, 5, 18, 6, -5 },
  { 374, 14, 28, 18, 2, -25 },
  { 423, 14, 22, 18, 2, -22 },
  { 462, 15, 22, 18, 2, -22 },
  { 504, 14, 22, 18, 2, -22 },
  { 543, 14, 22, 18, 2, -22 },
  { 582, 13, 22, 18, 2, -22 },
  { 618, 14, 22, 18, 2, -22 },
  { 657, 14, 22, 18, 2, -22 },
  { 696, 14, 22, 18, 2, -22 },
  { 735, 14, 22, 18, 2, -22 },
  { 774, 14, 22, 18, 2, -22 },
  { 813, 6, 17, 18, 6, -17 },
  { 826, 7, 22, 18, 5, -17 },
  { 846, 14, 16, 18, 2, -18 },
  { 874, 14, 11, 18, 2, -15 },
  { 894, 14, 16, 18, 2, -18 },
  { 922, 11, 22, 18, 4, -22 },
  { 953, 16, 27, 18, 1, -22 },
  { 1007, 16, 22, 18, 1, -22 },
  { 1051, 14, 22, 18, 2, -22 },
  { 1090, 14, 22, 18, 2, -22 },
  { 1129, 14, 22, 18, 2, -22 },
  { 1168, 13, 22, 18, 3, -22 },
  { 1204, 14, 22, 18, 2, -22 },
  { 1243, 14, 22, 18, 2, -22 },
  { 1282, 14, 22, 18, 2, -22 },
  { 1321, 12, 22, 18, 3, -22 },
  { 1354, 14, 22, 18, 1, -22 },
  { 1393, 15, 22, 18, 2, -22 },
  { 1435, 13, 22, 18, 3, -22 },
  { 1471, 14, 22, 18, 2, -22 },
  { 1510, 14, 22, 18, 2, -22 },
  { 1549, 14, 22, 18, 2, -22 },
  { 1588, 15, 22, 18, 2, -22 },
  { 1630, 14, 27, 18, 2, -22 },
  { 1678, 15, 22, 18, 2, -22 },
  { 1720, 14, 22, 18, 2, -22 },
  { 1759, 16, 22, 18, 1, -22 },
  { 1803, 14, 22, 18, 2, -22 },
  { 1842, 16, 22, 18, 1, -22 },
  { 1886, 18, 22, 18, 0, -22 },
  { 1936, 16, 22, 18, 1, -22 },
  { 1980, 16, 22, 18, 1, -22 },
  { 2024, 14, 22, 18, 2, -22 },
  { 2063, 8, 28, 18, 6, -25 },
  { 2091, 14, 28, 18, 2, -25 },
  { 2140, 8, 28, 18, 4, -25 },
  { 2168, 14, 12, 18, 2, -22 },
  { 2189, 14, 3, 18, 2, 1 },
  { 2195, 7, 5, 18, 5, -24 },
  { 2200, 14, 17, 18, 2, -17 },
  { 2230, 14, 22, 18, 2, -22 },
  { 2269, 14, 17, 18, 2, -17 },
  { 2299, 14, 22, 18, 2, -22 },
  { 2338, 14, 17, 18, 2, -17 },
  { 2368, 14, 22, 18, 2, -22 },
  { 2407, 14, 22, 18, 2, -17 },
  { 2446, 14, 22, 18, 2, -22 },
  { 2485, 15, 24, 18, 2, -24 },
  { 2530, 12, 29, 18, 2, -24 },
  { 2574, 15, 22, 18, 2, -22 },
  { 2616, 16, 22, 18, 1, -22 },
  { 2660, 14, 17, 18, 2, -17 },
  { 2690, 14, 17, 18, 2, -17 },
  { 2720, 14, 17, 18, 2, -17 },
  { 2750, 14, 22, 18, 2, -17 },
  { 2789, 14, 22, 18, 2, -17 },
  { 2828, 14, 17, 18, 3, -17 },
  { 2858, 14, 17, 18, 2, -17 },
  { 2888, 15, 21, 18, 1, -21 },
  { 2928, 14, 17, 18, 2, -17 },
  { 2958, 16, 17, 18, 1, -17 },
  { 2992, 16, 17, 18, 1, -17 },
  { 3026, 16, 17, 18, 1, -17 },
  { 3060, 16, 22, 18, 1, -17 },
  { 3104, 14, 17, 18, 2, -17 },
  { 3134, 14, 28, 18, 2, -25 },
  { 3183, 4, 28, 18, 7, -25 },
  { 3197, 14, 28, 18, 2, -25 },
  { 3246, 16, 7, 18, 1, -14 },
};

const GFXfont JetBrainsMono_Bold30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_BOLD30PT7B_H_
