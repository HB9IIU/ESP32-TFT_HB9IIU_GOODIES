#ifndef _JETBRAINSMONO_BOLD68PT7B_H_
#define _JETBRAINSMONO_BOLD68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xF1, 0xF3, 0xFF, 0x1F, 0xF0, 0xF8, 0xFF, 0xCF, 0xF8, 0x7C,
  0x3F, 0xE7, 0xFC, 0x3E, 0x1F, 0xF3, 0xFC, 0x1F, 0x07, 0xF9, 0xFE, 0x0F,
  0x80, 0x00, 0xFF, 0x87, 0xC0, 0x00, 0x7F, 0xC3, 0xE0, 0x00, 0x3F, 0xE1,
  0xF0, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x07, 0xFE, 0x7C, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xDF, 0xFE,
  0x00, 0x03, 0xE3, 0xFF, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0x00, 0xF8, 0x3F,
  0xE0, 0x00, 0x7C, 0x1F, 0xF0, 0x00, 0x3E, 0x0F, 0xF8, 0x00, 0x1F, 0x07,
  0xFF, 0xFC, 0x0F, 0x83, 0xFF, 0xFF, 0x07, 0xC1, 0xFF, 0xFF, 0x83, 0xE0,
  0xFF, 0xFF, 0xE1, 0xF0, 0xFF, 0x9F, 0xF8, 0xF8, 0xFF, 0xCF, 0xFE, 0x7C,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xFF, 0x80, 0x00, 0x1F, 0x83, 0xFF,
  0xF0, 0x00, 0x1F, 0xC3, 0xFF, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFE, 0x00,
  0x0F, 0xC3, 0xFC, 0x7F, 0x80, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xFE, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0xC0, 0x00, 0x0F,
  0xCF, 0xFF, 0xF0, 0x00, 0x0F, 0xC7, 0xFF, 0xF8, 0x00, 0x0F, 0xC7, 0xFF,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x1F, 0xC0,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x7E, 0x00, 0x03, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x7E,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0x7F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF9, 0xFF, 0x03, 0xFE, 0xFF,
  0x8F, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x87, 0xFC, 0xFF, 0x03, 0xFC, 0x7F,
  0x8F, 0xF0, 0x3F, 0xEF, 0xF8, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F,
  0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x7F,
  0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0x9F, 0xCF, 0xE7, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x20, 0x01,
  0xFC, 0x00, 0x41, 0xE0, 0x0F, 0xE0, 0x0F, 0x0F, 0xE0, 0x7E, 0x03, 0xF8,
  0xFF, 0x81, 0xF0, 0x7F, 0xC7, 0xFF, 0x0F, 0x87, 0xFF, 0x3F, 0xFE, 0x78,
  0xFF, 0xFB, 0xFF, 0xF9, 0xCF, 0xFF, 0xDF, 0xFF, 0xEE, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x10, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0xFF, 0xC3, 0xF8,
  0x7F, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFE, 0x3F, 0xE3,
  0xFF, 0xFC, 0x7F, 0xC7, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0xFC, 0x1F,
  0xFF, 0xE0, 0x20, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xF7,
  0xF8, 0x00, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x07,
  0xF8, 0x00, 0xC0, 0x07, 0xF8, 0x00, 0x80, 0x07, 0xF8, 0x00, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xC3, 0xFF, 0x00, 0x7F, 0x8F,
  0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x7F, 0xE0, 0x03, 0xFD, 0xFF,
  0x80, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x60, 0x01, 0xFE, 0x1F, 0xFC, 0x03, 0xFC, 0xFF,
  0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x02, 0x00,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0xBF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFE,
  0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x07,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0xE0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0x7F, 0xC0,
  0x0F, 0xFF, 0x7F, 0xE0, 0x00, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x03, 0xFE, 0x3F, 0xF9, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE7, 0xFF, 0x1F, 0xF0, 0x3C, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x1F, 0xFF, 0x80,
  0x1F, 0xFC, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0x9F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F,
  0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF,
  0x80, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0x80,
  0x3F, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0x1F,
  0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F,
  0x80, 0x3F, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x7F, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xE0,
  0x07, 0xFF, 0x1F, 0xFF, 0x80, 0x0F, 0xE1, 0xFD, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xC0,
  0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x2F, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFE,
  0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x2F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0x9F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xBF, 0xFD, 0xF0, 0x07, 0xDF, 0xFE, 0xFC, 0x07, 0xEF,
  0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0x9F, 0x01, 0xF7, 0xFF, 0xEF, 0xC1, 0xFB,
  0xFF, 0xF7, 0xE0, 0xFD, 0xFF, 0xFB, 0xF0, 0x7C, 0xFF, 0xFC, 0xFC, 0x7E,
  0x7F, 0xFE, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0x1F, 0x9F, 0xFF, 0x8F, 0x8F,
  0x8F, 0xFF, 0xC7, 0xEF, 0xC7, 0xFF, 0xE3, 0xF7, 0xE3, 0xFF, 0xF1, 0xFB,
  0xE1, 0xFF, 0xF8, 0x7D, 0xF1, 0xFF, 0xFC, 0x3F, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFC, 0x7F, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xC3, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xEF, 0xC0, 0x1F,
  0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0x3F, 0x80, 0xFF,
  0xFE, 0x7F, 0x01, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xF8, 0xFE, 0x07, 0xFF,
  0xF1, 0xFC, 0x0F, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xE3, 0xF8, 0x3F, 0xFF,
  0xC7, 0xF0, 0x7F, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFF, 0xFE,
  0x1F, 0xC3, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0x8F, 0xFF, 0xF0,
  0x7F, 0x1F, 0xFF, 0xE0, 0x7E, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF, 0x81,
  0xFC, 0xFF, 0xFF, 0x01, 0xF9, 0xFF, 0xFE, 0x03, 0xFB, 0xFF, 0xFC, 0x07,
  0xF3, 0xFF, 0xF8, 0x07, 0xE7, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xE0, 0x1F,
  0xDF, 0xFF, 0xC0, 0x1F, 0xBF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF,
  0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1E, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x07,
  0xFC, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x1F,
  0xF9, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F,
  0xE0, 0x3F, 0x9F, 0xC0, 0x7B, 0xC0, 0x7F, 0x3F, 0x80, 0xF7, 0x80, 0xFE,
  0x7F, 0x01, 0xEF, 0x01, 0xFC, 0xFE, 0x03, 0xDE, 0x03, 0xF9, 0xFC, 0x07,
  0xBC, 0x07, 0xF3, 0xF8, 0x0F, 0x78, 0x1F, 0xE7, 0xF0, 0x3E, 0xF0, 0x3F,
  0x8F, 0xF0, 0x7D, 0xF0, 0x7F, 0x0F, 0xE0, 0xFB, 0xE0, 0xFE, 0x1F, 0xC1,
  0xF7, 0xC1, 0xFC, 0x3F, 0x83, 0xEF, 0x83, 0xF8, 0x7F, 0x07, 0x8F, 0x07,
  0xF0, 0xFE, 0x0F, 0x1E, 0x0F, 0xE1, 0xFC, 0x1E, 0x3C, 0x1F, 0xC3, 0xF8,
  0x3C, 0x78, 0x3F, 0x87, 0xF0, 0xF8, 0xF0, 0x7E, 0x0F, 0xE1, 0xF1, 0xF0,
  0xFC, 0x1F, 0xC3, 0xE3, 0xE3, 0xF8, 0x1F, 0xC7, 0xC7, 0xC7, 0xF0, 0x3F,
  0x8F, 0x0F, 0x8F, 0xE0, 0x7F, 0x1E, 0x1F, 0x1F, 0xC0, 0xFE, 0x3C, 0x1E,
  0x3F, 0x81, 0xFC, 0x78, 0x3C, 0x7F, 0x03, 0xF9, 0xF0, 0x78, 0xFE, 0x07,
  0xF3, 0xE0, 0xF1, 0xF8, 0x0F, 0xE7, 0xC1, 0xE3, 0xF0, 0x1F, 0xCF, 0x83,
  0xE7, 0xE0, 0x3F, 0x9F, 0x07, 0xCF, 0xC0, 0x3F, 0x3C, 0x0F, 0x9F, 0x80,
  0x7E, 0x78, 0x1F, 0x7F, 0x00, 0xFE, 0xF0, 0x1E, 0xFE, 0x01, 0xFD, 0xE0,
  0x3D, 0xFC, 0x03, 0xFF, 0xC0, 0x7B, 0xF8, 0x07, 0xFF, 0x80, 0xF7, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F,
  0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x1F, 0xF0, 0xFF, 0xF0, 0x3F, 0xE7, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF,
  0xF0, 0xFF, 0xBF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFB, 0xE3, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xEF, 0xFF,
  0xFC, 0x7F, 0xCF, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x3F, 0xFE,
  0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x02, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFC, 0xFF, 0x8F,
  0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xFB, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xC7,
  0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0xE3, 0xFE, 0x03,
  0xFF, 0x87, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0,
  0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x7F, 0x9F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x87, 0xFC, 0x1F, 0xFF, 0xCF, 0xF8, 0x7F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF,
  0xBF, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F,
  0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF,
  0xF3, 0xFE, 0x0F, 0xFF, 0xC7, 0xFC, 0x0F, 0xFF, 0x0F, 0xF8, 0x03, 0xF0,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xF0, 0x3F, 0xE7, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xF0, 0xFF, 0xBF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xE3,
  0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x7E, 0x3F, 0xC3, 0xFE, 0x3F,
  0x3F, 0xF1, 0xFF, 0x9F, 0xBF, 0xF9, 0xFF, 0xEF, 0xDF, 0xFE, 0xFF, 0xF7,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF0, 0x1F, 0xFF, 0x81, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xF0, 0x3F, 0x01,
  0xFF, 0xF8, 0x1F, 0x80, 0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xFE, 0x07, 0xE0,
  0x3F, 0xFF, 0x03, 0xF0, 0x1F, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC,
  0x07, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xF8, 0x1F,
  0x80, 0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0x03,
  0xF0, 0x1F, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0xE0,
  0x7E, 0x03, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xF8, 0x1F, 0x80, 0xFF, 0xFC,
  0x0F, 0xC0, 0x7F, 0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0x03, 0xF0, 0x1F, 0xFF,
  0x81, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x03, 0xFF,
  0xF0, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0x7F, 0xFF, 0x07, 0xFD, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xCF, 0xF8, 0x01, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0x7F, 0xFF, 0x07, 0xFD, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xBF, 0xFC, 0x07, 0xFF, 0x7F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0x0F,
  0xF8, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0, 0x3C, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x87, 0xFC, 0x1F, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF,
  0xBF, 0xE7, 0xFF, 0xFF, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F,
  0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF,
  0x9F, 0xF0, 0x7F, 0xFE, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xC0, 0x0F, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0xF0,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x0F, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0x80, 0x7F, 0x7F, 0x01, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xFC, 0x07,
  0xF7, 0xF0, 0x1F, 0xF0, 0x1F, 0x8F, 0xE0, 0x7B, 0xC0, 0xFE, 0x3F, 0x81,
  0xEF, 0x03, 0xF8, 0xFE, 0x07, 0xBC, 0x0F, 0xE3, 0xF8, 0x3E, 0xF0, 0x3F,
  0x8F, 0xE0, 0xFB, 0xE0, 0xFE, 0x3F, 0x83, 0xCF, 0x83, 0xF0, 0xFE, 0x0F,
  0x3E, 0x0F, 0xC1, 0xF8, 0x3C, 0x78, 0x7F, 0x07, 0xF0, 0xF1, 0xE1, 0xFC,
  0x1F, 0xC3, 0xC7, 0x87, 0xF0, 0x7F, 0x1F, 0x1E, 0x1F, 0xC1, 0xFC, 0x7C,
  0x7C, 0x7F, 0x07, 0xF1, 0xE1, 0xF1, 0xF8, 0x0F, 0xC7, 0x87, 0xC7, 0xE0,
  0x3F, 0x1E, 0x0F, 0x3F, 0x80, 0xFE, 0x78, 0x3C, 0xFE, 0x03, 0xFB, 0xE0,
  0xF3, 0xF8, 0x0F, 0xEF, 0x83, 0xCF, 0xE0, 0x3F, 0xBE, 0x0F, 0xBF, 0x00,
  0xFE, 0xF0, 0x3E, 0xFC, 0x01, 0xFB, 0xC0, 0xFB, 0xF0, 0x07, 0xEF, 0x01,
  0xEF, 0xC0, 0x1F, 0xBC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xF1, 0xFF, 0xF8,
  0x01, 0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0x3F, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF,
  0xFC, 0x07, 0xF7, 0xFF, 0xFF, 0x81, 0xFD, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF,
  0x07, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF,
  0xCF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_Bold68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 11, 50, 41, 15, -50 },
  { 70, 23, 21, 41, 9, -50 },
  { 131, 37, 50, 41, 2, -50 },
  { 363, 33, 69, 41, 4, -59 },
  { 648, 41, 50, 41, 0, -50 },
  { 905, 36, 51, 41, 3, -50 },
  { 1135, 9, 21, 41, 16, -50 },
  { 1159, 22, 65, 41, 11, -57 },
  { 1338, 21, 65, 41, 8, -57 },
  { 1509, 37, 35, 41, 2, -41 },
  { 1671, 33, 33, 41, 4, -39 },
  { 1808, 17, 21, 41, 10, -10 },
  { 1853, 21, 8, 41, 10, -26 },
  { 1874, 13, 13, 41, 14, -12 },
  { 1896, 33, 63, 41, 4, -56 },
  { 2156, 31, 51, 41, 5, -50 },
  { 2354, 32, 50, 41, 6, -50 },
  { 2554, 32, 50, 41, 4, -50 },
  { 2754, 32, 51, 41, 4, -50 },
  { 2958, 31, 50, 41, 4, -50 },
  { 3152, 31, 51, 41, 5, -50 },
  { 3350, 33, 51, 41, 4, -50 },
  { 3561, 33, 50, 41, 4, -50 },
  { 3768, 32, 51, 41, 4, -50 },
  { 3972, 33, 50, 41, 4, -50 },
  { 4179, 13, 39, 41, 14, -38 },
  { 4243, 16, 49, 41, 11, -38 },
  { 4341, 31, 37, 41, 5, -41 },
  { 4485, 29, 25, 41, 6, -35 },
  { 4576, 31, 37, 41, 5, -41 },
  { 4720, 26, 50, 41, 8, -50 },
  { 4883, 37, 62, 41, 2, -50 },
  { 5170, 36, 50, 41, 2, -50 },
  { 5395, 32, 50, 41, 5, -50 },
  { 5595, 31, 51, 41, 5, -50 },
  { 5793, 31, 50, 41, 5, -50 },
  { 5987, 30, 50, 41, 6, -50 },
  { 6175, 31, 50, 41, 5, -50 },
  { 6369, 31, 51, 41, 5, -50 },
  { 6567, 31, 50, 41, 5, -50 },
  { 6761, 29, 50, 41, 6, -50 },
  { 6943, 33, 51, 41, 2, -50 },
  { 7154, 34, 50, 41, 5, -50 },
  { 7367, 30, 50, 41, 7, -50 },
  { 7555, 33, 50, 41, 4, -50 },
  { 7762, 31, 50, 41, 5, -50 },
  { 7956, 31, 51, 41, 5, -50 },
  { 8154, 33, 50, 41, 5, -50 },
  { 8361, 32, 62, 41, 5, -50 },
  { 8609, 33, 50, 41, 5, -50 },
  { 8816, 33, 51, 41, 4, -50 },
  { 9027, 35, 50, 41, 3, -50 },
  { 9246, 31, 51, 41, 5, -50 },
  { 9444, 36, 50, 41, 2, -50 },
  { 9669, 39, 50, 41, 1, -50 },
  { 9913, 37, 50, 41, 2, -50 },
  { 10145, 37, 50, 41, 2, -50 },
  { 10377, 30, 50, 41, 5, -50 },
  { 10565, 19, 63, 41, 13, -56 },
  { 10715, 33, 63, 41, 4, -56 },
  { 10975, 19, 63, 41, 9, -56 },
  { 11125, 31, 27, 41, 5, -50 },
  { 11230, 33, 7, 41, 4, 2 },
  { 11259, 17, 9, 41, 11, -53 },
  { 11279, 32, 39, 41, 4, -38 },
  { 11435, 31, 51, 41, 5, -50 },
  { 11633, 31, 39, 41, 5, -38 },
  { 11785, 31, 51, 41, 5, -50 },
  { 11983, 31, 39, 41, 5, -38 },
  { 12135, 33, 50, 41, 4, -50 },
  { 12342, 31, 50, 41, 5, -38 },
  { 12536, 31, 50, 41, 5, -50 },
  { 12730, 33, 53, 41, 5, -53 },
  { 12949, 26, 65, 41, 6, -53 },
  { 13161, 34, 50, 41, 5, -50 },
  { 13374, 36, 50, 41, 2, -50 },
  { 13599, 33, 38, 41, 4, -38 },
  { 13756, 31, 38, 41, 5, -38 },
  { 13904, 31, 39, 41, 5, -38 },
  { 14056, 31, 50, 41, 5, -38 },
  { 14250, 31, 50, 41, 5, -38 },
  { 14444, 32, 38, 41, 6, -38 },
  { 14596, 32, 39, 41, 5, -38 },
  { 14752, 33, 48, 41, 3, -48 },
  { 14950, 31, 38, 41, 5, -37 },
  { 15098, 35, 37, 41, 3, -37 },
  { 15260, 38, 37, 41, 1, -37 },
  { 15436, 36, 37, 41, 2, -37 },
  { 15603, 35, 49, 41, 3, -37 },
  { 15818, 31, 37, 41, 5, -37 },
  { 15962, 30, 64, 41, 5, -56 },
  { 16202, 9, 63, 41, 16, -56 },
  { 16273, 30, 64, 41, 5, -56 },
  { 16513, 34, 16, 41, 3, -32 },
};

const GFXfont JetBrainsMono_Bold68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_BOLD68PT7B_H_
