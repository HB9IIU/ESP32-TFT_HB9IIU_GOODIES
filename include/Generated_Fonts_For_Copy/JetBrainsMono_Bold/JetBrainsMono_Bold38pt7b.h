#ifndef _JETBRAINSMONO_BOLD38PT7B_H_
#define _JETBRAINSMONO_BOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9E, 0x3C, 0x78, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0xFD, 0xFF,
  0xF3, 0xE0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0x01, 0xC1,
  0xE0, 0x0E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x01,
  0xC0, 0xE0, 0x0E, 0x0F, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC1, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x1C, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x78, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xDD, 0xF9,
  0xF3, 0x9F, 0x3E, 0x73, 0xE7, 0x8E, 0x7C, 0xF9, 0xC0, 0x1F, 0x38, 0x03,
  0xF7, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x3B, 0xF0, 0x07, 0x3E, 0x00, 0xE3, 0xE0,
  0x1C, 0x7F, 0xE3, 0x8F, 0xFC, 0x73, 0xE7, 0xEE, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x7F, 0x80,
  0x39, 0xFF, 0x80, 0xE3, 0x87, 0x03, 0xCF, 0x0E, 0x0F, 0x1E, 0x1E, 0x1C,
  0x3C, 0x3C, 0x78, 0x78, 0x79, 0xE0, 0xF0, 0xE3, 0x80, 0xF3, 0xCE, 0x01,
  0xFF, 0xBC, 0x01, 0xFE, 0x70, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x40, 0x00, 0xE7, 0xF0, 0x03, 0xDF, 0xF0, 0x07,
  0x3C, 0xF0, 0x1C, 0xF0, 0xE0, 0x79, 0xE1, 0xC1, 0xE3, 0xC3, 0x83, 0x87,
  0x87, 0x0F, 0x0F, 0x0E, 0x3C, 0x1E, 0x1C, 0x70, 0x1F, 0xF9, 0xC0, 0x3F,
  0xE7, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0xF0, 0x3E, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xBE, 0x3E, 0xF1, 0xF3, 0xCF, 0x0F,
  0x7C, 0xF0, 0xFF, 0x8F, 0x07, 0xF8, 0xF0, 0x3F, 0x0F, 0x03, 0xF0, 0xF0,
  0x1F, 0x0F, 0x83, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF3, 0xE1,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xE0, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xF0,
  0x3F, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xE0,
  0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x1F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x0E, 0x00,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x38, 0x38, 0x31, 0xF1, 0xC7, 0xCF, 0xCE, 0xFE, 0xFF,
  0xEF, 0xF9, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0xC0,
  0x01, 0xEF, 0x00, 0x1E, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8,
  0x3E, 0x03, 0x80, 0xC0, 0x04, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x9F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1,
  0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x3C, 0x7F, 0x9F, 0x3F, 0xCF, 0x9F, 0xE7, 0xCF, 0xF0, 0x87,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x3F, 0xF8, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0x7C, 0x0F, 0x9F, 0x03, 0x87, 0xC0, 0xC1, 0xF0, 0x20, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7E, 0x1F, 0x9F, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3F,
  0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x7E, 0x1F,
  0x7F, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0x7F, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x3E, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3,
  0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E,
  0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01,
  0xE3, 0xE0, 0xF8, 0x7C, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3E, 0x1F, 0x9F, 0x03, 0xF7, 0xC0, 0x7D, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x7F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xE7, 0xC0, 0x7C,
  0xFE, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xEF, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0xFD, 0xFF, 0xFF, 0xF7, 0xC0, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C,
  0x3C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x38,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0xFF, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xE0, 0x0F,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x0F, 0xC3,
  0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x63, 0xFC, 0x1F, 0xDF, 0xE0, 0xFF, 0xFF, 0x0F, 0x9F, 0xF8,
  0x78, 0x7F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83,
  0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3,
  0xE3, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0x7F, 0x80, 0xF3, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3D, 0xE0,
  0x03, 0xDE, 0x00, 0x7D, 0xE0, 0x07, 0xDF, 0x00, 0x79, 0xF0, 0x07, 0x8F,
  0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x0F, 0x07, 0x81, 0xF0,
  0x78, 0x1F, 0x07, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0xFC, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xE0,
  0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x00, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7D, 0xF8, 0x3F,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xF0, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xF8,
  0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x1F, 0x7C, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC7, 0x7F, 0xB8, 0xEF, 0xF7, 0x1D, 0xFE, 0xF7, 0x3F,
  0xCE, 0xE7, 0xF9, 0xDC, 0xFF, 0x3B, 0xBF, 0xE3, 0xE7, 0xFC, 0x7C, 0xFF,
  0x8F, 0x9F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xF7, 0x07, 0xFB, 0xC3, 0xFD, 0xE1, 0xFE, 0x70, 0xFF, 0x3C, 0x7F, 0x9E,
  0x3F, 0xC7, 0x1F, 0xE3, 0xCF, 0xF1, 0xE7, 0xF8, 0x73, 0xFC, 0x3D, 0xFE,
  0x1E, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7F, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFC, 0x3F, 0x3E, 0x03, 0xEF,
  0x80, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0,
  0x3E, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F,
  0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x03, 0xEF,
  0x80, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xF8, 0x7F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x1F, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01,
  0xF3, 0xC0, 0x3E, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xF3, 0xF0, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xF8, 0x00,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xE3, 0xC0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xC1, 0xE0, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x9F, 0x00, 0x7D, 0xF0,
  0x07, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xF0, 0xF0, 0x7F, 0x87,
  0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0D, 0x87, 0xF8, 0x6C, 0x3F,
  0xC3, 0x61, 0xFE, 0x1B, 0x0E, 0xF1, 0xD8, 0xF3, 0xCE, 0xC7, 0x9E, 0x77,
  0x3C, 0xF3, 0xB9, 0xE7, 0x9D, 0xCF, 0x3C, 0xCE, 0x79, 0xE6, 0x33, 0xCF,
  0x31, 0x9E, 0x79, 0x8C, 0xE3, 0xDC, 0x67, 0x1E, 0xE3, 0x38, 0x77, 0x1F,
  0xC3, 0xB8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x80, 0x7C, 0x01,
  0xF3, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F,
  0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x1F, 0x07, 0xE0,
  0xF8, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0x7D, 0xF8, 0x03, 0xF0,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xE0, 0x3C, 0x78, 0x3E, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x8F, 0x03, 0xE7, 0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF,
  0xFE, 0x7E, 0x0F, 0xDF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC3, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7C, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xDF, 0x87, 0xF7, 0xFF, 0xFC, 0xFF,
  0xDF, 0x1F, 0xE7, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF3, 0xF8, 0xFB, 0xFE, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBE,
  0xFF, 0x9F, 0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF,
  0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x3F, 0x9F, 0x3F, 0xEF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFB, 0xE3, 0xF9,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xEF, 0xEF, 0x81, 0xF7,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0xF8,
  0x0F, 0xBF, 0x9F, 0x9F, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xCF, 0x9F, 0xF7, 0xDF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xFC, 0xFF, 0x7F, 0xFF, 0xBF, 0xF7, 0xC7, 0xFB, 0xE0, 0xE1, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF3, 0xF8, 0xFB, 0xFE,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xE0,
  0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7C, 0x7E, 0x0F, 0x87,
  0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3F, 0x7C, 0x03, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF7, 0xCF, 0x9F, 0xFB, 0xFB, 0xFF, 0xFF, 0x7C,
  0xF9, 0xFF, 0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0,
  0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x0E, 0x1F, 0xE1,
  0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3,
  0x87, 0xF8, 0x70, 0xFF, 0x0E, 0x1E, 0xF9, 0xFC, 0x7D, 0xFF, 0x3F, 0xFF,
  0xDF, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xF8, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF,
  0xC1, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x80,
  0xF9, 0xFC, 0x7D, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0x7F, 0xCF, 0x9F, 0xC7, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xCF, 0x9F, 0xF7, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFD, 0xF1, 0xFC, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0xF3, 0xF8, 0x7B, 0xFF, 0x3D, 0xFF, 0xDF, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0xFF, 0x1F, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF3,
  0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x1E, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0x8F,
  0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xF0, 0xF0, 0x7F,
  0x87, 0x83, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0D, 0x87, 0x38, 0x6C,
  0x79, 0xE3, 0x63, 0xCF, 0x3B, 0x1E, 0x79, 0xDC, 0xF3, 0xCE, 0xE7, 0x9E,
  0x67, 0x38, 0x73, 0x19, 0xC3, 0x98, 0xDE, 0x1F, 0xC6, 0xF0, 0xFE, 0x37,
  0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x7C, 0x03, 0xF3, 0xE0, 0x3E, 0x3F, 0x07,
  0xC1, 0xF0, 0xFC, 0x0F, 0x8F, 0x80, 0xFD, 0xF0, 0x07, 0xDF, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x00, 0x7D, 0xE0, 0x07, 0xDF, 0x00, 0xF8, 0xF8, 0x1F, 0x8F, 0x81,
  0xF0, 0x7C, 0x3E, 0x07, 0xE7, 0xE0, 0x3E, 0xFC, 0x01, 0xF0, 0xFC, 0x01,
  0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07,
  0x8F, 0x80, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x3D, 0xF0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x3D, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0x1F, 0x1F, 0xE1, 0xFF, 0xFC, 0x3F, 0xF7, 0x83, 0xFE, 0x00, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 13, 12, 23, 5, -28 },
  { 46, 21, 28, 23, 1, -28 },
  { 120, 19, 38, 23, 2, -33 },
  { 211, 23, 28, 23, 0, -28 },
  { 292, 20, 28, 23, 2, -28 },
  { 362, 5, 12, 23, 9, -28 },
  { 370, 12, 37, 23, 6, -32 },
  { 426, 12, 37, 23, 4, -32 },
  { 482, 21, 20, 23, 1, -23 },
  { 535, 19, 19, 23, 2, -22 },
  { 581, 9, 12, 23, 6, -6 },
  { 595, 12, 5, 23, 5, -15 },
  { 603, 7, 7, 23, 8, -7 },
  { 610, 19, 36, 23, 2, -32 },
  { 696, 17, 28, 23, 3, -28 },
  { 756, 18, 28, 23, 3, -28 },
  { 819, 18, 28, 23, 2, -28 },
  { 882, 18, 28, 23, 2, -28 },
  { 945, 18, 28, 23, 2, -28 },
  { 1008, 17, 28, 23, 3, -28 },
  { 1068, 19, 28, 23, 2, -28 },
  { 1135, 19, 28, 23, 2, -28 },
  { 1202, 18, 28, 23, 2, -28 },
  { 1265, 19, 28, 23, 2, -28 },
  { 1332, 7, 21, 23, 8, -21 },
  { 1351, 9, 27, 23, 6, -21 },
  { 1382, 17, 21, 23, 3, -23 },
  { 1427, 17, 13, 23, 3, -19 },
  { 1455, 17, 21, 23, 3, -23 },
  { 1500, 14, 28, 23, 5, -28 },
  { 1549, 21, 35, 23, 1, -28 },
  { 1641, 20, 28, 23, 1, -28 },
  { 1711, 18, 28, 23, 3, -28 },
  { 1774, 17, 28, 23, 3, -28 },
  { 1834, 17, 28, 23, 3, -28 },
  { 1894, 17, 28, 23, 3, -28 },
  { 1954, 17, 28, 23, 3, -28 },
  { 2014, 17, 28, 23, 3, -28 },
  { 2074, 17, 28, 23, 3, -28 },
  { 2134, 16, 28, 23, 3, -28 },
  { 2190, 18, 28, 23, 1, -28 },
  { 2253, 19, 28, 23, 3, -28 },
  { 2320, 16, 28, 23, 4, -28 },
  { 2376, 19, 28, 23, 2, -28 },
  { 2443, 17, 28, 23, 3, -28 },
  { 2503, 17, 28, 23, 3, -28 },
  { 2563, 18, 28, 23, 3, -28 },
  { 2626, 18, 35, 23, 3, -28 },
  { 2705, 18, 28, 23, 3, -28 },
  { 2768, 19, 28, 23, 2, -28 },
  { 2835, 19, 28, 23, 2, -28 },
  { 2902, 17, 28, 23, 3, -28 },
  { 2962, 20, 28, 23, 1, -28 },
  { 3032, 21, 28, 23, 1, -28 },
  { 3106, 21, 28, 23, 1, -28 },
  { 3180, 21, 28, 23, 1, -28 },
  { 3254, 17, 28, 23, 3, -28 },
  { 3314, 11, 36, 23, 7, -32 },
  { 3364, 18, 36, 23, 2, -32 },
  { 3445, 11, 36, 23, 5, -32 },
  { 3495, 17, 15, 23, 3, -28 },
  { 3527, 19, 4, 23, 2, 1 },
  { 3537, 10, 5, 23, 6, -30 },
  { 3544, 18, 21, 23, 2, -21 },
  { 3592, 17, 28, 23, 3, -28 },
  { 3652, 17, 21, 23, 3, -21 },
  { 3697, 17, 28, 23, 3, -28 },
  { 3757, 17, 21, 23, 3, -21 },
  { 3802, 19, 28, 23, 2, -28 },
  { 3869, 17, 28, 23, 3, -21 },
  { 3929, 17, 28, 23, 3, -28 },
  { 3989, 18, 30, 23, 3, -30 },
  { 4057, 15, 37, 23, 3, -30 },
  { 4127, 19, 28, 23, 3, -28 },
  { 4194, 20, 28, 23, 1, -28 },
  { 4264, 19, 21, 23, 2, -21 },
  { 4314, 17, 21, 23, 3, -21 },
  { 4359, 17, 21, 23, 3, -21 },
  { 4404, 17, 28, 23, 3, -21 },
  { 4464, 17, 28, 23, 3, -21 },
  { 4524, 17, 21, 23, 4, -21 },
  { 4569, 17, 21, 23, 3, -21 },
  { 4614, 18, 27, 23, 2, -27 },
  { 4675, 17, 21, 23, 3, -21 },
  { 4720, 20, 21, 23, 1, -21 },
  { 4773, 21, 21, 23, 1, -21 },
  { 4829, 20, 21, 23, 1, -21 },
  { 4882, 20, 28, 23, 1, -21 },
  { 4952, 17, 21, 23, 3, -21 },
  { 4997, 17, 36, 23, 3, -32 },
  { 5074, 5, 36, 23, 9, -32 },
  { 5097, 17, 36, 23, 3, -32 },
  { 5174, 19, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_Bold38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_BOLD38PT7B_H_
