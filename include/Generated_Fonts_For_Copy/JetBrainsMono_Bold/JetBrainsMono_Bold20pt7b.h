#ifndef _JETBRAINSMONO_BOLD20PT7B_H_
#define _JETBRAINSMONO_BOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0x60, 0xCF, 0x3C, 0xF3,
  0xCF, 0x30, 0x18, 0xC6, 0x61, 0x98, 0x46, 0xFF, 0xFF, 0xF3, 0x10, 0xCC,
  0x23, 0x18, 0xCF, 0xFD, 0x8C, 0x62, 0x19, 0x8C, 0x60, 0x0C, 0x03, 0x01,
  0xE1, 0xFE, 0x7F, 0xBB, 0x7E, 0xC1, 0xB0, 0x7C, 0x0F, 0xC0, 0xF8, 0x37,
  0x0D, 0xFB, 0x7E, 0xDD, 0xFE, 0x3F, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x37,
  0xC6, 0xCC, 0x6C, 0xCC, 0xCD, 0x8F, 0xD0, 0x7B, 0x00, 0x60, 0x04, 0xC0,
  0xFE, 0x1B, 0x33, 0x33, 0x33, 0x36, 0x37, 0xC1, 0xE0, 0x1C, 0x0F, 0xC7,
  0x31, 0x8E, 0x60, 0x1C, 0x03, 0x03, 0xE0, 0xFC, 0xF3, 0xEC, 0x7B, 0x1C,
  0xE7, 0xBF, 0xE7, 0xCC, 0xFF, 0xF0, 0x02, 0x1C, 0x79, 0xC7, 0x0C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x1C, 0x38, 0x3C, 0x3C, 0x38, 0x81,
  0xC3, 0xC1, 0xC1, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87,
  0x0E, 0x79, 0xE3, 0x80, 0x0C, 0x03, 0x08, 0xC7, 0xB7, 0xFB, 0xC3, 0x01,
  0xE0, 0xCC, 0x73, 0x88, 0x40, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x00, 0x7B, 0x9C, 0xCE, 0x60, 0xFF, 0xFF, 0xC0,
  0x4F, 0xFF, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x0E, 0x00, 0x1E, 0x0F, 0xC7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0xDF, 0xB7,
  0xED, 0xF8, 0x7E, 0x1F, 0x87, 0x61, 0x9F, 0xE3, 0xF0, 0x1C, 0x3E, 0x3F,
  0x1B, 0x89, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7,
  0xFF, 0xFE, 0x1E, 0x1F, 0xC7, 0x3B, 0x86, 0xE1, 0xC0, 0x60, 0x38, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1F, 0xF7, 0xFC, 0x7F, 0x9F, 0xE7,
  0xF8, 0x1C, 0x0E, 0x07, 0x01, 0xF0, 0x7E, 0x01, 0x80, 0x70, 0x1F, 0x87,
  0xE3, 0x9F, 0xE3, 0xF0, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0,
  0xE3, 0xE1, 0xF0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x7F, 0x9F, 0xE7,
  0xF9, 0x80, 0x60, 0x19, 0x87, 0xF9, 0xEE, 0x01, 0xC0, 0x70, 0x1F, 0x87,
  0x61, 0x9F, 0xE3, 0xF0, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07,
  0xF1, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x61, 0xDF, 0xE3, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xE1, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0x1E, 0x1F, 0xE7, 0x39, 0x86, 0x61,
  0x98, 0x63, 0xF0, 0x78, 0x7F, 0x98, 0x6E, 0x1F, 0x87, 0xE1, 0xDF, 0xE3,
  0xF0, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xFE, 0x3F,
  0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x7B, 0xDE, 0x00, 0x00, 0x00, 0x3B, 0x9C, 0xC6, 0x70, 0x01,
  0x07, 0x1F, 0x7C, 0xF0, 0xC0, 0xF0, 0x7C, 0x1F, 0x03, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0x0F,
  0x3E, 0xF8, 0xC0, 0x80, 0xF0, 0xFE, 0xFF, 0x07, 0x03, 0x07, 0x0F, 0x3E,
  0x3C, 0x30, 0x30, 0x00, 0x30, 0x78, 0x70, 0x1E, 0x1F, 0xE6, 0x1F, 0x03,
  0xC0, 0xF1, 0xFC, 0xF7, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCF, 0xF1,
  0xDC, 0x03, 0x80, 0x70, 0x0F, 0x80, 0xE0, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3F, 0x0C, 0xC3, 0x30, 0xCC, 0x73, 0x9F, 0xE7, 0xF9, 0x86, 0xE1, 0xF8,
  0x7C, 0x0C, 0xF8, 0x7F, 0x33, 0xD8, 0x7C, 0x3E, 0x1B, 0xFD, 0xFC, 0xC7,
  0x61, 0xF0, 0xF8, 0x7C, 0x3F, 0xFB, 0xF8, 0x1E, 0x0F, 0xE7, 0x39, 0x87,
  0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x87, 0x71, 0x9F,
  0xE3, 0xF0, 0xFC, 0x3F, 0xCF, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xBF, 0xEF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0xFF,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1E, 0x0F, 0xE7, 0x39, 0x87,
  0xE1, 0xF8, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0x9F,
  0xE3, 0xF0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x1F, 0x8F, 0xC7, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x78, 0x3E, 0x3F, 0xF8,
  0xF8, 0xC3, 0xE1, 0xF0, 0xD8, 0xEC, 0x66, 0x73, 0xF1, 0xF8, 0xFC, 0x67,
  0x31, 0x98, 0xEC, 0x76, 0x1F, 0x0E, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xE1,
  0xF8, 0x7F, 0x3F, 0xCF, 0xD2, 0xF7, 0xBD, 0xEF, 0x3B, 0xCC, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xF1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF9,
  0xFE, 0x7E, 0xDF, 0xB7, 0xED, 0xF9, 0xFE, 0x7F, 0x9F, 0xE3, 0xF8, 0xFE,
  0x3C, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE3, 0xF0, 0xFC, 0x7F, 0xBF, 0xF8,
  0x7C, 0x1E, 0x0F, 0x0F, 0xFE, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x1E, 0x0F, 0xC7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x61, 0x9F, 0xE3, 0xF0, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0xF8, 0x7F, 0xBF, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFE, 0xFE, 0x67,
  0x33, 0x98, 0xCC, 0x76, 0x1B, 0x0E, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE0,
  0x18, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x70, 0x1F, 0x87, 0xE1, 0xDF, 0xE3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73,
  0x9F, 0xE3, 0xF0, 0xC0, 0xF8, 0x3E, 0x1F, 0x87, 0x61, 0x98, 0x67, 0x39,
  0xCE, 0x33, 0x0C, 0xC3, 0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0xC6, 0x3E,
  0x67, 0x66, 0x66, 0x66, 0x67, 0x66, 0xF6, 0x6F, 0x66, 0x96, 0x69, 0x66,
  0x96, 0x69, 0x66, 0x94, 0x29, 0x43, 0x9C, 0x39, 0xC0, 0xE1, 0xF8, 0x77,
  0x39, 0xCE, 0x3F, 0x07, 0x81, 0xE0, 0x30, 0x1E, 0x07, 0x83, 0xF1, 0xCE,
  0x73, 0xB8, 0x7E, 0x1C, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x0C, 0x39, 0xC1,
  0x98, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x38,
  0x70, 0x70, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xFE, 0x0C, 0x07, 0x81, 0xE0, 0xFC, 0x33,
  0x0C, 0xC6, 0x1B, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0x8E, 0x3F, 0x1F,
  0xE6, 0x18, 0x06, 0x0F, 0xDF, 0xFE, 0x1F, 0x87, 0xE1, 0xFF, 0xF7, 0xDC,
  0xC0, 0x60, 0x30, 0x18, 0x0D, 0xE7, 0xFB, 0x8D, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7E, 0x37, 0xFB, 0x78, 0x3F, 0x1F, 0xE7, 0x1B, 0x87, 0xE0, 0x38,
  0x0E, 0x03, 0x87, 0x71, 0x9F, 0xE3, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x33,
  0xDB, 0xFD, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x36, 0x3B, 0xFC, 0xF6,
  0x3F, 0x1F, 0xE6, 0x1B, 0x87, 0xE1, 0xFF, 0xFE, 0x03, 0x80, 0x61, 0xDF,
  0xE3, 0xF0, 0x03, 0xC3, 0xF1, 0xFC, 0x70, 0x1C, 0x3F, 0xFF, 0xFC, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x3D, 0xBF, 0xD8,
  0xFC, 0x3E, 0x1F, 0x0F, 0x86, 0xC3, 0x7F, 0x9E, 0xC0, 0x60, 0x30, 0x39,
  0xF8, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xE7, 0xFB, 0x9D, 0x86, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0E, 0x18, 0x0E, 0x07, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3, 0xFF,
  0xFF, 0x06, 0x1C, 0x38, 0x00, 0x1F, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x0F, 0xFF, 0xF7, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x3E, 0x1B, 0x1D, 0x9C, 0xFE, 0x7E, 0x33, 0x99, 0xCC, 0x76, 0x1B, 0x0E,
  0xFC, 0x3F, 0x0F, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0xF0, 0x7C, 0xDB, 0xBF, 0xFC, 0xCF, 0x33,
  0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCC, 0xDE, 0x7F, 0xB9,
  0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xE0, 0x3F, 0x1F,
  0xE7, 0x1B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE3, 0xF0,
  0xDE, 0x7F, 0xB8, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0x7F, 0xB7,
  0x98, 0x0C, 0x06, 0x03, 0x00, 0x3D, 0xBF, 0xD8, 0xFC, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0x63, 0xBF, 0xCF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xDF, 0x7F,
  0xF8, 0xF8, 0x7C, 0x3E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x3F,
  0x1F, 0xE6, 0x1D, 0x80, 0x7C, 0x0F, 0xE0, 0x3C, 0x07, 0xE1, 0xDF, 0xE3,
  0xF0, 0x18, 0x06, 0x01, 0x83, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x70, 0x1F, 0x83, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1D, 0x86, 0x73, 0x9F, 0xE3, 0xF0, 0xE0, 0xF8, 0x76,
  0x19, 0x86, 0x73, 0x8C, 0xC3, 0x30, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0xE6,
  0x36, 0x66, 0x66, 0x66, 0x76, 0x6F, 0x66, 0x96, 0x69, 0x63, 0x94, 0x39,
  0xC3, 0x9C, 0x39, 0xC0, 0xE1, 0xDC, 0xE3, 0x30, 0xFC, 0x1E, 0x07, 0x81,
  0xE0, 0xFC, 0x73, 0x9C, 0xEE, 0x1C, 0xE1, 0xF8, 0x76, 0x19, 0xCE, 0x33,
  0x8E, 0xC3, 0xF0, 0x7C, 0x1E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0xFF, 0xFF, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0xFF, 0xFF,
  0x03, 0x0F, 0x0F, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x1C, 0xF8, 0xF8, 0x1C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0xF0, 0xF0, 0x38, 0x38, 0x30, 0x30, 0x30, 0x38, 0x1F, 0x1F, 0x38,
  0x30, 0x30, 0x38, 0x38, 0x38, 0xF0, 0xE0, 0x78, 0xFF, 0x3C, 0xFF, 0x1E,
};

const GFXglyph JetBrainsMono_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 6, 6, 12, 3, -15 },
  { 14, 10, 15, 12, 1, -15 },
  { 33, 10, 20, 12, 1, -17 },
  { 58, 12, 15, 12, 0, -15 },
  { 81, 10, 15, 12, 1, -15 },
  { 100, 2, 6, 12, 5, -15 },
  { 102, 7, 19, 12, 3, -17 },
  { 119, 7, 19, 12, 2, -17 },
  { 136, 10, 10, 12, 1, -12 },
  { 149, 10, 9, 12, 1, -11 },
  { 161, 5, 6, 12, 3, -3 },
  { 165, 6, 3, 12, 3, -8 },
  { 168, 4, 4, 12, 4, -4 },
  { 170, 10, 19, 12, 1, -17 },
  { 194, 10, 15, 12, 1, -15 },
  { 213, 9, 15, 12, 2, -15 },
  { 230, 10, 15, 12, 1, -15 },
  { 249, 10, 15, 12, 1, -15 },
  { 268, 9, 15, 12, 1, -15 },
  { 285, 10, 15, 12, 1, -15 },
  { 304, 10, 15, 12, 1, -15 },
  { 323, 10, 15, 12, 1, -15 },
  { 342, 10, 15, 12, 1, -15 },
  { 361, 10, 15, 12, 1, -15 },
  { 380, 4, 11, 12, 4, -11 },
  { 386, 5, 14, 12, 3, -11 },
  { 395, 8, 11, 12, 2, -12 },
  { 406, 8, 7, 12, 2, -10 },
  { 413, 8, 11, 12, 2, -12 },
  { 424, 8, 15, 12, 2, -15 },
  { 439, 10, 19, 12, 1, -15 },
  { 463, 10, 15, 12, 1, -15 },
  { 482, 9, 15, 12, 2, -15 },
  { 499, 10, 15, 12, 1, -15 },
  { 518, 10, 15, 12, 1, -15 },
  { 537, 9, 15, 12, 2, -15 },
  { 554, 9, 15, 12, 2, -15 },
  { 571, 10, 15, 12, 1, -15 },
  { 590, 8, 15, 12, 2, -15 },
  { 605, 8, 15, 12, 2, -15 },
  { 620, 9, 15, 12, 1, -15 },
  { 637, 9, 15, 12, 2, -15 },
  { 654, 9, 15, 12, 2, -15 },
  { 671, 10, 15, 12, 1, -15 },
  { 690, 10, 15, 12, 1, -15 },
  { 709, 10, 15, 12, 1, -15 },
  { 728, 9, 15, 12, 2, -15 },
  { 745, 10, 19, 12, 1, -15 },
  { 769, 9, 15, 12, 2, -15 },
  { 786, 10, 15, 12, 1, -15 },
  { 805, 10, 15, 12, 1, -15 },
  { 824, 10, 15, 12, 1, -15 },
  { 843, 10, 15, 12, 1, -15 },
  { 862, 12, 15, 12, 0, -15 },
  { 885, 10, 15, 12, 1, -15 },
  { 904, 12, 15, 12, 0, -15 },
  { 927, 8, 15, 12, 2, -15 },
  { 942, 5, 19, 12, 4, -17 },
  { 954, 10, 19, 12, 1, -17 },
  { 978, 5, 19, 12, 3, -17 },
  { 990, 10, 8, 12, 1, -15 },
  { 1000, 10, 3, 12, 1, 0 },
  { 1004, 5, 3, 12, 3, -16 },
  { 1006, 10, 11, 12, 1, -11 },
  { 1020, 9, 15, 12, 2, -15 },
  { 1037, 10, 11, 12, 1, -11 },
  { 1051, 9, 15, 12, 1, -15 },
  { 1068, 10, 11, 12, 1, -11 },
  { 1082, 10, 15, 12, 1, -15 },
  { 1101, 9, 15, 12, 1, -11 },
  { 1118, 9, 15, 12, 2, -15 },
  { 1135, 9, 16, 12, 2, -16 },
  { 1153, 7, 20, 12, 2, -16 },
  { 1171, 9, 15, 12, 2, -15 },
  { 1188, 10, 15, 12, 1, -15 },
  { 1207, 10, 11, 12, 1, -11 },
  { 1221, 9, 11, 12, 2, -11 },
  { 1234, 10, 11, 12, 1, -11 },
  { 1248, 9, 15, 12, 2, -11 },
  { 1265, 9, 15, 12, 1, -11 },
  { 1282, 9, 11, 12, 2, -11 },
  { 1295, 10, 11, 12, 1, -11 },
  { 1309, 10, 14, 12, 1, -14 },
  { 1327, 10, 11, 12, 1, -11 },
  { 1341, 10, 11, 12, 1, -11 },
  { 1355, 12, 11, 12, 0, -11 },
  { 1372, 10, 11, 12, 1, -11 },
  { 1386, 10, 15, 12, 1, -11 },
  { 1405, 8, 11, 12, 2, -11 },
  { 1416, 8, 19, 12, 2, -17 },
  { 1435, 2, 19, 12, 5, -17 },
  { 1440, 8, 19, 12, 2, -17 },
  { 1459, 10, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_Bold20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_BOLD20PT7B_H_
