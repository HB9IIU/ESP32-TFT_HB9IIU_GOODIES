#ifndef _JETBRAINSMONO_BOLD14PT7B_H_
#define _JETBRAINSMONO_BOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF4, 0xF0, 0xDE, 0xE7, 0x20, 0x12, 0x12, 0x7F, 0x7F, 0x26,
  0x24, 0xFF, 0x24, 0x64, 0x4C, 0x10, 0x21, 0xF6, 0xED, 0x1A, 0x1E, 0x1E,
  0x17, 0xAF, 0x73, 0xC1, 0x02, 0x00, 0xF1, 0x92, 0x96, 0xF4, 0x08, 0x16,
  0x3D, 0x29, 0x49, 0xC7, 0x79, 0x9B, 0x02, 0x0E, 0x16, 0xE7, 0x46, 0xDD,
  0xEC, 0xFF, 0x09, 0xDC, 0xCC, 0x63, 0x18, 0xC6, 0x18, 0xE3, 0x84, 0x8C,
  0x63, 0x33, 0x33, 0x33, 0x36, 0xC8, 0x18, 0x18, 0x49, 0xFF, 0x08, 0x3C,
  0x76, 0x24, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x00, 0x6D, 0x60, 0xF0,
  0xF8, 0x06, 0x18, 0x30, 0x41, 0x83, 0x0C, 0x18, 0x30, 0xC1, 0x82, 0x0C,
  0x18, 0x00, 0x7F, 0x3C, 0x71, 0xF7, 0x5C, 0x71, 0xCD, 0xE0, 0x39, 0xF2,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0xFF, 0xFC, 0x7F, 0x3C, 0x43, 0x0C, 0x63,
  0x18, 0xFF, 0xF0, 0xFC, 0x31, 0x8C, 0x3C, 0x30, 0x71, 0xCD, 0xE0, 0x1C,
  0x63, 0x18, 0x6F, 0x3F, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x36, 0xFC, 0x10,
  0x41, 0xCD, 0xE0, 0x18, 0x61, 0x83, 0x0F, 0xD9, 0xB1, 0xE3, 0xCC, 0xF0,
  0xFF, 0x8F, 0x30, 0x60, 0x83, 0x06, 0x18, 0x30, 0xC0, 0x7D, 0x9B, 0x16,
  0x67, 0x8F, 0xB1, 0x63, 0xCC, 0xF0, 0x7D, 0x9B, 0x1E, 0x3C, 0xCF, 0x82,
  0x0C, 0x30, 0xE0, 0xDD, 0x00, 0x3E, 0x67, 0x20, 0x01, 0x66, 0x4C, 0x0C,
  0xFE, 0x30, 0x70, 0x70, 0x40, 0xFC, 0x00, 0x3F, 0xFC, 0xC1, 0xC1, 0xC1,
  0x3F, 0xCC, 0x00, 0xF1, 0xC6, 0x37, 0xB1, 0x00, 0x47, 0x00, 0x3E, 0x63,
  0x43, 0xCD, 0xDB, 0xD9, 0xD9, 0xDB, 0xCD, 0x40, 0x60, 0x3C, 0x0C, 0x18,
  0x1C, 0x3C, 0x34, 0x36, 0x26, 0x7E, 0x7E, 0x63, 0xC3, 0xFD, 0x9B, 0x16,
  0x6F, 0x99, 0xB1, 0xE3, 0xCD, 0xF0, 0x7D, 0x9B, 0x1E, 0x0C, 0x18, 0x30,
  0x63, 0xEC, 0xF0, 0xFB, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xE0, 0xFF,
  0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xFF, 0xF0, 0xFF, 0x0C, 0x30, 0xFF, 0xFC,
  0x30, 0xC3, 0x00, 0x7D, 0x9B, 0x1E, 0x0C, 0x1B, 0xF1, 0xE2, 0xEC, 0xF0,
  0xC7, 0x1C, 0x71, 0xFF, 0xFC, 0x71, 0xC7, 0x10, 0xFC, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0xFF, 0xF0, 0x1E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xE3, 0x6E,
  0x78, 0xC7, 0x9B, 0x36, 0xCF, 0x9F, 0x36, 0x66, 0xCD, 0x8C, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC, 0xCF, 0x9E, 0xBD, 0xFB, 0x76,
  0xE1, 0xC3, 0x87, 0x0C, 0xC7, 0x9A, 0x79, 0xF7, 0x5D, 0x77, 0xCF, 0x30,
  0x7F, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xED, 0xE0, 0xFD, 0x9F, 0x1E, 0x3F,
  0xDF, 0xB0, 0x60, 0xC1, 0x80, 0x7D, 0x9B, 0x16, 0x2C, 0x58, 0xB1, 0x62,
  0xEC, 0xF0, 0x60, 0x60, 0x60, 0xFD, 0x9B, 0x1E, 0x3F, 0xDF, 0x36, 0x66,
  0xCD, 0x8C, 0x7D, 0x9B, 0x06, 0x07, 0x87, 0x81, 0xE3, 0xEC, 0xF0, 0xFE,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xED, 0xE0, 0xC3, 0x62, 0x62, 0x66, 0x26, 0x34, 0x34, 0x3C,
  0x1C, 0x18, 0xD9, 0xD9, 0x5B, 0x5B, 0x57, 0x57, 0x56, 0x56, 0x66, 0x66,
  0x63, 0x66, 0x34, 0x1C, 0x18, 0x1C, 0x3C, 0x36, 0x66, 0xE3, 0xC3, 0x62,
  0x26, 0x34, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFC, 0x30, 0xC6, 0x30,
  0xC6, 0x18, 0xFF, 0xF0, 0xFF, 0x88, 0x88, 0x88, 0x88, 0x88, 0xFF, 0xC1,
  0x81, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0xC0,
  0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x30, 0xE6, 0x93, 0xC4, 0xFF,
  0xFC, 0xE3, 0x3B, 0xFC, 0x4F, 0xFF, 0x1C, 0xFD, 0xC3, 0x0D, 0xBF, 0xC7,
  0x1C, 0x71, 0xEF, 0xF0, 0x3B, 0xFC, 0x70, 0xC3, 0x1E, 0xDE, 0x04, 0x17,
  0x7F, 0xCF, 0x1C, 0x71, 0xCD, 0xD0, 0x3B, 0xFC, 0x7F, 0xFF, 0x0C, 0xDE,
  0x3E, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0x77, 0xFC, 0xF1,
  0xC7, 0x37, 0x49, 0x0D, 0xF7, 0x00, 0xC3, 0x0D, 0xBF, 0xC7, 0x1C, 0x71,
  0xC7, 0x10, 0x30, 0x70, 0x07, 0x8F, 0x02, 0x04, 0x08, 0x11, 0xFF, 0xF8,
  0x1C, 0x70, 0x1E, 0x78, 0x20, 0x82, 0x08, 0x20, 0x86, 0xFB, 0x80, 0xC1,
  0x83, 0x1E, 0x6C, 0xDF, 0x3E, 0x6C, 0xCD, 0x8C, 0xF8, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x1F, 0x0F, 0xAD, 0xEE, 0x5C, 0xB9, 0x72, 0xE5,
  0xCB, 0xDB, 0xFC, 0x71, 0xC7, 0x1C, 0x71, 0x3B, 0xFC, 0x71, 0xC7, 0x1E,
  0xDE, 0xDB, 0xFC, 0x71, 0xC7, 0x1E, 0xFF, 0xC3, 0x0C, 0x00, 0x77, 0xFC,
  0xF1, 0xC7, 0x1E, 0xDD, 0x04, 0x10, 0x40, 0xDD, 0xFB, 0x1E, 0x3C, 0x18,
  0x30, 0x60, 0x79, 0xFB, 0x07, 0x83, 0xC0, 0xF3, 0x3E, 0x20, 0x8F, 0xFF,
  0x20, 0x82, 0x08, 0x3C, 0xF0, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0xDE, 0x87,
  0x8B, 0x32, 0x66, 0x8F, 0x0E, 0x18, 0xD9, 0xD9, 0x5B, 0x5B, 0x56, 0x56,
  0x66, 0x66, 0x63, 0x66, 0x3C, 0x1C, 0x1C, 0x3C, 0x26, 0xE3, 0xC7, 0x8B,
  0x33, 0x66, 0x87, 0x0E, 0x18, 0x30, 0x61, 0x80, 0xFF, 0xF0, 0xC6, 0x31,
  0x8F, 0xFF, 0x0C, 0x71, 0x86, 0x18, 0x6F, 0x3C, 0x18, 0x61, 0x86, 0x1C,
  0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x83, 0x0C, 0x30, 0xC3, 0xCF, 0x30,
  0xC3, 0x0C, 0xE3, 0x00, 0x41, 0xEE, 0x78, 0x60,
};

const GFXglyph JetBrainsMono_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 5, 4, 8, 2, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 14, 8, 1, -12 },
  { 30, 8, 10, 8, 0, -10 },
  { 40, 7, 10, 8, 1, -10 },
  { 49, 2, 4, 8, 3, -10 },
  { 50, 5, 14, 8, 2, -12 },
  { 59, 4, 14, 8, 2, -12 },
  { 66, 8, 8, 8, 0, -9 },
  { 74, 7, 7, 8, 1, -8 },
  { 81, 3, 4, 8, 2, -2 },
  { 83, 4, 1, 8, 2, -5 },
  { 84, 3, 2, 8, 3, -2 },
  { 85, 7, 14, 8, 1, -12 },
  { 98, 6, 10, 8, 1, -10 },
  { 106, 7, 10, 8, 1, -10 },
  { 115, 6, 10, 8, 1, -10 },
  { 123, 6, 10, 8, 1, -10 },
  { 131, 6, 10, 8, 1, -10 },
  { 139, 6, 10, 8, 1, -10 },
  { 147, 7, 10, 8, 1, -10 },
  { 156, 7, 10, 8, 1, -10 },
  { 165, 7, 10, 8, 1, -10 },
  { 174, 7, 10, 8, 1, -10 },
  { 183, 3, 8, 8, 3, -8 },
  { 186, 4, 10, 8, 2, -8 },
  { 191, 6, 7, 8, 1, -8 },
  { 197, 6, 5, 8, 1, -7 },
  { 201, 6, 7, 8, 1, -8 },
  { 207, 5, 10, 8, 2, -10 },
  { 214, 8, 13, 8, 0, -10 },
  { 227, 8, 10, 8, 0, -10 },
  { 237, 7, 10, 8, 1, -10 },
  { 246, 7, 10, 8, 1, -10 },
  { 255, 6, 10, 8, 1, -10 },
  { 263, 6, 10, 8, 1, -10 },
  { 271, 6, 10, 8, 1, -10 },
  { 279, 7, 10, 8, 1, -10 },
  { 288, 6, 10, 8, 1, -10 },
  { 296, 6, 10, 8, 1, -10 },
  { 304, 7, 10, 8, 0, -10 },
  { 313, 7, 10, 8, 1, -10 },
  { 322, 7, 10, 8, 1, -10 },
  { 331, 7, 10, 8, 1, -10 },
  { 340, 6, 10, 8, 1, -10 },
  { 348, 6, 10, 8, 1, -10 },
  { 356, 7, 10, 8, 1, -10 },
  { 365, 7, 13, 8, 1, -10 },
  { 377, 7, 10, 8, 1, -10 },
  { 386, 7, 10, 8, 1, -10 },
  { 395, 7, 10, 8, 1, -10 },
  { 404, 6, 10, 8, 1, -10 },
  { 412, 8, 10, 8, 0, -10 },
  { 422, 8, 10, 8, 0, -10 },
  { 432, 8, 10, 8, 0, -10 },
  { 442, 8, 10, 8, 0, -10 },
  { 452, 6, 10, 8, 1, -10 },
  { 460, 4, 14, 8, 3, -12 },
  { 467, 7, 14, 8, 1, -12 },
  { 480, 4, 14, 8, 2, -12 },
  { 487, 6, 5, 8, 1, -10 },
  { 491, 7, 2, 8, 1, 0 },
  { 493, 4, 2, 8, 2, -11 },
  { 494, 6, 8, 8, 1, -8 },
  { 500, 6, 10, 8, 1, -10 },
  { 508, 6, 8, 8, 1, -8 },
  { 514, 6, 10, 8, 1, -10 },
  { 522, 6, 8, 8, 1, -8 },
  { 528, 7, 10, 8, 1, -10 },
  { 537, 6, 11, 8, 1, -8 },
  { 546, 6, 10, 8, 1, -10 },
  { 554, 7, 11, 8, 1, -11 },
  { 564, 6, 14, 8, 1, -11 },
  { 575, 7, 10, 8, 1, -10 },
  { 584, 8, 10, 8, 0, -10 },
  { 594, 7, 8, 8, 1, -8 },
  { 601, 6, 8, 8, 1, -8 },
  { 607, 6, 8, 8, 1, -8 },
  { 613, 6, 11, 8, 1, -8 },
  { 622, 6, 11, 8, 1, -8 },
  { 631, 7, 8, 8, 1, -8 },
  { 638, 7, 8, 8, 1, -8 },
  { 645, 6, 10, 8, 1, -10 },
  { 653, 6, 8, 8, 1, -8 },
  { 659, 7, 8, 8, 1, -8 },
  { 666, 8, 8, 8, 0, -8 },
  { 674, 8, 8, 8, 0, -8 },
  { 682, 7, 11, 8, 1, -8 },
  { 692, 6, 8, 8, 1, -8 },
  { 698, 6, 14, 8, 1, -12 },
  { 709, 2, 14, 8, 3, -12 },
  { 713, 6, 14, 8, 1, -12 },
  { 724, 7, 4, 8, 1, -7 },
};

const GFXfont JetBrainsMono_Bold14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_BOLD14PT7B_H_
