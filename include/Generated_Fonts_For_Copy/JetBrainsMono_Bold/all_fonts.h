#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/JetBrainsMono_Bold
// Headers: 67

#include "JetBrainsMono_Bold6pt7b.h"
#include "JetBrainsMono_Bold7pt7b.h"
#include "JetBrainsMono_Bold8pt7b.h"
#include "JetBrainsMono_Bold9pt7b.h"
#include "JetBrainsMono_Bold10pt7b.h"
#include "JetBrainsMono_Bold11pt7b.h"
#include "JetBrainsMono_Bold12pt7b.h"
#include "JetBrainsMono_Bold13pt7b.h"
#include "JetBrainsMono_Bold14pt7b.h"
#include "JetBrainsMono_Bold15pt7b.h"
#include "JetBrainsMono_Bold16pt7b.h"
#include "JetBrainsMono_Bold17pt7b.h"
#include "JetBrainsMono_Bold18pt7b.h"
#include "JetBrainsMono_Bold19pt7b.h"
#include "JetBrainsMono_Bold20pt7b.h"
#include "JetBrainsMono_Bold21pt7b.h"
#include "JetBrainsMono_Bold22pt7b.h"
#include "JetBrainsMono_Bold23pt7b.h"
#include "JetBrainsMono_Bold24pt7b.h"
#include "JetBrainsMono_Bold25pt7b.h"
#include "JetBrainsMono_Bold26pt7b.h"
#include "JetBrainsMono_Bold27pt7b.h"
#include "JetBrainsMono_Bold28pt7b.h"
#include "JetBrainsMono_Bold29pt7b.h"
#include "JetBrainsMono_Bold30pt7b.h"
#include "JetBrainsMono_Bold31pt7b.h"
#include "JetBrainsMono_Bold32pt7b.h"
#include "JetBrainsMono_Bold33pt7b.h"
#include "JetBrainsMono_Bold34pt7b.h"
#include "JetBrainsMono_Bold35pt7b.h"
#include "JetBrainsMono_Bold36pt7b.h"
#include "JetBrainsMono_Bold37pt7b.h"
#include "JetBrainsMono_Bold38pt7b.h"
#include "JetBrainsMono_Bold39pt7b.h"
#include "JetBrainsMono_Bold40pt7b.h"
#include "JetBrainsMono_Bold41pt7b.h"
#include "JetBrainsMono_Bold42pt7b.h"
#include "JetBrainsMono_Bold43pt7b.h"
#include "JetBrainsMono_Bold44pt7b.h"
#include "JetBrainsMono_Bold45pt7b.h"
#include "JetBrainsMono_Bold46pt7b.h"
#include "JetBrainsMono_Bold47pt7b.h"
#include "JetBrainsMono_Bold48pt7b.h"
#include "JetBrainsMono_Bold49pt7b.h"
#include "JetBrainsMono_Bold50pt7b.h"
#include "JetBrainsMono_Bold51pt7b.h"
#include "JetBrainsMono_Bold52pt7b.h"
#include "JetBrainsMono_Bold53pt7b.h"
#include "JetBrainsMono_Bold54pt7b.h"
#include "JetBrainsMono_Bold55pt7b.h"
#include "JetBrainsMono_Bold56pt7b.h"
#include "JetBrainsMono_Bold57pt7b.h"
#include "JetBrainsMono_Bold58pt7b.h"
#include "JetBrainsMono_Bold59pt7b.h"
#include "JetBrainsMono_Bold60pt7b.h"
#include "JetBrainsMono_Bold61pt7b.h"
#include "JetBrainsMono_Bold62pt7b.h"
#include "JetBrainsMono_Bold63pt7b.h"
#include "JetBrainsMono_Bold64pt7b.h"
#include "JetBrainsMono_Bold65pt7b.h"
#include "JetBrainsMono_Bold66pt7b.h"
#include "JetBrainsMono_Bold67pt7b.h"
#include "JetBrainsMono_Bold68pt7b.h"
#include "JetBrainsMono_Bold69pt7b.h"
#include "JetBrainsMono_Bold70pt7b.h"
#include "JetBrainsMono_Bold71pt7b.h"
#include "JetBrainsMono_Bold72pt7b.h"
