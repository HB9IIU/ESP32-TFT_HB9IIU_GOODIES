#ifndef _JETBRAINSMONO_BOLD28PT7B_H_
#define _JETBRAINSMONO_BOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x00, 0x67,
  0xFF, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x06,
  0x1C, 0x1C, 0x30, 0x38, 0x60, 0x71, 0xC0, 0xC3, 0x8F, 0xFF, 0xDF, 0xFF,
  0x8E, 0x18, 0x1C, 0x30, 0x38, 0xE0, 0x61, 0xC0, 0xC3, 0x8F, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x18, 0x70, 0x30, 0xE0, 0x61, 0xC1, 0xC3, 0x03, 0x86,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1E, 0x03, 0xFE, 0x3F, 0xF9, 0xEF,
  0xDE, 0x4F, 0xF2, 0x7F, 0x90, 0x3C, 0x81, 0xF4, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0x02, 0x78, 0x11, 0xC0, 0x8F, 0xC4, 0x7F, 0x27, 0xFF,
  0xF9, 0xFF, 0xC3, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x08,
  0x00, 0xBF, 0x01, 0x9F, 0xC1, 0xDC, 0x61, 0xCE, 0x30, 0xC7, 0x18, 0xC3,
  0x8C, 0xE0, 0xEE, 0xE0, 0x7F, 0x60, 0x0E, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x33, 0xE0, 0x3B, 0xF8, 0x1B, 0x8C, 0x19, 0xC6, 0x1C, 0xE3, 0x1C,
  0x71, 0x8C, 0x38, 0xCE, 0x0F, 0xEE, 0x03, 0xE0, 0x07, 0x80, 0x3F, 0xC0,
  0xFF, 0xC1, 0xE7, 0x83, 0x87, 0x87, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x7C, 0x01, 0xFC, 0x07, 0xB8, 0xFF, 0x79, 0xDE, 0x7F, 0xBC, 0x7E,
  0x78, 0x7C, 0xF0, 0xF1, 0xE1, 0xF1, 0xFF, 0xE3, 0xFF, 0xE3, 0xF9, 0xE0,
  0xFF, 0xFF, 0xFF, 0x00, 0x81, 0xC3, 0xE3, 0xF3, 0xE3, 0xE1, 0xE1, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xC0, 0xE0, 0x80, 0x70,
  0x3E, 0x1F, 0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x78,
  0xFC, 0xFC, 0x78, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x07, 0x39, 0xDF, 0x67, 0xFF, 0x7F, 0x8F, 0xF8, 0x03, 0x80, 0x1D, 0x80,
  0x7B, 0x80, 0xE3, 0x83, 0xC7, 0x83, 0x06, 0x02, 0x08, 0x00, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3E, 0x78, 0xF3, 0xC7,
  0x8F, 0x1C, 0x78, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xFF, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xFC, 0xF1,
  0xEF, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x39, 0xF9, 0xCF,
  0xCE, 0x7E, 0x23, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x83, 0xDF,
  0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x0F, 0x81, 0xFC, 0x1F, 0xE1, 0xF7, 0x0E,
  0x38, 0x61, 0xC2, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x01, 0xFF, 0x1F, 0xFD, 0xFB, 0xEF, 0x07, 0xF0, 0x3F,
  0x81, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0xF7, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x77,
  0x87, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0xFC, 0xFF, 0xF7, 0xEF, 0xBC, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xFE, 0x0F, 0xF0, 0x7B, 0xFF, 0x9F, 0xF8, 0x3F,
  0x80, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x20, 0x77, 0xE7, 0xFF, 0xBE, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xF0, 0x7B, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xFC,
  0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0E, 0x78, 0xF1, 0xFF, 0x07,
  0xE0, 0x7F, 0xC7, 0x8F, 0x78, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x83,
  0xDF, 0xFC, 0xFF, 0xE1, 0xFC, 0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xFD, 0xF1,
  0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xFF, 0xFE,
  0xFE, 0xE3, 0xEF, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xC7, 0x80, 0x00, 0x08, 0x01,
  0xC0, 0x3E, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x1E, 0x00, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3C, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0x00, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC0,
  0x78, 0x03, 0x00, 0x00, 0xFF, 0x1F, 0xFB, 0xFF, 0x00, 0xF0, 0x1E, 0x01,
  0xC0, 0x78, 0x0F, 0x3F, 0xC7, 0xF8, 0xFE, 0x1E, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x00, 0x18, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x67, 0xE3,
  0xFF, 0xC7, 0x3F, 0x9C, 0x3F, 0x38, 0x7E, 0x70, 0xFC, 0xE1, 0xF9, 0xC3,
  0xF3, 0x87, 0xE3, 0x8F, 0xC7, 0xFF, 0x87, 0xFF, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xB8, 0x0E, 0x78,
  0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC1, 0xC3, 0xC3, 0xFF, 0x87, 0xFF, 0x1F,
  0xFE, 0x3C, 0x1E, 0x70, 0x3C, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xF0, 0xFF,
  0xC7, 0xFF, 0xBC, 0x7D, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E,
  0xFF, 0xE7, 0xFE, 0x3F, 0xFD, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFF, 0xBF, 0xF9, 0xFF, 0x80, 0x07, 0x81, 0xFF, 0x1F,
  0xFC, 0xFB, 0xEF, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0xF0, 0x7F,
  0x83, 0xDF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD,
  0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0xFF,
  0xBF, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x81,
  0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xDF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x80, 0xFE, 0x0F,
  0xF0, 0x7B, 0xFF, 0x8F, 0xFC, 0x3F, 0x80, 0xF0, 0x7F, 0xC1, 0xEF, 0x07,
  0x3C, 0x3C, 0xF0, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xFC, 0x3C, 0xF0, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xB1, 0xBD, 0x8F, 0xEE, 0xFF, 0x76, 0xFD,
  0xB7, 0xED, 0xBF, 0x7D, 0xF9, 0xCF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xF6, 0x1F, 0xB8, 0xFD, 0xC7, 0xE6, 0x3F,
  0x39, 0xF9, 0xCF, 0xC6, 0x7E, 0x3B, 0xF1, 0xDF, 0x86, 0xFC, 0x3F, 0xE1,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xF0, 0x0F, 0x01, 0xFF, 0x1F, 0xFC, 0xF3,
  0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0x9F,
  0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xFF, 0xEF, 0xFF,
  0x3F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xFC, 0xF3, 0xEF, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x87, 0xDF, 0xFC, 0x7F,
  0xC1, 0xFC, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0xFF,
  0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC,
  0x1E, 0xF0, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xF3, 0xC3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x38, 0xF0, 0xF3, 0xC1, 0xCF, 0x07, 0xBC, 0x1F, 0x0F, 0x01,
  0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0xE0, 0x3F, 0x83, 0xFF, 0xFC, 0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xF0, 0x1F, 0xE0, 0x39,
  0xC0, 0x73, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x3C,
  0x78, 0x78, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xEF, 0x03, 0xDC, 0x03, 0xB8,
  0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF1, 0xC7,
  0x71, 0xC7, 0x71, 0xC7, 0x73, 0x47, 0x73, 0x47, 0x73, 0x67, 0x73, 0x67,
  0x73, 0x67, 0x73, 0x66, 0x73, 0x66, 0x33, 0x6E, 0x32, 0x6E, 0x3E, 0x6E,
  0x3E, 0x2E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C,
  0x3E, 0x3C, 0xF8, 0x3E, 0xF0, 0x78, 0xF1, 0xE1, 0xE3, 0xC1, 0xEF, 0x03,
  0xDE, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0xFE, 0x03, 0xDE, 0x07, 0x3C, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0x79,
  0xC0, 0xF7, 0x80, 0xF0, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xC3,
  0xC7, 0x87, 0x8E, 0x07, 0x3C, 0x0F, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x07, 0x60, 0x3B, 0x81, 0xDC, 0x1C, 0x70,
  0xE3, 0x8E, 0x1E, 0x70, 0x77, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF1, 0xE3, 0x8F, 0x07, 0x01, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0x80,
  0x3C, 0x01, 0xE7, 0xFF, 0x7F, 0xFF, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xFC, 0xFF, 0xFF, 0xE7, 0xEF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x18, 0x7B, 0xF3, 0xFF, 0xDF, 0xBE, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xBF, 0xFD,
  0xEF, 0x80, 0x07, 0x01, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x07, 0xF8, 0x3F,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0xFF, 0x07, 0xBF,
  0xF8, 0xFF, 0x83, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xE7,
  0x9F, 0xBD, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0xFB, 0xFF, 0xDF, 0xFE, 0x7E,
  0xF0, 0x07, 0x01, 0xFE, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF0, 0x3F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x07, 0xBE, 0xF8,
  0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x07,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x0C, 0x01, 0xFB, 0xDF, 0xFF, 0xF3, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xF7, 0xFF, 0xBF, 0xFC, 0x7D,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x8F, 0xFC, 0x7F, 0xC3, 0xFC, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x18, 0x7B, 0xF3, 0xFF, 0xDF, 0x3E,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF,
  0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0xFF, 0xDF, 0xF3, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC1, 0xEF,
  0x07, 0xBC, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3F, 0xF0, 0xFF, 0x83,
  0xFF, 0x0F, 0x1E, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0xBC, 0x0F,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x06, 0x33, 0xBD, 0xFF, 0xF7, 0xFC, 0xE7, 0xF3, 0x9F, 0xCE,
  0x7F, 0x39, 0xFC, 0xE7, 0xF3, 0x9F, 0xCE, 0x7F, 0x39, 0xFC, 0xE7, 0xF3,
  0x9F, 0xCE, 0x7F, 0x39, 0xFC, 0xE7, 0x01, 0x87, 0xBF, 0x3F, 0xFD, 0xF3,
  0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x07, 0x01, 0xFF, 0x1F,
  0xFC, 0xFB, 0xEF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0x3F, 0xF8, 0xFF, 0x83, 0xF8, 0x01, 0x87,
  0xBF, 0x3F, 0xFD, 0xFB, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xFB, 0xFF, 0xDE, 0xFC,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xFB,
  0xDF, 0xFF, 0xF3, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xBF, 0xFD, 0xFF, 0xE7, 0xEF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x07, 0x7F, 0x3F,
  0xFD, 0xF3, 0xEF, 0x0F, 0x70, 0x3F, 0x81, 0xFC, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x01,
  0xFF, 0x1F, 0xFD, 0xF1, 0xFF, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0x7F, 0x07, 0xFF, 0xFD, 0xFF, 0xC7, 0xFC,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xE7, 0xFF, 0x1F, 0xF0, 0x7F, 0x00,
  0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xC3, 0x83, 0x87, 0x8F, 0x0F,
  0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x3D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xFE,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x34,
  0x7E, 0x6C, 0xDC, 0xD9, 0x99, 0xB7, 0x3B, 0x6E, 0x76, 0xDC, 0xE9, 0xB9,
  0xF1, 0x73, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x00, 0xF8, 0x3C,
  0x78, 0xF0, 0xF1, 0xE0, 0xF7, 0x80, 0xEE, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7B, 0xC1, 0xE3, 0x83, 0xC7, 0x8F, 0x07,
  0xBC, 0x0F, 0x80, 0xF0, 0x1E, 0xF0, 0x79, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7,
  0x87, 0x8F, 0x07, 0x1C, 0x0F, 0x78, 0x0E, 0xF0, 0x1D, 0xC0, 0x3F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0x01, 0xF8, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE3,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x1D, 0xFC, 0x77, 0xF9, 0xF8,
  0xF7, 0xE1, 0xFF, 0x83, 0xE0,
};

const GFXglyph JetBrainsMono_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 9, 8, 17, 4, -20 },
  { 23, 15, 20, 17, 1, -20 },
  { 61, 13, 28, 17, 2, -24 },
  { 107, 17, 21, 17, 0, -21 },
  { 152, 15, 21, 17, 1, -21 },
  { 192, 3, 8, 17, 7, -20 },
  { 195, 9, 27, 17, 5, -24 },
  { 226, 9, 27, 17, 3, -24 },
  { 257, 15, 15, 17, 1, -17 },
  { 286, 13, 13, 17, 2, -16 },
  { 308, 7, 8, 17, 4, -4 },
  { 315, 9, 3, 17, 4, -11 },
  { 319, 5, 5, 17, 6, -5 },
  { 323, 13, 26, 17, 2, -23 },
  { 366, 13, 21, 17, 2, -21 },
  { 401, 13, 20, 17, 2, -20 },
  { 434, 13, 21, 17, 2, -21 },
  { 469, 13, 20, 17, 2, -20 },
  { 502, 12, 20, 17, 2, -20 },
  { 532, 13, 20, 17, 2, -20 },
  { 565, 13, 20, 17, 2, -20 },
  { 598, 13, 20, 17, 2, -20 },
  { 631, 13, 21, 17, 2, -21 },
  { 666, 13, 21, 17, 2, -21 },
  { 701, 5, 16, 17, 6, -16 },
  { 711, 7, 20, 17, 4, -16 },
  { 729, 13, 15, 17, 2, -17 },
  { 754, 13, 10, 17, 2, -14 },
  { 771, 13, 15, 17, 2, -17 },
  { 796, 11, 20, 17, 3, -20 },
  { 824, 15, 26, 17, 1, -21 },
  { 873, 15, 20, 17, 1, -20 },
  { 911, 13, 20, 17, 2, -20 },
  { 944, 13, 21, 17, 2, -21 },
  { 979, 13, 20, 17, 2, -20 },
  { 1012, 13, 20, 17, 2, -20 },
  { 1045, 13, 20, 17, 2, -20 },
  { 1078, 13, 21, 17, 2, -21 },
  { 1113, 13, 20, 17, 2, -20 },
  { 1146, 11, 20, 17, 3, -20 },
  { 1174, 13, 20, 17, 1, -20 },
  { 1207, 14, 20, 17, 2, -20 },
  { 1242, 12, 20, 17, 3, -20 },
  { 1272, 13, 20, 17, 2, -20 },
  { 1305, 13, 20, 17, 2, -20 },
  { 1338, 13, 21, 17, 2, -21 },
  { 1373, 14, 20, 17, 2, -20 },
  { 1408, 13, 26, 17, 2, -21 },
  { 1451, 14, 20, 17, 2, -20 },
  { 1486, 13, 21, 17, 2, -21 },
  { 1521, 15, 20, 17, 1, -20 },
  { 1559, 13, 20, 17, 2, -20 },
  { 1592, 15, 20, 17, 1, -20 },
  { 1630, 16, 20, 17, 0, -20 },
  { 1670, 15, 20, 17, 1, -20 },
  { 1708, 15, 20, 17, 1, -20 },
  { 1746, 13, 20, 17, 2, -20 },
  { 1779, 8, 26, 17, 5, -23 },
  { 1805, 13, 26, 17, 2, -23 },
  { 1848, 8, 26, 17, 4, -23 },
  { 1874, 13, 10, 17, 2, -20 },
  { 1891, 13, 3, 17, 2, 1 },
  { 1896, 6, 4, 17, 5, -22 },
  { 1899, 13, 16, 17, 2, -16 },
  { 1925, 13, 20, 17, 2, -20 },
  { 1958, 13, 16, 17, 2, -16 },
  { 1984, 13, 20, 17, 2, -20 },
  { 2017, 13, 16, 17, 2, -16 },
  { 2043, 13, 20, 17, 2, -20 },
  { 2076, 13, 21, 17, 2, -16 },
  { 2111, 13, 20, 17, 2, -20 },
  { 2144, 14, 22, 17, 2, -22 },
  { 2183, 11, 27, 17, 2, -22 },
  { 2221, 14, 20, 17, 2, -20 },
  { 2256, 15, 20, 17, 1, -20 },
  { 2294, 14, 16, 17, 1, -16 },
  { 2322, 13, 16, 17, 2, -16 },
  { 2348, 13, 16, 17, 2, -16 },
  { 2374, 13, 21, 17, 2, -16 },
  { 2409, 13, 21, 17, 2, -16 },
  { 2444, 13, 16, 17, 3, -16 },
  { 2470, 13, 16, 17, 2, -16 },
  { 2496, 14, 20, 17, 1, -20 },
  { 2531, 13, 15, 17, 2, -15 },
  { 2556, 15, 15, 17, 1, -15 },
  { 2585, 15, 15, 17, 1, -15 },
  { 2614, 15, 15, 17, 1, -15 },
  { 2643, 15, 20, 17, 1, -15 },
  { 2681, 13, 15, 17, 2, -15 },
  { 2706, 13, 26, 17, 2, -23 },
  { 2749, 3, 26, 17, 7, -23 },
  { 2759, 13, 26, 17, 2, -23 },
  { 2802, 14, 6, 17, 1, -13 },
};

const GFXfont JetBrainsMono_Bold28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_BOLD28PT7B_H_
