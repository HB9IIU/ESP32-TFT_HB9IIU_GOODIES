#ifndef _JETBRAINSMONO_BOLD22PT7B_H_
#define _JETBRAINSMONO_BOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xED, 0x81, 0xFF, 0xE7, 0xCF, 0x9F, 0x3C, 0x78,
  0xF1, 0x80, 0x18, 0xE1, 0x8C, 0x18, 0xC1, 0x8C, 0xFF, 0xFF, 0xFF, 0x31,
  0x83, 0x18, 0x31, 0x83, 0x18, 0xFF, 0xEF, 0xFE, 0x63, 0x06, 0x30, 0x63,
  0x06, 0x30, 0x04, 0x00, 0x80, 0x10, 0x0F, 0xC7, 0xFC, 0xEB, 0x99, 0x3B,
  0x20, 0x74, 0x0F, 0x80, 0xFE, 0x0F, 0xE0, 0x7E, 0x09, 0xC1, 0x3F, 0x27,
  0x75, 0xEF, 0xF8, 0xFE, 0x02, 0x00, 0x40, 0x08, 0x00, 0x7C, 0x1B, 0xE1,
  0xB1, 0x99, 0x8C, 0xCC, 0x6C, 0x3E, 0xC1, 0xF6, 0x00, 0x60, 0x06, 0x00,
  0x3F, 0x83, 0x6E, 0x32, 0x33, 0x11, 0x98, 0x8D, 0x87, 0xF8, 0x1E, 0x1F,
  0x03, 0xF8, 0x71, 0xC7, 0x1C, 0x70, 0x03, 0x00, 0x38, 0x07, 0xC0, 0xEC,
  0x7E, 0xEE, 0xE7, 0xCE, 0x3C, 0xE3, 0x8E, 0x3C, 0x7F, 0xE7, 0xE7, 0xFF,
  0xFF, 0xF8, 0x0E, 0x3C, 0xF3, 0x8E, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x1C, 0x38, 0x70, 0x70, 0xF8, 0xF8, 0x70, 0x20, 0xC1, 0xC3, 0xE1,
  0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x38,
  0xF3, 0xC6, 0x08, 0x00, 0x0E, 0x00, 0xE0, 0x86, 0x2E, 0x4E, 0xFD, 0xF3,
  0xF8, 0x0E, 0x01, 0xB0, 0x3B, 0x87, 0x1C, 0x30, 0x80, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x00, 0x3C, 0xE7, 0x1C, 0x71, 0x8E, 0x00, 0xFF, 0xFF, 0xF8, 0xEF, 0xFE,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x78, 0x00, 0x1F, 0x8F, 0xF9, 0xC7, 0x30, 0x7E, 0x0F, 0xC1,
  0xF9, 0x3F, 0x77, 0xEE, 0xFC, 0x1F, 0x83, 0xB0, 0x76, 0x0E, 0xE3, 0x8F,
  0xF0, 0xFC, 0x1E, 0x1F, 0x8F, 0xE3, 0xB8, 0x8E, 0x23, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFF, 0x1F, 0x8F,
  0xF9, 0xC7, 0x70, 0x7E, 0x0E, 0x01, 0x80, 0x70, 0x1E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0xFB, 0xFF, 0x7F, 0xCF, 0xF8, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0xE0, 0x7E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x7E, 0x0E, 0xE3, 0x9F, 0xF1, 0xF8, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1E,
  0x07, 0x03, 0x81, 0xC3, 0x70, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x30,
  0x0C, 0x03, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x39, 0x0F, 0xF3, 0xFE,
  0xE3, 0xC0, 0x70, 0x1C, 0x07, 0xC1, 0xF8, 0xEF, 0xF8, 0xFC, 0x07, 0x81,
  0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1D, 0xE3, 0xFE, 0x71, 0xDC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0E, 0xE3, 0x9F, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0x83,
  0xF0, 0x7E, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x1F, 0x8F, 0xF9, 0xC7, 0x30, 0x76,
  0x0C, 0xE3, 0x8E, 0xF0, 0xF8, 0x3F, 0x8E, 0x39, 0x83, 0xF0, 0x7E, 0x0E,
  0xE3, 0xDF, 0xF1, 0xFC, 0x1F, 0x8F, 0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3B, 0x8F, 0x7F, 0xC3, 0xB8, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0xEF, 0xE0, 0x00, 0x00, 0x0E, 0xFE, 0x38, 0xF3, 0x80, 0x00,
  0x00, 0x00, 0x04, 0xE3, 0x9E, 0x71, 0xC6, 0x38, 0x00, 0xC0, 0xF0, 0xF8,
  0xF8, 0xF8, 0x30, 0x0F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1C, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x70, 0x3C, 0x7E, 0x7E, 0x3C, 0x0C, 0x02, 0x00, 0xFC,
  0xFE, 0xFF, 0x07, 0x07, 0x07, 0x0F, 0x7E, 0x7C, 0x70, 0x70, 0x00, 0x00,
  0x70, 0x70, 0x70, 0x1F, 0x87, 0xFC, 0x60, 0xEE, 0x06, 0xC0, 0x7C, 0x37,
  0xC7, 0xBC, 0xE7, 0xCC, 0x7C, 0xC7, 0xCC, 0x7C, 0xC7, 0xCE, 0x7C, 0x7B,
  0xC3, 0x7C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x01, 0xF0, 0x0F, 0x03, 0xE0,
  0x7C, 0x0D, 0x81, 0xB8, 0x77, 0x0E, 0xE1, 0x8C, 0x31, 0xCE, 0x39, 0xFF,
  0x3F, 0xE6, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFE, 0x3F, 0xEC, 0x3B, 0x07,
  0xC1, 0xF0, 0x6C, 0x7B, 0xF8, 0xFF, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0xFF, 0xFB, 0xF8, 0x3F, 0x1F, 0xEE, 0x3B, 0x07, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xC1, 0xF8, 0xE7, 0xF8, 0xFC, 0xFE,
  0x3F, 0xEC, 0x7B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xFF, 0xEF, 0xF3, 0xF8, 0xFF, 0xFF, 0xFE, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x3F,
  0x1F, 0xEE, 0x3B, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x3F, 0xCF, 0xF3, 0xFC,
  0x1F, 0x07, 0xC1, 0xF8, 0xE7, 0xF8, 0xFC, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x07,
  0xE1, 0xFC, 0xF7, 0xF8, 0xFC, 0xC1, 0xD8, 0x3B, 0x0E, 0x61, 0xCC, 0x71,
  0x8E, 0x3F, 0x87, 0xF0, 0xFE, 0x18, 0xE3, 0x1C, 0x63, 0x8C, 0x39, 0x87,
  0x30, 0x76, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x3F, 0xC7, 0xEC, 0xBD, 0xB7, 0xF6, 0xFA, 0xDF, 0x73, 0xEE, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF9, 0xF6, 0x7D, 0x9F, 0x77, 0xCD, 0xF3, 0x7C, 0xFF, 0x1F,
  0xC7, 0xF1, 0xFC, 0x3F, 0x0F, 0x3F, 0x3F, 0xEE, 0x3B, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xE7, 0xF8,
  0xFC, 0xFF, 0x3F, 0xEC, 0x3F, 0x07, 0xC0, 0xF0, 0x3C, 0x1F, 0xFF, 0xFF,
  0xBF, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1F, 0x8F, 0xF9,
  0xC7, 0x30, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xB0, 0x76, 0x0E, 0xE3, 0x8F, 0xF0, 0xFC, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0xFE, 0x3F, 0xEC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFE, 0xFF,
  0x3F, 0x8C, 0x73, 0x1C, 0xC3, 0xB0, 0xEC, 0x1F, 0x07, 0x1F, 0x8F, 0xF9,
  0xC7, 0x30, 0x76, 0x00, 0xE0, 0x1F, 0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x03,
  0x80, 0x7E, 0x0E, 0xE3, 0xDF, 0xF1, 0xFC, 0xFF, 0xFF, 0xFC, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0xE7, 0xF8,
  0xFC, 0xE0, 0x7C, 0x1F, 0x83, 0xB0, 0x77, 0x0C, 0xE3, 0x9C, 0x71, 0x8E,
  0x39, 0x87, 0x70, 0xEE, 0x0D, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0xE7,
  0x3B, 0x39, 0xD9, 0xCE, 0xCA, 0x66, 0x53, 0x32, 0x99, 0x96, 0xCC, 0xB6,
  0x6D, 0xB3, 0xED, 0x9F, 0x6C, 0x79, 0x63, 0x8E, 0x1C, 0x70, 0xE3, 0x87,
  0x1C, 0xE0, 0xE7, 0x0C, 0x71, 0xC3, 0x98, 0x3B, 0x81, 0xF0, 0x1F, 0x00,
  0xE0, 0x0F, 0x01, 0xF0, 0x1B, 0x83, 0xB8, 0x31, 0xC7, 0x1C, 0xE0, 0xEE,
  0x0F, 0xF0, 0x3B, 0x83, 0x8E, 0x1C, 0x71, 0xC1, 0x8E, 0x0E, 0xE0, 0x37,
  0x01, 0xF0, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x70, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x0E, 0x01, 0xE0, 0x6C, 0x0D,
  0xC3, 0x98, 0x63, 0x1C, 0x73, 0x06, 0xE0, 0xE0, 0xFF, 0xFF, 0xFC, 0xE3,
  0x8E, 0x1F, 0x87, 0xF9, 0xC7, 0x00, 0x70, 0x0E, 0x7F, 0xDF, 0xFF, 0x07,
  0xE0, 0xFC, 0x3D, 0xFF, 0x9F, 0x70, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xDF,
  0x37, 0xEE, 0x3B, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0xED,
  0xFB, 0x7C, 0x3F, 0x3F, 0xEE, 0x3B, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC1, 0xF8, 0xE7, 0xF8, 0xFC, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x7D, 0xFF,
  0xFE, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xFF, 0xFD,
  0xF7, 0x3F, 0x3F, 0xEE, 0x3B, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0xC0,
  0x78, 0xE7, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x38, 0x06, 0x00, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x7D, 0xFF, 0xFE, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xE3, 0xFF, 0xF7, 0xDC, 0x07, 0x01, 0x80, 0xE7, 0xF9, 0xF8, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xDF, 0x37, 0xEE, 0x3B, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x1E, 0x07, 0x80, 0xC0, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x07, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFE,
  0xFC, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1D, 0xC7, 0x38, 0xE7, 0x38,
  0xE7, 0x1F, 0xC3, 0xF8, 0x73, 0x8E, 0x71, 0xC7, 0x38, 0xF7, 0x0F, 0xFC,
  0x1F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xF8, 0x3F, 0xDD, 0xDF, 0xBF,
  0x99, 0xF3, 0x3E, 0x67, 0xCC, 0xF9, 0x9F, 0x33, 0xE6, 0x7C, 0xCF, 0x99,
  0xF3, 0x30, 0xDF, 0x37, 0xEE, 0x3B, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x3F, 0x3F, 0xEE, 0x3B, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xE7, 0xF8, 0xF8, 0xDF, 0x37, 0xEE, 0x3B,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0xED, 0xFB, 0x7C, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x7D, 0xFF, 0xFE, 0x3F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0xFF, 0xFD, 0xF7, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0xEF, 0xBF, 0xFF, 0x1F, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x3F, 0x8F, 0xF9, 0xC3, 0xB0, 0x07, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0x80, 0xEE, 0x1D, 0xFF, 0x1F, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x0F, 0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0xF0, 0x3E, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xB8, 0xE7, 0xF8, 0xF8, 0xE0, 0xFC, 0x1D,
  0x83, 0x38, 0xE7, 0x1C, 0x63, 0x8E, 0x61, 0xDC, 0x1B, 0x83, 0xE0, 0x7C,
  0x07, 0x80, 0xE7, 0x3B, 0x39, 0xD9, 0xCC, 0xCA, 0x66, 0x53, 0x32, 0xD9,
  0xD6, 0xC7, 0xBE, 0x3C, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC0, 0xF0, 0xEE,
  0x38, 0xEE, 0x1D, 0xC1, 0xF0, 0x1C, 0x03, 0xC0, 0xF8, 0x3B, 0x8E, 0x39,
  0xC7, 0x70, 0x70, 0xE0, 0xFC, 0x1D, 0xC3, 0x38, 0xE3, 0x9C, 0x73, 0x0E,
  0xE0, 0xDC, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70,
  0x3F, 0xFF, 0xF0, 0x07, 0x87, 0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x7E, 0x3F, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C,
  0x0E, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0F, 0xC7, 0xE3, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x18, 0x1C, 0x3E, 0x1E, 0x00, 0x7C, 0x7F, 0x8F,
  0x3B, 0xE3, 0xF0, 0x3C,
};

const GFXglyph JetBrainsMono_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 7, 7, 13, 3, -16 },
  { 14, 12, 16, 13, 1, -16 },
  { 38, 11, 22, 13, 1, -19 },
  { 69, 13, 16, 13, 0, -16 },
  { 95, 12, 16, 13, 1, -16 },
  { 119, 3, 7, 13, 5, -16 },
  { 122, 7, 21, 13, 4, -18 },
  { 141, 7, 21, 13, 3, -18 },
  { 160, 12, 11, 13, 1, -13 },
  { 177, 11, 11, 13, 1, -13 },
  { 193, 6, 7, 13, 3, -3 },
  { 199, 7, 3, 13, 3, -9 },
  { 202, 4, 4, 13, 5, -4 },
  { 204, 11, 20, 13, 1, -18 },
  { 232, 11, 16, 13, 1, -16 },
  { 254, 10, 16, 13, 2, -16 },
  { 274, 11, 16, 13, 1, -16 },
  { 296, 11, 16, 13, 1, -16 },
  { 318, 10, 16, 13, 1, -16 },
  { 338, 10, 16, 13, 2, -16 },
  { 358, 11, 16, 13, 1, -16 },
  { 380, 11, 16, 13, 1, -16 },
  { 402, 11, 16, 13, 1, -16 },
  { 424, 11, 16, 13, 1, -16 },
  { 446, 4, 12, 13, 5, -12 },
  { 452, 6, 16, 13, 3, -12 },
  { 464, 10, 12, 13, 2, -13 },
  { 479, 9, 8, 13, 2, -11 },
  { 488, 10, 12, 13, 2, -13 },
  { 503, 8, 16, 13, 3, -16 },
  { 519, 12, 20, 13, 1, -16 },
  { 549, 11, 16, 13, 1, -16 },
  { 571, 10, 16, 13, 2, -16 },
  { 591, 10, 16, 13, 2, -16 },
  { 611, 10, 16, 13, 2, -16 },
  { 631, 10, 16, 13, 2, -16 },
  { 651, 10, 16, 13, 2, -16 },
  { 671, 10, 16, 13, 2, -16 },
  { 691, 10, 16, 13, 2, -16 },
  { 711, 9, 16, 13, 2, -16 },
  { 729, 10, 16, 13, 1, -16 },
  { 749, 11, 16, 13, 2, -16 },
  { 771, 10, 16, 13, 2, -16 },
  { 791, 11, 16, 13, 1, -16 },
  { 813, 10, 16, 13, 2, -16 },
  { 833, 10, 16, 13, 2, -16 },
  { 853, 10, 16, 13, 2, -16 },
  { 873, 11, 20, 13, 1, -16 },
  { 901, 10, 16, 13, 2, -16 },
  { 921, 11, 16, 13, 1, -16 },
  { 943, 11, 16, 13, 1, -16 },
  { 965, 10, 16, 13, 2, -16 },
  { 985, 11, 16, 13, 1, -16 },
  { 1007, 13, 16, 13, 0, -16 },
  { 1033, 12, 16, 13, 1, -16 },
  { 1057, 13, 16, 13, 0, -16 },
  { 1083, 9, 16, 13, 2, -16 },
  { 1101, 6, 20, 13, 4, -18 },
  { 1116, 11, 20, 13, 1, -18 },
  { 1144, 6, 20, 13, 3, -18 },
  { 1159, 11, 9, 13, 1, -16 },
  { 1172, 11, 2, 13, 1, 1 },
  { 1175, 5, 3, 13, 4, -17 },
  { 1177, 11, 12, 13, 1, -12 },
  { 1194, 10, 16, 13, 2, -16 },
  { 1214, 10, 12, 13, 2, -12 },
  { 1229, 10, 16, 13, 2, -16 },
  { 1249, 10, 12, 13, 2, -12 },
  { 1264, 11, 16, 13, 1, -16 },
  { 1286, 10, 16, 13, 2, -12 },
  { 1306, 10, 16, 13, 2, -16 },
  { 1326, 10, 17, 13, 2, -17 },
  { 1348, 8, 21, 13, 2, -17 },
  { 1369, 11, 16, 13, 2, -16 },
  { 1391, 11, 16, 13, 1, -16 },
  { 1413, 11, 12, 13, 1, -12 },
  { 1430, 10, 12, 13, 2, -12 },
  { 1445, 10, 12, 13, 2, -12 },
  { 1460, 10, 16, 13, 2, -12 },
  { 1480, 10, 16, 13, 2, -12 },
  { 1500, 10, 12, 13, 2, -12 },
  { 1515, 11, 12, 13, 1, -12 },
  { 1532, 11, 16, 13, 1, -16 },
  { 1554, 10, 12, 13, 2, -12 },
  { 1569, 11, 12, 13, 1, -12 },
  { 1586, 13, 12, 13, 0, -12 },
  { 1606, 11, 12, 13, 1, -12 },
  { 1623, 11, 16, 13, 1, -12 },
  { 1645, 9, 12, 13, 2, -12 },
  { 1659, 9, 20, 13, 2, -18 },
  { 1682, 3, 20, 13, 5, -18 },
  { 1690, 9, 20, 13, 2, -18 },
  { 1713, 11, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_Bold22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_BOLD22PT7B_H_
