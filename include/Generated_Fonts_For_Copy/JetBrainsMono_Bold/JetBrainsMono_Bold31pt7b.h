#ifndef _JETBRAINSMONO_BOLD31PT7B_H_
#define _JETBRAINSMONO_BOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xEF, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8E, 0xF1, 0xDE, 0x38, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0x60, 0xE0, 0x70, 0x61, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0x87, 0x0E, 0x03, 0x06, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0,
  0x70, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0x87, 0x01, 0x83, 0x81, 0xC3, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0xFC, 0x03, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0xFB, 0x3D,
  0xE6, 0x3B, 0xCC, 0x07, 0x98, 0x07, 0xB0, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x0C, 0xF0, 0x18, 0xF0, 0x31, 0xFE, 0x63,
  0xFC, 0xC7, 0xFD, 0xBE, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xEF, 0xE0, 0x39, 0xFE,
  0x0E, 0x71, 0xC1, 0x8E, 0x18, 0x71, 0xC3, 0x1C, 0x38, 0x63, 0x07, 0x1C,
  0xE0, 0x7F, 0xB8, 0x07, 0xEE, 0x00, 0x21, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x3E, 0x00, 0xEF, 0xE0, 0x3B, 0xCE, 0x0E, 0x71, 0xC1, 0xCE,
  0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x07, 0xBC, 0xE0, 0x7F, 0x38, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xCF, 0x83, 0xC3, 0xC1,
  0xC1, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x17, 0xF8, 0x77, 0x9E, 0x7B, 0xC7, 0xF9, 0xE1, 0xFC, 0xF0,
  0xFC, 0x78, 0x3E, 0x3C, 0x1F, 0x0F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0x78,
  0x7E, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x00, 0xC0, 0xF0, 0x7C, 0x3F,
  0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x01, 0xC0, 0x10, 0x80, 0x70, 0x3E,
  0x1F, 0x87, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E,
  0x3F, 0x3F, 0x3F, 0x1F, 0x0E, 0x04, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x04, 0x1C, 0x33, 0xCE, 0x7B, 0xF6, 0xFD, 0xFD, 0xFF,
  0x0F, 0xF8, 0x01, 0xE0, 0x01, 0xD8, 0x01, 0xEE, 0x01, 0xE7, 0x80, 0xF1,
  0xE0, 0xF0, 0xF8, 0x10, 0x30, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x7C,
  0xF3, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0xC7, 0xFF, 0x9F, 0xBF, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x39, 0xFD, 0xE7, 0xF7, 0x9F, 0xCC, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xDE, 0x1F, 0x7F, 0xF8,
  0xFF, 0xE1, 0xFE, 0x00, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0x9E, 0x0C, 0x78, 0x21, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x00, 0x1F, 0x80, 0x7F,
  0x81, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x1F, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC3, 0xDE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x73, 0xE1, 0xDF, 0xE7, 0xFF, 0x9F, 0x3F,
  0x78, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xC0, 0xFF, 0x03,
  0xDE, 0x1F, 0x7F, 0xF8, 0xFF, 0xE1, 0xFE, 0x00, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xFB, 0xC1, 0xFF, 0xE3, 0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFB, 0xC3, 0xE7, 0xFF, 0xC7,
  0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFE, 0x07, 0xBC, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xE7, 0xE7, 0x83, 0xDE, 0x07, 0xBC,
  0x0F, 0x38, 0x1E, 0x78, 0x7C, 0x79, 0xF0, 0x7F, 0xC0, 0x7F, 0x03, 0xFF,
  0x0F, 0x8F, 0x1E, 0x0F, 0x78, 0x1E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7,
  0xC3, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xE1,
  0xFF, 0xE3, 0xE7, 0xEF, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0xF3, 0xFF, 0xE7, 0xFF, 0xC3, 0xFF, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x39, 0xFF, 0xDF, 0x78, 0x3E, 0xFD, 0xF9, 0xF1, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE7, 0xCF, 0x3E, 0x7C, 0xF1, 0xE7, 0x8F, 0x1C,
  0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x87,
  0xF8, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0xF8, 0x0F, 0xF8, 0xFF, 0xCF,
  0xFE, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x3F, 0xE3,
  0xFC, 0x3F, 0x83, 0x80, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x8F, 0x83, 0xE7, 0x80, 0x73, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x07, 0xE0,
  0xFB, 0xF0, 0xFD, 0xF8, 0xF1, 0xFC, 0x78, 0xFE, 0x38, 0x3F, 0x1C, 0x1F,
  0x8E, 0x0F, 0xC7, 0x07, 0xE3, 0x87, 0xF1, 0xC3, 0xF8, 0xF1, 0xFC, 0x3F,
  0x7E, 0x0F, 0xBF, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1E,
  0xF0, 0x0E, 0x78, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xC7, 0x81, 0xC3, 0xC1,
  0xE1, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1E, 0x03,
  0x8F, 0x01, 0xE7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3E, 0xFF, 0x01, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x9E, 0x07, 0xBC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xEF, 0xFF,
  0xDF, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7,
  0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x3F, 0xE0, 0xF3, 0xE3, 0xE7, 0xFF, 0x87, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07,
  0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0,
  0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xF7, 0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xF3, 0xE3, 0xE7, 0xFF, 0x87, 0xFF,
  0x03, 0xF8, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFB, 0xE3, 0xE7,
  0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0,
  0xF1, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8D, 0xFB, 0x3B, 0xF7, 0x77,
  0xEE, 0xCF, 0xDD, 0xBF, 0x9F, 0x7F, 0x3E, 0xFE, 0x79, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0x80, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xB8, 0x7F, 0xE1, 0xFF, 0x87, 0xF7, 0x1F, 0xDC, 0x7F, 0x71,
  0xFC, 0xE7, 0xF3, 0x9F, 0xCE, 0x7F, 0x1D, 0xFC, 0x77, 0xF1, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xDF, 0x1F, 0x7F, 0xF8, 0xFF,
  0xE0, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xF7, 0xFF, 0xEF, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0xE1, 0xFF, 0xE3, 0xF7, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x07,
  0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x01, 0xDE,
  0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x7B, 0xC0, 0xF3, 0xE3,
  0xE7, 0xFF, 0x87, 0xFF, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC3, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFC, 0x3C, 0x78, 0x78, 0x78,
  0xF0, 0xF1, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xFC,
  0x07, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xF7, 0xEF, 0x83, 0xDE,
  0x03, 0xBC, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC3, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xDF, 0x1F, 0x7F, 0xF8, 0xFF, 0xE1, 0xFE,
  0x00, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3,
  0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x0F,
  0x03, 0xC7, 0x81, 0xE3, 0x80, 0xF1, 0xC0, 0x39, 0xE0, 0x1E, 0xF0, 0x0F,
  0x70, 0x07, 0xB8, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0xF0, 0xE1, 0xDC, 0x38, 0x77, 0x1E, 0x1D, 0xC7, 0x87, 0x71,
  0xE3, 0xDC, 0x6C, 0xF7, 0x1B, 0x39, 0xC6, 0xCE, 0x79, 0xB3, 0x9E, 0x6C,
  0xE3, 0x9B, 0x38, 0xEC, 0xCE, 0x3B, 0x33, 0x8E, 0xCC, 0xE3, 0xB3, 0xB8,
  0xEC, 0x6C, 0x3B, 0x1F, 0x0E, 0xC7, 0xC3, 0xB1, 0xF0, 0xEC, 0x7C, 0x1E,
  0x1F, 0x07, 0x87, 0xC1, 0xE1, 0xF0, 0xF8, 0x0F, 0x3C, 0x07, 0x9F, 0x07,
  0x87, 0x83, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x83,
  0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3E, 0xF0, 0x07, 0xF8, 0x07, 0x9E,
  0x03, 0xCF, 0x03, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x78, 0x07, 0xBC, 0x03, 0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0x81, 0xCF, 0x0F, 0x1C,
  0x38, 0x79, 0xE0, 0xE7, 0x83, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0xDE, 0x0F,
  0x70, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFD, 0xDF, 0xF7, 0x3F, 0x9C, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3F, 0x3D,
  0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0xFF,
  0xDF, 0xEF, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC3, 0xEF,
  0x03, 0xDE, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0xFF, 0x03, 0xCF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFC, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF1, 0xFB,
  0xCF, 0xFF, 0x7F, 0xFD, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1F, 0x7F,
  0xFC, 0xFF, 0xF1, 0xFB, 0xC0, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x3D, 0xE0, 0xF7, 0xFF, 0x8F, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0xBC, 0xFF, 0xF7, 0xFF,
  0xDE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x0F, 0x7C, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xCF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3F,
  0x3D, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0xFF, 0xCF, 0xFC, 0xFF, 0x0F, 0x80, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xEF, 0x7D, 0xFE, 0xFF, 0xDF,
  0xFF, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F,
  0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1,
  0xC7, 0xE3, 0x8E, 0xF3, 0xF3, 0xDF, 0xEF, 0xFF, 0xFE, 0x1F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x0F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x9E, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3D, 0xF1, 0xF7, 0xFF, 0x8F,
  0xFC, 0x0F, 0xE0, 0xF3, 0xF3, 0xDF, 0xEF, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xFD, 0xFE, 0xF3, 0xF3, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0xBC, 0xFF, 0xF7,
  0xFF, 0xDE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xF7, 0xFF, 0xCF, 0xFF,
  0x1F, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0xF7, 0xF3, 0xFF, 0xEF, 0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xF3, 0xC1, 0xE7, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x0F, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0x9F, 0xFF, 0x3F,
  0xFC, 0x1F, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x3D, 0xF1, 0xF7, 0xFF, 0x8F,
  0xFC, 0x0F, 0xE0, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x0E,
  0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0xF1, 0xFC, 0x78, 0xEE, 0x36, 0x77,
  0x9B, 0x39, 0xCD, 0x9C, 0xE6, 0xCE, 0x76, 0x67, 0x3B, 0x37, 0x9D, 0x9B,
  0x8E, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x3C,
  0x3C, 0x00, 0x78, 0x1F, 0x3C, 0x1E, 0x3E, 0x3C, 0x1E, 0x7C, 0x0F, 0x78,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0x78, 0x1E, 0x78, 0x3E, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0xF8, 0x0F,
  0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x07, 0x70,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x03, 0xC3, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x07, 0xFC, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x0F, 0xF0, 0x3F, 0x80, 0xFC,
  0x00, 0x10, 0x00, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x7E, 0x3D, 0xFC, 0x7F,
  0xF8, 0x7F, 0x00, 0x38,
};

const GFXglyph JetBrainsMono_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 11, 10, 19, 4, -23 },
  { 30, 17, 23, 19, 1, -23 },
  { 79, 15, 31, 19, 2, -27 },
  { 138, 19, 23, 19, 0, -23 },
  { 193, 17, 23, 19, 1, -23 },
  { 242, 4, 10, 19, 7, -23 },
  { 247, 10, 30, 19, 5, -26 },
  { 285, 9, 30, 19, 4, -26 },
  { 319, 17, 16, 19, 1, -19 },
  { 353, 15, 15, 19, 2, -18 },
  { 382, 7, 10, 19, 5, -5 },
  { 391, 10, 4, 19, 4, -12 },
  { 396, 6, 5, 19, 6, -5 },
  { 400, 15, 29, 19, 2, -26 },
  { 455, 14, 23, 19, 2, -23 },
  { 496, 14, 23, 19, 3, -23 },
  { 537, 15, 23, 19, 2, -23 },
  { 581, 14, 23, 19, 2, -23 },
  { 622, 14, 23, 19, 2, -23 },
  { 663, 14, 23, 19, 2, -23 },
  { 704, 15, 23, 19, 2, -23 },
  { 748, 15, 23, 19, 2, -23 },
  { 792, 15, 23, 19, 2, -23 },
  { 836, 15, 23, 19, 2, -23 },
  { 880, 6, 17, 19, 6, -17 },
  { 893, 7, 22, 19, 5, -17 },
  { 913, 14, 17, 19, 2, -19 },
  { 943, 13, 11, 19, 3, -16 },
  { 961, 14, 17, 19, 2, -19 },
  { 991, 12, 23, 19, 4, -23 },
  { 1026, 17, 29, 19, 1, -23 },
  { 1088, 17, 23, 19, 1, -23 },
  { 1137, 15, 23, 19, 2, -23 },
  { 1181, 15, 23, 19, 2, -23 },
  { 1225, 15, 23, 19, 2, -23 },
  { 1269, 13, 23, 19, 3, -23 },
  { 1307, 15, 23, 19, 2, -23 },
  { 1351, 15, 23, 19, 2, -23 },
  { 1395, 14, 23, 19, 2, -23 },
  { 1436, 13, 23, 19, 3, -23 },
  { 1474, 15, 23, 19, 1, -23 },
  { 1518, 16, 23, 19, 2, -23 },
  { 1564, 14, 23, 19, 3, -23 },
  { 1605, 15, 23, 19, 2, -23 },
  { 1649, 14, 23, 19, 2, -23 },
  { 1690, 14, 23, 19, 2, -23 },
  { 1731, 15, 23, 19, 2, -23 },
  { 1775, 15, 29, 19, 2, -23 },
  { 1830, 15, 23, 19, 2, -23 },
  { 1874, 15, 23, 19, 2, -23 },
  { 1918, 16, 23, 19, 1, -23 },
  { 1964, 14, 23, 19, 2, -23 },
  { 2005, 17, 23, 19, 1, -23 },
  { 2054, 18, 23, 19, 0, -23 },
  { 2106, 17, 23, 19, 1, -23 },
  { 2155, 17, 23, 19, 1, -23 },
  { 2204, 14, 23, 19, 2, -23 },
  { 2245, 8, 29, 19, 6, -26 },
  { 2274, 15, 29, 19, 2, -26 },
  { 2329, 9, 29, 19, 4, -26 },
  { 2362, 14, 12, 19, 2, -23 },
  { 2383, 15, 3, 19, 2, 1 },
  { 2389, 8, 4, 19, 5, -24 },
  { 2393, 14, 17, 19, 2, -17 },
  { 2423, 14, 23, 19, 2, -23 },
  { 2464, 15, 17, 19, 2, -17 },
  { 2496, 14, 23, 19, 2, -23 },
  { 2537, 14, 17, 19, 2, -17 },
  { 2567, 15, 23, 19, 2, -23 },
  { 2611, 14, 23, 19, 2, -17 },
  { 2652, 14, 23, 19, 2, -23 },
  { 2693, 15, 24, 19, 2, -24 },
  { 2738, 12, 30, 19, 3, -24 },
  { 2783, 16, 23, 19, 2, -23 },
  { 2829, 16, 23, 19, 1, -23 },
  { 2875, 15, 17, 19, 2, -17 },
  { 2907, 14, 17, 19, 2, -17 },
  { 2937, 14, 17, 19, 2, -17 },
  { 2967, 14, 23, 19, 2, -17 },
  { 3008, 14, 23, 19, 2, -17 },
  { 3049, 14, 17, 19, 3, -17 },
  { 3079, 15, 17, 19, 2, -17 },
  { 3111, 15, 22, 19, 1, -22 },
  { 3153, 14, 17, 19, 2, -17 },
  { 3183, 16, 17, 19, 1, -17 },
  { 3217, 17, 17, 19, 1, -17 },
  { 3254, 16, 17, 19, 1, -17 },
  { 3288, 16, 23, 19, 1, -17 },
  { 3334, 14, 17, 19, 2, -17 },
  { 3364, 14, 29, 19, 2, -26 },
  { 3415, 4, 29, 19, 7, -26 },
  { 3430, 14, 29, 19, 2, -26 },
  { 3481, 15, 8, 19, 2, -15 },
};

const GFXfont JetBrainsMono_Bold31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_BOLD31PT7B_H_
