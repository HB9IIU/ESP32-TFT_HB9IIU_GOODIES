#ifndef _JETBRAINSMONO_BOLD16PT7B_H_
#define _JETBRAINSMONO_BOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold16pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x01, 0xF0, 0xCF, 0x3C, 0xF2, 0xC8, 0x19, 0x0C,
  0x84, 0x4F, 0xF7, 0xF9, 0x90, 0xC8, 0x44, 0xFF, 0x93, 0x19, 0x8C, 0x80,
  0x10, 0x10, 0x3C, 0x7E, 0xD6, 0xD1, 0xF0, 0x78, 0x3E, 0x16, 0x13, 0xD3,
  0xFE, 0x7C, 0x10, 0x10, 0x70, 0xF6, 0x6D, 0x93, 0x68, 0xFE, 0x09, 0x00,
  0x80, 0x7E, 0x34, 0x89, 0x24, 0x4B, 0x1E, 0x38, 0x7C, 0x46, 0x40, 0x60,
  0x70, 0xF3, 0xDA, 0xCE, 0xCC, 0xFE, 0x7B, 0xFF, 0xC0, 0x1B, 0xD9, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0xC7, 0x1C, 0x20, 0xC7, 0x0C, 0x71, 0x8C, 0x63,
  0x18, 0xC6, 0x67, 0x72, 0x00, 0x0C, 0x06, 0x13, 0x3F, 0x73, 0xF0, 0xE0,
  0xD8, 0x66, 0x22, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x76, 0x66, 0xC0, 0xFF, 0xC0, 0x7D, 0x80, 0x07, 0x06, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xE0, 0xC0, 0x3C, 0x7E,
  0xC6, 0xC3, 0xC3, 0xDB, 0xDB, 0xC3, 0xC3, 0xC6, 0x7E, 0x7C, 0x18, 0x78,
  0xF8, 0xD8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3C, 0x7E,
  0xC6, 0xC6, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0xFF, 0xFC,
  0x38, 0xE3, 0x07, 0xC1, 0x83, 0x07, 0x8F, 0xFB, 0xE0, 0x0E, 0x18, 0x61,
  0xC3, 0x0C, 0xF9, 0xE3, 0xFF, 0xFC, 0x18, 0x30, 0xFF, 0xFF, 0x06, 0x0D,
  0xDF, 0xF9, 0x83, 0x07, 0x8F, 0xFB, 0xE0, 0x0C, 0x18, 0x38, 0x30, 0x60,
  0x7E, 0xE6, 0xC3, 0xC3, 0xC3, 0xFE, 0x7C, 0xFF, 0xFF, 0xC3, 0xC6, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x70, 0x3C, 0x7E, 0xC6, 0xC6, 0x66,
  0x7C, 0x7C, 0xE6, 0xC3, 0xC7, 0xFE, 0x7C, 0x3C, 0x7E, 0xC6, 0xC3, 0xC3,
  0xC7, 0x7E, 0x26, 0x0C, 0x18, 0x18, 0x30, 0x7D, 0x80, 0x17, 0xE0, 0x37,
  0x30, 0x00, 0x03, 0x76, 0x6C, 0x02, 0x0C, 0x7B, 0xCC, 0x1E, 0x0F, 0x07,
  0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC1, 0xE0, 0xF0, 0x61,
  0xCF, 0x78, 0xC0, 0xF3, 0xE1, 0xC3, 0x0D, 0xF7, 0x98, 0x60, 0x06, 0x18,
  0x3C, 0x7E, 0xC3, 0x83, 0x8D, 0x9B, 0x93, 0x93, 0x93, 0x9B, 0x9D, 0x80,
  0xC0, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x6C, 0x64, 0x66, 0x66, 0xFE,
  0xC6, 0xC3, 0xC3, 0xF8, 0xFE, 0xC6, 0xC7, 0xC6, 0xFC, 0xFE, 0xC7, 0xC3,
  0xC3, 0xFE, 0xFC, 0x3C, 0x7E, 0xC6, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC7, 0x7E, 0x3C, 0xF8, 0xFE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC6, 0xFE, 0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x3C, 0x7E, 0xC6, 0xC3, 0xC0, 0xC0, 0xCF, 0xCF, 0xC3, 0xC7,
  0x7E, 0x3C, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xE3, 0xC7, 0x8F, 0x1E,
  0x30, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0,
  0x1F, 0x1F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x83, 0x63, 0x7F, 0x3E,
  0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xFC, 0xFC, 0xCC, 0xCE, 0xC6, 0xC6, 0xC3,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xC7,
  0xE7, 0xA7, 0xEF, 0xFB, 0xFB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3,
  0xC7, 0x8F, 0x9F, 0x3A, 0x76, 0xED, 0xCB, 0x9F, 0x3E, 0x30, 0x3C, 0xFF,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8D, 0xFB, 0xE0, 0xF8, 0xFE, 0xC7,
  0xC3, 0xC3, 0xC7, 0xFE, 0xF0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xC6,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x7C, 0x0C, 0x06, 0x07,
  0xF8, 0xFE, 0xC7, 0xC3, 0xC3, 0xC6, 0xFE, 0xCC, 0xCC, 0xC6, 0xC6, 0xC7,
  0x3C, 0x7E, 0xC6, 0xC1, 0xE0, 0x78, 0x3E, 0x06, 0x03, 0xC3, 0xFE, 0x7C,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8D, 0xFB, 0xE0, 0xC3,
  0xC3, 0xC2, 0xC6, 0x66, 0x66, 0x64, 0x6C, 0x3C, 0x3C, 0x38, 0x38, 0xCC,
  0xE6, 0x73, 0x69, 0xB5, 0xDA, 0xAD, 0xD6, 0xEB, 0x73, 0x39, 0x9C, 0xCE,
  0x60, 0x61, 0xB1, 0x8C, 0xC6, 0xC1, 0xE0, 0xE0, 0x70, 0x3C, 0x36, 0x19,
  0x98, 0xDC, 0x30, 0xE1, 0xB0, 0xD8, 0xC6, 0x63, 0x60, 0xF0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFC, 0x18, 0x60, 0xC3, 0x0E, 0x18,
  0x60, 0xC3, 0xFF, 0xF0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0,
  0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x06, 0x06, 0x07, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF,
  0xE0, 0x18, 0x38, 0x3C, 0x6C, 0x66, 0x46, 0xC3, 0xFF, 0xFF, 0xCE, 0x70,
  0x3C, 0xFF, 0x18, 0x37, 0xF8, 0xF1, 0xF7, 0x7E, 0xC1, 0x83, 0x06, 0xEF,
  0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0xFE, 0xE0, 0x3C, 0x7E, 0xC7, 0xC0, 0xC0,
  0xC0, 0xC7, 0x7E, 0x7C, 0x06, 0x0C, 0x1B, 0xF7, 0xF8, 0xF1, 0xE3, 0xC7,
  0x8F, 0xFB, 0xF0, 0x3C, 0xFF, 0x1E, 0x1F, 0xF8, 0x30, 0x33, 0x7C, 0x0F,
  0x1F, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x7E,
  0xFF, 0x1E, 0x3C, 0x78, 0xF9, 0xBF, 0x06, 0x0D, 0xFB, 0xE0, 0xC1, 0x83,
  0x06, 0xEF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0x08, 0x18, 0x18,
  0x00, 0x78, 0x78, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x04, 0x1C,
  0x30, 0x07, 0xCF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xBF, 0x7C,
  0xC0, 0xC0, 0xC0, 0xC3, 0xC6, 0xCE, 0xCC, 0xF8, 0xCC, 0xCE, 0xC6, 0xC3,
  0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03,
  0xE1, 0xF0, 0xB6, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDD,
  0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x3C, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xBF, 0x7C, 0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0xDD, 0x83,
  0x06, 0x00, 0x7E, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x7E, 0x0C, 0x18,
  0x30, 0xDE, 0xDE, 0xE3, 0xE3, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x7C, 0x7E,
  0xC0, 0xE0, 0x7E, 0x06, 0x03, 0xE6, 0x7E, 0x30, 0x63, 0xFF, 0xF3, 0x06,
  0x0C, 0x18, 0x30, 0x7C, 0x78, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xBF,
  0x7C, 0xC3, 0xC3, 0xC6, 0x66, 0x66, 0x6C, 0x3C, 0x3C, 0x38, 0xCC, 0xA6,
  0xD3, 0x69, 0xB7, 0x5B, 0xA9, 0xDC, 0xE6, 0x33, 0x00, 0xC7, 0x66, 0x6C,
  0x3C, 0x18, 0x3C, 0x6C, 0x66, 0xC7, 0xC3, 0xC7, 0x66, 0x66, 0x6C, 0x3C,
  0x3C, 0x38, 0x18, 0x18, 0x30, 0x30, 0xFF, 0xFC, 0x38, 0xE1, 0x86, 0x18,
  0x7F, 0xFE, 0x0E, 0x3C, 0x60, 0xC1, 0x83, 0x3E, 0x7C, 0x18, 0x30, 0x60,
  0xC1, 0xC1, 0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE0, 0xC1, 0x83,
  0x06, 0x0F, 0x8F, 0x30, 0x60, 0xC1, 0x83, 0x1E, 0x38, 0x00, 0x20, 0xF3,
  0xDB, 0xCE,
};

const GFXglyph JetBrainsMono_Bold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 6, 5, 10, 2, -12 },
  { 10, 9, 12, 10, 0, -12 },
  { 24, 8, 16, 10, 1, -14 },
  { 40, 10, 12, 10, 0, -12 },
  { 55, 8, 12, 10, 1, -12 },
  { 67, 2, 5, 10, 4, -12 },
  { 69, 5, 15, 10, 3, -13 },
  { 79, 5, 15, 10, 2, -13 },
  { 89, 9, 9, 10, 0, -10 },
  { 100, 8, 8, 10, 1, -9 },
  { 108, 4, 5, 10, 2, -2 },
  { 111, 5, 2, 10, 2, -6 },
  { 113, 3, 3, 10, 3, -3 },
  { 115, 8, 15, 10, 1, -13 },
  { 130, 8, 12, 10, 1, -12 },
  { 142, 8, 12, 10, 1, -12 },
  { 154, 8, 12, 10, 1, -12 },
  { 166, 7, 12, 10, 1, -12 },
  { 177, 7, 12, 10, 1, -12 },
  { 188, 7, 12, 10, 1, -12 },
  { 199, 8, 12, 10, 1, -12 },
  { 211, 8, 12, 10, 1, -12 },
  { 223, 8, 12, 10, 1, -12 },
  { 235, 8, 12, 10, 1, -12 },
  { 247, 3, 9, 10, 3, -9 },
  { 251, 4, 12, 10, 2, -9 },
  { 257, 7, 9, 10, 1, -10 },
  { 265, 7, 6, 10, 1, -8 },
  { 271, 7, 9, 10, 1, -10 },
  { 279, 6, 12, 10, 2, -12 },
  { 288, 8, 15, 10, 1, -12 },
  { 303, 8, 12, 10, 1, -12 },
  { 315, 8, 12, 10, 1, -12 },
  { 327, 8, 12, 10, 1, -12 },
  { 339, 8, 12, 10, 1, -12 },
  { 351, 7, 12, 10, 1, -12 },
  { 362, 8, 12, 10, 1, -12 },
  { 374, 8, 12, 10, 1, -12 },
  { 386, 7, 12, 10, 1, -12 },
  { 397, 7, 12, 10, 1, -12 },
  { 408, 8, 12, 10, 0, -12 },
  { 420, 8, 12, 10, 1, -12 },
  { 432, 7, 12, 10, 2, -12 },
  { 443, 8, 12, 10, 1, -12 },
  { 455, 7, 12, 10, 1, -12 },
  { 466, 7, 12, 10, 1, -12 },
  { 477, 8, 12, 10, 1, -12 },
  { 489, 8, 15, 10, 1, -12 },
  { 504, 8, 12, 10, 1, -12 },
  { 516, 8, 12, 10, 1, -12 },
  { 528, 8, 12, 10, 1, -12 },
  { 540, 7, 12, 10, 1, -12 },
  { 551, 8, 12, 10, 1, -12 },
  { 563, 9, 12, 10, 0, -12 },
  { 577, 9, 12, 10, 0, -12 },
  { 591, 9, 12, 10, 0, -12 },
  { 605, 7, 12, 10, 1, -12 },
  { 616, 4, 15, 10, 3, -13 },
  { 624, 8, 15, 10, 1, -13 },
  { 639, 5, 15, 10, 2, -13 },
  { 649, 8, 7, 10, 1, -12 },
  { 656, 8, 2, 10, 1, 0 },
  { 658, 4, 3, 10, 3, -13 },
  { 660, 7, 9, 10, 1, -9 },
  { 668, 7, 12, 10, 1, -12 },
  { 679, 8, 9, 10, 1, -9 },
  { 688, 7, 12, 10, 1, -12 },
  { 699, 7, 9, 10, 1, -9 },
  { 707, 8, 12, 10, 1, -12 },
  { 719, 7, 12, 10, 1, -9 },
  { 730, 7, 12, 10, 1, -12 },
  { 741, 8, 13, 10, 1, -13 },
  { 754, 7, 16, 10, 1, -13 },
  { 768, 8, 12, 10, 1, -12 },
  { 780, 9, 12, 10, 0, -12 },
  { 794, 8, 9, 10, 1, -9 },
  { 803, 7, 9, 10, 1, -9 },
  { 811, 7, 9, 10, 1, -9 },
  { 819, 7, 12, 10, 1, -9 },
  { 830, 7, 12, 10, 1, -9 },
  { 841, 8, 9, 10, 1, -9 },
  { 850, 8, 9, 10, 1, -9 },
  { 859, 7, 11, 10, 1, -11 },
  { 869, 7, 9, 10, 1, -9 },
  { 877, 8, 9, 10, 1, -9 },
  { 886, 9, 9, 10, 0, -9 },
  { 897, 8, 9, 10, 1, -9 },
  { 906, 8, 12, 10, 1, -9 },
  { 918, 7, 9, 10, 1, -9 },
  { 926, 7, 15, 10, 1, -13 },
  { 940, 2, 15, 10, 4, -13 },
  { 944, 7, 15, 10, 1, -13 },
  { 958, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_Bold16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_BOLD16PT7B_H_
