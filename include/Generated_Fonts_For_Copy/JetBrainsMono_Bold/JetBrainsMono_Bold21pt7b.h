#ifndef _JETBRAINSMONO_BOLD21PT7B_H_
#define _JETBRAINSMONO_BOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0xD8, 0x0D, 0xF8, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8,
  0xC0, 0x18, 0xC3, 0x18, 0x63, 0x7F, 0xFF, 0xFE, 0x63, 0x0C, 0x61, 0x8C,
  0x31, 0x1F, 0xFB, 0xFF, 0x31, 0x86, 0x30, 0xC6, 0x19, 0x80, 0x04, 0x01,
  0x00, 0x40, 0xFE, 0x7F, 0xD9, 0x76, 0x4D, 0x90, 0x74, 0x1F, 0x83, 0xF8,
  0x1F, 0x05, 0xC1, 0x3E, 0x4F, 0xD7, 0x7F, 0x8F, 0xC0, 0x40, 0x10, 0x04,
  0x00, 0x7C, 0x3E, 0x63, 0x31, 0x19, 0x89, 0x8C, 0xD8, 0x3E, 0xC0, 0xCC,
  0x00, 0xC0, 0x04, 0xE0, 0x6F, 0x86, 0xCC, 0x66, 0x63, 0x33, 0x31, 0xFB,
  0x07, 0x80, 0x0C, 0x07, 0xE1, 0xFE, 0x38, 0xC6, 0x00, 0xE0, 0x0C, 0x03,
  0xC0, 0xFC, 0xFD, 0x9B, 0x1F, 0x63, 0xCC, 0x39, 0xC7, 0x3F, 0xF3, 0xE7,
  0xFF, 0xFD, 0x80, 0x02, 0x1C, 0x79, 0xE3, 0x8E, 0x18, 0x30, 0xE1, 0xC3,
  0x87, 0x06, 0x0C, 0x18, 0x38, 0x38, 0x78, 0x78, 0x30, 0x20, 0x81, 0xC3,
  0xC1, 0xC1, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x1C, 0x73, 0xC7, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x66, 0x6F, 0x5E,
  0xFF, 0x83, 0x00, 0xD8, 0x3B, 0x8E, 0x78, 0x86, 0x00, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x3B, 0x9C,
  0xE6, 0x70, 0xFF, 0xFC, 0x6F, 0xF7, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x00, 0x0C, 0x0F, 0xE7, 0xF9, 0x87, 0xE0,
  0xF8, 0x3E, 0x0F, 0xB3, 0xEE, 0xF9, 0x3E, 0x0F, 0x83, 0xE0, 0xDC, 0x77,
  0xF8, 0xFC, 0x3C, 0x1F, 0x0E, 0xC3, 0x30, 0x8C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x0C, 0x0F, 0xE7,
  0xF9, 0x87, 0xE1, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x07, 0xFD, 0xFF, 0x7F, 0xDF, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x81, 0xF8, 0x0F, 0x01, 0xC0, 0x70, 0x1F, 0x87, 0x71, 0xDF, 0xE3, 0xF0,
  0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x9D, 0xC7, 0xE1, 0xF8,
  0x7F, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x7F, 0xDF, 0xF6, 0x01, 0x80,
  0x60, 0x1B, 0xC7, 0xF9, 0xC7, 0x01, 0xC0, 0x70, 0x1F, 0x87, 0x71, 0xDF,
  0xE3, 0xF0, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0xF9, 0xFF,
  0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0x71, 0xDF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0x87, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0x0C, 0x0F, 0xE7, 0xF9, 0x87, 0x61, 0xD8, 0x77,
  0x38, 0xFC, 0x3F, 0x1C, 0xE6, 0x1F, 0x83, 0xE0, 0xDC, 0x77, 0xF8, 0xFC,
  0x0C, 0x0F, 0xE7, 0xFF, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0xC7, 0x7F, 0xCF,
  0x60, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x6F, 0xF6, 0x00, 0x00,
  0x07, 0xF7, 0x33, 0xDE, 0x60, 0x00, 0x00, 0x01, 0xCE, 0xE7, 0x33, 0x80,
  0x00, 0x80, 0xC3, 0xE7, 0xCF, 0x87, 0x03, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xE0, 0x10, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x60, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0E, 0x1F, 0x3E, 0x7C, 0x30, 0x10,
  0x00, 0xFC, 0xFE, 0x0E, 0x07, 0x07, 0x06, 0x7E, 0x7C, 0x70, 0x60, 0x00,
  0x00, 0x60, 0xF0, 0x70, 0x04, 0x07, 0xF1, 0xC7, 0x70, 0x7C, 0x07, 0x80,
  0xF1, 0xDE, 0x77, 0xCC, 0x79, 0x8F, 0x31, 0xE6, 0x3C, 0xC7, 0x9F, 0xF1,
  0xDE, 0x00, 0xE0, 0x0E, 0x00, 0xF8, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x7C,
  0x0D, 0x83, 0xB0, 0x76, 0x0C, 0xE1, 0x9C, 0x71, 0x8F, 0xF1, 0xFF, 0x30,
  0xEE, 0x0D, 0xC1, 0xB8, 0x38, 0xFF, 0x3F, 0xEC, 0x3B, 0x06, 0xC3, 0xB0,
  0xEF, 0xF3, 0xFC, 0xC3, 0xB0, 0x6C, 0x1F, 0x06, 0xC3, 0xBF, 0xCF, 0xE0,
  0x08, 0x3F, 0xBF, 0xFC, 0x7C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x1F, 0x1F, 0xFC, 0x7C, 0xFE, 0x7F, 0xB0, 0xF8, 0x7C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x7F, 0xFB, 0xF8, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x08, 0x3F, 0xBF,
  0xFC, 0x7C, 0x1E, 0x03, 0x01, 0x80, 0xCF, 0xE7, 0xF0, 0x78, 0x3C, 0x1F,
  0x1F, 0xFC, 0x7C, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0E, 0xFF, 0xFF, 0xC7, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF,
  0xFE, 0x0F, 0xC3, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x7C, 0x1F, 0x07, 0xE3, 0x9F, 0xE3, 0xF0, 0xC1, 0xF0, 0xEC, 0x33,
  0x1C, 0xC7, 0x33, 0x8F, 0xE3, 0xF8, 0xCE, 0x31, 0x8C, 0x73, 0x1C, 0xC3,
  0xB0, 0xEC, 0x1C, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xF1, 0xFC, 0x5F, 0x3F,
  0x4F, 0xDB, 0xF6, 0xBC, 0xEF, 0xBB, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0C, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x1E, 0xCF, 0x67, 0xB3,
  0xCD, 0xE6, 0xF3, 0x78, 0xFC, 0x7E, 0x3F, 0x0E, 0x18, 0x3F, 0xBF, 0xDC,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F,
  0xFC, 0xFC, 0xFF, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x3B, 0xFE,
  0xFE, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x04, 0x0F, 0xE7,
  0xF9, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE1, 0xDC, 0x77, 0xF8, 0xFC, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0xFF, 0x3F,
  0xEC, 0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x7B, 0xFC, 0xFE, 0x33, 0x8C, 0x73,
  0x1C, 0xC3, 0xB0, 0xEC, 0x1C, 0x0C, 0x0F, 0xE7, 0xFD, 0x87, 0x60, 0xD8,
  0x07, 0x01, 0xF8, 0x3F, 0x81, 0xF0, 0x1C, 0x03, 0xE0, 0xFC, 0x77, 0xFC,
  0xFC, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E,
  0x3F, 0xF9, 0xF8, 0xE0, 0xFC, 0x1B, 0x83, 0x30, 0xE7, 0x1C, 0xE3, 0x1C,
  0x61, 0x9C, 0x3B, 0x87, 0x60, 0xEC, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xE7, 0x36, 0x73, 0x67, 0x36, 0x73, 0x65, 0x36, 0x53, 0x6D, 0x76, 0xD6,
  0x6D, 0x66, 0x9E, 0x79, 0xE3, 0x9E, 0x39, 0xE3, 0x8E, 0x38, 0xE0, 0xE1,
  0xEE, 0x39, 0xCE, 0x1D, 0xC3, 0xF0, 0x3E, 0x07, 0x80, 0x70, 0x1F, 0x03,
  0xE0, 0xEE, 0x39, 0xC7, 0x1D, 0xC3, 0xB8, 0x38, 0xF0, 0x77, 0x06, 0x38,
  0xE3, 0x8C, 0x19, 0xC1, 0xD8, 0x0D, 0x80, 0xF8, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xFF, 0xFE,
  0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0xFF, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x0E, 0x07, 0x81, 0xB0, 0xEC, 0x33,
  0x9C, 0x66, 0x1F, 0x83, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0x0E, 0x0F, 0xE7,
  0xBD, 0x87, 0x01, 0xCF, 0xF7, 0xFF, 0x87, 0xE1, 0xF8, 0x77, 0xFC, 0xF7,
  0xC0, 0x60, 0x30, 0x19, 0xCD, 0xF7, 0xFF, 0x8F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7E, 0x3F, 0xFB, 0x7C, 0x0E, 0x0F, 0xE7, 0xFD, 0x87, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x60, 0xDC, 0x77, 0xF8, 0x7C, 0x01, 0xC0, 0x70, 0x1C,
  0x77, 0x7F, 0xDF, 0xF6, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x87, 0x71,
  0xDF, 0xF3, 0xDC, 0x1E, 0x0F, 0xE7, 0x3D, 0x87, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0x60, 0x1C, 0x77, 0xF8, 0x7C, 0x0F, 0xC3, 0xF1, 0xC0, 0x70, 0x1C,
  0x3F, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x3B, 0xBF, 0xFF, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xFF,
  0xDF, 0xE0, 0x70, 0x38, 0x3D, 0xFC, 0xFC, 0xC0, 0x60, 0x30, 0x19, 0xCD,
  0xF7, 0xFF, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0E,
  0x08, 0x07, 0x01, 0xC0, 0x20, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x02, 0x07,
  0x0F, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0xFE, 0xFC, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x07,
  0xC3, 0xB0, 0xEC, 0x73, 0x38, 0xFE, 0x3F, 0x8C, 0xE3, 0x1C, 0xC7, 0x30,
  0xEC, 0x1C, 0xFC, 0x1F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1F, 0xC1, 0xF8, 0xD9,
  0x9F, 0xFB, 0xB3, 0x66, 0x7C, 0xCF, 0x99, 0xF3, 0x3E, 0x67, 0xCC, 0xF9,
  0x9F, 0x33, 0xE6, 0x70, 0xCE, 0x6F, 0xBF, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x70, 0x0E, 0x0F, 0xE7, 0xFD, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x61, 0xDC, 0x77, 0xF8, 0x7C, 0xCE, 0x6F, 0xBF,
  0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xFF, 0xDB, 0xEC, 0x06,
  0x03, 0x01, 0x80, 0x3B, 0xBF, 0xFF, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xF1, 0xFF, 0xEF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xCE, 0x37, 0xEF,
  0x7B, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x1F, 0x1F, 0xE7, 0x1D, 0x80, 0x70, 0x1F, 0xC3, 0xFC, 0x07, 0x00, 0xF8,
  0x77, 0xFC, 0xFE, 0x1C, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xF0, 0x7C, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xFF, 0xC7, 0xC0,
  0xE0, 0xFC, 0x1B, 0x87, 0x30, 0xE7, 0x18, 0xE3, 0x0C, 0xE1, 0xD8, 0x3B,
  0x03, 0xE0, 0x78, 0x0F, 0x00, 0xE6, 0x36, 0x63, 0x67, 0x36, 0x73, 0x65,
  0x76, 0x56, 0x6D, 0x67, 0xD6, 0x39, 0xE3, 0x9E, 0x39, 0xE3, 0x8C, 0xE0,
  0xEE, 0x39, 0xCE, 0x1D, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x3B, 0x0E,
  0x71, 0xC7, 0x70, 0x70, 0xE0, 0xFC, 0x19, 0x87, 0x38, 0xE7, 0x18, 0x77,
  0x0E, 0xE0, 0xD8, 0x1F, 0x03, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70,
  0x70, 0x3F, 0xFF, 0xF0, 0x07, 0x87, 0xC3, 0x81, 0x80, 0xC0, 0x60, 0x38,
  0x18, 0xFC, 0x7C, 0x3F, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07,
  0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x7C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1F, 0x87, 0xC7, 0xE7, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x7C, 0x3C, 0x00, 0x78, 0x1F, 0x9F, 0x3B,
  0xE3, 0xEC, 0x38,
};

const GFXglyph JetBrainsMono_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 7, 6, 13, 3, -15 },
  { 13, 11, 15, 13, 1, -15 },
  { 34, 10, 21, 13, 1, -18 },
  { 61, 13, 15, 13, 0, -15 },
  { 86, 11, 16, 13, 1, -16 },
  { 108, 3, 6, 13, 5, -15 },
  { 111, 7, 21, 13, 3, -18 },
  { 130, 7, 21, 13, 2, -18 },
  { 149, 11, 11, 13, 1, -13 },
  { 165, 10, 10, 13, 1, -12 },
  { 178, 5, 6, 13, 3, -3 },
  { 182, 7, 2, 13, 3, -8 },
  { 184, 4, 4, 13, 4, -4 },
  { 186, 10, 19, 13, 1, -17 },
  { 210, 10, 16, 13, 1, -16 },
  { 230, 10, 15, 13, 2, -15 },
  { 249, 10, 16, 13, 1, -16 },
  { 269, 10, 15, 13, 1, -15 },
  { 288, 10, 15, 13, 1, -15 },
  { 307, 10, 15, 13, 1, -15 },
  { 326, 10, 15, 13, 1, -15 },
  { 345, 10, 15, 13, 1, -15 },
  { 364, 10, 16, 13, 1, -16 },
  { 384, 10, 16, 13, 1, -16 },
  { 404, 4, 12, 13, 4, -12 },
  { 410, 5, 15, 13, 3, -12 },
  { 420, 9, 12, 13, 2, -13 },
  { 434, 9, 8, 13, 2, -11 },
  { 443, 9, 12, 13, 2, -13 },
  { 457, 8, 15, 13, 3, -15 },
  { 472, 11, 20, 13, 1, -16 },
  { 500, 11, 15, 13, 1, -15 },
  { 521, 10, 15, 13, 2, -15 },
  { 540, 9, 16, 13, 2, -16 },
  { 558, 9, 15, 13, 2, -15 },
  { 575, 9, 15, 13, 2, -15 },
  { 592, 9, 15, 13, 2, -15 },
  { 609, 9, 16, 13, 2, -16 },
  { 627, 9, 15, 13, 2, -15 },
  { 644, 9, 15, 13, 2, -15 },
  { 661, 10, 15, 13, 1, -15 },
  { 680, 10, 15, 13, 2, -15 },
  { 699, 9, 15, 13, 2, -15 },
  { 716, 10, 15, 13, 1, -15 },
  { 735, 9, 15, 13, 2, -15 },
  { 752, 9, 16, 13, 2, -16 },
  { 770, 10, 15, 13, 2, -15 },
  { 789, 10, 20, 13, 1, -16 },
  { 814, 10, 15, 13, 2, -15 },
  { 833, 10, 16, 13, 1, -16 },
  { 853, 11, 15, 13, 1, -15 },
  { 874, 9, 15, 13, 2, -15 },
  { 891, 11, 15, 13, 1, -15 },
  { 912, 12, 15, 13, 0, -15 },
  { 935, 11, 15, 13, 1, -15 },
  { 956, 12, 15, 13, 0, -15 },
  { 979, 9, 15, 13, 2, -15 },
  { 996, 6, 19, 13, 4, -17 },
  { 1011, 10, 19, 13, 1, -17 },
  { 1035, 6, 19, 13, 3, -17 },
  { 1050, 10, 8, 13, 1, -15 },
  { 1060, 10, 2, 13, 1, 1 },
  { 1063, 6, 2, 13, 3, -16 },
  { 1065, 10, 12, 13, 1, -12 },
  { 1080, 9, 15, 13, 2, -15 },
  { 1097, 10, 12, 13, 1, -12 },
  { 1112, 10, 15, 13, 1, -15 },
  { 1131, 10, 12, 13, 1, -12 },
  { 1146, 10, 15, 13, 1, -15 },
  { 1165, 9, 16, 13, 2, -12 },
  { 1183, 9, 15, 13, 2, -15 },
  { 1200, 10, 17, 13, 2, -17 },
  { 1222, 8, 21, 13, 2, -17 },
  { 1243, 10, 15, 13, 2, -15 },
  { 1262, 11, 15, 13, 1, -15 },
  { 1283, 11, 12, 13, 1, -12 },
  { 1300, 9, 12, 13, 2, -12 },
  { 1314, 10, 12, 13, 1, -12 },
  { 1329, 9, 16, 13, 2, -12 },
  { 1347, 9, 16, 13, 2, -12 },
  { 1365, 10, 12, 13, 2, -12 },
  { 1380, 10, 12, 13, 1, -12 },
  { 1395, 10, 15, 13, 1, -15 },
  { 1414, 9, 12, 13, 2, -12 },
  { 1428, 11, 12, 13, 1, -12 },
  { 1445, 12, 12, 13, 0, -12 },
  { 1463, 11, 12, 13, 1, -12 },
  { 1480, 11, 16, 13, 1, -12 },
  { 1502, 9, 12, 13, 2, -12 },
  { 1516, 9, 19, 13, 2, -17 },
  { 1538, 3, 19, 13, 5, -17 },
  { 1546, 9, 19, 13, 2, -17 },
  { 1568, 11, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_Bold21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_BOLD21PT7B_H_
