#ifndef _NOTOSANS_BLACK12PT7B_H_
#define _NOTOSANS_BLACK12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black12pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0xC3, 0xE0, 0xFE, 0xB5, 0xA0, 0x16, 0x16, 0x34, 0x7F,
  0x3C, 0xFE, 0xFE, 0x6C, 0x68, 0x10, 0xFB, 0xD7, 0x87, 0xC3, 0xE5, 0xFE,
  0x78, 0x20, 0x61, 0x9E, 0x23, 0x6C, 0x6F, 0x07, 0x7E, 0xDB, 0xC3, 0x78,
  0xCF, 0x31, 0xC0, 0x18, 0x1F, 0x06, 0x61, 0xF0, 0x39, 0x9F, 0xEE, 0xF1,
  0xFC, 0x7F, 0xC0, 0xFF, 0x36, 0x66, 0xEC, 0xC6, 0x66, 0x30, 0xC6, 0x63,
  0x33, 0x33, 0x66, 0xE0, 0x32, 0x5F, 0xCE, 0x7C, 0xA0, 0x21, 0x3F, 0xF2,
  0x10, 0x6D, 0x60, 0xFF, 0x7C, 0x18, 0xCC, 0x63, 0x31, 0x8C, 0xC0, 0x38,
  0xF9, 0xB7, 0x7E, 0xFD, 0xDB, 0x3E, 0x38, 0x1C, 0xFF, 0xDF, 0x1C, 0x71,
  0xC7, 0x1C, 0x39, 0xF9, 0x30, 0x61, 0xC7, 0x1C, 0x7F, 0xFE, 0x39, 0xF9,
  0x30, 0x63, 0x03, 0x83, 0xFE, 0xF8, 0x0C, 0x38, 0xF1, 0xE6, 0xD9, 0xBF,
  0x86, 0x0C, 0xFF, 0xF1, 0xEF, 0x8C, 0x7F, 0xF0, 0x1C, 0x79, 0x83, 0xCF,
  0xDD, 0xDB, 0xBE, 0x3C, 0xFF, 0xFC, 0x30, 0x61, 0xC3, 0x0E, 0x18, 0x70,
  0x38, 0xF9, 0xB3, 0xE3, 0x8F, 0xBB, 0xBF, 0x7C, 0x38, 0xFB, 0xB7, 0x77,
  0xEE, 0xC3, 0x3E, 0x78, 0x7D, 0x00, 0xF8, 0x6D, 0x00, 0xDA, 0xC0, 0x08,
  0xDF, 0x8F, 0x1C, 0x20, 0xF8, 0x3F, 0xF0, 0x86, 0x3C, 0x37, 0xF2, 0x00,
  0x33, 0xF8, 0xC7, 0x38, 0xC0, 0x0C, 0x70, 0x0E, 0x0F, 0xE6, 0x4D, 0x7D,
  0x5B, 0x74, 0xD5, 0xFD, 0xB6, 0x33, 0x07, 0xC0, 0x1C, 0x1E, 0x0D, 0x86,
  0xC7, 0x63, 0xF9, 0xFD, 0xC6, 0xE3, 0x80, 0xF1, 0xFB, 0x36, 0x6F, 0x99,
  0xB3, 0xFE, 0xF8, 0x39, 0xFE, 0x70, 0xC3, 0x0C, 0x3F, 0x7C, 0xF1, 0xFB,
  0x3E, 0x3C, 0x78, 0xF3, 0xFE, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF, 0x1F, 0xF8,
  0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC0, 0x1C, 0xFF, 0x96, 0x0D, 0xFB, 0xF1,
  0xFF, 0x7E, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC6, 0xFF, 0xDC,
  0xE7, 0x39, 0xCE, 0xF8, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFC, 0xC7, 0x9F,
  0x76, 0xCF, 0x9F, 0x37, 0x66, 0xCE, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F,
  0xFC, 0xE1, 0xF8, 0xFF, 0x3F, 0xCB, 0xF6, 0xF5, 0xBD, 0xEF, 0x73, 0xCC,
  0xC0, 0xE3, 0xF3, 0xF3, 0xFB, 0xDB, 0xDF, 0xCF, 0xCF, 0xC7, 0x38, 0x7E,
  0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFE, 0x7C, 0xF3, 0xFC, 0xF3, 0xFF, 0xEC,
  0x30, 0xC0, 0x38, 0x7E, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFE, 0x7C, 0x0E,
  0x07, 0xF1, 0xFB, 0x36, 0x6F, 0xDF, 0x37, 0x66, 0xCE, 0x77, 0xEC, 0xB8,
  0xF8, 0xE1, 0xFE, 0xF0, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x7C, 0xE3, 0xE7, 0x67, 0x66,
  0x76, 0x3E, 0x3C, 0x3C, 0x1C, 0xC6, 0x3E, 0x73, 0x67, 0x36, 0xF7, 0x6F,
  0x67, 0xD6, 0x3D, 0xE3, 0x9E, 0x39, 0xC0, 0xE3, 0x33, 0x8D, 0x87, 0xC1,
  0xC1, 0xE0, 0xF8, 0xEE, 0xE3, 0x80, 0xE7, 0x66, 0x6E, 0x3C, 0x3C, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0xE1, 0x86, 0x1C, 0x7F, 0xFE, 0xFF,
  0x6D, 0xB6, 0xDB, 0x80, 0xC6, 0x18, 0xC3, 0x18, 0xC3, 0x18, 0xFD, 0xB6,
  0xDB, 0x6F, 0x80, 0x30, 0xC3, 0x9E, 0x4F, 0x30, 0xFC, 0xF0, 0xC0, 0x38,
  0xF8, 0x3B, 0xFE, 0xFF, 0xDD, 0x80, 0xC3, 0x0D, 0xBF, 0xCF, 0x3C, 0xFF,
  0xF8, 0x3D, 0xF6, 0x38, 0x61, 0xF3, 0xC0, 0x06, 0x0C, 0xDB, 0xF6, 0x7C,
  0xD9, 0xBF, 0x76, 0x38, 0xF9, 0x9F, 0xF6, 0x0F, 0x8F, 0x00, 0x3B, 0xDF,
  0xF6, 0x31, 0x8C, 0x60, 0x36, 0xFD, 0x9F, 0x36, 0x6F, 0xDD, 0x83, 0x7E,
  0xF0, 0xC3, 0x0D, 0xBF, 0xCF, 0x3C, 0xF3, 0xCC, 0xFF, 0xFF, 0xC0, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xFE, 0xC1, 0x83, 0x3E, 0xED, 0x9F, 0x3E, 0x6E,
  0xCE, 0xFF, 0xFF, 0xC0, 0xD9, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C,
  0xCC, 0xDB, 0xFC, 0xF3, 0xCF, 0x3C, 0xC0, 0x38, 0xFD, 0x9F, 0x36, 0x6F,
  0xCF, 0x00, 0xDB, 0xFC, 0xF3, 0xCF, 0xFF, 0xB0, 0xC3, 0x00, 0x36, 0xFD,
  0x9F, 0x36, 0x6F, 0xDD, 0x83, 0x06, 0x0C, 0xDF, 0xB9, 0x8C, 0x63, 0x00,
  0x3D, 0xEE, 0x1E, 0x1D, 0xF7, 0x80, 0x23, 0xFE, 0xC6, 0x31, 0xE7, 0xCF,
  0x3C, 0xF3, 0xCF, 0xFF, 0xC0, 0xC7, 0xCD, 0xBB, 0x63, 0xC7, 0x0E, 0x00,
  0xCE, 0x7D, 0xD9, 0xAB, 0x35, 0x67, 0xBC, 0x77, 0x0C, 0xE0, 0xE6, 0x6E,
  0x3C, 0x38, 0x3C, 0x6E, 0xE7, 0xC7, 0xCD, 0xBB, 0x63, 0xC7, 0x0E, 0x1C,
  0x70, 0xC0, 0xFF, 0xF1, 0x8C, 0x73, 0xFF, 0xC0, 0x19, 0xCC, 0x67, 0x73,
  0xC6, 0x31, 0xCE, 0xFF, 0xFF, 0xFF, 0xC7, 0x18, 0xC3, 0x1C, 0xEC, 0x67,
  0x38, 0xFD, 0xC0,
};

const GFXglyph NotoSans_Black12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 5, 4, 6, 1, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 7, 10, 7, 0, -9 },
  { 26, 11, 9, 11, 0, -9 },
  { 39, 10, 9, 10, 0, -9 },
  { 51, 2, 4, 4, 1, -9 },
  { 52, 4, 11, 4, 0, -9 },
  { 58, 4, 11, 4, 0, -9 },
  { 64, 6, 6, 6, 0, -9 },
  { 69, 5, 6, 7, 1, -7 },
  { 73, 3, 4, 4, 0, -2 },
  { 75, 4, 2, 4, 0, -4 },
  { 76, 3, 2, 3, 0, -2 },
  { 77, 5, 9, 5, 0, -9 },
  { 83, 7, 9, 7, 0, -9 },
  { 91, 6, 9, 7, 0, -9 },
  { 98, 7, 9, 7, 0, -9 },
  { 106, 7, 9, 7, 0, -9 },
  { 114, 7, 9, 7, 0, -9 },
  { 122, 5, 9, 7, 1, -9 },
  { 128, 7, 9, 7, 0, -9 },
  { 136, 7, 9, 7, 0, -9 },
  { 144, 7, 9, 7, 0, -9 },
  { 152, 7, 9, 7, 0, -9 },
  { 160, 3, 7, 3, 0, -7 },
  { 163, 3, 9, 4, 0, -7 },
  { 167, 5, 7, 7, 1, -8 },
  { 172, 5, 4, 7, 1, -6 },
  { 175, 5, 7, 7, 1, -8 },
  { 180, 6, 9, 6, 0, -9 },
  { 187, 10, 10, 11, 0, -9 },
  { 200, 9, 9, 9, 0, -9 },
  { 211, 7, 9, 8, 1, -9 },
  { 219, 6, 9, 8, 1, -9 },
  { 226, 7, 9, 9, 1, -9 },
  { 234, 5, 9, 7, 1, -9 },
  { 240, 5, 9, 6, 1, -9 },
  { 246, 7, 9, 9, 1, -9 },
  { 254, 7, 9, 9, 1, -9 },
  { 262, 5, 9, 5, 0, -9 },
  { 268, 4, 12, 4, -1, -9 },
  { 274, 7, 9, 8, 1, -9 },
  { 282, 6, 9, 7, 1, -9 },
  { 289, 10, 9, 12, 1, -9 },
  { 301, 8, 9, 10, 1, -9 },
  { 310, 8, 9, 10, 1, -9 },
  { 319, 6, 9, 8, 1, -9 },
  { 326, 8, 11, 10, 1, -9 },
  { 337, 7, 9, 8, 1, -9 },
  { 345, 6, 9, 7, 1, -9 },
  { 352, 7, 9, 7, 0, -9 },
  { 360, 7, 9, 9, 1, -9 },
  { 368, 8, 9, 8, 0, -9 },
  { 377, 12, 9, 12, 0, -9 },
  { 391, 9, 9, 9, 0, -9 },
  { 402, 8, 9, 8, 0, -9 },
  { 411, 7, 9, 7, 0, -9 },
  { 419, 3, 11, 4, 1, -9 },
  { 424, 5, 9, 5, 0, -9 },
  { 430, 3, 11, 4, 0, -9 },
  { 435, 6, 6, 6, 0, -9 },
  { 440, 6, 1, 6, 0, 1 },
  { 441, 5, 2, 5, 0, -9 },
  { 443, 7, 7, 7, 0, -7 },
  { 450, 6, 9, 8, 1, -9 },
  { 457, 6, 7, 6, 0, -7 },
  { 463, 7, 9, 8, 0, -9 },
  { 471, 7, 7, 7, 0, -7 },
  { 478, 5, 9, 5, 0, -9 },
  { 484, 7, 10, 8, 0, -7 },
  { 493, 6, 9, 8, 1, -9 },
  { 500, 2, 9, 4, 1, -9 },
  { 503, 4, 12, 4, -1, -9 },
  { 509, 7, 9, 8, 1, -9 },
  { 517, 2, 9, 4, 1, -9 },
  { 520, 10, 7, 12, 1, -7 },
  { 529, 6, 7, 8, 1, -7 },
  { 535, 7, 7, 8, 0, -7 },
  { 542, 6, 10, 8, 1, -7 },
  { 550, 7, 10, 8, 0, -7 },
  { 559, 5, 7, 6, 1, -7 },
  { 564, 6, 7, 6, 0, -7 },
  { 570, 5, 8, 6, 0, -8 },
  { 575, 6, 7, 8, 1, -7 },
  { 581, 7, 7, 7, 0, -7 },
  { 588, 11, 7, 11, 0, -7 },
  { 598, 8, 7, 8, 0, -7 },
  { 605, 7, 10, 7, 0, -7 },
  { 614, 6, 7, 6, 0, -7 },
  { 620, 5, 11, 5, 0, -9 },
  { 627, 2, 12, 6, 2, -9 },
  { 630, 5, 11, 5, 0, -9 },
  { 637, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_Black12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black12pt7bBitmaps,
  (GFXglyph *)NotoSans_Black12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_BLACK12PT7B_H_
