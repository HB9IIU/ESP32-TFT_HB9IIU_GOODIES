#ifndef _NOTOSANS_BLACK21PT7B_H_
#define _NOTOSANS_BLACK21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0xFF, 0xF0, 0xF7, 0xFB, 0xFD,
  0xEE, 0xE7, 0x70, 0x07, 0x70, 0x39, 0xC0, 0xE6, 0x03, 0x98, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xC7, 0x38, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x86, 0x70,
  0x39, 0xC0, 0xE6, 0x03, 0xB8, 0x00, 0x0C, 0x01, 0x81, 0xFF, 0x7F, 0xEF,
  0xDD, 0xD8, 0x3F, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC6, 0xFF, 0xFD,
  0xFF, 0xBF, 0xE0, 0xE0, 0x0C, 0x00, 0x3C, 0x0F, 0x07, 0xE0, 0xE0, 0x77,
  0x1C, 0x0F, 0x71, 0xC0, 0xE7, 0x38, 0x0F, 0x77, 0x80, 0x77, 0x77, 0xC7,
  0xEE, 0xFE, 0x3E, 0xEE, 0xE0, 0x1C, 0xEE, 0x01, 0xCE, 0xF0, 0x38, 0xEE,
  0x03, 0x8E, 0xE0, 0x70, 0x7E, 0x0F, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0xC0,
  0x7B, 0xC0, 0x79, 0xE0, 0x7B, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x1E,
  0xFF, 0xBC, 0xF7, 0xFC, 0xF3, 0xFC, 0xF1, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xBF, 0xFF, 0xF7, 0x70, 0x3D, 0xE7, 0x1C, 0xF3, 0xCE, 0x38, 0xE3,
  0x8E, 0x38, 0xF3, 0xC7, 0x1C, 0x78, 0xF0, 0xF1, 0xC7, 0x9E, 0x38, 0xE3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x38, 0xE7, 0x9E, 0x73, 0xC0, 0x0E, 0x01, 0xC0,
  0x38, 0x3F, 0xF7, 0xFF, 0xFF, 0xC7, 0xC1, 0xDC, 0x3B, 0xC3, 0x20, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x7F, 0xFE, 0xEE, 0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x07, 0x83, 0xC1,
  0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x83,
  0x83, 0xC0, 0x3F, 0x0F, 0xF1, 0xFF, 0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x7B, 0xCF, 0x79, 0xE7, 0xFC, 0xFF, 0x0F, 0xC0, 0x0F,
  0x8F, 0xCF, 0xEF, 0xFF, 0xFB, 0xBC, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x87, 0xFC, 0xFF, 0xE3, 0x9E, 0x21, 0xE0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x7F, 0x3F, 0xEF, 0xFD, 0x0F, 0x03, 0xC1, 0xE3, 0xF0,
  0xFC, 0x3F, 0xC0, 0xF0, 0x3E, 0x0F, 0xFF, 0xFF, 0xEF, 0xF0, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x3F, 0xC7, 0xBC, 0x73, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7F, 0x9F, 0xE7,
  0xF9, 0xC0, 0xF0, 0x3F, 0xCF, 0xFB, 0xFF, 0x47, 0xC0, 0xF0, 0x3E, 0x0F,
  0xFF, 0xFF, 0xEF, 0xF0, 0x0F, 0xC7, 0xF9, 0xFF, 0x3C, 0x0F, 0x01, 0xEF,
  0x3B, 0xF7, 0xFE, 0xF3, 0xFE, 0x3F, 0xC7, 0xF9, 0xE7, 0xFC, 0xFF, 0x8F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x00, 0x3F, 0x0F,
  0xFB, 0xFF, 0x79, 0xEF, 0x3C, 0xFF, 0x8F, 0xE1, 0xF8, 0x7F, 0xDE, 0x7B,
  0x87, 0xF8, 0xFF, 0xFD, 0xFF, 0x8F, 0xE0, 0x3F, 0x0F, 0xF3, 0xFF, 0x79,
  0xEF, 0x3D, 0xE3, 0xFC, 0xFF, 0xFF, 0x7F, 0xC7, 0xB8, 0x0F, 0x03, 0xE7,
  0xF8, 0xFE, 0x1F, 0x80, 0x6F, 0xFF, 0x00, 0x00, 0x6F, 0xFF, 0x6F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xEE, 0xE0, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C,
  0x3C, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xC0, 0x3C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF0, 0xFC, 0xFC, 0xFC, 0x3C, 0x08, 0x00, 0x3F, 0x3F, 0xF7, 0xFD, 0x8F,
  0x03, 0xC1, 0xF0, 0xF8, 0x7C, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x1E, 0x07,
  0x81, 0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0x07, 0x8F, 0x00, 0xE7, 0x3F,
  0xBF, 0x3F, 0xDF, 0xB8, 0xEF, 0xDC, 0x77, 0xEE, 0x3B, 0xF7, 0x3D, 0xFB,
  0xFF, 0xDC, 0xFB, 0xE7, 0x18, 0xC3, 0xC0, 0x20, 0xFF, 0xE0, 0x1F, 0xF0,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEF,
  0x03, 0xDE, 0x07, 0x9C, 0x1E, 0x3C, 0x3C, 0x78, 0x7F, 0xF1, 0xFF, 0xF3,
  0xFF, 0xE7, 0x83, 0xDF, 0x07, 0xFE, 0x07, 0x80, 0xFF, 0x9F, 0xFB, 0xFF,
  0xF9, 0xFF, 0x1F, 0xE7, 0xBF, 0xF7, 0xFC, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9,
  0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0xE3, 0xFF, 0x3F, 0xE7, 0xC6, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC2, 0x7F,
  0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x3E, 0xFF, 0xEF,
  0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xFD, 0xFE,
  0xFF, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F,
  0xF1, 0xFF, 0xCF, 0xFC, 0xF8, 0x27, 0x80, 0x7C, 0x03, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x83, 0xFE, 0x1E, 0xF8, 0xF7, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFE,
  0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xBE, 0xFE, 0xFC, 0xF0, 0xF0, 0xFF,
  0x8F, 0x3C, 0xF9, 0xE7, 0x8F, 0x78, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF,
  0x87, 0xBC, 0x3C, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xFB, 0xC3, 0xC0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFE, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xB9, 0xDF, 0xDC, 0xEF, 0xEF, 0x77, 0xF3,
  0xBB, 0xF9, 0xF9, 0xFC, 0xFC, 0xFE, 0x7E, 0x7F, 0x1E, 0x3F, 0x8F, 0x1E,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F, 0xBC, 0xFE, 0xF3,
  0xF9, 0xEF, 0xE7, 0xBF, 0x8F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83,
  0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xEF, 0x83,
  0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7B, 0xE0, 0xF3,
  0xE3, 0xE7, 0xFF, 0x87, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x1F, 0xF3, 0xFF,
  0x79, 0xEF, 0x3F, 0xE7, 0xBC, 0xF7, 0xFE, 0xFF, 0x9F, 0xE3, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3,
  0xEF, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7B,
  0xE0, 0xF3, 0xE3, 0xE7, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0x3E, 0xF1,
  0xEF, 0x3E, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0xF8, 0xF7, 0x8F, 0x3C, 0xF3,
  0xEF, 0x1E, 0xF0, 0xF0, 0x3F, 0xDF, 0xFF, 0xFF, 0xC2, 0xF0, 0x3F, 0x07,
  0xF1, 0xFE, 0x1F, 0xC1, 0xF0, 0x3F, 0x0F, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x9F, 0xFF, 0xF7, 0xFE, 0x3F, 0x80, 0xF8, 0x3F, 0xF0, 0x79, 0xE1,
  0xF3, 0xC3, 0xC7, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x1F, 0x78, 0x1E, 0xF0,
  0x3D, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0xF0, 0x78, 0x7D, 0xE1, 0xE1, 0xE7, 0x8F, 0x87, 0x9E, 0x3F, 0x1E, 0x78,
  0xFC, 0x70, 0xE3, 0xF3, 0xC3, 0xCF, 0xCF, 0x0F, 0x77, 0x3C, 0x3D, 0xCE,
  0xE0, 0x77, 0x3B, 0x81, 0xDC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0xF8, 0xF8, 0xF1, 0xE0,
  0xF7, 0xC1, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7B, 0xC1, 0xF7, 0xC3, 0xC7, 0x8F, 0x87, 0xBE, 0x0F, 0x80, 0xF8,
  0x7D, 0xE1, 0xE7, 0xCF, 0x8F, 0x3C, 0x3D, 0xF0, 0x7F, 0x81, 0xFC, 0x03,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xFE, 0xF0,
  0x38, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0x81,
  0xE0, 0x70, 0x3C, 0x1E, 0xFF, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0xC0, 0x78, 0x0F,
  0x83, 0xB0, 0x77, 0x1C, 0x73, 0x8E, 0xE0, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x78, 0x78, 0x1F, 0x0F, 0xF9, 0xFF, 0x10, 0xF0, 0x1E,
  0xFF, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0xFF, 0xBE, 0x70, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF3, 0x8F, 0x7C, 0xFF, 0xEF, 0x9E, 0xF9, 0xEF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF9, 0xEF, 0xFE, 0xFF, 0xEF, 0x7C, 0x0F, 0x0F,
  0xF7, 0xFB, 0xE6, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x9F, 0xE7, 0xF8,
  0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF1, 0xDE, 0xFF, 0xDF, 0xFF, 0xDF,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x9F, 0xFF, 0xDF, 0xF9, 0xE7, 0x1F,
  0x07, 0xF9, 0xFF, 0x78, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x2F,
  0xF9, 0xFF, 0x0F, 0xE0, 0x0F, 0x8F, 0xCF, 0xE7, 0x83, 0xF7, 0xFB, 0xFC,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0xEF,
  0xFD, 0xFF, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFD,
  0xFF, 0x9E, 0xF0, 0x1F, 0x87, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF3, 0x8F, 0x7E, 0xFF, 0xEF, 0xDF, 0xF8, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x77, 0xDC,
  0x0F, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x3C, 0x7C, 0x70, 0x03,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7B,
  0xF7, 0xEF, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0xF8,
  0xFB, 0xCF, 0x9E, 0x78, 0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xBE,
  0x78, 0xF3, 0xC7, 0xDE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0x87, 0x9F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7C, 0xF9, 0xFF, 0x9F,
  0x1F, 0xE3, 0xE3, 0xFC, 0x7C, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E,
  0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xF0, 0xE3, 0x8F, 0xFE, 0xFF, 0xEF, 0x9F,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0x1F, 0x07, 0xF9, 0xFF, 0x7C, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xEF, 0xFD, 0xFF, 0x0F, 0xC0, 0xF3, 0x8F, 0x7C, 0xFF, 0xEF, 0x9E, 0xF9,
  0xEF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF9, 0xEF, 0xFE, 0xFF, 0xEF, 0x7C, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0xEF, 0xFD, 0xFF, 0xFC,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFD, 0xFF, 0x9E, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xE3, 0xFB, 0xFF, 0xDF, 0xEF,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x3E, 0x3F, 0xFF,
  0xDE, 0x2F, 0x87, 0xF9, 0xFE, 0x3F, 0x87, 0xFF, 0xFF, 0xDF, 0xC0, 0x38,
  0x38, 0x7F, 0xFF, 0xFF, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7F, 0x7F,
  0x3F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0xF0, 0x7F, 0x87, 0x9E, 0x3C,
  0xF1, 0xE3, 0x9E, 0x1E, 0xF0, 0xF7, 0x83, 0xB8, 0x1F, 0xC0, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF1, 0xF1, 0xEE, 0x3E, 0x3D, 0xE7, 0xC7, 0x3C, 0xD9,
  0xE7, 0xBB, 0xBC, 0x77, 0x77, 0x0E, 0xEE, 0xE1, 0xFD, 0xDC, 0x3F, 0x1F,
  0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xFB, 0xC7, 0x8F,
  0x7C, 0x7F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0xE1, 0xEF,
  0x9E, 0x3D, 0xF1, 0xF0, 0xF0, 0x7F, 0xC7, 0x9E, 0x3C, 0xF1, 0xE3, 0x9E,
  0x1E, 0xF0, 0xF7, 0x83, 0xB8, 0x1F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x78, 0x00, 0x7F, 0xDF, 0xF7, 0xFC,
  0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0x1E,
  0x7C, 0xF9, 0xC3, 0x87, 0x0E, 0x3C, 0xF9, 0xE3, 0xE1, 0xC3, 0x87, 0x0E,
  0x1E, 0x3E, 0x3C, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF1, 0xF3, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3E, 0x3C, 0xF9, 0xC3, 0x87,
  0x0E, 0x3C, 0xF9, 0xE2, 0x00, 0xFC, 0x7F, 0xFC, 0xFE, 0x04,
};

const GFXglyph NotoSans_Black21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 9, 5, 11, 1, -15 },
  { 15, 14, 15, 14, 0, -15 },
  { 42, 11, 17, 12, 1, -16 },
  { 66, 20, 15, 20, 0, -15 },
  { 104, 16, 15, 17, 1, -15 },
  { 134, 4, 5, 6, 1, -15 },
  { 137, 6, 18, 8, 1, -15 },
  { 151, 6, 18, 8, 1, -15 },
  { 165, 11, 10, 11, 0, -16 },
  { 179, 10, 11, 12, 1, -13 },
  { 193, 4, 6, 6, 1, -3 },
  { 196, 6, 3, 7, 0, -7 },
  { 199, 4, 4, 6, 1, -4 },
  { 201, 9, 15, 9, 0, -15 },
  { 218, 11, 15, 12, 1, -15 },
  { 239, 9, 15, 12, 1, -15 },
  { 256, 12, 15, 12, 0, -15 },
  { 279, 10, 15, 12, 1, -15 },
  { 298, 12, 15, 12, 0, -15 },
  { 321, 10, 15, 12, 1, -15 },
  { 340, 11, 15, 12, 1, -15 },
  { 361, 11, 15, 12, 1, -15 },
  { 382, 11, 15, 12, 1, -15 },
  { 403, 11, 15, 12, 1, -15 },
  { 424, 4, 12, 6, 1, -12 },
  { 430, 4, 15, 6, 1, -12 },
  { 438, 10, 11, 12, 1, -13 },
  { 452, 10, 7, 12, 1, -11 },
  { 461, 10, 11, 12, 1, -13 },
  { 475, 10, 15, 11, 0, -15 },
  { 494, 17, 17, 19, 1, -15 },
  { 531, 15, 15, 15, 0, -15 },
  { 560, 11, 15, 14, 2, -15 },
  { 581, 12, 15, 14, 1, -15 },
  { 604, 12, 15, 15, 2, -15 },
  { 627, 9, 15, 12, 2, -15 },
  { 644, 8, 15, 11, 2, -15 },
  { 659, 13, 15, 16, 1, -15 },
  { 684, 12, 15, 16, 2, -15 },
  { 707, 8, 15, 9, 1, -15 },
  { 722, 8, 20, 7, -2, -15 },
  { 742, 13, 15, 14, 2, -15 },
  { 767, 9, 15, 12, 2, -15 },
  { 784, 17, 15, 20, 2, -15 },
  { 816, 14, 15, 18, 2, -15 },
  { 843, 15, 15, 17, 1, -15 },
  { 872, 11, 15, 13, 2, -15 },
  { 893, 15, 19, 17, 1, -15 },
  { 929, 12, 15, 14, 2, -15 },
  { 952, 10, 15, 12, 1, -15 },
  { 971, 11, 15, 12, 1, -15 },
  { 992, 12, 15, 16, 2, -15 },
  { 1015, 15, 15, 15, 0, -15 },
  { 1044, 22, 15, 22, 0, -15 },
  { 1086, 15, 15, 15, 0, -15 },
  { 1115, 14, 15, 14, 0, -15 },
  { 1142, 11, 15, 13, 1, -15 },
  { 1163, 5, 19, 7, 1, -15 },
  { 1175, 9, 15, 9, 0, -15 },
  { 1192, 6, 19, 7, 0, -15 },
  { 1207, 11, 10, 11, 0, -15 },
  { 1221, 11, 3, 11, 0, 1 },
  { 1226, 7, 3, 9, 1, -16 },
  { 1229, 11, 12, 13, 1, -12 },
  { 1246, 12, 16, 14, 1, -16 },
  { 1270, 10, 12, 11, 1, -12 },
  { 1285, 11, 16, 14, 1, -16 },
  { 1307, 11, 12, 13, 1, -12 },
  { 1324, 9, 16, 9, 0, -16 },
  { 1342, 11, 17, 14, 1, -12 },
  { 1366, 12, 16, 14, 1, -16 },
  { 1390, 5, 16, 7, 1, -16 },
  { 1400, 7, 21, 7, -1, -16 },
  { 1419, 13, 16, 14, 1, -16 },
  { 1445, 4, 16, 7, 1, -16 },
  { 1453, 19, 12, 21, 1, -12 },
  { 1482, 12, 12, 14, 1, -12 },
  { 1500, 11, 12, 13, 1, -12 },
  { 1517, 12, 17, 14, 1, -12 },
  { 1543, 11, 17, 14, 1, -12 },
  { 1567, 9, 12, 10, 1, -12 },
  { 1581, 9, 12, 11, 1, -12 },
  { 1595, 8, 14, 10, 1, -14 },
  { 1609, 12, 12, 14, 1, -12 },
  { 1627, 13, 12, 13, 0, -12 },
  { 1647, 19, 12, 19, 0, -12 },
  { 1676, 13, 12, 13, 0, -12 },
  { 1696, 13, 17, 13, 0, -12 },
  { 1724, 10, 12, 11, 0, -12 },
  { 1739, 7, 19, 9, 1, -15 },
  { 1756, 3, 21, 11, 4, -16 },
  { 1764, 7, 19, 9, 1, -15 },
  { 1781, 10, 4, 12, 1, -9 },
};

const GFXfont NotoSans_Black21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black21pt7bBitmaps,
  (GFXglyph *)NotoSans_Black21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_BLACK21PT7B_H_
