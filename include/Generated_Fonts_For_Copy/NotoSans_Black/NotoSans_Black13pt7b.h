#ifndef _NOTOSANS_BLACK13PT7B_H_
#define _NOTOSANS_BLACK13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xDE, 0xF6, 0x1A, 0x16, 0x7F, 0x7F, 0x34, 0xFF,
  0xFF, 0x6C, 0x6C, 0x10, 0xFD, 0xFE, 0x87, 0x8F, 0xC7, 0xCB, 0x7E, 0xF0,
  0x40, 0x71, 0xCD, 0x98, 0xDB, 0x0D, 0xB6, 0x76, 0xF0, 0x5B, 0x0D, 0xB1,
  0x9B, 0x18, 0xE0, 0x3E, 0x1D, 0x87, 0x60, 0xF0, 0x7D, 0xDB, 0xEE, 0x79,
  0xFE, 0x3D, 0xC0, 0xFC, 0x33, 0x66, 0x6E, 0xE6, 0x66, 0x63, 0xC6, 0x73,
  0x33, 0x33, 0x33, 0x6E, 0x10, 0x23, 0xFF, 0xF3, 0x8D, 0x80, 0x30, 0xC3,
  0x3F, 0x30, 0xC3, 0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x1C, 0x63, 0x8C, 0x31,
  0xC6, 0x18, 0xC0, 0x7C, 0xFD, 0x9F, 0x3E, 0x6C, 0xDB, 0xBF, 0x3C, 0x3B,
  0xFF, 0x73, 0x9C, 0xE7, 0x38, 0x7D, 0xFD, 0x38, 0x71, 0xC7, 0x1C, 0x7F,
  0xFE, 0xFC, 0xFC, 0x39, 0xE3, 0xC1, 0xC3, 0xFF, 0xFC, 0x0C, 0x38, 0xF3,
  0xE6, 0xDF, 0xFF, 0x86, 0x0C, 0xFB, 0xEC, 0x3E, 0xFC, 0x71, 0xFF, 0xF8,
  0x3E, 0xFD, 0x83, 0xEF, 0xFC, 0xD9, 0xBF, 0x3C, 0xFF, 0xFC, 0x38, 0x61,
  0xC3, 0x0E, 0x1C, 0x70, 0x7C, 0xDD, 0xBB, 0xE3, 0xCD, 0xF9, 0xBF, 0x7C,
  0x7C, 0xFF, 0x9F, 0x37, 0xE6, 0xC3, 0xBE, 0x78, 0xF0, 0x3C, 0x6C, 0x00,
  0xDB, 0xC0, 0x0C, 0xFF, 0x30, 0x78, 0x70, 0x40, 0xFF, 0xF0, 0x3F, 0xFC,
  0x83, 0x83, 0x87, 0x7B, 0x88, 0x00, 0xFD, 0xF0, 0xC7, 0x38, 0xC0, 0x0C,
  0x30, 0x3F, 0x18, 0x6D, 0xFE, 0xEB, 0xB2, 0xED, 0xBB, 0xFF, 0x24, 0x77,
  0x0F, 0xC0, 0x1E, 0x1F, 0x0D, 0x86, 0xE7, 0x33, 0xF9, 0xFF, 0xC7, 0xE1,
  0x80, 0xFD, 0xFF, 0xBF, 0xEF, 0xDD, 0xFB, 0xFF, 0xFC, 0x7F, 0xFF, 0x86,
  0x0C, 0x18, 0x38, 0xFF, 0x7E, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE6,
  0xFE, 0xFC, 0xFF, 0xFE, 0x3E, 0xFB, 0x8E, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF,
  0xFF, 0x18, 0xC0, 0x7F, 0xFE, 0xE0, 0xC0, 0xCF, 0xCF, 0xE7, 0x7F, 0x3F,
  0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFB, 0x8C, 0x63,
  0x18, 0xCF, 0xF8, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xBD, 0xC0, 0xE7,
  0xEE, 0xFC, 0xF8, 0xF8, 0xFC, 0xEE, 0xEE, 0xE7, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x3F, 0xFC, 0xF1, 0xFE, 0x3F, 0xCF, 0xF9, 0xFD, 0xBF, 0xB5, 0xF7,
  0xBE, 0x77, 0xCE, 0xE0, 0xF1, 0xF8, 0xFE, 0x7B, 0x3D, 0xDE, 0x6F, 0x3F,
  0x8F, 0xC7, 0x80, 0x7E, 0x7F, 0xB8, 0xD8, 0x7C, 0x3E, 0x1F, 0x9C, 0xFE,
  0x3E, 0x00, 0xFD, 0xFF, 0xBF, 0x7F, 0xDF, 0x38, 0x70, 0xE0, 0x7E, 0x7F,
  0xB8, 0xD8, 0x7C, 0x3E, 0x1F, 0x9C, 0xFE, 0x3E, 0x03, 0x01, 0xE0, 0xFC,
  0xFE, 0xEE, 0xEE, 0xFC, 0xFC, 0xEC, 0xEE, 0xE7, 0xFF, 0xFC, 0x3C, 0x7C,
  0x78, 0xFF, 0xF8, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFE, 0x7C, 0xE3, 0xB1, 0x9D, 0xCE,
  0xE3, 0x61, 0xB0, 0xF8, 0x38, 0x1C, 0x00, 0xE7, 0x1B, 0x39, 0xD9, 0xEE,
  0xCF, 0x67, 0x5B, 0x1E, 0xD8, 0xF3, 0xC7, 0x9C, 0x3C, 0xE0, 0xE3, 0xBB,
  0x8F, 0x83, 0xC1, 0xC1, 0xF0, 0xDC, 0xE6, 0xE3, 0x80, 0xE3, 0xBB, 0x9D,
  0x87, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0xFF, 0xFE, 0x0E, 0x1C,
  0x38, 0x38, 0x70, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x70, 0xE1, 0x86,
  0x1C, 0x30, 0xC1, 0x86, 0x1C, 0xFD, 0xB6, 0xDB, 0x6D, 0xF0, 0x30, 0x71,
  0xE3, 0x6C, 0xD8, 0xC0, 0xFE, 0xE7, 0x7E, 0x5C, 0x7B, 0xFE, 0x6F, 0xDF,
  0x80, 0xC1, 0x83, 0x06, 0xEF, 0xF9, 0xF3, 0xE7, 0xFD, 0xB8, 0x7F, 0xEC,
  0x30, 0xC3, 0xE7, 0x80, 0x0E, 0x1C, 0x3F, 0xFF, 0xF9, 0xF3, 0xE7, 0xFE,
  0xFC, 0x7F, 0xBC, 0xFF, 0xC3, 0xF7, 0xC0, 0x3D, 0xE7, 0x3E, 0xF9, 0xC7,
  0x1C, 0x71, 0xC0, 0xFF, 0xFF, 0x3E, 0x7C, 0xFF, 0xDF, 0x86, 0xFD, 0xF0,
  0xC1, 0x83, 0x07, 0xEF, 0xF9, 0xF3, 0xE7, 0xCF, 0x9C, 0xF3, 0xFF, 0xF0,
  0x33, 0x03, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0xC0, 0xC0, 0xC0, 0xCE, 0xDC,
  0xD8, 0xF8, 0xFC, 0xCE, 0xCF, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x39,
  0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x98, 0xFD, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3,
  0x80, 0x7D, 0xFB, 0x3E, 0x7C, 0xFF, 0x9E, 0x00, 0xFD, 0xFF, 0x3E, 0x7C,
  0xFF, 0xB7, 0x60, 0xC1, 0x80, 0xFF, 0xFF, 0x3E, 0x7C, 0xFF, 0xDF, 0x87,
  0x0E, 0x1C, 0xDF, 0xF9, 0x8C, 0x63, 0x00, 0xFE, 0xF9, 0xF3, 0xFF, 0xC0,
  0x30, 0xC7, 0xBE, 0x71, 0xC7, 0x1F, 0x3C, 0xCF, 0x9F, 0x3E, 0x7C, 0xFF,
  0xDD, 0x80, 0xE7, 0x66, 0x66, 0x7E, 0x3C, 0x3C, 0x18, 0xEE, 0x76, 0xF6,
  0x6F, 0x66, 0xFE, 0x6B, 0xC3, 0x9C, 0x39, 0xC0, 0xE7, 0x7E, 0x3C, 0x3C,
  0x3E, 0x7E, 0xE7, 0xE7, 0x66, 0x66, 0x7E, 0x3C, 0x3C, 0x18, 0x18, 0x78,
  0x70, 0xFF, 0xF1, 0x8C, 0x73, 0xFF, 0xC0, 0x39, 0x8C, 0x6F, 0x71, 0xC6,
  0x31, 0xCE, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0x8C, 0x63, 0x8C, 0xC6, 0x37,
  0xB8, 0xE7, 0xF9, 0x80,
};

const GFXglyph NotoSans_Black13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 5, 3, 7, 1, -9 },
  { 6, 8, 9, 9, 0, -9 },
  { 15, 7, 11, 8, 0, -10 },
  { 25, 12, 9, 12, 0, -9 },
  { 39, 10, 9, 10, 0, -9 },
  { 51, 2, 3, 4, 1, -9 },
  { 52, 4, 12, 5, 0, -10 },
  { 58, 4, 12, 5, 0, -10 },
  { 64, 7, 6, 7, 0, -10 },
  { 70, 6, 7, 8, 1, -8 },
  { 76, 3, 4, 4, 0, -2 },
  { 78, 4, 2, 4, 0, -4 },
  { 79, 2, 2, 4, 1, -2 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 7, 9, 8, 0, -9 },
  { 95, 5, 9, 8, 1, -9 },
  { 101, 7, 9, 8, 0, -9 },
  { 109, 7, 9, 8, 0, -9 },
  { 117, 7, 9, 8, 0, -9 },
  { 125, 6, 9, 8, 1, -9 },
  { 132, 7, 9, 8, 0, -9 },
  { 140, 7, 9, 8, 0, -9 },
  { 148, 7, 9, 8, 0, -9 },
  { 156, 7, 9, 8, 0, -9 },
  { 164, 2, 7, 4, 1, -7 },
  { 166, 3, 9, 4, 0, -7 },
  { 170, 6, 7, 8, 1, -8 },
  { 176, 6, 5, 8, 1, -7 },
  { 180, 6, 7, 8, 1, -8 },
  { 186, 6, 9, 7, 0, -9 },
  { 193, 10, 10, 12, 1, -9 },
  { 206, 9, 9, 9, 0, -9 },
  { 217, 7, 9, 9, 1, -9 },
  { 225, 7, 9, 8, 1, -9 },
  { 233, 8, 9, 10, 1, -9 },
  { 242, 6, 9, 7, 1, -9 },
  { 249, 5, 9, 7, 1, -9 },
  { 255, 8, 9, 10, 1, -9 },
  { 264, 8, 9, 10, 1, -9 },
  { 273, 5, 9, 6, 0, -9 },
  { 279, 5, 12, 5, -1, -9 },
  { 287, 8, 9, 9, 1, -9 },
  { 296, 6, 9, 8, 1, -9 },
  { 303, 11, 9, 13, 1, -9 },
  { 316, 9, 9, 11, 1, -9 },
  { 327, 9, 9, 10, 1, -9 },
  { 338, 7, 9, 8, 1, -9 },
  { 346, 9, 11, 10, 1, -9 },
  { 359, 8, 9, 9, 1, -9 },
  { 368, 6, 9, 8, 1, -9 },
  { 375, 7, 9, 8, 0, -9 },
  { 383, 8, 9, 10, 1, -9 },
  { 392, 9, 9, 9, 0, -9 },
  { 403, 13, 9, 14, 0, -9 },
  { 418, 9, 9, 9, 0, -9 },
  { 429, 9, 9, 9, 0, -9 },
  { 440, 8, 9, 8, 0, -9 },
  { 449, 3, 12, 4, 1, -10 },
  { 454, 6, 9, 6, 0, -9 },
  { 461, 3, 12, 4, 0, -10 },
  { 466, 7, 6, 7, 0, -9 },
  { 472, 7, 1, 7, 0, 1 },
  { 473, 4, 2, 5, 1, -10 },
  { 474, 7, 7, 8, 0, -7 },
  { 481, 7, 10, 8, 1, -10 },
  { 490, 6, 7, 7, 1, -7 },
  { 496, 7, 10, 8, 1, -10 },
  { 505, 6, 7, 8, 1, -7 },
  { 511, 6, 10, 5, 0, -10 },
  { 519, 7, 10, 8, 1, -7 },
  { 528, 7, 10, 9, 1, -10 },
  { 537, 2, 10, 4, 1, -10 },
  { 540, 4, 13, 4, -1, -10 },
  { 547, 8, 10, 9, 1, -10 },
  { 557, 2, 10, 4, 1, -10 },
  { 560, 11, 7, 13, 1, -7 },
  { 570, 7, 7, 9, 1, -7 },
  { 577, 7, 7, 8, 1, -7 },
  { 584, 7, 10, 8, 1, -7 },
  { 593, 7, 10, 8, 1, -7 },
  { 602, 5, 7, 6, 1, -7 },
  { 607, 5, 7, 7, 1, -7 },
  { 612, 6, 9, 6, 0, -9 },
  { 619, 7, 7, 9, 1, -7 },
  { 626, 8, 7, 8, 0, -7 },
  { 633, 12, 7, 12, 0, -7 },
  { 644, 8, 7, 8, 0, -7 },
  { 651, 8, 10, 8, 0, -7 },
  { 661, 6, 7, 7, 0, -7 },
  { 667, 5, 11, 6, 0, -9 },
  { 674, 2, 13, 7, 2, -10 },
  { 678, 5, 11, 6, 0, -9 },
  { 685, 6, 3, 8, 1, -6 },
};

const GFXfont NotoSans_Black13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black13pt7bBitmaps,
  (GFXglyph *)NotoSans_Black13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_BLACK13PT7B_H_
