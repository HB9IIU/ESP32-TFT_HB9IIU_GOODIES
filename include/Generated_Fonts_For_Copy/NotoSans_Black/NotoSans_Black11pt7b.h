#ifndef _NOTOSANS_BLACK11PT7B_H_
#define _NOTOSANS_BLACK11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black11pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0x1F, 0xFB, 0xB0, 0x34, 0x69, 0xFB, 0xF2, 0x9F, 0xDA,
  0x3C, 0x3B, 0xFD, 0x1C, 0x3C, 0x7F, 0xDE, 0x10, 0x73, 0x3C, 0x8D, 0x63,
  0xD6, 0x7F, 0xC2, 0xD1, 0xB4, 0xC7, 0x38, 0x36, 0x1B, 0x07, 0x07, 0xB7,
  0x7B, 0xF8, 0xFF, 0xE8, 0x76, 0x6C, 0xCC, 0x46, 0x63, 0xC6, 0x62, 0x33,
  0x26, 0x6C, 0x33, 0xFF, 0xDE, 0x58, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x69,
  0x60, 0xFC, 0x7C, 0x19, 0x8C, 0x66, 0x31, 0x18, 0x39, 0xF6, 0xFB, 0xED,
  0xB7, 0xDE, 0x1B, 0xFE, 0xB1, 0x8C, 0x63, 0x7B, 0xF4, 0xC7, 0x39, 0xCF,
  0xFF, 0xF9, 0xF0, 0xCE, 0x3C, 0x3F, 0xFE, 0x18, 0x63, 0x9E, 0xDB, 0xF1,
  0x86, 0x79, 0xE6, 0x1E, 0x5C, 0x3F, 0xFE, 0x3D, 0xF6, 0x3F, 0xEF, 0xB7,
  0xDE, 0xFF, 0xF0, 0xC6, 0x18, 0xC3, 0x1C, 0x79, 0xF6, 0xDE, 0x7B, 0x3E,
  0xDE, 0x79, 0xFC, 0xFB, 0x7C, 0x37, 0x9C, 0xEC, 0x07, 0xC0, 0xEC, 0x06,
  0x96, 0x04, 0x77, 0x3C, 0x3C, 0x10, 0xFF, 0xF0, 0x3F, 0xC3, 0xC3, 0xC7,
  0xF3, 0x00, 0x7F, 0xC6, 0x72, 0x00, 0x8E, 0x1E, 0x18, 0xDB, 0xAA, 0x5D,
  0x2E, 0xB5, 0x3C, 0xE6, 0x1E, 0x00, 0x3C, 0x3C, 0x3C, 0x7E, 0x66, 0x7E,
  0xFE, 0xC3, 0xFB, 0xFC, 0xFE, 0xFF, 0x3F, 0xFE, 0x7F, 0xEC, 0x30, 0xC3,
  0x0F, 0x9E, 0xF9, 0xFB, 0x36, 0x7C, 0xD9, 0xBF, 0x7C, 0xFF, 0xF1, 0xEF,
  0x63, 0xFF, 0xFF, 0xCF, 0xFC, 0xCC, 0x7F, 0xFC, 0x37, 0xDF, 0x3F, 0xDF,
  0xCF, 0x9F, 0x3F, 0xFF, 0xF9, 0xF3, 0xE7, 0xF7, 0x66, 0x66, 0x7F, 0x33,
  0x33, 0x33, 0x33, 0x3E, 0xCF, 0xBB, 0x67, 0x8F, 0x9B, 0x37, 0x67, 0xC6,
  0x31, 0x8C, 0x63, 0xFF, 0xE3, 0xF1, 0xF9, 0xFE, 0xFF, 0x5E, 0xEF, 0x77,
  0xB3, 0xE7, 0xCF, 0xDF, 0xBD, 0xFB, 0x73, 0xE7, 0x7D, 0xFF, 0x1E, 0x3C,
  0x78, 0xFF, 0xBE, 0xF3, 0xED, 0xF6, 0xFB, 0x0C, 0x30, 0x7D, 0xFF, 0x1E,
  0x3C, 0x78, 0xFF, 0xBE, 0x0C, 0x1C, 0xF1, 0xF3, 0x76, 0xCF, 0x1B, 0x37,
  0x67, 0x3D, 0xF6, 0x1E, 0x3C, 0x3F, 0xFE, 0xFF, 0xF3, 0x0C, 0x30, 0xC3,
  0x0C, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xBF, 0x3C, 0xC7, 0xE6, 0x66, 0x6E,
  0x7C, 0x3C, 0x3C, 0x38, 0xC6, 0x6D, 0xCD, 0xB9, 0xB7, 0x66, 0xBC, 0xD7,
  0x8E, 0xF1, 0xCC, 0xE7, 0x66, 0x3C, 0x3C, 0x38, 0x3C, 0x66, 0xE7, 0xC6,
  0xDD, 0xB1, 0xC3, 0x83, 0x06, 0x0C, 0xFF, 0xF1, 0xC6, 0x31, 0xCF, 0xFF,
  0xEA, 0xAA, 0xF0, 0xC2, 0x18, 0xC3, 0x18, 0xC3, 0xED, 0xB6, 0xDB, 0xFC,
  0x20, 0xC7, 0x16, 0xCC, 0xFC, 0xF0, 0x7D, 0x37, 0xFB, 0xED, 0xF0, 0xC3,
  0x0F, 0xB6, 0xDF, 0x7F, 0xBE, 0x7D, 0xAE, 0x38, 0x79, 0xE0, 0x0C, 0x37,
  0xDF, 0xEF, 0xB7, 0xDF, 0x7D, 0xBF, 0xFF, 0x64, 0xF0, 0x7B, 0x3C, 0xC6,
  0x31, 0x8C, 0x7D, 0xBE, 0xFB, 0x7D, 0xF0, 0xDF, 0x70, 0xC3, 0x0F, 0xBF,
  0xCF, 0x3C, 0xF3, 0xB3, 0xFF, 0xC0, 0x23, 0x03, 0x33, 0x33, 0x33, 0xFE,
  0xC3, 0x0D, 0xF6, 0xF3, 0xED, 0xB3, 0xFF, 0xFF, 0xFB, 0xEE, 0xF7, 0x7B,
  0xBD, 0xDE, 0xEC, 0xFB, 0xFC, 0xF3, 0xCF, 0x30, 0x7C, 0xDB, 0xBB, 0x76,
  0xC7, 0x00, 0xFB, 0x6D, 0xF7, 0xFB, 0xEC, 0x30, 0xC0, 0x7D, 0xBE, 0xFB,
  0x7D, 0xF0, 0xC3, 0x0C, 0xBF, 0xCC, 0xCC, 0x7E, 0x5C, 0x7D, 0xFC, 0x67,
  0xD8, 0xC6, 0x3D, 0xE0, 0xCF, 0x3C, 0xF7, 0xFF, 0xB0, 0xCE, 0xD9, 0xB3,
  0xC3, 0x87, 0x00, 0xCC, 0xDF, 0xE7, 0xF9, 0xFE, 0x73, 0x8C, 0xC0, 0xEE,
  0xD8, 0xE1, 0xC6, 0xDD, 0xC0, 0xCE, 0xD9, 0xB3, 0xC3, 0x87, 0x0C, 0x38,
  0x40, 0xFF, 0xCC, 0xCF, 0xFC, 0x33, 0x22, 0xEE, 0x22, 0x33, 0xFF, 0xFF,
  0xF0, 0xEE, 0x66, 0x33, 0x66, 0xEC, 0x77, 0xF0,
};

const GFXglyph NotoSans_Black11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 6, 1, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 9, 6, 0, -8 },
  { 20, 10, 8, 10, 0, -8 },
  { 30, 9, 8, 9, 0, -8 },
  { 39, 2, 3, 3, 1, -8 },
  { 40, 4, 10, 4, 0, -8 },
  { 45, 4, 10, 4, 0, -8 },
  { 50, 6, 5, 6, 0, -8 },
  { 54, 6, 6, 6, 0, -7 },
  { 59, 3, 4, 3, 0, -2 },
  { 61, 3, 2, 4, 0, -4 },
  { 62, 3, 2, 3, 0, -2 },
  { 63, 5, 8, 5, 0, -8 },
  { 68, 6, 8, 6, 0, -8 },
  { 74, 5, 8, 6, 0, -8 },
  { 79, 6, 8, 6, 0, -8 },
  { 85, 6, 8, 6, 0, -8 },
  { 91, 6, 8, 6, 0, -8 },
  { 97, 6, 8, 6, 0, -8 },
  { 103, 6, 8, 6, 0, -8 },
  { 109, 6, 8, 6, 0, -8 },
  { 115, 6, 8, 6, 0, -8 },
  { 121, 6, 8, 6, 0, -8 },
  { 127, 3, 6, 3, 0, -6 },
  { 130, 3, 8, 3, 0, -6 },
  { 133, 6, 6, 6, 0, -7 },
  { 138, 6, 4, 6, 0, -6 },
  { 141, 6, 6, 6, 0, -7 },
  { 146, 5, 8, 6, 0, -8 },
  { 151, 9, 9, 10, 0, -8 },
  { 162, 8, 8, 8, 0, -8 },
  { 170, 6, 8, 7, 1, -8 },
  { 176, 6, 8, 7, 1, -8 },
  { 182, 7, 8, 8, 1, -8 },
  { 189, 5, 8, 6, 1, -8 },
  { 194, 4, 8, 6, 1, -8 },
  { 198, 6, 8, 8, 1, -8 },
  { 204, 7, 8, 8, 1, -8 },
  { 211, 4, 8, 5, 0, -8 },
  { 215, 4, 10, 4, -1, -8 },
  { 220, 7, 8, 8, 1, -8 },
  { 227, 5, 8, 6, 1, -8 },
  { 232, 9, 8, 11, 1, -8 },
  { 241, 7, 8, 9, 1, -8 },
  { 248, 7, 8, 9, 1, -8 },
  { 255, 6, 8, 7, 1, -8 },
  { 261, 7, 10, 9, 1, -8 },
  { 270, 7, 8, 7, 1, -8 },
  { 277, 6, 8, 6, 0, -8 },
  { 283, 6, 8, 7, 0, -8 },
  { 289, 7, 8, 8, 1, -8 },
  { 296, 8, 8, 8, 0, -8 },
  { 304, 11, 8, 11, 0, -8 },
  { 315, 8, 8, 8, 0, -8 },
  { 323, 7, 8, 7, 0, -8 },
  { 330, 6, 8, 7, 0, -8 },
  { 336, 2, 10, 4, 1, -8 },
  { 339, 5, 8, 5, 0, -8 },
  { 344, 3, 10, 4, 0, -8 },
  { 348, 6, 5, 6, 0, -8 },
  { 352, 6, 1, 6, 0, 1 },
  { 353, 4, 1, 5, 0, -8 },
  { 354, 6, 6, 7, 0, -6 },
  { 359, 6, 8, 7, 1, -8 },
  { 365, 6, 6, 6, 0, -6 },
  { 370, 6, 8, 7, 0, -8 },
  { 376, 6, 6, 7, 0, -6 },
  { 381, 5, 8, 5, 0, -8 },
  { 386, 6, 9, 7, 0, -6 },
  { 393, 6, 8, 7, 1, -8 },
  { 399, 2, 9, 4, 1, -9 },
  { 402, 4, 12, 4, -1, -9 },
  { 408, 6, 8, 7, 1, -8 },
  { 414, 2, 8, 4, 1, -8 },
  { 416, 9, 6, 11, 1, -6 },
  { 423, 6, 6, 7, 1, -6 },
  { 428, 7, 6, 7, 0, -6 },
  { 434, 6, 9, 7, 1, -6 },
  { 441, 6, 9, 7, 0, -6 },
  { 448, 4, 6, 5, 1, -6 },
  { 451, 5, 6, 6, 0, -6 },
  { 455, 5, 7, 5, 0, -7 },
  { 460, 6, 6, 7, 1, -6 },
  { 465, 7, 6, 7, 0, -6 },
  { 471, 10, 6, 10, 0, -6 },
  { 479, 7, 6, 7, 0, -6 },
  { 485, 7, 9, 7, 0, -6 },
  { 493, 5, 6, 6, 0, -6 },
  { 497, 4, 10, 5, 0, -8 },
  { 502, 2, 10, 6, 2, -8 },
  { 505, 4, 10, 5, 0, -8 },
  { 510, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Black11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black11pt7bBitmaps,
  (GFXglyph *)NotoSans_Black11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_BLACK11PT7B_H_
