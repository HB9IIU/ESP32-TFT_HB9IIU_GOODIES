#ifndef _NOTOSANS_BLACK47PT7B_H_
#define _NOTOSANS_BLACK47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0x9F, 0xC0, 0x80, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xBF,
  0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xF9, 0xF8, 0x7F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F,
  0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F,
  0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x3F, 0xEF, 0x9F, 0x9F, 0xE7, 0xC0, 0x8F, 0xF3, 0xE0,
  0x07, 0xF9, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3E, 0x7F, 0x80, 0x1F, 0x3F, 0xD8, 0x0F, 0x9F, 0xEF, 0x87, 0xDF, 0xF7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xF0,
  0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC7,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x1F, 0xC1,
  0xE0, 0x3F, 0x8F, 0xE7, 0xF1, 0xFF, 0x03, 0xFB, 0xF8, 0xFE, 0x7F, 0xF8,
  0x7F, 0xFF, 0x3F, 0x9F, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF9, 0xFC, 0xFF, 0xFF, 0x0F, 0xFE, 0x7F, 0x1F, 0xCF, 0xE0, 0x7F, 0x0F,
  0xE3, 0xF9, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x3F, 0x00,
  0x07, 0xF0, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x03, 0xF9, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x07,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xF8, 0x7F, 0xFF, 0xFD, 0xFF, 0x0F,
  0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF9, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F,
  0xF0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x83, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x18, 0x1F, 0x01, 0x3E,
  0x3E, 0x3F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x7F, 0x9F, 0xC1, 0xFE, 0x3F,
  0xC0, 0xFC, 0x3E, 0x00, 0x70, 0x70, 0x00, 0x20, 0x40, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFC, 0x08,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFC, 0x7F, 0xC3, 0xFE, 0xFF, 0x83,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xC3,
  0xFE, 0x7F, 0xC7, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xFB, 0xFF, 0x3F, 0x3F, 0xF1, 0xE3, 0xFF,
  0x0C, 0x3F, 0xF0, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x1F, 0x83, 0xFF, 0x07, 0x00, 0xFF, 0x83, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0x0F,
  0xFE, 0x18, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x1F,
  0xE7, 0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFC, 0x1F, 0xF0,
  0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xF8, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFE,
  0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC7, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xEF, 0xFC, 0xFF, 0xC7, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0,
  0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFC,
  0x07, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xEF, 0xF1, 0xFF, 0xE7, 0xF8,
  0x3F, 0xE7, 0xF8, 0x07, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE7, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x9F, 0xC0, 0x80, 0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xCF,
  0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x83, 0xFF, 0x18, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x18, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xCF,
  0xE3, 0xF8, 0x7F, 0xFF, 0x9F, 0x8F, 0xC3, 0xFF, 0xFE, 0x7F, 0x7F, 0x1F,
  0xFF, 0xF8, 0xFD, 0xF8, 0xFF, 0xFF, 0xE3, 0xF7, 0xE3, 0xF8, 0x3F, 0x8F,
  0xFF, 0x8F, 0xC0, 0xFE, 0x3F, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0xF1, 0xFC,
  0x0F, 0xE3, 0xFF, 0xC7, 0xE0, 0x3F, 0x8F, 0xFF, 0x1F, 0x80, 0xFC, 0x3F,
  0xFC, 0x7F, 0x03, 0xF0, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xFF, 0xC7, 0xF0,
  0x7F, 0x1F, 0xBF, 0x0F, 0xF7, 0xFE, 0xFE, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xE0, 0xFF, 0xEF, 0xFE, 0x1F, 0xC1, 0xFF,
  0x0F, 0xE0, 0x3F, 0x80, 0xE0, 0x0E, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x40, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF9, 0xFC, 0x3F, 0xF8, 0x03, 0x87, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x18, 0xFF, 0xF0, 0x1F, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0xFF, 0x81, 0xFF, 0xEF, 0xF8, 0x0F, 0xFE, 0xFF, 0x80, 0x7F, 0xEF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0xFF,
  0xEF, 0xF8, 0x1F, 0xFC, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE7, 0xF8,
  0x3F, 0xFC, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0xC1, 0xFF,
  0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF,
  0x7F, 0xF0, 0x07, 0xFC, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0xC0, 0x7F, 0xC7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x8F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x01,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xEF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x1F, 0xF8, 0xFF,
  0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0xFF,
  0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x0F,
  0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8,
  0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0xFF,
  0x80, 0xFF, 0xCF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xEF,
  0xE0, 0x1F, 0xBF, 0xFF, 0xBF, 0x80, 0x7E, 0xFF, 0xFE, 0xFE, 0x03, 0xFB,
  0xFF, 0xFB, 0xFC, 0x0F, 0xEF, 0xFF, 0xE7, 0xF0, 0x3F, 0x3F, 0xFF, 0xDF,
  0xC1, 0xFC, 0xFF, 0xFF, 0x7F, 0x07, 0xF3, 0xFF, 0xFC, 0xFE, 0x1F, 0xCF,
  0xFF, 0xF3, 0xF8, 0x7E, 0x3F, 0xFF, 0xCF, 0xE3, 0xF8, 0xFF, 0xFF, 0x3F,
  0xCF, 0xE3, 0xFF, 0xFC, 0x7F, 0x3F, 0x0F, 0xFF, 0xF1, 0xFD, 0xFC, 0x3F,
  0xFF, 0xC7, 0xF7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0xFE, 0x7F, 0xC1,
  0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0xFF, 0x1F, 0xF1,
  0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0x0F, 0xF8,
  0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0x03, 0xFE,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF8,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF8, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xCF,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xE1, 0xFC, 0xFF, 0x80,
  0x18, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x03, 0xFE, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xFE, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xCF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xE1, 0xFF, 0x03, 0xF7, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xEF, 0xC0, 0xFF,
  0x03, 0xFC, 0x1F, 0xDF, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xBF, 0x87, 0xFC,
  0x0F, 0xF8, 0x7F, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE3, 0xF8, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF1, 0xFC, 0xFF, 0x80,
  0x7F, 0xCF, 0xE3, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xC7, 0xF3, 0xFC, 0x00,
  0xFF, 0x3F, 0x8F, 0xE7, 0xF8, 0x01, 0xFE, 0xFE, 0x0F, 0xCF, 0xF0, 0x03,
  0xFD, 0xFC, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF8,
  0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF,
  0xBF, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x01, 0xFF,
  0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0,
  0x0F, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x0F, 0x83, 0xFF, 0x04, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0x3F, 0xFC, 0x7F, 0x1F, 0xF8, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFC, 0x1F, 0xF3,
  0xFF, 0x0F, 0xFB, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xCF,
  0xFE, 0x1F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x1F, 0xF8, 0x0C, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x27, 0xFE, 0x03, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC1, 0xFE, 0x3F, 0xE1, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF7, 0xFE, 0x1F, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xBF, 0xC3, 0xFF, 0x9F, 0xE0, 0xFF, 0x07, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xFF, 0x83, 0xFC, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x8F, 0xFE, 0x01,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x87, 0xFF, 0x3F, 0xC7, 0xFF, 0xDF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0,
  0x3F, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0x83, 0xFC, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF4, 0x00, 0x0F, 0xFB, 0x80, 0x1F, 0xFD,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x1F, 0xF7, 0xFF, 0x8F,
  0xFB, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xF0, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x0F,
  0xFC, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x83, 0xFF, 0x0F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0x9F,
  0xF0, 0x0F, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0xFF,
  0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xDF, 0xFF, 0x9F, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFE, 0x0F, 0xF8, 0x7F,
  0x1F, 0xFF, 0x3F, 0xDF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0x3F, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xDF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x8F, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F,
  0xFC, 0x3F, 0xCF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF,
  0xF8, 0x7F, 0xCF, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x87, 0xFF, 0x3F, 0xC7, 0xFF, 0xDF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0x83, 0xFC, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFB, 0xFC, 0xFF, 0x7F, 0xBF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x81, 0xCF, 0xF8, 0x04, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xC1, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0x1F,
  0xFE, 0x3F, 0x83, 0xFE, 0x1F, 0xC0, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xEF, 0xF0, 0x3F, 0xF8,
  0x1F, 0xE7, 0xF8, 0x3F, 0xFC, 0x0F, 0xF3, 0xFE, 0x1F, 0xFF, 0x0F, 0xF9,
  0xFF, 0x0F, 0xFF, 0x87, 0xF8, 0x7F, 0x87, 0xFF, 0xC3, 0xFC, 0x3F, 0xC3,
  0xF7, 0xE1, 0xFE, 0x1F, 0xE3, 0xFB, 0xF1, 0xFF, 0x0F, 0xF9, 0xFD, 0xFC,
  0xFF, 0x03, 0xFC, 0xFC, 0xFE, 0x7F, 0x81, 0xFE, 0x7E, 0x7F, 0x3F, 0xC0,
  0xFF, 0x3F, 0x3F, 0x9F, 0xE0, 0x3F, 0xBF, 0x8F, 0xDF, 0xE0, 0x1F, 0xDF,
  0xC7, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0xFF, 0xE1, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF,
  0x81, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x7F, 0xE0,
  0x3F, 0xF7, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFE, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_Black47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 35, 14, 2, -34 },
  { 45, 19, 13, 25, 3, -34 },
  { 76, 29, 34, 31, 1, -34 },
  { 200, 25, 39, 27, 1, -36 },
  { 322, 43, 34, 45, 1, -34 },
  { 505, 36, 34, 38, 2, -34 },
  { 658, 8, 13, 14, 3, -34 },
  { 671, 14, 42, 17, 2, -35 },
  { 745, 14, 42, 17, 1, -35 },
  { 819, 23, 23, 25, 1, -36 },
  { 886, 23, 23, 28, 2, -28 },
  { 953, 11, 14, 15, 1, -7 },
  { 973, 13, 7, 15, 1, -16 },
  { 985, 10, 9, 14, 2, -8 },
  { 997, 21, 34, 21, 0, -34 },
  { 1087, 24, 34, 28, 2, -34 },
  { 1189, 20, 34, 28, 2, -34 },
  { 1274, 25, 34, 28, 1, -34 },
  { 1381, 24, 34, 28, 2, -34 },
  { 1483, 26, 34, 28, 1, -34 },
  { 1594, 23, 34, 28, 2, -34 },
  { 1692, 24, 34, 28, 2, -34 },
  { 1794, 24, 34, 28, 2, -34 },
  { 1896, 24, 34, 28, 2, -34 },
  { 1998, 25, 34, 28, 1, -34 },
  { 2105, 10, 27, 14, 2, -26 },
  { 2139, 11, 33, 14, 1, -26 },
  { 2185, 23, 26, 28, 2, -30 },
  { 2260, 23, 17, 28, 2, -25 },
  { 2309, 23, 26, 28, 2, -30 },
  { 2384, 23, 35, 24, 0, -34 },
  { 2485, 38, 38, 42, 2, -34 },
  { 2666, 34, 34, 34, 0, -34 },
  { 2811, 25, 34, 32, 4, -34 },
  { 2918, 27, 34, 31, 2, -34 },
  { 3033, 28, 34, 35, 4, -34 },
  { 3152, 20, 34, 26, 4, -34 },
  { 3237, 19, 34, 25, 4, -34 },
  { 3318, 30, 34, 35, 2, -34 },
  { 3446, 28, 34, 36, 4, -34 },
  { 3565, 17, 34, 21, 2, -34 },
  { 3638, 17, 45, 17, -4, -34 },
  { 3734, 28, 34, 32, 4, -34 },
  { 3853, 22, 34, 27, 4, -34 },
  { 3947, 38, 34, 45, 4, -34 },
  { 4109, 32, 34, 39, 4, -34 },
  { 4245, 33, 34, 37, 2, -34 },
  { 4386, 24, 34, 30, 4, -34 },
  { 4488, 34, 42, 37, 2, -34 },
  { 4667, 28, 34, 32, 4, -34 },
  { 4786, 24, 34, 27, 2, -34 },
  { 4888, 26, 34, 28, 1, -34 },
  { 4999, 29, 34, 36, 3, -34 },
  { 5123, 33, 34, 33, 0, -34 },
  { 5264, 47, 34, 49, 1, -34 },
  { 5464, 34, 34, 34, 0, -34 },
  { 5609, 31, 34, 31, 0, -34 },
  { 5741, 27, 34, 29, 1, -34 },
  { 5856, 11, 43, 15, 3, -35 },
  { 5916, 21, 34, 21, 0, -34 },
  { 6006, 12, 43, 15, 1, -35 },
  { 6071, 25, 22, 25, 0, -34 },
  { 6140, 24, 6, 24, 0, 3 },
  { 6158, 16, 8, 20, 2, -36 },
  { 6174, 24, 26, 29, 2, -26 },
  { 6252, 25, 36, 30, 3, -36 },
  { 6365, 22, 26, 25, 2, -26 },
  { 6437, 25, 36, 30, 2, -36 },
  { 6550, 25, 26, 29, 2, -26 },
  { 6632, 20, 36, 19, 1, -36 },
  { 6722, 25, 37, 30, 2, -26 },
  { 6838, 25, 36, 31, 3, -36 },
  { 6951, 9, 36, 15, 3, -36 },
  { 6992, 14, 47, 15, -2, -36 },
  { 7075, 28, 36, 31, 3, -36 },
  { 7201, 9, 36, 15, 3, -36 },
  { 7242, 41, 26, 47, 3, -26 },
  { 7376, 25, 26, 31, 3, -26 },
  { 7458, 26, 26, 30, 2, -26 },
  { 7543, 25, 37, 30, 3, -26 },
  { 7659, 25, 37, 30, 2, -26 },
  { 7775, 19, 26, 22, 3, -26 },
  { 7837, 20, 26, 24, 2, -26 },
  { 7902, 19, 31, 22, 1, -31 },
  { 7976, 25, 26, 31, 3, -26 },
  { 8058, 29, 26, 29, 0, -26 },
  { 8153, 41, 26, 43, 1, -26 },
  { 8287, 29, 26, 30, 0, -26 },
  { 8382, 29, 37, 29, 0, -26 },
  { 8517, 22, 26, 24, 1, -26 },
  { 8589, 18, 42, 20, 1, -34 },
  { 8684, 6, 46, 24, 9, -36 },
  { 8719, 18, 42, 20, 1, -34 },
  { 8814, 23, 9, 28, 2, -21 },
};

const GFXfont NotoSans_Black47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black47pt7bBitmaps,
  (GFXglyph *)NotoSans_Black47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_BLACK47PT7B_H_
