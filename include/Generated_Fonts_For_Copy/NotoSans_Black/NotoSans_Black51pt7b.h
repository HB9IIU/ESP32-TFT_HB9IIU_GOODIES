#ifndef _NOTOSANS_BLACK51PT7B_H_
#define _NOTOSANS_BLACK51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0x1F, 0xC0, 0x40, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFD,
  0xFF, 0x1F, 0xEF, 0xF8, 0xFF, 0x7F, 0x87, 0xF9, 0xFC, 0x3F, 0xCF, 0xE1,
  0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x7F, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xCF, 0x87, 0xCF, 0xF9, 0xF0, 0x11, 0xFF,
  0x3E, 0x00, 0x3F, 0xE7, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7C, 0xFF, 0x80, 0x0F,
  0x8F, 0xF4, 0x01, 0xF1, 0xFE, 0xF0, 0x3E, 0x7F, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xF3, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x0F, 0xE0, 0x00, 0xFF,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE1,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F,
  0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF1, 0xFE, 0x1F, 0xE0, 0x7F, 0x3F, 0xC7,
  0xF1, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0x8F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE7, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x3F, 0xCF,
  0xFF, 0xF8, 0x3F, 0xF0, 0xFE, 0x3F, 0xCF, 0xF0, 0x3F, 0x07, 0xF8, 0xFE,
  0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x3F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xDF, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x02,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x7E, 0x0F, 0x7F, 0x3F,
  0x7F, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0x01,
  0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0x87, 0xC0, 0x03, 0x81, 0xC0,
  0x00, 0x40, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF1,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0xF1,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0x80, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE3,
  0xFF, 0x9F, 0xF8, 0x7F, 0xE7, 0xFC, 0x0F, 0xFB, 0xFF, 0x03, 0xFE, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xF9,
  0xFF, 0x07, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xFC, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFB, 0xFE, 0xFF, 0xDF, 0xF3, 0xFC, 0xFF, 0x8F, 0x8F,
  0xFC, 0x38, 0x7F, 0xE0, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xF3, 0xFF, 0xC3, 0xF0, 0x1F, 0xF8, 0x3C, 0x03, 0xFF,
  0x02, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0x03, 0xFF, 0x86, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFB, 0xFF,
  0x00, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFF, 0x01, 0xFE, 0x3F, 0xF0, 0x3F,
  0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0x83, 0xFF, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x08, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE8, 0x00, 0x1F, 0xFB, 0x80, 0x0F, 0xFE, 0xFE, 0x0F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF9, 0xFF, 0xC3, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xE0,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0x8F, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F, 0xFB, 0xFF, 0x87, 0xFE, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1,
  0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xDF, 0xF1, 0xFF, 0xF7, 0xFC, 0x3F,
  0xF9, 0xFF, 0x01, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x08, 0x07, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x04, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F,
  0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0x1F, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xE3, 0xF8, 0x08, 0x00, 0x03, 0x01, 0xFC, 0x3F, 0xE7, 0xFE,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF3, 0xFE, 0x3F, 0xE0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0x01, 0xFF, 0x8C,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0xC1, 0xFE,
  0x0F, 0xFF, 0xE7, 0xF0, 0xFF, 0x07, 0xFF, 0xFC, 0xFE, 0x3F, 0x87, 0xFF,
  0xFE, 0x3F, 0x9F, 0xE3, 0xFF, 0xFF, 0x8F, 0xE7, 0xF0, 0xFF, 0xFF, 0xE1,
  0xF9, 0xFC, 0x7F, 0xC3, 0xF8, 0x7F, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xFF,
  0x8F, 0xF0, 0x3F, 0x87, 0xFF, 0xE3, 0xF8, 0x0F, 0xE1, 0xFF, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0x3F,
  0x87, 0xEF, 0xE3, 0xF8, 0x0F, 0xE1, 0xFB, 0xF8, 0xFE, 0x07, 0xF8, 0xFE,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xBF, 0x87, 0xF9, 0xFF, 0xDF, 0xCF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xC7, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xF0,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFD,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC,
  0x1F, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F,
  0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xC3, 0xFF, 0xC0, 0x0E, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x47, 0xFF, 0xC0,
  0x1E, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0x80, 0x7F,
  0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF,
  0xDF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xBF,
  0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF,
  0x80, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0xE7, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xF0, 0xFF, 0xF8, 0x00, 0x61, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFD, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xC0, 0x3F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFA, 0x1F, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0xCF,
  0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x03, 0xFF,
  0x1F, 0xFC, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFB,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF,
  0x80, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xDF, 0xC0, 0x1F, 0xDF,
  0xFF, 0xEF, 0xF0, 0x0F, 0xEF, 0xFF, 0xF7, 0xF8, 0x07, 0xF7, 0xFF, 0xFB,
  0xFC, 0x07, 0xFB, 0xFF, 0xFC, 0xFE, 0x03, 0xFB, 0xFF, 0xFE, 0x7F, 0x81,
  0xFD, 0xFF, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0xFF, 0xCF, 0xE0, 0xFE, 0x7F,
  0xFF, 0xE7, 0xF8, 0x7F, 0x3F, 0xFF, 0xF3, 0xFC, 0x3F, 0x9F, 0xFF, 0xF9,
  0xFE, 0x3F, 0xCF, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF, 0xFE, 0x3F, 0xCF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xEF, 0xF1, 0xFF, 0xFF, 0x87, 0xF7, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xF0,
  0x1F, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0xFF, 0xC7,
  0xFE, 0x0F, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F,
  0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xE0, 0x7F,
  0xEF, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x7F,
  0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xC0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xCF,
  0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F,
  0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x80, 0xFF,
  0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00,
  0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x3E, 0x1F,
  0xF0, 0x01, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F,
  0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFB, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x7F, 0x03, 0xFE, 0x07,
  0xFE, 0x1F, 0xEF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFD, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xBF, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFC, 0x7F, 0x0F, 0xF8, 0x03, 0xFE, 0x7F, 0x8F, 0xF3,
  0xFE, 0x00, 0x7F, 0xCF, 0xF1, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0x3F,
  0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0x83, 0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xF0,
  0x7F, 0x3F, 0xC0, 0x03, 0xFF, 0xFE, 0x0F, 0xEF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00,
  0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xDF,
  0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0x0F, 0xFE,
  0x06, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0x8F, 0xF0, 0xFF, 0xC0, 0xFE, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC1, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xCF, 0xFE,
  0x0F, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xEF, 0xFE, 0x07,
  0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE,
  0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF,
  0x0F, 0xF9, 0xFF, 0xE0, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xF8, 0x3C, 0x7F, 0xF0, 0x04, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0x7F,
  0xF0, 0x06, 0x7F, 0xF8, 0x3E, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x03, 0xE0, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0xFF, 0xF3,
  0xFE, 0x3F, 0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE3, 0xFF, 0xBF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xF8,
  0x1F, 0xFB, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xFE, 0x0F, 0xFE,
  0x3F, 0xC0, 0xFF, 0x83, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0x83, 0xFE, 0x7F,
  0xE0, 0x3F, 0xEF, 0xFC, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x04, 0xFF, 0xE0, 0x03, 0x8F, 0xFF,
  0xCF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0x84, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xC3, 0xFC, 0x3F, 0xFE, 0x7F, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xE1, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFE, 0xFF, 0x83, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x00,
  0x40, 0x7F, 0xC0, 0x00, 0x0F, 0xFA, 0x00, 0x03, 0xFF, 0x70, 0x00, 0xFF,
  0xEF, 0xF0, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF,
  0xFF, 0x8F, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x06, 0x0F, 0xF1,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xBF, 0xF3, 0xFE, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF,
  0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD,
  0xFF, 0xBF, 0xF7, 0xFE, 0x00, 0x18, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xEF, 0xFC,
  0x03, 0xFF, 0x9F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x1F,
  0xFC, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x9F,
  0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x78, 0x07, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x7F,
  0xF7, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xFF, 0x0F, 0xF9, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF0, 0xFF, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0x9F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0xE0, 0xFF, 0xC7,
  0xFC, 0x0F, 0xFC, 0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xC3, 0xFC, 0x3F, 0xFE, 0x7F, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xE1, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFE, 0xFF, 0x83, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x00, 0x40,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xF0, 0x7C, 0xFF, 0xC0, 0x33, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x02, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x86, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x02, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF1, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0x8F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F,
  0xFD, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x3F, 0xFC, 0x07, 0xFC, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0x3F, 0xE0,
  0x7F, 0xFC, 0x1F, 0xF1, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x3F,
  0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xEF,
  0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x7F, 0x1F, 0xF0, 0x3F, 0xE7, 0xF3, 0xF8,
  0xFF, 0x81, 0xFF, 0x3F, 0x9F, 0xC7, 0xF8, 0x0F, 0xF9, 0xFC, 0xFE, 0x7F,
  0xC0, 0x3F, 0xCF, 0xE7, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x1F, 0xDF, 0xF0,
  0x0F, 0xF7, 0xF0, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x87, 0xF7, 0xF8, 0x01,
  0xFF, 0xFC, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF, 0xE0, 0xFD, 0xFC, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3,
  0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x07,
  0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x50, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x4F, 0xFE, 0x00, 0x37, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0xC0, 0x07, 0xFF, 0x20, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_Black51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 37, 15, 2, -36 },
  { 52, 21, 13, 27, 3, -36 },
  { 87, 32, 36, 34, 1, -36 },
  { 231, 27, 42, 29, 1, -39 },
  { 373, 46, 37, 48, 1, -37 },
  { 586, 39, 38, 41, 2, -37 },
  { 772, 9, 13, 15, 3, -36 },
  { 787, 15, 45, 18, 2, -37 },
  { 872, 15, 45, 18, 1, -37 },
  { 957, 25, 25, 27, 1, -39 },
  { 1036, 26, 24, 30, 2, -30 },
  { 1114, 12, 14, 16, 1, -7 },
  { 1135, 14, 8, 16, 1, -18 },
  { 1149, 11, 10, 15, 2, -9 },
  { 1163, 22, 38, 23, 0, -37 },
  { 1268, 26, 38, 30, 2, -37 },
  { 1392, 21, 36, 30, 2, -36 },
  { 1487, 27, 37, 30, 1, -37 },
  { 1612, 26, 38, 30, 2, -37 },
  { 1736, 28, 36, 30, 1, -36 },
  { 1862, 26, 37, 30, 2, -36 },
  { 1983, 26, 38, 30, 2, -37 },
  { 2107, 26, 36, 30, 2, -36 },
  { 2224, 26, 38, 30, 2, -37 },
  { 2348, 26, 38, 30, 2, -37 },
  { 2472, 11, 30, 15, 2, -29 },
  { 2514, 12, 36, 15, 1, -29 },
  { 2568, 25, 28, 30, 2, -32 },
  { 2656, 26, 18, 30, 2, -27 },
  { 2715, 25, 28, 30, 2, -32 },
  { 2803, 25, 38, 26, 0, -37 },
  { 2922, 42, 41, 46, 2, -37 },
  { 3138, 37, 37, 37, 0, -37 },
  { 3310, 28, 36, 34, 4, -36 },
  { 3436, 29, 38, 33, 3, -37 },
  { 3574, 31, 36, 37, 4, -36 },
  { 3714, 22, 36, 28, 4, -36 },
  { 3813, 21, 36, 27, 4, -36 },
  { 3908, 31, 38, 38, 3, -37 },
  { 4056, 31, 36, 39, 4, -36 },
  { 4196, 19, 36, 22, 2, -36 },
  { 4282, 18, 47, 18, -4, -36 },
  { 4388, 31, 36, 35, 4, -36 },
  { 4528, 24, 36, 30, 4, -36 },
  { 4636, 41, 36, 49, 4, -36 },
  { 4821, 35, 36, 43, 4, -36 },
  { 4979, 35, 38, 41, 3, -37 },
  { 5146, 26, 36, 32, 4, -36 },
  { 5263, 36, 46, 41, 3, -37 },
  { 5470, 31, 36, 35, 4, -36 },
  { 5610, 26, 38, 29, 2, -37 },
  { 5734, 28, 36, 30, 1, -36 },
  { 5860, 31, 37, 39, 4, -36 },
  { 6004, 35, 36, 35, 0, -36 },
  { 6162, 51, 36, 53, 1, -36 },
  { 6392, 37, 36, 37, 0, -36 },
  { 6559, 34, 36, 34, 0, -36 },
  { 6712, 28, 36, 31, 2, -36 },
  { 6838, 12, 46, 17, 3, -37 },
  { 6907, 22, 38, 23, 0, -37 },
  { 7012, 13, 46, 17, 1, -37 },
  { 7087, 27, 25, 27, 0, -37 },
  { 7172, 26, 6, 26, 0, 3 },
  { 7192, 17, 8, 21, 2, -39 },
  { 7209, 27, 30, 32, 2, -29 },
  { 7311, 28, 40, 33, 3, -39 },
  { 7451, 24, 30, 27, 2, -29 },
  { 7541, 27, 40, 33, 2, -39 },
  { 7676, 27, 30, 32, 2, -29 },
  { 7778, 21, 39, 21, 1, -39 },
  { 7881, 27, 41, 33, 2, -29 },
  { 8020, 28, 39, 34, 3, -39 },
  { 8157, 11, 40, 17, 3, -40 },
  { 8212, 16, 52, 17, -3, -40 },
  { 8316, 31, 39, 34, 3, -39 },
  { 8468, 10, 39, 16, 3, -39 },
  { 8517, 45, 29, 51, 3, -29 },
  { 8681, 28, 29, 34, 3, -29 },
  { 8783, 28, 30, 32, 2, -29 },
  { 8888, 28, 41, 33, 3, -29 },
  { 9032, 27, 41, 33, 2, -29 },
  { 9171, 20, 29, 24, 3, -29 },
  { 9244, 22, 30, 26, 2, -29 },
  { 9327, 21, 35, 23, 1, -34 },
  { 9419, 28, 29, 34, 3, -28 },
  { 9521, 31, 28, 31, 0, -28 },
  { 9630, 45, 28, 46, 1, -28 },
  { 9788, 32, 28, 32, 0, -28 },
  { 9900, 31, 40, 31, 0, -28 },
  { 10055, 24, 28, 26, 1, -28 },
  { 10139, 18, 46, 22, 2, -37 },
  { 10243, 6, 50, 26, 10, -39 },
  { 10281, 19, 46, 22, 2, -37 },
  { 10391, 26, 10, 30, 2, -23 },
};

const GFXfont NotoSans_Black51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black51pt7bBitmaps,
  (GFXglyph *)NotoSans_Black51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_BLACK51PT7B_H_
