#ifndef _NOTOSANS_BLACK52PT7B_H_
#define _NOTOSANS_BLACK52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xE3, 0xF8, 0x08, 0x00, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F,
  0xEF, 0xF0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFE, 0xF7, 0xF8, 0xFF, 0x8F, 0x03, 0x8F, 0xF8, 0xF0, 0x00, 0xFF, 0x8F,
  0x00, 0x0F, 0xFC, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0x7F, 0xF0, 0x00, 0xF1, 0xFF, 0x00,
  0x0F, 0x1F, 0xF6, 0x00, 0xF1, 0xFF, 0x7C, 0x0F, 0x3F, 0xF7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF1, 0xFC,
  0x0F, 0x80, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0xE0, 0xFF, 0x7F, 0x8F, 0xE3,
  0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xCF, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x1F,
  0xFF, 0xE3, 0xFF, 0xF9, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xE3, 0xF8, 0xFF,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF1, 0xFC, 0x7F, 0x80, 0x70, 0x3F, 0xC7, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x87,
  0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x7F, 0xF8,
  0x07, 0xFF, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x01, 0xC0, 0xFC, 0x06, 0x7E, 0x3F, 0x1F, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xF3,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x0F, 0x83, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x0F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFE, 0x3F, 0x80, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFB, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x3F, 0xE0,
  0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7,
  0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x1F,
  0xFB, 0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF,
  0xC3, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0x3F, 0xCF, 0xFC, 0x7E, 0x3F, 0xF0,
  0xF0, 0xFF, 0xC3, 0x83, 0xFF, 0x04, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFC,
  0x0F, 0xFE, 0x0F, 0x80, 0x7F, 0xE0, 0x60, 0x07, 0xFE, 0x04, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xEF, 0xFF, 0x87, 0x00, 0x7F,
  0xE0, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE,
  0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0x3F, 0xF0, 0x0F, 0xF1, 0xFF,
  0x80, 0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0x7F, 0xE0, 0x7F, 0x83, 0xFF, 0x07,
  0xFC, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x1F, 0x9F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x00,
  0x87, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x87, 0xC0, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0xFF, 0xF0,
  0xFF, 0xBF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE1, 0xFF, 0xBF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0x9F,
  0xFE, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF, 0xF8, 0x1F, 0xF9, 0xFF, 0x03, 0xFF,
  0x3F, 0xE0, 0x7F, 0xE7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE7, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0xFF, 0xDF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xF3, 0xFF, 0x9F, 0xF8, 0x3F, 0xFB, 0xFF, 0x03, 0xFF,
  0x7F, 0xE0, 0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0x7F, 0x8F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFB, 0xFE, 0x07, 0xFC, 0x7F, 0xC0,
  0x0E, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x08, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0x0F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0x80,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0xFF, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xE3, 0xF8, 0x08, 0x00, 0x0F, 0xC3, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x3F, 0xF3, 0xFE, 0x1F, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0x8E, 0x00, 0x7F, 0xC4, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0xFF, 0xF1, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0x9F, 0xC3, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFC, 0x7F, 0x0F, 0xFF, 0xFE, 0x3F, 0x9F, 0xE3, 0xFF, 0xFF,
  0xC7, 0xF3, 0xF8, 0x7F, 0xC3, 0xF8, 0x7E, 0x7F, 0x1F, 0xE0, 0x7F, 0x0F,
  0xCF, 0xE3, 0xF8, 0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xFF,
  0x1F, 0xE0, 0x3F, 0x87, 0xFF, 0xE3, 0xF8, 0x07, 0xF0, 0xFD, 0xFC, 0x7F,
  0x00, 0xFE, 0x1F, 0xBF, 0x8F, 0xE0, 0x3F, 0xC7, 0xF7, 0xF1, 0xFC, 0x07,
  0xF8, 0xFE, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xDF, 0xC3, 0xF8, 0x3F, 0xE7,
  0xF3, 0xF8, 0x7F, 0xDF, 0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0x87,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xBF, 0xFC, 0x1F, 0xE0,
  0xFF, 0xE3, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xDF, 0xF8, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0xBF,
  0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xDF, 0xF8,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xE0, 0x0F, 0x1F, 0xFE, 0x00, 0x10, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0x3F,
  0xFE, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0xFC,
  0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x70, 0x7F, 0xF8, 0x00, 0x10,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0x7F, 0xF8, 0x01, 0xFF,
  0x3F, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80,
  0x3D, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xF7, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xFF, 0xFD, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF,
  0xFB, 0xFC, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0x03, 0xFD, 0xFF, 0xFF, 0xBF,
  0xC0, 0xFF, 0x7F, 0xFF, 0xE7, 0xF8, 0x3F, 0x9F, 0xFF, 0xF9, 0xFE, 0x0F,
  0xE7, 0xFF, 0xFE, 0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0x9F, 0xE1, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFC, 0x7F, 0x1F, 0xFF, 0xF8, 0xFF, 0x3F, 0xC7, 0xFF, 0xFE,
  0x3F, 0xCF, 0xF1, 0xFF, 0xFF, 0x87, 0xFB, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x7F,
  0xE0, 0x7F, 0xFF, 0xE7, 0xFE, 0x0F, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF,
  0x8F, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0x07, 0xFE,
  0x3F, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xFF, 0x80,
  0xFF, 0xDF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF,
  0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xCF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF,
  0xE0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0xFF, 0x1F, 0xF8, 0x03, 0xC7, 0xFE,
  0x00, 0x21, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F, 0xFF,
  0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xF9, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xF9, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xF9, 0xFE, 0x3F, 0xE0,
  0x07, 0xFC, 0x7F, 0x0F, 0xE3, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0xFE, 0x3F,
  0xE0, 0x07, 0xFC, 0xFF, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0xFF,
  0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x07, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xE0,
  0x7F, 0x7F, 0xC0, 0x03, 0xFE, 0xFE, 0x07, 0xF7, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF,
  0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00,
  0xFF, 0xEF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3C, 0x07, 0xFF, 0x06, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0x8F, 0xFF, 0x8F, 0xF0, 0xFF, 0xC0, 0xFE, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFD,
  0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFD,
  0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0xF0, 0x0C, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x27, 0xFF, 0x00, 0x73, 0xFF, 0xE3, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x1F, 0xE3, 0xFF, 0x07, 0xFF, 0x3F, 0xF0, 0xFF, 0xFB, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7,
  0xFF, 0x03, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xFF,
  0x07, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x47, 0xFF, 0x80, 0x1C, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0x0F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFD, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF7,
  0xFF, 0x8F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0xF0, 0x7F, 0xF3, 0xFF,
  0x03, 0xFE, 0x3F, 0xF0, 0x02, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x70, 0x00, 0x7F, 0xF7, 0xF0, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0xFF, 0xF8, 0x7F, 0xEF, 0xFF,
  0xE3, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF,
  0x03, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x3F,
  0x8F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF1, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB,
  0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xEC, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xDF,
  0xF8, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x07, 0xFE,
  0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF7,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x01, 0xFF,
  0xC7, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x9F, 0xF8, 0x07, 0xFF,
  0xBF, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0x7F, 0xFC, 0x3F, 0xE7, 0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE,
  0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFD, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xDF, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x0F,
  0xF8, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0x8F, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0x8F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC7,
  0xFC, 0x0F, 0xFC, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0x0F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFD, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0x7F, 0xF0, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF7, 0xFF, 0x8F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0xF0, 0x7F, 0xF3, 0xFF, 0x03, 0xFE,
  0x3F, 0xF0, 0x02, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFD, 0xFE, 0x7F, 0xE0, 0x38,
  0xFF, 0xC0, 0x11, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x16, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x70, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF,
  0xCF, 0xF0, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0x07, 0xF0, 0x06, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80,
  0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0x9F, 0xF0, 0x3F, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0xF8, 0x1F,
  0xF9, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xC7, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFD, 0xFC, 0x3F, 0xE0,
  0xFF, 0x87, 0xF7, 0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0xDF, 0xC3, 0xFE, 0x07,
  0xFC, 0x7F, 0x7F, 0x8F, 0xF8, 0x1F, 0xF3, 0xFD, 0xFE, 0x7F, 0xC0, 0x7F,
  0xCF, 0xF3, 0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0x8F, 0xE7, 0xFC, 0x03, 0xFC,
  0xFE, 0x3F, 0x9F, 0xF0, 0x0F, 0xFB, 0xF8, 0xFF, 0x7F, 0x80, 0x3F, 0xEF,
  0xE3, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x1F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xC0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x8F, 0xFE,
  0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x13, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x4F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFE, 0xC0, 0x03, 0xFF, 0x20, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_Black52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 38, 15, 2, -37 },
  { 54, 21, 13, 27, 3, -37 },
  { 89, 32, 37, 34, 1, -37 },
  { 237, 28, 43, 30, 1, -40 },
  { 388, 47, 38, 49, 1, -38 },
  { 612, 40, 39, 42, 2, -38 },
  { 807, 9, 13, 15, 3, -37 },
  { 822, 15, 46, 19, 2, -38 },
  { 909, 16, 46, 19, 1, -38 },
  { 1001, 26, 25, 28, 1, -40 },
  { 1083, 26, 25, 30, 2, -31 },
  { 1165, 12, 15, 16, 1, -8 },
  { 1188, 14, 8, 17, 1, -18 },
  { 1202, 11, 10, 15, 2, -9 },
  { 1216, 23, 39, 23, 0, -38 },
  { 1329, 27, 39, 30, 2, -38 },
  { 1461, 22, 37, 30, 2, -37 },
  { 1563, 28, 38, 30, 1, -38 },
  { 1696, 26, 39, 30, 2, -38 },
  { 1823, 29, 37, 30, 1, -37 },
  { 1958, 26, 38, 30, 2, -37 },
  { 2082, 27, 39, 30, 2, -38 },
  { 2214, 27, 37, 30, 2, -37 },
  { 2339, 27, 39, 30, 2, -38 },
  { 2471, 27, 39, 30, 2, -38 },
  { 2603, 11, 30, 15, 2, -29 },
  { 2645, 12, 36, 15, 1, -29 },
  { 2699, 26, 28, 30, 2, -33 },
  { 2790, 26, 19, 30, 2, -28 },
  { 2852, 26, 28, 30, 2, -33 },
  { 2943, 25, 39, 26, 0, -38 },
  { 3065, 43, 42, 47, 2, -38 },
  { 3291, 38, 37, 38, 0, -37 },
  { 3467, 29, 37, 35, 4, -37 },
  { 3602, 29, 39, 34, 3, -38 },
  { 3744, 32, 37, 38, 4, -37 },
  { 3892, 22, 37, 29, 4, -37 },
  { 3994, 22, 37, 28, 4, -37 },
  { 4096, 32, 39, 38, 3, -38 },
  { 4252, 32, 37, 40, 4, -37 },
  { 4400, 19, 37, 23, 2, -37 },
  { 4488, 18, 49, 18, -4, -37 },
  { 4599, 32, 37, 36, 4, -37 },
  { 4747, 24, 37, 30, 4, -37 },
  { 4858, 42, 37, 50, 4, -37 },
  { 5053, 35, 37, 43, 4, -37 },
  { 5215, 36, 39, 41, 3, -38 },
  { 5391, 27, 37, 33, 4, -37 },
  { 5516, 37, 47, 41, 3, -38 },
  { 5734, 32, 37, 35, 4, -37 },
  { 5882, 26, 39, 30, 2, -38 },
  { 6009, 28, 37, 31, 1, -37 },
  { 6139, 32, 38, 39, 4, -37 },
  { 6291, 36, 37, 36, 0, -37 },
  { 6458, 52, 37, 54, 1, -37 },
  { 6699, 37, 37, 38, 0, -37 },
  { 6871, 35, 37, 35, 0, -37 },
  { 7033, 28, 37, 32, 2, -37 },
  { 7163, 13, 47, 17, 3, -38 },
  { 7240, 23, 39, 23, 0, -38 },
  { 7353, 13, 47, 17, 1, -38 },
  { 7430, 28, 24, 27, 0, -37 },
  { 7514, 26, 7, 26, 0, 3 },
  { 7537, 18, 8, 22, 2, -40 },
  { 7555, 27, 30, 32, 2, -29 },
  { 7657, 28, 41, 33, 3, -40 },
  { 7801, 25, 30, 28, 2, -29 },
  { 7895, 28, 41, 33, 2, -40 },
  { 8039, 28, 30, 32, 2, -29 },
  { 8144, 22, 40, 21, 1, -40 },
  { 8254, 28, 41, 33, 2, -29 },
  { 8398, 29, 40, 35, 3, -40 },
  { 8543, 11, 40, 17, 3, -40 },
  { 8598, 17, 52, 17, -3, -40 },
  { 8709, 31, 40, 34, 3, -40 },
  { 8864, 10, 40, 17, 3, -40 },
  { 8914, 46, 29, 52, 3, -29 },
  { 9081, 29, 29, 35, 3, -29 },
  { 9187, 29, 30, 33, 2, -29 },
  { 9296, 28, 41, 33, 3, -29 },
  { 9440, 28, 41, 33, 2, -29 },
  { 9584, 21, 29, 24, 3, -29 },
  { 9661, 23, 30, 27, 2, -29 },
  { 9748, 21, 36, 24, 1, -35 },
  { 9843, 28, 30, 35, 3, -29 },
  { 9948, 32, 29, 32, 0, -29 },
  { 10064, 46, 29, 47, 1, -29 },
  { 10231, 33, 29, 33, 0, -29 },
  { 10351, 32, 41, 32, 0, -29 },
  { 10515, 24, 29, 26, 1, -29 },
  { 10602, 19, 47, 23, 2, -38 },
  { 10714, 7, 51, 26, 10, -40 },
  { 10759, 19, 47, 23, 2, -38 },
  { 10871, 26, 10, 30, 2, -23 },
};

const GFXfont NotoSans_Black52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black52pt7bBitmaps,
  (GFXglyph *)NotoSans_Black52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_BLACK52PT7B_H_
