#ifndef _NOTOSANS_BLACK31PT7B_H_
#define _NOTOSANS_BLACK31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x80, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0x03, 0xCF, 0x80,
  0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x3C, 0x78, 0x07,
  0x9E, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x1E,
  0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79,
  0xF0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x1F, 0xFC, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFB, 0x8C, 0xFB, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0x9F,
  0x83, 0x9F, 0xF3, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x3F, 0x00, 0x7C, 0x07, 0xF8, 0x07,
  0x80, 0xFF, 0xC0, 0xF8, 0x0F, 0xBE, 0x1F, 0x00, 0xF3, 0xE1, 0xE0, 0x0F,
  0x3E, 0x3E, 0x00, 0xF3, 0xE3, 0xC0, 0x0F, 0x3E, 0x7C, 0x00, 0xF3, 0xE7,
  0x86, 0x0F, 0xBE, 0xF9, 0xFC, 0xFF, 0xCF, 0x3F, 0xC7, 0xFD, 0xF7, 0xFE,
  0x3F, 0xBE, 0x79, 0xE0, 0x03, 0xCF, 0x9F, 0x00, 0x7C, 0xF9, 0xF0, 0x07,
  0x8F, 0x9F, 0x00, 0xF8, 0xF9, 0xF0, 0x0F, 0x07, 0x9F, 0x01, 0xF0, 0x7F,
  0xE0, 0x1E, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x01, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFE, 0x3F, 0xF8, 0xFC, 0x7F,
  0xFC, 0xFC, 0x7E, 0xFF, 0xF8, 0xFC, 0x7F, 0xF8, 0xFC, 0x3F, 0xF0, 0xFC,
  0x1F, 0xF0, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x8F,
  0xC7, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x08, 0x78, 0x5F,
  0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x7F, 0x80, 0xF7,
  0x83, 0xEF, 0x8F, 0x8F, 0x03, 0x18, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFF, 0xFF, 0xE7, 0xC0, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7E, 0x3E,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xF8, 0x1F, 0xC1,
  0xFE, 0x3F, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xBF, 0x39, 0xF8, 0x8F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0xF0, 0x3F, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x38, 0x7F, 0x10, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE,
  0x3C, 0xFE, 0x20, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x7F, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7E, 0x1F, 0xBF, 0x0F,
  0x9F, 0x8F, 0x8F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x10,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xFD, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x70, 0xFD,
  0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0x7F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0x7C, 0x3F, 0x7E,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFE, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFE, 0xFE, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x3F, 0x9F, 0x07,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x47, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xC0, 0x7D, 0xFB, 0xFF, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xDF, 0xFF, 0xFE, 0x7C, 0x7D, 0xFF, 0xFF, 0xF7, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF,
  0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0xFB, 0xFF,
  0xF3, 0xFF, 0xF7, 0xC7, 0xE4, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x87, 0xE3, 0xC3, 0xC7, 0xFE, 0x79,
  0xF3, 0xFF, 0x9E, 0x79, 0xFD, 0xE7, 0x9E, 0x78, 0x78, 0xFF, 0xBE, 0x1E,
  0x3F, 0xCF, 0x87, 0x9F, 0xF3, 0xE1, 0xE7, 0xBC, 0xF8, 0xF9, 0xEF, 0x3E,
  0x3E, 0x7B, 0xE7, 0xFF, 0xFC, 0x79, 0xFF, 0xFF, 0x1E, 0x3F, 0x9F, 0x87,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x1F, 0xC0, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0,
  0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F, 0x80,
  0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFC,
  0x07, 0xE3, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE7, 0xFD, 0xF3, 0xF8, 0x0B, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFC,
  0x3F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xFE, 0xF8, 0xFE, 0x01, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7F, 0x07, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0xFF, 0xDF, 0xF3,
  0xFE, 0x7F, 0x8F, 0xC0, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7F, 0x7E,
  0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0xE7, 0xE0, 0xFD,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xC0, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xBC,
  0x0F, 0xFF, 0xEF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF,
  0xDE, 0x1E, 0xFF, 0xF7, 0xCF, 0xBF, 0xFD, 0xF3, 0xCF, 0xFF, 0x3C, 0xF3,
  0xFF, 0xCF, 0xFC, 0xFF, 0xF3, 0xFF, 0x3F, 0xFC, 0xFF, 0x8F, 0xFF, 0x1F,
  0xE3, 0xFF, 0xC7, 0xF8, 0xFF, 0xF1, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0x7E, 0x1F,
  0xFD, 0xF8, 0xFF, 0xEF, 0xC7, 0xFF, 0x3F, 0x3F, 0xF9, 0xF9, 0xFF, 0xC7,
  0xEF, 0xFE, 0x3F, 0x7F, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7,
  0xFD, 0xFF, 0x7F, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7E, 0x7F, 0x07, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F,
  0xBF, 0x80, 0xFE, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xCF, 0xF1, 0xF8, 0x7F,
  0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xF0,
  0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x7E, 0x0F, 0xEF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xC0, 0x0F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F,
  0x3E, 0x7C, 0x04, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0x7E, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0xFE, 0x01, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE1,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x7E, 0x07, 0xE0, 0x3E,
  0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF0, 0x7E,
  0x3E, 0x0F, 0xF0, 0x7C, 0x3F, 0x0F, 0xF0, 0x7C, 0x3F, 0x0F, 0xF8, 0xFC,
  0x1F, 0x1F, 0xF8, 0xFC, 0x1F, 0x1F, 0x78, 0xF8, 0x1F, 0x9F, 0x78, 0xF8,
  0x1F, 0x9E, 0x7D, 0xF8, 0x0F, 0xBE, 0x7D, 0xF8, 0x0F, 0xBE, 0x7D, 0xF0,
  0x0F, 0xBE, 0x3D, 0xF0, 0x0F, 0xFC, 0x3D, 0xF0, 0x07, 0xFC, 0x3F, 0xF0,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0xFC,
  0x0F, 0xE3, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xCF, 0xE0, 0x7F, 0x1F, 0x83, 0xF8, 0x7F,
  0x0F, 0xC0, 0xFE, 0x7F, 0x03, 0xFB, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFB,
  0xF0, 0x3F, 0x9F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF,
  0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x7B, 0xE0, 0x3C, 0xF0, 0x3E, 0x7C, 0x1E, 0x1E, 0x0F, 0x0F, 0x8F, 0x03,
  0xC7, 0x81, 0xF7, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x1F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x18, 0x3F, 0x00, 0x3F, 0x07, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7F, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0x7F, 0xDF, 0x3F, 0x8F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFB, 0xF8, 0xFF,
  0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xCF, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF, 0xEF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xF3, 0xF0, 0x07, 0xFC, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xE7, 0xF1, 0x8F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x27, 0xFB, 0xCF, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0xBF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xE7, 0xF7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x87, 0xEF, 0xEF, 0xF7,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0x3E, 0x1F, 0x1F, 0x0F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE1, 0xF3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x33,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x7F,
  0xC7, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0xFC, 0x0F, 0xFE, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFC, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0xCF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF3, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF,
  0xC3, 0xF7, 0xF3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xBF, 0x0F, 0x9F,
  0x80, 0x0F, 0xC0, 0x07, 0xEE, 0x0F, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFB, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF9, 0xFF, 0xFF, 0xFF,
  0xBF, 0xEF, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0xFC, 0x3F, 0xBF,
  0x1F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xEF, 0xE3, 0xF1, 0xFC,
  0xFC, 0x3F, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x7F, 0x9F, 0x7F, 0xDF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF,
  0x0F, 0xE1, 0xFF, 0xE0, 0xFC, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0,
  0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8,
  0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07,
  0xE0, 0xF9, 0xFC, 0x7D, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE3,
  0xFB, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xEF, 0xC3, 0xF7, 0xF3, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC,
  0x07, 0xF8, 0x00, 0xF9, 0xFC, 0x7D, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xE7, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xDF, 0x87, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF,
  0xF8, 0xFD, 0xF8, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xCF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xF3, 0xFB, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0xC3, 0xF7, 0xF3, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xBF, 0x0F, 0x9F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0xFF, 0xBF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0xF1, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0xFC, 0x13, 0xFC, 0x07, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x93, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xDF, 0x1F,
  0x8F, 0x80, 0xFC, 0x07, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0xBF, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC3, 0xF7, 0xE3,
  0xFC, 0x3E, 0x7E, 0x3F, 0xC3, 0xE7, 0xE3, 0xFC, 0x7E, 0x3E, 0x3F, 0xC7,
  0xE3, 0xE3, 0xFE, 0x7C, 0x3F, 0x7F, 0xE7, 0xC3, 0xF7, 0x9E, 0xFC, 0x1F,
  0x79, 0xEF, 0x81, 0xF7, 0x9E, 0xF8, 0x1F, 0x79, 0xFF, 0x80, 0xFF, 0x9F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x0F, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0x0F, 0xEF, 0xE1, 0xF8,
  0xFE, 0x7E, 0x0F, 0xDF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x81,
  0xFB, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xF3, 0xF8, 0x7E, 0xFE, 0x0F, 0xE0,
  0xFC, 0x07, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xF1, 0xF8,
  0x7E, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x7F, 0x8F, 0xE1, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x1F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0xF8, 0x00, 0x3E, 0x01, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0x80, 0x7C,
};

const GFXglyph NotoSans_Black31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 22, 9, 1, -22 },
  { 21, 12, 8, 16, 2, -22 },
  { 33, 19, 22, 21, 1, -22 },
  { 86, 16, 26, 18, 1, -24 },
  { 138, 28, 22, 29, 1, -22 },
  { 215, 24, 22, 25, 1, -22 },
  { 281, 5, 8, 9, 2, -22 },
  { 286, 9, 28, 11, 1, -23 },
  { 318, 9, 28, 11, 1, -23 },
  { 350, 15, 15, 17, 1, -24 },
  { 379, 16, 16, 18, 1, -19 },
  { 411, 7, 9, 10, 1, -5 },
  { 419, 8, 5, 10, 1, -11 },
  { 424, 7, 5, 9, 1, -5 },
  { 429, 14, 22, 14, 0, -22 },
  { 468, 16, 22, 18, 1, -22 },
  { 512, 13, 22, 18, 1, -22 },
  { 548, 16, 22, 18, 1, -22 },
  { 592, 16, 22, 18, 1, -22 },
  { 636, 17, 22, 18, 1, -22 },
  { 683, 16, 22, 18, 1, -22 },
  { 727, 16, 22, 18, 1, -22 },
  { 771, 16, 22, 18, 1, -22 },
  { 815, 16, 22, 18, 1, -22 },
  { 859, 16, 22, 18, 1, -22 },
  { 903, 7, 17, 9, 1, -17 },
  { 918, 7, 21, 9, 1, -17 },
  { 937, 16, 17, 18, 1, -20 },
  { 971, 16, 11, 18, 1, -16 },
  { 993, 16, 17, 18, 1, -20 },
  { 1027, 15, 22, 16, 0, -22 },
  { 1069, 26, 24, 28, 1, -22 },
  { 1147, 23, 22, 23, 0, -22 },
  { 1211, 17, 22, 21, 2, -22 },
  { 1258, 17, 22, 20, 2, -22 },
  { 1305, 19, 22, 23, 2, -22 },
  { 1358, 14, 22, 17, 2, -22 },
  { 1397, 13, 22, 17, 2, -22 },
  { 1433, 19, 22, 23, 2, -22 },
  { 1486, 19, 22, 24, 2, -22 },
  { 1539, 12, 22, 14, 1, -22 },
  { 1572, 11, 29, 11, -2, -22 },
  { 1612, 19, 22, 21, 2, -22 },
  { 1665, 15, 22, 18, 2, -22 },
  { 1707, 26, 22, 30, 2, -22 },
  { 1779, 21, 22, 26, 2, -22 },
  { 1837, 21, 22, 25, 2, -22 },
  { 1895, 16, 22, 20, 2, -22 },
  { 1939, 22, 27, 25, 2, -22 },
  { 2014, 19, 22, 21, 2, -22 },
  { 2067, 16, 22, 18, 1, -22 },
  { 2111, 17, 22, 18, 1, -22 },
  { 2158, 19, 22, 23, 2, -22 },
  { 2211, 22, 22, 22, 0, -22 },
  { 2272, 32, 22, 32, 0, -22 },
  { 2360, 22, 22, 22, 0, -22 },
  { 2421, 21, 22, 21, 0, -22 },
  { 2479, 17, 22, 19, 1, -22 },
  { 2526, 7, 28, 10, 2, -23 },
  { 2551, 14, 22, 14, 0, -22 },
  { 2590, 7, 28, 10, 1, -23 },
  { 2615, 17, 14, 16, 0, -22 },
  { 2645, 16, 4, 16, 0, 2 },
  { 2653, 11, 5, 13, 1, -24 },
  { 2660, 16, 17, 19, 1, -17 },
  { 2694, 17, 24, 20, 2, -24 },
  { 2745, 15, 17, 17, 1, -17 },
  { 2777, 17, 24, 20, 1, -24 },
  { 2828, 17, 17, 19, 1, -17 },
  { 2865, 13, 24, 13, 1, -24 },
  { 2904, 17, 24, 20, 1, -17 },
  { 2955, 17, 24, 21, 2, -24 },
  { 3006, 6, 24, 10, 2, -24 },
  { 3024, 10, 31, 10, -2, -24 },
  { 3063, 18, 24, 20, 2, -24 },
  { 3117, 6, 24, 10, 2, -24 },
  { 3135, 27, 17, 31, 2, -17 },
  { 3193, 17, 17, 21, 2, -17 },
  { 3230, 17, 17, 20, 1, -17 },
  { 3267, 17, 24, 20, 2, -17 },
  { 3318, 17, 24, 20, 1, -17 },
  { 3369, 12, 17, 15, 2, -17 },
  { 3395, 14, 17, 16, 1, -17 },
  { 3425, 12, 21, 14, 1, -21 },
  { 3457, 17, 17, 21, 2, -17 },
  { 3494, 19, 17, 19, 0, -17 },
  { 3535, 28, 17, 28, 0, -17 },
  { 3595, 19, 17, 20, 0, -17 },
  { 3636, 19, 24, 19, 0, -17 },
  { 3693, 14, 17, 16, 1, -17 },
  { 3723, 11, 27, 13, 1, -22 },
  { 3761, 4, 31, 16, 6, -24 },
  { 3777, 12, 27, 13, 1, -22 },
  { 3818, 16, 6, 18, 1, -14 },
};

const GFXfont NotoSans_Black31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black31pt7bBitmaps,
  (GFXglyph *)NotoSans_Black31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_BLACK31PT7B_H_
