#ifndef _NOTOSANS_BLACK16PT7B_H_
#define _NOTOSANS_BLACK16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF8, 0xDF, 0x80, 0xEF, 0xBE, 0xF3, 0x1D, 0x86, 0x61,
  0xB9, 0xFF, 0x7F, 0xC6, 0xCF, 0xFF, 0xFF, 0x36, 0x0D, 0x87, 0x60, 0x08,
  0x1F, 0xDF, 0xDD, 0x2E, 0x83, 0xE0, 0xFC, 0x1F, 0x0B, 0xBF, 0xDF, 0xC7,
  0x80, 0x80, 0x30, 0x10, 0xF0, 0xC3, 0xB3, 0x87, 0x66, 0x0E, 0xDC, 0x1D,
  0xB7, 0x9F, 0xFF, 0x19, 0xB7, 0x06, 0x66, 0x0C, 0xDC, 0x31, 0xF8, 0xE1,
  0xE0, 0x18, 0x07, 0xE0, 0x77, 0x06, 0x70, 0x7E, 0x03, 0xE0, 0x7C, 0xEF,
  0xFE, 0xEF, 0xCE, 0x78, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x37, 0xEE, 0xEC,
  0xCC, 0xCC, 0xEE, 0x67, 0x30, 0xE3, 0x8C, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x3B, 0x80, 0x18, 0x18, 0x7B, 0xFF, 0x1C, 0x3E, 0x76, 0x14, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x77, 0x6E, 0xFF, 0xFE, 0xDF,
  0x80, 0x0E, 0x1C, 0x30, 0xE1, 0xC7, 0x0E, 0x18, 0x70, 0xE1, 0x87, 0x00,
  0x18, 0x7C, 0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0xFE, 0x7C,
  0x3D, 0xFF, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x0C, 0x3F, 0xBF,
  0xCC, 0xF0, 0x70, 0x38, 0x38, 0x38, 0x38, 0x3F, 0xFF, 0xFF, 0xF0, 0x38,
  0xFE, 0xFE, 0x8E, 0x0E, 0x7C, 0x7C, 0x0E, 0x0F, 0x8F, 0xFE, 0xFC, 0x0F,
  0x07, 0x87, 0xC7, 0xE3, 0x73, 0xBB, 0xFF, 0xFF, 0xFF, 0x83, 0x81, 0xC0,
  0xFE, 0xFE, 0xE0, 0xE0, 0xFE, 0xFE, 0x0F, 0x07, 0x8E, 0xFE, 0xFC, 0x0E,
  0x3E, 0x7E, 0xE0, 0xEC, 0xDE, 0xFF, 0xE7, 0xE7, 0xEF, 0xFE, 0x7C, 0xFF,
  0xFF, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x18, 0xFE,
  0xFE, 0xE7, 0xEE, 0x7C, 0x7C, 0xEE, 0xC7, 0xE7, 0xFE, 0x7E, 0x08, 0x1F,
  0x1F, 0xCE, 0x7E, 0x3B, 0xBD, 0xFE, 0x7F, 0x03, 0x07, 0x9F, 0x8F, 0x80,
  0xFF, 0x80, 0x37, 0xE0, 0x77, 0x70, 0x00, 0x07, 0x76, 0xE0, 0x03, 0x0F,
  0x3E, 0xF8, 0xE0, 0x7C, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xE0, 0x78, 0x1E, 0x0F, 0x3E, 0xF0, 0xC0, 0x80, 0x18, 0xFE, 0x7F,
  0x47, 0x0F, 0x1E, 0x3C, 0x38, 0x00, 0x18, 0x38, 0x38, 0x03, 0x00, 0xFE,
  0x1E, 0x1C, 0xCF, 0x6C, 0xFF, 0xEC, 0xCF, 0x66, 0x7B, 0x37, 0xDF, 0xF6,
  0x77, 0x38, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x83,
  0xB8, 0x39, 0x83, 0x9C, 0x7F, 0xC7, 0xFC, 0x7F, 0xEF, 0x0E, 0xF0, 0xF0,
  0xFF, 0x7F, 0xF8, 0xFC, 0xFF, 0xF7, 0xFB, 0x9F, 0xC7, 0xE7, 0xFF, 0xBF,
  0x80, 0x0C, 0x1F, 0xDF, 0xDE, 0x2E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7C,
  0x9F, 0xC7, 0xE0, 0xFF, 0x3F, 0xEE, 0x3B, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x8F, 0xFF, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0x87, 0x0F, 0xFF, 0xF8, 0x70,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0x0F, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3,
  0x80, 0x06, 0x0F, 0xF7, 0xFB, 0xC2, 0xE0, 0x39, 0xFE, 0x7F, 0x9F, 0xE1,
  0xFE, 0x77, 0xFC, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xFF, 0xFE,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0xE7, 0x1C, 0x71, 0xC7, 0x1C,
  0x73, 0xFF, 0xC0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xFB,
  0x00, 0xE3, 0xF9, 0xEE, 0x73, 0xB8, 0xFE, 0x3F, 0x8F, 0xE3, 0x9C, 0xE7,
  0xB8, 0xEE, 0x3C, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xF6, 0xFF,
  0xB6, 0xFD, 0xF7, 0xEF, 0xBF, 0x3D, 0xF9, 0xCE, 0xF8, 0xFF, 0x1F, 0xF3,
  0xFE, 0x7E, 0xEF, 0xDD, 0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0x87, 0x80,
  0x0E, 0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1,
  0xFF, 0x79, 0xFF, 0x1F, 0x80, 0xFE, 0x7F, 0xB9, 0xDC, 0xFE, 0x77, 0xFB,
  0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x78, 0xEE,
  0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFF, 0x79, 0xFF, 0x1F, 0x80, 0x38,
  0x07, 0x80, 0x78, 0xFF, 0x3F, 0xCE, 0x7B, 0x9E, 0xEF, 0x3F, 0x8F, 0xE3,
  0xBC, 0xE7, 0x38, 0xEE, 0x3C, 0x18, 0x7F, 0xFE, 0xE2, 0xF0, 0xFC, 0x7E,
  0x1F, 0x07, 0xCF, 0xFE, 0xFC, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0xF1, 0xEE, 0x39, 0xC7,
  0x3C, 0xE3, 0xB8, 0x77, 0x0E, 0xE0, 0xDC, 0x1F, 0x03, 0xE0, 0x3C, 0x00,
  0xE1, 0xC7, 0x73, 0xC7, 0x73, 0xC7, 0x73, 0xE6, 0x73, 0x6E, 0x3B, 0x6E,
  0x3F, 0x6E, 0x3F, 0x6C, 0x3E, 0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0xF1, 0xE7,
  0x9C, 0x3B, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x03, 0xF8, 0x3B, 0xC7,
  0x1C, 0xF0, 0xF0, 0xF1, 0xEE, 0x78, 0xEE, 0x1F, 0xC1, 0xF0, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x7F, 0xBF, 0xC1, 0xE1, 0xE0,
  0xE0, 0xE0, 0xF0, 0x70, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCF, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x0C, 0x1C,
  0x38, 0x30, 0x70, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x18,
  0x1E, 0x0F, 0x06, 0xC6, 0x63, 0x1B, 0x0E, 0xFF, 0xFF, 0xF1, 0xC0, 0xFE,
  0x7F, 0x47, 0x1F, 0xFF, 0xE7, 0xE7, 0xFF, 0xFB, 0xE0, 0x70, 0x38, 0x1D,
  0xCF, 0xF7, 0xBB, 0x9F, 0xCF, 0xE7, 0xFB, 0xBF, 0xDF, 0xC0, 0x3E, 0xFF,
  0xD7, 0x0E, 0x1C, 0x3C, 0xFF, 0x7E, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xFF,
  0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0x3C, 0x7F, 0xE7, 0xFF, 0xFF, 0xE0,
  0xE1, 0xFF, 0x3F, 0x3E, 0x7C, 0xE3, 0xEF, 0xC7, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC0, 0x7B, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0x07,
  0xFF, 0xFE, 0x7C, 0xE0, 0x70, 0x38, 0x1D, 0xCF, 0xF7, 0xBF, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x39, 0xC0,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xFE, 0xE0, 0x38, 0x0E, 0x03,
  0x8E, 0xE7, 0x3B, 0x8F, 0xE3, 0xF8, 0xFE, 0x39, 0xCE, 0x7B, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xEE, 0x7B, 0xFF, 0xFF, 0x7B, 0xF9, 0xE7, 0xE7,
  0x9F, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9C, 0xCF, 0x7F, 0xBD, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80, 0x3C, 0x3F, 0xB9, 0xDC, 0xEE,
  0x7F, 0x3B, 0x9C, 0xFE, 0x3E, 0x00, 0xEE, 0x7F, 0xBD, 0xDC, 0xFE, 0x7F,
  0x3F, 0xDD, 0xFE, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x7B, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0xCF, 0xFF,
  0xF8, 0xE3, 0x8E, 0x38, 0xE0, 0x7F, 0xFB, 0x97, 0x8F, 0xC7, 0xE3, 0xFE,
  0xFC, 0x18, 0x71, 0xFF, 0xF7, 0x8F, 0x1E, 0x3C, 0x7A, 0x7C, 0xF8, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x9F, 0xFF, 0x7B, 0x80, 0xE3, 0xDC,
  0xE7, 0x39, 0xCE, 0x37, 0x0F, 0xC3, 0xE0, 0x78, 0x1E, 0x00, 0xE3, 0x9D,
  0x9E, 0x77, 0x79, 0xDD, 0xF6, 0x76, 0xF8, 0xFB, 0xE3, 0xCF, 0x8F, 0x3C,
  0x3C, 0x70, 0xF3, 0xDC, 0xE3, 0xF0, 0xFC, 0x1E, 0x0F, 0xC3, 0xF1, 0xCE,
  0xF3, 0xC0, 0xE1, 0xDC, 0xE7, 0x39, 0xCE, 0x37, 0x0F, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x07, 0xC1, 0xE0, 0x70, 0x00, 0x7F, 0x7F, 0x0E, 0x1C, 0x1C,
  0x38, 0x70, 0xFF, 0xFF, 0x04, 0x73, 0xCE, 0x38, 0xEF, 0xB8, 0xF8, 0xE3,
  0x8E, 0x3C, 0x70, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x87, 0x38, 0xE7, 0x39,
  0xE3, 0x7B, 0x9C, 0xEF, 0x73, 0x00, 0xF1, 0xFF, 0x8E,
};

const GFXglyph NotoSans_Black16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 5, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 10, 11, 11, 0, -11 },
  { 23, 9, 13, 9, 0, -12 },
  { 38, 15, 12, 15, 0, -12 },
  { 61, 12, 12, 13, 1, -12 },
  { 79, 3, 4, 5, 1, -11 },
  { 81, 4, 15, 6, 1, -12 },
  { 89, 5, 15, 6, 0, -12 },
  { 99, 8, 8, 9, 0, -12 },
  { 107, 8, 8, 9, 1, -10 },
  { 115, 4, 4, 5, 0, -2 },
  { 117, 5, 3, 5, 0, -6 },
  { 119, 3, 3, 5, 1, -3 },
  { 121, 7, 12, 7, 0, -12 },
  { 132, 8, 12, 9, 1, -12 },
  { 144, 6, 11, 9, 1, -11 },
  { 153, 9, 12, 9, 0, -12 },
  { 167, 8, 12, 9, 1, -12 },
  { 179, 9, 11, 9, 0, -11 },
  { 192, 8, 11, 9, 1, -11 },
  { 203, 8, 12, 9, 1, -12 },
  { 215, 8, 11, 9, 1, -11 },
  { 226, 8, 12, 9, 1, -12 },
  { 238, 9, 12, 9, 0, -12 },
  { 252, 3, 9, 5, 1, -9 },
  { 256, 4, 11, 5, 0, -9 },
  { 262, 8, 9, 9, 1, -10 },
  { 271, 8, 5, 9, 1, -8 },
  { 276, 8, 9, 9, 1, -10 },
  { 285, 8, 12, 8, 0, -12 },
  { 297, 13, 13, 14, 1, -12 },
  { 319, 12, 11, 12, 0, -11 },
  { 336, 9, 11, 11, 1, -11 },
  { 349, 9, 12, 10, 1, -12 },
  { 363, 10, 11, 12, 1, -11 },
  { 377, 7, 11, 9, 1, -11 },
  { 387, 7, 11, 9, 1, -11 },
  { 397, 10, 12, 12, 1, -12 },
  { 412, 10, 11, 12, 1, -11 },
  { 426, 6, 11, 7, 1, -11 },
  { 435, 5, 15, 6, -1, -11 },
  { 445, 10, 11, 11, 1, -11 },
  { 459, 8, 11, 9, 1, -11 },
  { 470, 13, 11, 15, 1, -11 },
  { 488, 11, 11, 13, 1, -11 },
  { 504, 11, 12, 13, 1, -12 },
  { 521, 9, 11, 10, 1, -11 },
  { 534, 11, 15, 13, 1, -12 },
  { 555, 10, 11, 11, 1, -11 },
  { 569, 8, 12, 9, 1, -12 },
  { 581, 9, 11, 9, 0, -11 },
  { 594, 10, 11, 12, 1, -11 },
  { 608, 11, 11, 11, 0, -11 },
  { 624, 16, 11, 17, 0, -11 },
  { 646, 12, 11, 12, 0, -11 },
  { 663, 11, 11, 11, 0, -11 },
  { 679, 9, 11, 10, 0, -11 },
  { 692, 4, 15, 5, 1, -12 },
  { 700, 7, 12, 7, 0, -12 },
  { 711, 4, 15, 5, 0, -12 },
  { 719, 9, 7, 8, 0, -11 },
  { 727, 8, 2, 8, 0, 1 },
  { 729, 5, 2, 7, 1, -12 },
  { 731, 8, 9, 10, 1, -9 },
  { 740, 9, 12, 10, 1, -12 },
  { 754, 7, 9, 9, 1, -9 },
  { 762, 8, 12, 10, 1, -12 },
  { 774, 8, 9, 10, 1, -9 },
  { 783, 7, 12, 7, 0, -12 },
  { 794, 8, 13, 10, 1, -9 },
  { 807, 9, 12, 11, 1, -12 },
  { 821, 3, 12, 5, 1, -12 },
  { 826, 5, 16, 5, -1, -12 },
  { 836, 10, 12, 11, 1, -12 },
  { 851, 3, 12, 5, 1, -12 },
  { 856, 14, 9, 16, 1, -9 },
  { 872, 9, 9, 11, 1, -9 },
  { 883, 9, 9, 10, 1, -9 },
  { 894, 9, 13, 10, 1, -9 },
  { 909, 8, 13, 10, 1, -9 },
  { 922, 6, 9, 8, 1, -9 },
  { 929, 7, 9, 8, 1, -9 },
  { 937, 7, 11, 7, 0, -11 },
  { 947, 9, 9, 11, 1, -9 },
  { 958, 10, 9, 10, 0, -9 },
  { 970, 14, 9, 15, 0, -9 },
  { 986, 10, 9, 10, 0, -9 },
  { 998, 10, 13, 10, 0, -9 },
  { 1015, 8, 9, 8, 0, -9 },
  { 1024, 6, 15, 7, 0, -12 },
  { 1036, 2, 15, 8, 3, -12 },
  { 1040, 5, 15, 7, 1, -12 },
  { 1050, 8, 3, 9, 1, -7 },
};

const GFXfont NotoSans_Black16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black16pt7bBitmaps,
  (GFXglyph *)NotoSans_Black16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_BLACK16PT7B_H_
