#ifndef _NOTOSANS_BLACK41PT7B_H_
#define _NOTOSANS_BLACK41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFF, 0x3F, 0xBF, 0x1F, 0xDF, 0x8F,
  0xEF, 0xC7, 0xF7, 0xE3, 0xFB, 0xF1, 0xFD, 0xF8, 0xFE, 0xFC, 0x3E, 0x7E,
  0x1F, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x1F, 0x1F, 0x80,
  0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x7E, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xF9, 0xE0, 0x8F, 0xE7, 0x80, 0x3F, 0x9E, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7B, 0xFC, 0x01, 0xE7, 0xF4,
  0x07, 0x9F, 0xDE, 0x1E, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE0,
  0x07, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0x7E, 0x03, 0xF0, 0x03, 0xF3, 0xF8,
  0x3F, 0x00, 0x1F, 0x8F, 0xC1, 0xF8, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xE7, 0xE3, 0xF0, 0x7F, 0x7E, 0x7E, 0x3F, 0xE1, 0xFF,
  0xF3, 0xF3, 0xFF, 0x8F, 0xFF, 0x3F, 0x3F, 0xFE, 0x3F, 0xF9, 0xF9, 0xFF,
  0xF0, 0xFF, 0x9F, 0x9F, 0xCF, 0xC1, 0xE0, 0xFC, 0xFC, 0x7E, 0x00, 0x0F,
  0xC7, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0xFC,
  0x00, 0x7E, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0x7E, 0x3F, 0x00, 0x3F, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0x0F, 0xDF, 0x80, 0x1F, 0x80, 0x7F, 0xFC, 0x00,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x83,
  0xFC, 0x1F, 0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xE7,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0x9F, 0xFF, 0xF0, 0x7F, 0x8F, 0xFF,
  0xF0, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0x87,
  0xFF, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x03,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x06, 0x0F, 0x07, 0x7C, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x3F, 0x9F, 0xC0, 0xF0,
  0xF8, 0x03, 0x0E, 0x00, 0x00, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7,
  0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x8F,
  0xF3, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xBF, 0xCF, 0x9F, 0xE3, 0x8F, 0xF1, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xF8, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xE1, 0xFF, 0x1C, 0x07, 0xF8, 0x40, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0x81,
  0xFE, 0x10, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF7, 0xF8, 0x1F, 0xDF, 0xE0, 0xFE,
  0x7F, 0x83, 0xF9, 0xFE, 0x1F, 0xC7, 0xF8, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x10,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xEF, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x40, 0x1F, 0xCF, 0xF0, 0x7F, 0x7F, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0x7F, 0x03, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF,
  0xF1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x87,
  0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC7, 0xFC, 0xFF, 0x9F, 0xE1, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0xFF, 0x07, 0xFB,
  0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE1, 0xFF, 0xBF, 0x81, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1E, 0x3F, 0xDF,
  0xEF, 0xF7, 0xFB, 0xFC, 0xFC, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE7, 0xF3, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xBF, 0xF3, 0x80, 0xFF, 0x20, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x07,
  0xFF, 0x3F, 0x1F, 0x0F, 0xFF, 0xCF, 0x9F, 0x8F, 0xFF, 0xE7, 0xEF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xC7, 0xF1, 0xF8, 0xFF, 0xE7, 0xE0, 0xFC, 0x7F, 0xE3,
  0xF0, 0x7E, 0x3F, 0xF1, 0xF0, 0x3F, 0x1F, 0xF8, 0xF8, 0x1F, 0x8F, 0xFC,
  0x7C, 0x0F, 0xC7, 0xFE, 0x3E, 0x07, 0xE7, 0xFF, 0x1F, 0x87, 0xF3, 0xEF,
  0x8F, 0xC7, 0xFB, 0xF7, 0xE7, 0xFF, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xF9,
  0xF8, 0x7F, 0xEF, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x38, 0x01, 0xFF, 0xF7, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0xBF,
  0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xC1, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB,
  0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFE, 0x0F, 0xFB, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xF8, 0x1C, 0x7F, 0xC0, 0x08, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x01, 0x1F, 0xF8, 0x1E, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xF9, 0xFE, 0x03, 0xFE, 0xFF,
  0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x1F, 0xF3, 0xFC, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC0, 0x38, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x0F,
  0xF7, 0xFE, 0x03, 0xFC, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF,
  0xC3, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F,
  0x9F, 0xE0, 0x7F, 0xCF, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0xE1, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF,
  0xF0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xE7, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3,
  0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x7F, 0x81, 0xFF,
  0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF8, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xDF, 0x81, 0xF7, 0xFF, 0xEF, 0xC1, 0xFB,
  0xFF, 0xF3, 0xF0, 0xFD, 0xFF, 0xF9, 0xF8, 0x7E, 0xFF, 0xFC, 0xFC, 0x7E,
  0x7F, 0xFE, 0x7F, 0x3F, 0x3F, 0xFF, 0x1F, 0x9F, 0x9F, 0xFF, 0x8F, 0xCF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFC, 0x3F, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xEF, 0xF0, 0x7F, 0xFE, 0xFF, 0x07, 0xFF, 0xE7, 0xF8,
  0x7F, 0xFE, 0x7F, 0x87, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x3F, 0xC7, 0xFF,
  0xE1, 0xFE, 0x7F, 0xFE, 0x1F, 0xE7, 0xFF, 0xE0, 0xFF, 0x7F, 0xFE, 0x0F,
  0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00,
  0xFF, 0x9F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00,
  0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0xFF,
  0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xFC,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFD, 0xFF,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F,
  0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF,
  0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0,
  0x3F, 0xEF, 0xF0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0,
  0x1C, 0xFF, 0x00, 0x4F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFD, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xDF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xCF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xF8, 0x0F, 0xF3, 0xF8, 0x0F, 0xFC, 0x07, 0xF9,
  0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFF, 0x81, 0xFC, 0x3F, 0x81,
  0xFF, 0xC1, 0xFE, 0x1F, 0xC1, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0xFD, 0xF0,
  0x7F, 0x03, 0xF8, 0x7E, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x7E, 0x1F, 0xC0,
  0xFE, 0x3F, 0xBF, 0x1F, 0xE0, 0x7F, 0x1F, 0x9F, 0x8F, 0xE0, 0x1F, 0xCF,
  0xCF, 0xE7, 0xF0, 0x0F, 0xE7, 0xE3, 0xF3, 0xF8, 0x07, 0xF3, 0xF1, 0xFB,
  0xFC, 0x03, 0xFB, 0xF8, 0xFD, 0xFC, 0x00, 0xFD, 0xF8, 0x7E, 0xFE, 0x00,
  0x7F, 0xFC, 0x1F, 0x7F, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x8F, 0xF8,
  0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F,
  0x8F, 0xF0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3E, 0x7E, 0x00, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7C, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xBF, 0xF0, 0x60, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFD,
  0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFD, 0xFC, 0xFF,
  0xE3, 0xF0, 0xFF, 0x0F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0x03, 0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0xBF, 0xC1,
  0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF,
  0x8F, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFB, 0xFF, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xF0, 0xE7,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x81, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x07, 0xE3, 0xFC, 0x7F, 0xEF, 0xF3, 0xFF, 0xBF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xE7,
  0xF0, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0x3F, 0xEF, 0xF8, 0x3F, 0xBF,
  0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x11, 0xFF, 0x03, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0x90, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xE1, 0xFC, 0x7F, 0xE7, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xEF, 0xF0, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFD, 0x00,
  0x1F, 0xE7, 0xE1, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0x83, 0xF9, 0xFF,
  0x8F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x3C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3F, 0x81, 0xFE,
  0x1F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC3, 0xFF, 0x3F, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC,
  0xFF, 0x83, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x07,
  0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F,
  0xE0, 0xFE, 0x7F, 0xC0, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0x9F, 0xFC, 0x7F, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0x81, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0x81, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0x80, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0x03,
  0xF8, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0x8F, 0xCF, 0xFF, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F,
  0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x3F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x1F, 0x83,
  0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xF8, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x0F,
  0xEF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0x0F, 0xE7, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x7F, 0xE7, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x7F, 0xEF, 0xF0, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0xFC,
  0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xE2, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xC7, 0xCF, 0xE0,
  0x23, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFF,
  0x1F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF1,
  0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x08, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFC, 0xFF, 0xE7, 0xF1,
  0xFF, 0x0F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xF0, 0x3F,
  0xDF, 0xE0, 0xFF, 0x81, 0xFC, 0xFF, 0x07, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F,
  0xF0, 0xFF, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0xFF, 0x1F, 0xFC, 0x3F, 0x87,
  0xF8, 0xFB, 0xF1, 0xFC, 0x1F, 0xC7, 0xDF, 0x9F, 0xE0, 0xFE, 0x7E, 0xFC,
  0xFE, 0x07, 0xF3, 0xF7, 0xE7, 0xF0, 0x1F, 0x9F, 0xBF, 0x3F, 0x80, 0xFE,
  0xF8, 0xFD, 0xF8, 0x07, 0xF7, 0xC7, 0xEF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0,
  0x7F, 0x87, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0xFF,
  0x01, 0xFF, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0,
  0x3F, 0xEF, 0xF8, 0x0F, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF,
  0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF1, 0xFE,
  0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x09, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0E, 0x01, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0x80, 0x3F, 0xE0,
};

const GFXglyph NotoSans_Black41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 29, 12, 2, -29 },
  { 30, 17, 10, 21, 2, -29 },
  { 52, 25, 29, 27, 1, -29 },
  { 143, 22, 33, 24, 1, -31 },
  { 234, 37, 30, 39, 1, -30 },
  { 373, 32, 30, 33, 1, -30 },
  { 493, 8, 10, 12, 2, -29 },
  { 503, 13, 36, 15, 1, -30 },
  { 562, 12, 36, 15, 1, -30 },
  { 616, 20, 20, 22, 1, -31 },
  { 666, 20, 19, 24, 2, -24 },
  { 714, 9, 12, 13, 1, -6 },
  { 728, 11, 6, 13, 1, -14 },
  { 737, 8, 7, 12, 2, -7 },
  { 744, 18, 30, 18, 0, -30 },
  { 812, 22, 30, 24, 1, -30 },
  { 895, 17, 29, 24, 2, -29 },
  { 957, 21, 30, 24, 1, -30 },
  { 1036, 21, 30, 24, 1, -30 },
  { 1115, 22, 29, 24, 1, -29 },
  { 1195, 20, 29, 24, 2, -29 },
  { 1268, 22, 30, 24, 1, -30 },
  { 1351, 21, 29, 24, 2, -29 },
  { 1428, 22, 30, 24, 1, -30 },
  { 1511, 22, 30, 24, 1, -30 },
  { 1594, 8, 23, 12, 2, -23 },
  { 1617, 9, 29, 12, 1, -23 },
  { 1650, 20, 22, 24, 2, -26 },
  { 1705, 20, 15, 24, 2, -22 },
  { 1743, 20, 22, 24, 2, -26 },
  { 1798, 20, 30, 21, 0, -30 },
  { 1873, 33, 33, 37, 2, -30 },
  { 2010, 30, 29, 30, 0, -29 },
  { 2119, 23, 29, 28, 3, -29 },
  { 2203, 23, 30, 27, 2, -30 },
  { 2290, 25, 29, 30, 3, -29 },
  { 2381, 18, 29, 23, 3, -29 },
  { 2447, 17, 29, 22, 3, -29 },
  { 2509, 26, 30, 30, 2, -30 },
  { 2607, 25, 29, 31, 3, -29 },
  { 2698, 16, 29, 18, 1, -29 },
  { 2756, 14, 38, 14, -3, -29 },
  { 2823, 25, 29, 28, 3, -29 },
  { 2914, 19, 29, 24, 3, -29 },
  { 2983, 33, 29, 40, 3, -29 },
  { 3103, 28, 29, 34, 3, -29 },
  { 3205, 29, 30, 33, 2, -30 },
  { 3314, 21, 29, 26, 3, -29 },
  { 3391, 29, 37, 33, 2, -30 },
  { 3526, 25, 29, 28, 3, -29 },
  { 3617, 20, 30, 24, 2, -30 },
  { 3692, 22, 29, 24, 1, -29 },
  { 3772, 25, 29, 31, 3, -29 },
  { 3863, 28, 29, 28, 0, -29 },
  { 3965, 41, 29, 43, 1, -29 },
  { 4114, 30, 29, 30, 0, -29 },
  { 4223, 27, 29, 27, 0, -29 },
  { 4321, 23, 29, 25, 1, -29 },
  { 4405, 10, 37, 13, 2, -30 },
  { 4452, 18, 30, 18, 0, -30 },
  { 4520, 10, 37, 13, 1, -30 },
  { 4567, 22, 19, 22, 0, -29 },
  { 4620, 21, 5, 21, 0, 3 },
  { 4634, 14, 6, 17, 2, -31 },
  { 4645, 22, 23, 26, 1, -23 },
  { 4709, 22, 31, 26, 3, -31 },
  { 4795, 19, 23, 22, 2, -23 },
  { 4850, 22, 31, 26, 2, -31 },
  { 4936, 22, 23, 25, 2, -23 },
  { 5000, 17, 31, 17, 1, -31 },
  { 5066, 22, 33, 26, 2, -23 },
  { 5157, 22, 31, 27, 3, -31 },
  { 5243, 8, 32, 13, 3, -32 },
  { 5275, 13, 42, 13, -2, -32 },
  { 5344, 24, 31, 27, 3, -31 },
  { 5437, 8, 31, 13, 3, -31 },
  { 5468, 35, 23, 41, 3, -23 },
  { 5569, 22, 23, 27, 3, -23 },
  { 5633, 22, 23, 26, 2, -23 },
  { 5697, 22, 33, 26, 3, -23 },
  { 5788, 22, 33, 26, 2, -23 },
  { 5879, 16, 23, 19, 3, -23 },
  { 5925, 18, 23, 21, 2, -23 },
  { 5977, 17, 27, 19, 1, -27 },
  { 6035, 22, 23, 27, 3, -23 },
  { 6099, 25, 23, 25, 0, -23 },
  { 6171, 37, 23, 37, 0, -23 },
  { 6278, 26, 23, 26, 0, -23 },
  { 6353, 25, 33, 25, 0, -23 },
  { 6457, 19, 23, 21, 1, -23 },
  { 6512, 15, 37, 18, 1, -30 },
  { 6582, 5, 40, 21, 8, -31 },
  { 6607, 16, 37, 18, 1, -30 },
  { 6681, 20, 7, 24, 2, -18 },
};

const GFXfont NotoSans_Black41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black41pt7bBitmaps,
  (GFXglyph *)NotoSans_Black41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_BLACK41PT7B_H_
