#ifndef _NOTOSANS_BLACK6PT7B_H_
#define _NOTOSANS_BLACK6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE2, 0xA0, 0x6F, 0xF6, 0x5F, 0x3E, 0xD3, 0x63, 0x52, 0x63, 0x6D,
  0xF0, 0x80, 0x6A, 0x40, 0xD5, 0x80, 0x5F, 0x80, 0x5D, 0x00, 0xE0, 0xC0,
  0x80, 0x69, 0x40, 0xF6, 0xB0, 0x74, 0x90, 0xE5, 0x70, 0xEC, 0xF0, 0x6F,
  0x90, 0xFC, 0xF0, 0x7E, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xF0, 0xA0,
  0xCE, 0x39, 0x80, 0xFC, 0x8F, 0x00, 0xEC, 0x20, 0x7D, 0xF6, 0xF0, 0x67,
  0xF9, 0xFE, 0xDF, 0x7C, 0xC7, 0xFD, 0xDE, 0xFF, 0x70, 0xFF, 0x60, 0x7F,
  0xD7, 0xDF, 0xDD, 0xD7, 0xFF, 0xC0, 0xFE, 0xED, 0xDB, 0x70, 0xCD, 0xEF,
  0x70, 0xCD, 0x6B, 0x30, 0x7D, 0xD7, 0xEF, 0xEC, 0x76, 0xB4, 0xE1, 0x80,
  0xFF, 0xED, 0xF8, 0xF0, 0xE9, 0x20, 0xDD, 0xD7, 0xD7, 0x66, 0xB5, 0xD7,
  0x9A, 0xF6, 0x6D, 0xF6, 0x66, 0xE6, 0x4F, 0xEA, 0xC0, 0x89, 0x30, 0xD5,
  0xC0, 0x56, 0x80, 0xE0, 0xC0, 0x7F, 0x80, 0xCC, 0xEF, 0xE0, 0xF1, 0x80,
  0x27, 0xD6, 0xFD, 0x80, 0x6B, 0x24, 0xF7, 0xF0, 0xCC, 0xFF, 0xF0, 0xCF,
  0xC0, 0xCF, 0xF0, 0xCD, 0xEE, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF0, 0xEB, 0x60, 0xEF, 0xEC, 0xF7, 0x90, 0xFB, 0x00, 0xEF, 0x80, 0x5D,
  0x30, 0xFF, 0x70, 0xB6, 0x60, 0xBB, 0xD6, 0xF6, 0xF0, 0xB6, 0x6C, 0xEB,
  0x80, 0x5D, 0x40, 0xFC, 0xD5, 0xC0, 0xE0,
};

const GFXglyph NotoSans_Black6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 3, 1, 3, 0, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 6, 4, 6, 0, -4 },
  { 10, 5, 4, 5, 0, -4 },
  { 13, 1, 1, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 2, 5, 2, 0, -4 },
  { 18, 3, 3, 3, 0, -5 },
  { 20, 3, 3, 4, 0, -4 },
  { 22, 2, 2, 2, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 2, 0, -1 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 3, 4, 4, 0, -4 },
  { 47, 1, 3, 2, 0, -3 },
  { 48, 2, 4, 2, 0, -3 },
  { 49, 3, 3, 4, 0, -4 },
  { 51, 3, 2, 4, 0, -3 },
  { 52, 3, 3, 4, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 5, 4, 5, 0, -4 },
  { 59, 4, 4, 4, 0, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 4, 4, 5, 0, -4 },
  { 75, 2, 4, 3, 0, -4 },
  { 76, 2, 5, 2, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 5, 4, 6, 0, -4 },
  { 85, 5, 4, 5, 0, -4 },
  { 88, 4, 4, 5, 0, -4 },
  { 90, 4, 4, 4, 0, -4 },
  { 92, 5, 5, 5, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 3, 4, 3, 0, -4 },
  { 100, 3, 4, 4, 0, -4 },
  { 102, 4, 4, 5, 0, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 6, 4, 6, 0, -4 },
  { 109, 4, 4, 4, 0, -4 },
  { 111, 4, 4, 4, 0, -4 },
  { 113, 4, 4, 4, 0, -4 },
  { 115, 2, 5, 2, 0, -4 },
  { 117, 3, 4, 3, 0, -4 },
  { 119, 2, 5, 2, 0, -4 },
  { 121, 3, 3, 3, 0, -4 },
  { 123, 3, 1, 3, 0, 0 },
  { 124, 2, 1, 3, 0, -5 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 3, 3, 3, 0, -3 },
  { 132, 3, 5, 4, 0, -5 },
  { 134, 3, 3, 4, 0, -3 },
  { 136, 3, 5, 2, 0, -5 },
  { 138, 3, 4, 4, 0, -3 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 2, 5, 2, 0, -5 },
  { 145, 2, 6, 2, 0, -5 },
  { 147, 4, 5, 4, 0, -5 },
  { 150, 2, 5, 2, 0, -5 },
  { 152, 6, 3, 6, 0, -3 },
  { 155, 4, 3, 4, 0, -3 },
  { 157, 4, 3, 4, 0, -3 },
  { 159, 4, 4, 4, 0, -3 },
  { 161, 3, 4, 4, 0, -3 },
  { 163, 3, 3, 3, 0, -3 },
  { 165, 3, 3, 3, 0, -3 },
  { 167, 3, 4, 3, 0, -4 },
  { 169, 4, 3, 4, 0, -3 },
  { 171, 4, 3, 4, 0, -3 },
  { 173, 5, 3, 5, 0, -3 },
  { 175, 4, 3, 4, 0, -3 },
  { 177, 4, 4, 4, 0, -3 },
  { 179, 3, 3, 3, 0, -3 },
  { 181, 2, 5, 3, 0, -4 },
  { 183, 1, 6, 3, 1, -5 },
  { 184, 2, 5, 3, 0, -4 },
  { 186, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Black6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black6pt7bBitmaps,
  (GFXglyph *)NotoSans_Black6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_BLACK6PT7B_H_
