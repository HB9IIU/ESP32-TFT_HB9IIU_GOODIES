#ifndef _NOTOSANS_BLACK29PT7B_H_
#define _NOTOSANS_BLACK29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xFB, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0x03, 0x8E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xC7, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xE0, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x71, 0xE0, 0x1C, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x7F, 0xC3, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0xBE, 0xE6, 0x79, 0xC0, 0xFB, 0x81, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xDF, 0xC3, 0xBF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x3E, 0x00, 0xF8, 0x1F, 0xE0, 0x3C, 0x0F, 0xF8, 0x1E, 0x03, 0xFF,
  0x07, 0x80, 0xF3, 0xC3, 0xC0, 0x3C, 0xF1, 0xF0, 0x0F, 0x3C, 0x78, 0x03,
  0xCF, 0x3E, 0x00, 0xF3, 0xCF, 0x1C, 0x3F, 0xF7, 0x9F, 0xCF, 0xF9, 0xEF,
  0xF9, 0xFE, 0xF3, 0xFE, 0x3E, 0x3D, 0xF7, 0xC0, 0x1E, 0x7C, 0xF0, 0x0F,
  0x9F, 0x3C, 0x03, 0xC7, 0xCF, 0x01, 0xF1, 0xF3, 0xC0, 0x78, 0x3D, 0xF0,
  0x3C, 0x0F, 0xF8, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xC7, 0xE3, 0xFE, 0x1F, 0x9F, 0xFC, 0x7E, 0x7F, 0xFB, 0xF3, 0xF3, 0xFF,
  0xCF, 0xC7, 0xFE, 0x3F, 0x0F, 0xF8, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFC, 0xFF, 0xFF, 0xFF, 0x7B,
  0xDE, 0x1F, 0x8F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87,
  0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E,
  0x3E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0xF7, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC0, 0x7F, 0x83, 0xDE, 0x1F, 0x3C, 0x3C, 0xE0, 0x21, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x7D, 0xF7, 0xDE, 0xFB, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xFF, 0xFF, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xCF,
  0x8F, 0xBF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xBE, 0x3F, 0x7E, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF1, 0xFF,
  0x3F, 0xF7, 0xFF, 0xFF, 0xF7, 0xDF, 0x39, 0xF1, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xCF,
  0x0F, 0x88, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3,
  0xFF, 0xE3, 0xFF, 0xC4, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x1F, 0xF8, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0x9F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0x80, 0x1F, 0x00, 0x3E, 0xC0, 0x7F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0xE0, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xC7, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xFC, 0x4F, 0xC0, 0x1F, 0x00,
  0x7C, 0xF0, 0xFB, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x3F, 0x7E, 0x7E, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xF3, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3F, 0x7E, 0x3F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xC7, 0xFF, 0xDF, 0x8F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x0F,
  0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xDF, 0x8F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xFF, 0xFB, 0xFF, 0xF3, 0xFB, 0xE3,
  0xE7, 0xC0, 0x1F, 0x00, 0x3E, 0x01, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x07, 0xF8, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0xFF, 0xFF, 0xDF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7D, 0xF7, 0xDE, 0xFB, 0xEF, 0x3C, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x01, 0xFE, 0x0F,
  0xF8, 0xFF, 0xC7, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x7C, 0xFC, 0x81, 0xF0, 0x07, 0xC0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8,
  0x1F, 0x00, 0x3C, 0x3E, 0x1F, 0x1E, 0x7C, 0xFF, 0xDE, 0x79, 0xFF, 0xCF,
  0x79, 0xF3, 0xCF, 0xF3, 0xE3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF,
  0xF3, 0xC3, 0xCF, 0xF3, 0xC7, 0xCE, 0xF3, 0xEF, 0xDE, 0x71, 0xFF, 0xFC,
  0x79, 0xFD, 0xFC, 0x7C, 0x30, 0x30, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0x7C, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFD, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x01,
  0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF3, 0xF8, 0x11,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x02, 0x3F, 0x8F, 0x1F,
  0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xEF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xC0, 0x27, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x0F, 0xFF, 0xC3, 0xFD, 0xF0, 0xFF, 0x7C, 0x3F, 0xDF, 0x81, 0xF7, 0xE0,
  0x7D, 0xFC, 0x1F, 0x3F, 0xC7, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x0F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFF, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0, 0x80, 0xFC, 0x0F, 0xFF, 0x07, 0xEF,
  0xC3, 0xFB, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF7,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xBF, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0xCF,
  0xC3, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFB,
  0xC3, 0xDF, 0xFB, 0xE7, 0xDF, 0xF9, 0xE7, 0x9F, 0xF9, 0xE7, 0x9F, 0xF9,
  0xF7, 0x9F, 0xF9, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8,
  0xFF, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xBE, 0x1F, 0xFB, 0xF1, 0xFF, 0x9F, 0x1F,
  0xF9, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0xFD, 0xFF, 0x87, 0xDF, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7,
  0xC0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFE, 0x3F, 0xCF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7,
  0xC0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFE, 0x3F, 0xCF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0x1F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0x7E, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xDF, 0x81,
  0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7F, 0x3F, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F,
  0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0xFC,
  0x0F, 0x9F, 0x83, 0xF0, 0x3E, 0x7E, 0x1F, 0xE1, 0xF8, 0xF8, 0x7F, 0x87,
  0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0x1F, 0xF3, 0xF0,
  0x7C, 0xFB, 0xCF, 0x81, 0xF3, 0xEF, 0x3E, 0x07, 0xCF, 0x3C, 0xF8, 0x1F,
  0x3C, 0xF3, 0xE0, 0x3E, 0xF3, 0xFF, 0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF3,
  0xF0, 0x3F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xEF,
  0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xEF, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F,
  0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xEF, 0xC0, 0x7D, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xFC,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xFF,
  0xFF, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x1E,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8,
  0x1F, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF1, 0x07, 0xE0, 0x07,
  0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0x9F, 0x8F, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x7C, 0x7D, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBF, 0x9F, 0x3E,
  0x00, 0x0F, 0xF8, 0x7F, 0xF3, 0xFF, 0x9F, 0xFE, 0x7E, 0x13, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x5F, 0x86, 0x7F, 0xF8,
  0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x1F, 0xBF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F,
  0x9F, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7E, 0x7C, 0x3E, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x02, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF1, 0xFE,
  0x3F, 0xE3, 0xFE, 0x3E, 0x03, 0xE0, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xBF, 0x00, 0x3F, 0x80, 0x3F, 0x78, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xF8, 0x3F, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0x23, 0xEF, 0xFF, 0xF8, 0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x04, 0x0F, 0x87, 0xE3, 0xF1, 0xF0,
  0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x7F, 0xBF,
  0xDF, 0xEF, 0xE7, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0xF0, 0xFE, 0xF8, 0x7E, 0x7C,
  0x7E, 0x3E, 0x7E, 0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x7E, 0x3E, 0x1F, 0x9F, 0x0F, 0xEF, 0x83,
  0xF7, 0xC1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xF8, 0xFE, 0x7F, 0xFE, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xF1, 0xFF, 0xE1, 0xF8, 0xFF,
  0xF0, 0xF8, 0x3F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07,
  0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0,
  0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF1, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF9,
  0xF9, 0xF7, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFE, 0x7C, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x3F, 0xDF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x1F, 0xE3, 0xFF, 0xDF, 0xFD, 0xFB, 0xEF, 0xC1, 0x7F,
  0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xDF, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC9, 0xFF, 0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xDF, 0x3F, 0x9F, 0xFC, 0x0F, 0xDF, 0x07, 0xE7, 0xC1, 0xF9, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xDF, 0x0F, 0xE3, 0xF7, 0xC3,
  0xF8, 0xF9, 0xF9, 0xFE, 0x3E, 0x3E, 0x7F, 0x8F, 0x8F, 0x9F, 0xE7, 0xE3,
  0xE7, 0xBD, 0xF0, 0xFB, 0xEF, 0x7C, 0x1F, 0xF3, 0xDF, 0x07, 0xFC, 0xF7,
  0x81, 0xFF, 0x3D, 0xE0, 0x7F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xDF, 0xC7,
  0xE3, 0xF3, 0xF0, 0x7E, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0x3F, 0x0F, 0xCF, 0xE7, 0xE1, 0xFB, 0xF8, 0x3F, 0xFC, 0x0F, 0xDF, 0x03,
  0xE7, 0xE1, 0xF9, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC1, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x05, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x81, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xF8, 0x7F, 0x0F,
  0xE0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0x7E, 0x1F, 0xC7,
  0xF8, 0xFC, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x3F, 0x87,
  0xF0, 0xFC, 0x1E, 0x00, 0x3E, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xD0, 0x06, 0x00,
};

const GFXglyph NotoSans_Black29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 11, 8, 15, 2, -21 },
  { 28, 18, 21, 19, 1, -21 },
  { 76, 15, 24, 17, 1, -22 },
  { 121, 26, 21, 27, 1, -21 },
  { 190, 22, 21, 23, 1, -21 },
  { 248, 5, 8, 8, 2, -21 },
  { 253, 9, 26, 10, 1, -21 },
  { 283, 8, 26, 10, 1, -21 },
  { 309, 14, 14, 16, 1, -22 },
  { 334, 15, 14, 17, 1, -17 },
  { 361, 6, 8, 9, 1, -4 },
  { 367, 8, 4, 9, 1, -10 },
  { 371, 6, 5, 8, 1, -5 },
  { 375, 13, 21, 13, 0, -21 },
  { 410, 15, 21, 17, 1, -21 },
  { 450, 12, 21, 17, 1, -21 },
  { 482, 15, 21, 17, 1, -21 },
  { 522, 15, 21, 17, 1, -21 },
  { 562, 17, 21, 17, 0, -21 },
  { 607, 15, 21, 17, 1, -21 },
  { 647, 15, 21, 17, 1, -21 },
  { 687, 15, 21, 17, 1, -21 },
  { 727, 15, 21, 17, 1, -21 },
  { 767, 15, 21, 17, 1, -21 },
  { 807, 6, 16, 8, 1, -16 },
  { 819, 6, 20, 9, 1, -16 },
  { 834, 15, 15, 17, 1, -18 },
  { 863, 15, 10, 17, 1, -15 },
  { 882, 15, 15, 17, 1, -18 },
  { 911, 14, 21, 15, 0, -21 },
  { 948, 24, 23, 26, 1, -21 },
  { 1017, 21, 21, 21, 0, -21 },
  { 1073, 16, 21, 20, 2, -21 },
  { 1115, 17, 21, 19, 1, -21 },
  { 1160, 18, 21, 21, 2, -21 },
  { 1208, 13, 21, 16, 2, -21 },
  { 1243, 12, 21, 16, 2, -21 },
  { 1275, 18, 21, 21, 1, -21 },
  { 1323, 18, 21, 22, 2, -21 },
  { 1371, 11, 21, 13, 1, -21 },
  { 1400, 10, 28, 10, -2, -21 },
  { 1435, 18, 21, 20, 2, -21 },
  { 1483, 14, 21, 17, 2, -21 },
  { 1520, 24, 21, 28, 2, -21 },
  { 1583, 20, 21, 24, 2, -21 },
  { 1636, 21, 21, 23, 1, -21 },
  { 1692, 15, 21, 18, 2, -21 },
  { 1732, 21, 26, 23, 1, -21 },
  { 1801, 18, 21, 20, 2, -21 },
  { 1849, 15, 21, 17, 1, -21 },
  { 1889, 15, 21, 17, 1, -21 },
  { 1929, 18, 21, 22, 2, -21 },
  { 1977, 20, 21, 20, 0, -21 },
  { 2030, 30, 21, 30, 0, -21 },
  { 2109, 21, 21, 21, 0, -21 },
  { 2165, 19, 21, 19, 0, -21 },
  { 2215, 16, 21, 18, 1, -21 },
  { 2257, 7, 26, 9, 2, -21 },
  { 2280, 13, 21, 13, 0, -21 },
  { 2315, 7, 26, 9, 1, -21 },
  { 2338, 16, 14, 15, 0, -21 },
  { 2366, 15, 3, 15, 0, 2 },
  { 2372, 10, 4, 12, 1, -22 },
  { 2377, 15, 16, 18, 1, -16 },
  { 2407, 15, 22, 19, 2, -22 },
  { 2449, 14, 16, 16, 1, -16 },
  { 2477, 16, 22, 19, 1, -22 },
  { 2521, 16, 16, 18, 1, -16 },
  { 2553, 12, 22, 12, 1, -22 },
  { 2586, 16, 23, 19, 1, -16 },
  { 2632, 16, 22, 19, 2, -22 },
  { 2676, 6, 23, 9, 2, -23 },
  { 2694, 9, 30, 9, -1, -23 },
  { 2728, 17, 22, 19, 2, -22 },
  { 2775, 5, 22, 9, 2, -22 },
  { 2789, 25, 16, 29, 2, -16 },
  { 2839, 16, 16, 19, 2, -16 },
  { 2871, 16, 16, 18, 1, -16 },
  { 2903, 15, 23, 19, 2, -16 },
  { 2947, 16, 23, 19, 1, -16 },
  { 2993, 11, 16, 14, 2, -16 },
  { 3015, 13, 16, 15, 1, -16 },
  { 3041, 11, 19, 13, 1, -19 },
  { 3068, 16, 16, 19, 2, -16 },
  { 3100, 18, 16, 18, 0, -16 },
  { 3136, 26, 16, 26, 0, -16 },
  { 3188, 18, 16, 18, 0, -16 },
  { 3224, 18, 23, 18, 0, -16 },
  { 3276, 13, 16, 15, 1, -16 },
  { 3302, 11, 26, 13, 1, -21 },
  { 3338, 4, 28, 15, 5, -22 },
  { 3352, 11, 26, 13, 1, -21 },
  { 3388, 15, 6, 17, 1, -13 },
};

const GFXfont NotoSans_Black29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black29pt7bBitmaps,
  (GFXglyph *)NotoSans_Black29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_BLACK29PT7B_H_
