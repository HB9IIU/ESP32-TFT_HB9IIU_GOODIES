#ifndef _NOTOSANS_BLACK24PT7B_H_
#define _NOTOSANS_BLACK24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDC, 0x00, 0x3B, 0xFF, 0xF0,
  0xFB, 0xDC, 0xF7, 0x3D, 0xCF, 0x73, 0xDC, 0xF0, 0x07, 0xBC, 0x0E, 0x70,
  0x1C, 0xE0, 0x39, 0xC7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x87, 0x38, 0x0E,
  0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x1E, 0x70, 0x39, 0xE0, 0x06, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0x62, 0xF6, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0x06, 0xFC,
  0x6F, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x60, 0x06, 0x00, 0x3E, 0x03, 0xC1,
  0xFC, 0x1E, 0x07, 0xF8, 0x70, 0x1C, 0xE3, 0xC0, 0xF3, 0x8E, 0x03, 0xCE,
  0x78, 0x07, 0x39, 0xC4, 0x1F, 0xEF, 0x7E, 0x7F, 0x3B, 0xFC, 0xFD, 0xCE,
  0xF0, 0x0F, 0x39, 0xC0, 0x39, 0xE7, 0x01, 0xE7, 0x9C, 0x07, 0x0E, 0x70,
  0x3C, 0x3F, 0xC0, 0xE0, 0xFE, 0x07, 0x81, 0xF0, 0x1F, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xFE, 0x00,
  0x7F, 0x1E, 0x3F, 0x8F, 0x9F, 0xF3, 0xEF, 0xBF, 0xF3, 0xE7, 0xFC, 0xF8,
  0xFE, 0x3F, 0x7F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xCF, 0xC0, 0xFB,
  0x9C, 0xE7, 0x38, 0x1E, 0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF,
  0x9E, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x77,
  0x7F, 0xFF, 0xFF, 0xC7, 0xC1, 0xFC, 0x3B, 0x8F, 0x78, 0xC6, 0x00, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x7B, 0xDF, 0xEF, 0x7B, 0x80, 0xFF, 0xFF, 0xF8,
  0x77, 0xFF, 0xE0, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF0, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x9E, 0xF9, 0xFF, 0x9F,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF9, 0xF7, 0xFF,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x07, 0xC3, 0xF1, 0xFD, 0xFF, 0xFF, 0xDF,
  0xF7, 0x7C, 0x9F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0x3F, 0xC7, 0xFE, 0xFF, 0xE7, 0xFF, 0x61, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xCF, 0xFE, 0x7F, 0xE7, 0x3F, 0x01,
  0xE0, 0x1E, 0x3F, 0xC3, 0xF8, 0x3F, 0xC3, 0xFE, 0x03, 0xF0, 0x1F, 0x81,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFE, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0x7C, 0x3D, 0xF1, 0xE7,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80, 0x7F, 0xCF,
  0xFE, 0xFF, 0xE2, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x3F, 0xE7, 0xE0, 0x78, 0x0F, 0x00,
  0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF,
  0x7F, 0xF3, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0xC7, 0xFE, 0xFF, 0xFF,
  0x9F, 0xF9, 0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x3F, 0xC7, 0xFE, 0xF9, 0xFF,
  0x0F, 0xF0, 0xFF, 0x8F, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xFC,
  0xFF, 0xEF, 0x9F, 0xF1, 0xFF, 0x0F, 0xF1, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF,
  0x3E, 0xF0, 0x0F, 0x01, 0xE4, 0xFE, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0xFF,
  0xFE, 0xE0, 0x00, 0x00, 0x03, 0xBF, 0xFF, 0x00, 0xFF, 0xFE, 0xE0, 0x00,
  0x00, 0x03, 0xDE, 0xFF, 0x7B, 0xDC, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFE,
  0x3F, 0x8F, 0xE0, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF0, 0x07,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF0, 0x7F, 0x3F, 0xCF, 0xF0, 0xFC, 0x0E, 0x00, 0x80, 0x00,
  0x3F, 0xCF, 0xFE, 0x7F, 0xE7, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0xFC,
  0x0F, 0x81, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x1E, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0x0F, 0xC3, 0xC0, 0x1C,
  0x78, 0xFD, 0xE7, 0x3F, 0xEE, 0xF7, 0xFE, 0xEE, 0x79, 0xEF, 0xE7, 0x1E,
  0xFE, 0x71, 0xEE, 0xE7, 0x1E, 0xEE, 0x7B, 0xFE, 0xF7, 0xFF, 0xC7, 0x3E,
  0x78, 0x78, 0x00, 0x03, 0xC0, 0x30, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xF7,
  0x80, 0x7B, 0xE0, 0x7C, 0xF0, 0x3E, 0x78, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F,
  0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0x80, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xE7, 0xFF, 0x0F, 0xF8,
  0x7F, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFF, 0xBC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xF3, 0xFF,
  0x9F, 0xDE, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x09, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0xFF, 0xC1, 0xFF,
  0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF,
  0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xF3, 0xFD, 0xE7, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFB,
  0xE0, 0xF7, 0xC1, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0x07, 0xFC, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0xFF, 0xFF, 0xFF, 0xE7, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF3, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x87,
  0xDF, 0xEF, 0xE7, 0xE0, 0xF8, 0x7F, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0x8F,
  0xBE, 0x1F, 0x7C, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x87, 0xDF, 0x0F, 0x9F, 0x1F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7E, 0xF8, 0x7C,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xB8, 0xEF, 0xF7, 0x9D, 0xFE, 0xF7, 0xBF,
  0xDE, 0xF7, 0xF9, 0xDC, 0xFF, 0x3F, 0x9F, 0xE7, 0xF3, 0xFC, 0x7C, 0x7F,
  0x8F, 0x8F, 0xF1, 0xF1, 0xE0, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xF7, 0x8F, 0xF7, 0xCF, 0xF3, 0xCF, 0xF3,
  0xEF, 0xF1, 0xEF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xEF, 0xE7,
  0xC1, 0xF7, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xEF, 0x83, 0xF7, 0xC1, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0x0F, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xEF, 0xE7, 0xC1, 0xF7, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x83, 0xF7, 0xC1, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0x9F, 0x8F, 0x0F,
  0x1E, 0x1E, 0x3C, 0x7C, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07,
  0x9F, 0x0F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3E, 0x78, 0x7E, 0xF0, 0x7E, 0x1F,
  0xE7, 0xFF, 0x7F, 0xEF, 0x8E, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F,
  0xE1, 0xFF, 0x07, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF8,
  0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC3, 0xC3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x3C, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x00,
  0xF8, 0x3E, 0x0F, 0xBC, 0x1F, 0x07, 0x9E, 0x0F, 0x83, 0xCF, 0x8F, 0xC3,
  0xE3, 0xC7, 0xF1, 0xE1, 0xE3, 0xB8, 0xF0, 0xF1, 0xDC, 0x78, 0x78, 0xEE,
  0x7C, 0x3E, 0xF7, 0xBC, 0x0F, 0x7B, 0xDE, 0x07, 0xBD, 0xEF, 0x03, 0xDC,
  0x77, 0x81, 0xEE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0xBE, 0x0F, 0x8F, 0x8F,
  0x83, 0xE7, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0xC1, 0xF1, 0xF0,
  0xF8, 0xFC, 0xF8, 0x3E, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x3E, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F,
  0xFF, 0xF0, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCF, 0xFF, 0xFC, 0x06, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x01, 0xF8,
  0x1E, 0xE0, 0xE7, 0x0F, 0x1C, 0x70, 0xF3, 0x83, 0xB8, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3E, 0x0F, 0x01, 0x07, 0xFE, 0x3F, 0xF3, 0xFF, 0x20, 0xF0,
  0x0F, 0x3F, 0xF7, 0xFF, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7,
  0xE7, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0x0F, 0x7C, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEE, 0x7C, 0x03, 0x03, 0xFC, 0xFF, 0xBF, 0xFF, 0xC5, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xFB, 0xBF, 0xF3, 0xFE, 0x3F, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x8F, 0x9F, 0xFD, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xF7,
  0xEF, 0xFF, 0x7F, 0x79, 0xF3, 0xC0, 0x02, 0x00, 0xFF, 0x1F, 0xFC, 0xFF,
  0xEF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x04,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x1F, 0xCF, 0xE3, 0xF9, 0xF0, 0x7C, 0x3F,
  0xEF, 0xFB, 0xFE, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x00, 0x08, 0x01, 0xFB, 0xDF, 0xFE, 0xFF, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFF, 0x3E, 0xFF, 0xF7,
  0xFF, 0x9F, 0x7C, 0x03, 0xE8, 0x1F, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0x7E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x10, 0x7B, 0xF3, 0xFF,
  0xDF, 0xFE, 0xF9, 0xF7, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xC0, 0x23, 0xFE, 0xF0, 0x01, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x08, 0x3C, 0xF8, 0xF0, 0x00,
  0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF3, 0xFF, 0xFF, 0xFE, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC3, 0xEF, 0x1F, 0x3C, 0xF8, 0xF7, 0xC3, 0xDF, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC3, 0xEF, 0x8F, 0x3F, 0x3C, 0x7C, 0xF0, 0xFB, 0xC3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x01,
  0x0E, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF9, 0xFF, 0x0F,
  0x8F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x01, 0x07, 0x3F,
  0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7C, 0x02, 0x00, 0xFE, 0x0F,
  0xFC, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7,
  0xDF, 0x3E, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x01, 0x0F, 0x7E, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0x7C, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x08, 0x01, 0xFB, 0xDF, 0xFE, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFF, 0x7E, 0xFF, 0xF7, 0xFF, 0x9F, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x01, 0x73,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x80, 0x04, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x87, 0xF9, 0xFF,
  0x1F, 0xC1, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x0F, 0x0F,
  0xFF, 0xFF, 0xFD, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xEB, 0xFC,
  0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xF7, 0xE7, 0x80,
  0xF8, 0x3E, 0xF0, 0xF9, 0xF1, 0xF3, 0xE3, 0xC3, 0xCF, 0x87, 0x9E, 0x07,
  0xBC, 0x0F, 0x78, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0xFC, 0x7D, 0xE3, 0xF1, 0xE7, 0x8F, 0xCF, 0x9F, 0x3F, 0x3E,
  0x3D, 0xFC, 0xF0, 0xF7, 0x7B, 0xC3, 0xDD, 0xEF, 0x0F, 0x73, 0xB8, 0x1D,
  0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0xFC, 0x7E, 0xFC, 0xF8, 0xFB, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x7D, 0xF0, 0xFB, 0xE3, 0xE3, 0xEF,
  0xC3, 0xE0, 0xF8, 0x3E, 0xF0, 0xF9, 0xF1, 0xF3, 0xE3, 0xC3, 0xC7, 0x87,
  0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01,
  0xE0, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81,
  0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0xC7, 0xE3,
  0xC1, 0xC0, 0xE0, 0x70, 0x78, 0xFC, 0x7E, 0x3C, 0x1F, 0x83, 0xC1, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0x07, 0xE3, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x7C, 0x3F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3F, 0x0F, 0xC3, 0xE7, 0xF3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3E, 0x3F, 0x1F, 0x0F, 0x00, 0x38, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0x81,
  0xE0,
};

const GFXglyph NotoSans_Black24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 17, 7, 1, -17 },
  { 12, 10, 6, 13, 1, -17 },
  { 20, 15, 17, 16, 0, -17 },
  { 52, 12, 19, 14, 1, -18 },
  { 81, 22, 17, 23, 0, -17 },
  { 128, 18, 17, 19, 1, -17 },
  { 167, 5, 6, 7, 1, -17 },
  { 171, 7, 22, 9, 1, -18 },
  { 191, 7, 22, 9, 1, -18 },
  { 211, 11, 11, 13, 1, -18 },
  { 227, 12, 11, 14, 1, -14 },
  { 244, 5, 7, 7, 1, -4 },
  { 249, 7, 3, 8, 0, -8 },
  { 252, 5, 4, 7, 1, -4 },
  { 255, 11, 17, 11, 0, -17 },
  { 279, 12, 17, 14, 1, -17 },
  { 305, 10, 17, 14, 1, -17 },
  { 327, 12, 17, 14, 1, -17 },
  { 353, 12, 17, 14, 1, -17 },
  { 379, 14, 17, 14, 0, -17 },
  { 409, 12, 17, 14, 1, -17 },
  { 435, 12, 17, 14, 1, -17 },
  { 461, 12, 17, 14, 1, -17 },
  { 487, 12, 17, 14, 1, -17 },
  { 513, 12, 17, 14, 1, -17 },
  { 539, 5, 13, 7, 1, -13 },
  { 548, 5, 16, 7, 1, -13 },
  { 558, 12, 13, 14, 1, -15 },
  { 578, 12, 9, 14, 1, -13 },
  { 592, 12, 13, 14, 1, -15 },
  { 612, 12, 17, 12, 0, -17 },
  { 638, 20, 19, 22, 1, -17 },
  { 686, 17, 17, 17, 0, -17 },
  { 723, 13, 17, 16, 2, -17 },
  { 751, 14, 17, 16, 1, -17 },
  { 781, 14, 17, 18, 2, -17 },
  { 811, 10, 17, 13, 2, -17 },
  { 833, 10, 17, 13, 2, -17 },
  { 855, 15, 17, 18, 1, -17 },
  { 887, 15, 17, 18, 2, -17 },
  { 919, 9, 17, 11, 1, -17 },
  { 939, 9, 22, 8, -2, -17 },
  { 964, 15, 17, 16, 2, -17 },
  { 996, 11, 17, 14, 2, -17 },
  { 1020, 19, 17, 23, 2, -17 },
  { 1061, 16, 17, 20, 2, -17 },
  { 1095, 17, 17, 19, 1, -17 },
  { 1132, 12, 17, 15, 2, -17 },
  { 1158, 17, 21, 19, 1, -17 },
  { 1203, 15, 17, 16, 2, -17 },
  { 1235, 12, 17, 14, 1, -17 },
  { 1261, 13, 17, 14, 1, -17 },
  { 1289, 14, 17, 18, 2, -17 },
  { 1319, 17, 17, 17, 0, -17 },
  { 1356, 25, 17, 25, 0, -17 },
  { 1410, 17, 17, 17, 0, -17 },
  { 1447, 16, 17, 16, 0, -17 },
  { 1481, 13, 17, 15, 1, -17 },
  { 1509, 6, 22, 8, 1, -18 },
  { 1526, 11, 17, 11, 0, -17 },
  { 1550, 5, 22, 8, 1, -18 },
  { 1564, 13, 11, 13, 0, -17 },
  { 1582, 12, 2, 12, 0, 2 },
  { 1585, 8, 3, 10, 1, -18 },
  { 1588, 12, 14, 15, 1, -14 },
  { 1609, 12, 18, 15, 2, -18 },
  { 1636, 11, 14, 13, 1, -14 },
  { 1656, 13, 18, 15, 1, -18 },
  { 1686, 13, 14, 15, 1, -14 },
  { 1709, 10, 18, 10, 1, -18 },
  { 1732, 13, 20, 15, 1, -14 },
  { 1765, 13, 18, 16, 2, -18 },
  { 1795, 5, 19, 8, 1, -19 },
  { 1807, 7, 25, 8, -1, -19 },
  { 1829, 14, 18, 16, 2, -18 },
  { 1861, 4, 18, 8, 2, -18 },
  { 1870, 20, 14, 24, 2, -14 },
  { 1905, 13, 14, 16, 2, -14 },
  { 1928, 13, 14, 15, 1, -14 },
  { 1951, 12, 20, 15, 2, -14 },
  { 1981, 13, 20, 15, 1, -14 },
  { 2014, 9, 14, 11, 2, -14 },
  { 2030, 10, 14, 12, 1, -14 },
  { 2048, 9, 16, 11, 1, -16 },
  { 2066, 13, 13, 16, 2, -13 },
  { 2088, 15, 13, 15, 0, -13 },
  { 2113, 22, 13, 22, 0, -13 },
  { 2149, 15, 13, 15, 0, -13 },
  { 2174, 15, 19, 15, 0, -13 },
  { 2210, 11, 13, 12, 1, -13 },
  { 2228, 9, 21, 10, 1, -17 },
  { 2252, 3, 23, 12, 5, -18 },
  { 2261, 9, 21, 10, 1, -17 },
  { 2285, 12, 5, 14, 1, -11 },
};

const GFXfont NotoSans_Black24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black24pt7bBitmaps,
  (GFXglyph *)NotoSans_Black24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_BLACK24PT7B_H_
