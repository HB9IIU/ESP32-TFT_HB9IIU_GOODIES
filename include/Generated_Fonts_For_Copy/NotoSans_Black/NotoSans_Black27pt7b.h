#ifndef _NOTOSANS_BLACK27PT7B_H_
#define _NOTOSANS_BLACK27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x03,
  0x3E, 0xFF, 0xF7, 0x80, 0xF3, 0xFE, 0x7B, 0xCF, 0x79, 0xEF, 0x3D, 0xE7,
  0xBC, 0xF0, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x79,
  0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0x3C, 0x07, 0x9E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x79, 0xE0, 0x3C, 0xE0,
  0x1C, 0x70, 0x0E, 0x78, 0x07, 0x3C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0xF8,
  0x0F, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xB3, 0xBC, 0xC0, 0xFB, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x37, 0xE0, 0xDF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x1F, 0xC0, 0x78, 0x1F, 0xE0, 0x78, 0x0F, 0xF8, 0x3C,
  0x07, 0xBC, 0x3C, 0x07, 0x9E, 0x3C, 0x03, 0xCF, 0x1E, 0x00, 0xE7, 0x9E,
  0x00, 0x7B, 0xCF, 0x3C, 0x3F, 0xEF, 0x3F, 0x9F, 0xE7, 0xBF, 0xC7, 0xF7,
  0xBF, 0xF0, 0x43, 0xDE, 0x78, 0x03, 0xCF, 0x3C, 0x03, 0xC7, 0x9E, 0x01,
  0xE3, 0xCF, 0x01, 0xE1, 0xE7, 0x80, 0xF0, 0x7F, 0x80, 0xF0, 0x3F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0x8F, 0xF8, 0xF8, 0xFF, 0xE7, 0xCF, 0xDF,
  0xFE, 0x7C, 0x7F, 0xE3, 0xE1, 0xFF, 0x1F, 0x87, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3C, 0x3E, 0x1F,
  0xF0, 0x78, 0x7C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x80, 0xFE, 0x0F, 0x78, 0xF3, 0xE1, 0x8C, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7D, 0xE7, 0x9E,
  0xFB, 0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xEF, 0xFF, 0x78, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0x02, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFC,
  0x7F, 0xFB, 0xF3, 0xEF, 0x8F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xDF, 0x3E, 0x7F, 0xF8, 0xFF,
  0xC3, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x7F, 0x9F, 0xF7, 0xFF, 0xFF,
  0xDE, 0xF9, 0x9F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x01, 0x00, 0xFF, 0x87, 0xFF,
  0x3F, 0xFE, 0xFF, 0xF9, 0xC3, 0xE2, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0xFF, 0x8F, 0xFF, 0x1F,
  0xFE, 0x7F, 0xF8, 0x83, 0xE0, 0x0F, 0x80, 0x7C, 0x1F, 0xE0, 0x7F, 0x01,
  0xFE, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x3E, 0xF8, 0x79, 0xF1,
  0xF3, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7C, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0x3F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xC7, 0xFC, 0x00, 0x00, 0x60, 0x1F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF9,
  0xF0, 0x07, 0x80, 0x3E, 0x78, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF,
  0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x03, 0x00, 0x7F, 0x87, 0xFF, 0x9F, 0xFE, 0xFC, 0xFB, 0xE3, 0xE7, 0xCF,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xFC, 0xFD, 0xFB, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x07, 0xF8, 0x03,
  0x00, 0x7F, 0x87, 0xFF, 0x1F, 0xFE, 0xFF, 0xFB, 0xE3, 0xEF, 0x87, 0xFE,
  0x1F, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0x7C, 0x31, 0xE0,
  0x0F, 0x80, 0x7E, 0x7F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x7B, 0xFF,
  0xFE, 0x78, 0x00, 0x00, 0x00, 0x03, 0x3E, 0xFF, 0xF7, 0x80, 0x7B, 0xFF,
  0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x79, 0xE7, 0xBE, 0xF3, 0xCF,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7C,
  0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC,
  0x7F, 0xC7, 0xFC, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x02,
  0x01, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0x90, 0x7C, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xF9, 0xFC, 0x1E, 0x00, 0xF8, 0xF0, 0xF1,
  0xE7, 0x8F, 0xFB, 0xDE, 0x7F, 0xEF, 0x73, 0xE7, 0x9F, 0xCF, 0x1E, 0x7F,
  0x78, 0x79, 0xFD, 0xE1, 0xE7, 0xF7, 0x87, 0x3F, 0xCF, 0x3E, 0xFF, 0x3F,
  0xFF, 0x9C, 0x7F, 0xFC, 0x78, 0xF1, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0x1C,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xBE, 0x00, 0xFB, 0xE0,
  0x0F, 0x9E, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x0F,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0,
  0x7C, 0x7C, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0xFF, 0xF1, 0xFF,
  0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xFF, 0x0F, 0xBE, 0x1F, 0x7F, 0xFE,
  0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xC3, 0xFF, 0x83, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x40, 0x07,
  0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x04, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7F, 0x06, 0x3F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFC, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x00,
  0x60, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xF8, 0x11,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFB, 0xE0, 0x7D, 0xF8, 0x3E, 0xFE, 0x1F, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFF, 0xFF,
  0xFD, 0xFC, 0xFC, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x3E, 0x1F, 0x9F, 0x1F,
  0x8F, 0x8F, 0x87, 0xCF, 0xC3, 0xEF, 0xC1, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0x9F, 0x87, 0xC7, 0xC3, 0xE3, 0xF1,
  0xF0, 0xFC, 0xF8, 0x7E, 0x7C, 0x1F, 0xBE, 0x0F, 0xE0, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xDE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0x7F, 0xEF, 0x3D, 0xFF, 0xBC, 0xF7, 0xFE, 0xF3,
  0xDF, 0xF9, 0xFE, 0x7F, 0xE7, 0xF9, 0xFF, 0x9F, 0xE7, 0xFE, 0x7F, 0x1F,
  0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xC0, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFD, 0xF0, 0xFF, 0xFC,
  0x3F, 0xEF, 0x8F, 0xFB, 0xF3, 0xFE, 0x7C, 0xFF, 0x9F, 0xBF, 0xE3, 0xEF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0x81, 0xFC, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F, 0x81, 0xFB, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x7E, 0xF8,
  0x0F, 0xDF, 0x81, 0xFB, 0xF8, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF8,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF,
  0xF8, 0xFF, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x03,
  0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0,
  0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x9F, 0x07, 0xCF, 0xC3, 0xE3,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7E, 0x7C, 0x1F, 0xBE, 0x0F, 0xE0, 0x01, 0x00,
  0x7F, 0xE3, 0xFF, 0xDF, 0xFE, 0x7F, 0xFB, 0xF0, 0x4F, 0xC0, 0x3F, 0x80,
  0x7F, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x3F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xEF,
  0x81, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F,
  0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x83, 0xF7, 0xC1,
  0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x3C, 0x1F, 0xC3,
  0xC3, 0xE3, 0xFC, 0x7C, 0x3E, 0x3F, 0xC7, 0xC3, 0xE3, 0xFC, 0x7C, 0x1E,
  0x3F, 0xC7, 0x81, 0xF7, 0x9E, 0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xF7, 0x9E,
  0xF8, 0x0F, 0x79, 0xEF, 0x80, 0xF7, 0x8E, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE7, 0xC1, 0xF8, 0xFC, 0x7E, 0x0F, 0x8F, 0xC1,
  0xFB, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7E, 0x07,
  0xE7, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xCF, 0xC1, 0xFB, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xDF, 0x07, 0xE7, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x3E, 0x07,
  0xCF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF,
  0xFF, 0xFC, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xFC, 0x0F, 0x38, 0x1E, 0x78, 0x38, 0x70, 0xF0, 0xF1, 0xC0, 0xF7,
  0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x3F, 0x07, 0xC1,
  0xF0, 0x38, 0x1F, 0xE1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x10, 0x7C, 0x01,
  0xF3, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFE, 0xF3, 0xF3, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xBE, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0xF3, 0xE0, 0x0F, 0xF0, 0xFF, 0xCF, 0xFC, 0xFF,
  0xE7, 0xC1, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x04,
  0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC7, 0xDF, 0x9F, 0xDF, 0x7F, 0xFE,
  0xFF, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x7E, 0xFF, 0xFD, 0xFF, 0xF9, 0xFD, 0xF1, 0xF3, 0xE0, 0x0F,
  0xE0, 0x7F, 0xF1, 0xFF, 0xE3, 0xF7, 0xE7, 0xC3, 0xDF, 0x07, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x13, 0xFB, 0xE7, 0xFF, 0xC7,
  0xFF, 0x83, 0xFE, 0x00, 0x07, 0x03, 0xFC, 0xFF, 0x1F, 0xE3, 0xE0, 0x7C,
  0x1F, 0xF7, 0xFE, 0xFF, 0xDF, 0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x3E, 0x7F,
  0x7D, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xFB, 0xFF, 0xF7, 0xFF, 0xE7, 0xF7, 0xC7,
  0xDF, 0x80, 0x3F, 0x40, 0x7C, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xBF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7C, 0xF7, 0xFF, 0xF2, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x1F, 0x1F, 0x1F, 0x04, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFE, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8,
  0xF8, 0xF9, 0xF8, 0xFB, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF3, 0xF1, 0xF9, 0xEF, 0xF7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xE3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC,
  0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3,
  0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0x80, 0xF3,
  0xF3, 0xDF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xC0, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7D, 0xF1, 0xFB, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xF3, 0xE3, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xBE, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x3E, 0x7F, 0x7D,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF1, 0xFB, 0xFF, 0xF7, 0xFF, 0xE7, 0xF7, 0xC7, 0xDF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x1F, 0xC7, 0xFF, 0xFF, 0xEF,
  0x8E, 0xF8, 0x0F, 0xF0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0x80, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0xEF,
  0xFD, 0xFF, 0xBF, 0xF1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xF9, 0xFF, 0x3F, 0xE3, 0xF8, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xF3, 0xF3, 0xC0, 0xFC, 0x1F,
  0xBE, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC3, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x7E, 0x1F, 0x7C, 0x7E, 0x1F,
  0x7C, 0x7F, 0x1F, 0x7C, 0x7F, 0x3E, 0x3C, 0xFF, 0x3E, 0x3E, 0xF7, 0x3E,
  0x3E, 0xF7, 0xBC, 0x3E, 0xF7, 0xBC, 0x1E, 0xE7, 0xFC, 0x1F, 0xE7, 0xFC,
  0x1F, 0xE3, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0xBF, 0x1F, 0x8F, 0xDF, 0x83, 0xEF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xDF, 0x07, 0xEF, 0xC3, 0xE3, 0xE3, 0xF1, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x1E,
  0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x43, 0xF0, 0xFC, 0x7F, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x8F, 0xE3, 0xF0, 0xF0, 0x3F, 0x0F, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xF0, 0xFC, 0x3F, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x3E, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x81, 0xFC, 0x7F, 0x03, 0xC7, 0xF1, 0xFC, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC3, 0xE0, 0x80, 0x00, 0x7E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x81, 0xF0,
};

const GFXglyph NotoSans_Black27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 19, 8, 1, -19 },
  { 16, 11, 7, 14, 2, -19 },
  { 26, 17, 19, 18, 0, -19 },
  { 67, 14, 23, 16, 1, -21 },
  { 108, 25, 20, 26, 0, -20 },
  { 171, 21, 20, 22, 1, -20 },
  { 224, 4, 7, 8, 2, -19 },
  { 228, 8, 24, 10, 1, -20 },
  { 252, 8, 24, 10, 1, -20 },
  { 276, 13, 13, 15, 1, -21 },
  { 298, 14, 13, 16, 1, -16 },
  { 321, 6, 8, 8, 1, -4 },
  { 327, 7, 4, 9, 1, -9 },
  { 331, 6, 5, 8, 1, -5 },
  { 335, 12, 20, 12, 0, -20 },
  { 365, 14, 20, 16, 1, -20 },
  { 400, 11, 19, 16, 1, -19 },
  { 427, 14, 20, 16, 1, -20 },
  { 462, 14, 20, 16, 1, -20 },
  { 497, 15, 19, 16, 0, -19 },
  { 533, 14, 19, 16, 1, -19 },
  { 567, 14, 20, 16, 1, -20 },
  { 602, 14, 19, 16, 1, -19 },
  { 636, 14, 20, 16, 1, -20 },
  { 671, 14, 20, 16, 1, -20 },
  { 706, 6, 15, 8, 1, -15 },
  { 718, 6, 19, 8, 1, -15 },
  { 733, 14, 15, 16, 1, -17 },
  { 760, 14, 9, 16, 1, -14 },
  { 776, 14, 15, 16, 1, -17 },
  { 803, 13, 20, 14, 0, -20 },
  { 836, 22, 22, 24, 1, -20 },
  { 897, 20, 19, 20, 0, -19 },
  { 945, 15, 19, 18, 2, -19 },
  { 981, 16, 20, 18, 1, -20 },
  { 1021, 16, 19, 20, 2, -19 },
  { 1059, 12, 19, 15, 2, -19 },
  { 1088, 11, 19, 15, 2, -19 },
  { 1115, 17, 20, 20, 1, -20 },
  { 1158, 17, 19, 21, 2, -19 },
  { 1199, 10, 19, 12, 1, -19 },
  { 1223, 9, 25, 10, -2, -19 },
  { 1252, 17, 19, 19, 2, -19 },
  { 1293, 13, 19, 16, 2, -19 },
  { 1324, 22, 19, 26, 2, -19 },
  { 1377, 18, 19, 23, 2, -19 },
  { 1420, 19, 20, 22, 1, -20 },
  { 1468, 14, 19, 17, 2, -19 },
  { 1502, 20, 25, 22, 1, -20 },
  { 1565, 17, 19, 18, 2, -19 },
  { 1606, 14, 20, 16, 1, -20 },
  { 1641, 14, 19, 16, 1, -19 },
  { 1675, 16, 19, 20, 2, -19 },
  { 1713, 19, 19, 19, 0, -19 },
  { 1759, 28, 19, 28, 0, -19 },
  { 1826, 19, 19, 20, 0, -19 },
  { 1872, 18, 19, 18, 0, -19 },
  { 1915, 15, 19, 17, 1, -19 },
  { 1951, 6, 25, 9, 2, -20 },
  { 1970, 12, 20, 12, 0, -20 },
  { 2000, 6, 25, 9, 1, -20 },
  { 2019, 15, 12, 14, 0, -19 },
  { 2042, 14, 3, 14, 0, 2 },
  { 2048, 9, 5, 11, 1, -21 },
  { 2054, 14, 15, 17, 1, -15 },
  { 2081, 14, 21, 17, 2, -21 },
  { 2118, 13, 15, 15, 1, -15 },
  { 2143, 15, 21, 17, 1, -21 },
  { 2183, 15, 15, 17, 1, -15 },
  { 2212, 11, 21, 11, 1, -21 },
  { 2241, 15, 21, 17, 1, -15 },
  { 2281, 14, 21, 18, 2, -21 },
  { 2318, 5, 21, 9, 2, -21 },
  { 2332, 8, 27, 9, -1, -21 },
  { 2359, 16, 21, 18, 2, -21 },
  { 2401, 5, 21, 9, 2, -21 },
  { 2415, 23, 15, 27, 2, -15 },
  { 2459, 14, 15, 18, 2, -15 },
  { 2486, 15, 15, 17, 1, -15 },
  { 2515, 14, 21, 17, 2, -15 },
  { 2552, 15, 21, 17, 1, -15 },
  { 2592, 10, 15, 13, 2, -15 },
  { 2611, 12, 15, 14, 1, -15 },
  { 2634, 11, 18, 12, 1, -18 },
  { 2659, 14, 15, 18, 2, -15 },
  { 2686, 17, 15, 17, 0, -15 },
  { 2718, 24, 15, 25, 0, -15 },
  { 2763, 17, 15, 17, 0, -15 },
  { 2795, 16, 21, 16, 0, -15 },
  { 2837, 12, 15, 14, 1, -15 },
  { 2860, 10, 25, 12, 1, -20 },
  { 2892, 4, 27, 14, 5, -21 },
  { 2906, 10, 25, 12, 1, -20 },
  { 2938, 14, 5, 16, 1, -12 },
};

const GFXfont NotoSans_Black27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black27pt7bBitmaps,
  (GFXglyph *)NotoSans_Black27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_BLACK27PT7B_H_
