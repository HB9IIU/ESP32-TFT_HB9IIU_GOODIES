#ifndef _NOTOSANS_BLACK43PT7B_H_
#define _NOTOSANS_BLACK43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0,
  0x00, 0x00, 0x00, 0x10, 0x7E, 0x7F, 0xBF, 0xDF, 0xFF, 0xF7, 0xF9, 0xF8,
  0x10, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0xC7, 0xE0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9,
  0xFF, 0xF3, 0xF3, 0xF9, 0xE0, 0x47, 0xF3, 0xC0, 0x0F, 0xF7, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1E, 0x7F, 0x80, 0x3C, 0x7F, 0x60, 0x78, 0xFE, 0xFC, 0xF7,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x7E, 0x00, 0x3F,
  0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x7F, 0x0F,
  0xC0, 0x01, 0xF8, 0xFE, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x7E, 0x00, 0x07,
  0xE3, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0x1F, 0xCF, 0xCF,
  0xE7, 0xFE, 0x1F, 0xFF, 0x9F, 0x9F, 0xFE, 0x3F, 0xFE, 0x7E, 0x7F, 0xFC,
  0x3F, 0xFC, 0xFC, 0xFF, 0xFC, 0x3F, 0xF3, 0xF1, 0xF9, 0xF8, 0x3F, 0x87,
  0xE7, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x1F, 0x80, 0x07,
  0xE0, 0xFE, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0xFE, 0x00, 0x3F, 0x01, 0xF9,
  0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x07,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF,
  0x3F, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFE, 0x0F,
  0xF8, 0x1F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFD, 0xFF, 0xC0, 0x3F, 0xFC,
  0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF0,
  0x07, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8,
  0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xC3, 0xE1, 0xEF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0xC1,
  0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x0F, 0x0E, 0x00, 0x10, 0x40, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x3F, 0x3F,
  0xDF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0x83, 0xFC,
  0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xEF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0xFF,
  0x07, 0xFD, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0,
  0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xF7, 0xFC, 0xF9, 0xFF, 0x1C, 0x7F, 0xC6, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x83,
  0xFE, 0x1E, 0x03, 0xFC, 0x10, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0x01, 0xFF, 0x10, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xEF,
  0xF0, 0x1F, 0xEF, 0xF0, 0x1F, 0xCF, 0xF0, 0x3F, 0x8F, 0xF0, 0x7F, 0x8F,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF9, 0xE1, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0x02, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0xFF, 0x07, 0xF7, 0xFF, 0x0F, 0xEF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFB,
  0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF,
  0xE1, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xC1, 0xFE,
  0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xBF, 0xE3, 0xFE, 0x3F, 0xE7, 0xF8,
  0x3F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x7F, 0x81,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x81, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xC3, 0xFE, 0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xFB,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xEF, 0xF0, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F,
  0xF7, 0xF0, 0x7F, 0xCF, 0xE0, 0x1C, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x3E, 0x7F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFC, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x3F, 0x3F, 0xDF, 0xEF,
  0xFF, 0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFC, 0x3F, 0xE7, 0x00, 0xFF, 0x20,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0xFC, 0x3F, 0x83, 0xFF, 0x9F, 0xC7, 0xE1, 0xFF, 0xF9, 0xF9, 0xF8, 0x7F,
  0xFF, 0x1F, 0x3F, 0x1F, 0xFF, 0xE3, 0xEF, 0xC7, 0xF8, 0xFC, 0x7F, 0xF8,
  0xFC, 0x1F, 0x8F, 0xFF, 0x3F, 0x83, 0xF1, 0xFF, 0xE7, 0xE0, 0x7E, 0x3F,
  0xFC, 0xFC, 0x0F, 0xC7, 0xFF, 0x1F, 0x81, 0xF8, 0xFF, 0xE3, 0xF0, 0x3F,
  0x1F, 0x7C, 0x7E, 0x0F, 0xE3, 0xEF, 0xCF, 0xE1, 0xFC, 0xFD, 0xF8, 0xFF,
  0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0xFF, 0xE7, 0xE1, 0xFF, 0xFF, 0xF8, 0x7E,
  0x1F, 0xF9, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x08, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F,
  0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x87,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x0F, 0xF1,
  0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0x87, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0x38, 0x7F, 0xE0, 0x04, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0C, 0x3F, 0xFC, 0x7E, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xFE, 0xFF, 0x80, 0xFF, 0xBF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x0F, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC0, 0x18, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80,
  0x3F, 0xDF, 0xF8, 0x07, 0xF9, 0xFF, 0x80, 0xFF, 0x3F, 0xFE, 0x7F, 0xE3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xFB, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0x78, 0x00,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F,
  0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8,
  0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0xFB,
  0xF0, 0x1F, 0xBF, 0xFF, 0x7F, 0x03, 0xF7, 0xFF, 0xEF, 0xE0, 0x7E, 0xFF,
  0xFE, 0xFC, 0x1F, 0xDF, 0xFF, 0xDF, 0xC3, 0xF3, 0xFF, 0xFB, 0xF8, 0x7E,
  0x7F, 0xFF, 0x3F, 0x0F, 0xCF, 0xFF, 0xE7, 0xE3, 0xF1, 0xFF, 0xFC, 0xFE,
  0x7E, 0x3F, 0xFF, 0x9F, 0xCF, 0xC7, 0xFF, 0xF1, 0xFB, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xFE, 0x0F,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xEF, 0xF0, 0x3F,
  0xFF, 0x9F, 0xE0, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF,
  0xF3, 0xFE, 0x3F, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0x1F, 0xF3, 0xFF, 0xFC,
  0x3F, 0xCF, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0,
  0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF,
  0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xC3, 0xFE,
  0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xDF, 0xF0, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8,
  0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x3F, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF9, 0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xF0, 0x1C, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE7,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x9F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFF,
  0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFF, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFD, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xBF, 0x0F, 0xF0,
  0x3F, 0xC7, 0xF7, 0xE1, 0xFE, 0x07, 0xF8, 0xFE, 0xFC, 0x3F, 0xC0, 0xFF,
  0x1F, 0x9F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF1, 0xF9, 0xFE, 0x01, 0xFC, 0x7E,
  0x3F, 0x3F, 0xC0, 0x3F, 0xDF, 0xC7, 0xE7, 0xF8, 0x07, 0xFB, 0xF8, 0xFC,
  0xFE, 0x00, 0x7F, 0x7E, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC1, 0xFF, 0xF8,
  0x01, 0xFD, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80,
  0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F,
  0xCF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xF7, 0xF3, 0xFF, 0x8F, 0xC7, 0xFC, 0x3F, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x3F,
  0x83, 0xFC, 0xFF, 0x87, 0xFB, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFB, 0xFF,
  0x1F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0x3F, 0xF0, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xE3,
  0xCF, 0xF8, 0x04, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x27, 0xFE, 0x1E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE3, 0xFC,
  0x3F, 0xE7, 0xF8, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0x7F,
  0x8F, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFC, 0xFF, 0x9F,
  0xE0, 0xFF, 0x7F, 0xC0, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x31, 0xFF, 0xEF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x10, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xF3, 0xFC,
  0x7F, 0xF7, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xBF, 0xC7, 0xFE, 0x7F,
  0x83, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFD, 0x00, 0x0F, 0xFB,
  0xC0, 0x7F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x3F,
  0x83, 0xFD, 0xFF, 0xC7, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE,
  0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xDF, 0xE0, 0x7F, 0xCF, 0xF0, 0x7F, 0xC7, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F,
  0xE1, 0xFE, 0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xCF, 0xFC, 0x3F,
  0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF3,
  0xFC, 0x0F, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0x87,
  0xF3, 0xFF, 0x8F, 0xFF, 0x3F, 0xBF, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFE, 0x7F, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0x83, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x03, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFC, 0x1F,
  0xE1, 0xF8, 0xFF, 0xE3, 0xFB, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x7F, 0xC3, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0xC3,
  0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFE, 0x1F, 0xC1, 0xFC, 0xFF,
  0xC3, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xBF, 0xF3, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFD, 0xFF, 0x8F, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xDF,
  0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE,
  0x1F, 0xF3, 0xFC, 0x7F, 0xF7, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xBF,
  0xC7, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xDF, 0xDF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0x3F, 0x3F, 0xC0, 0x47, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC2,
  0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF0, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xDF, 0xCF, 0xFF, 0x3F, 0x87, 0xFC, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xF8,
  0x1F, 0xEF, 0xF0, 0x3F, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0xC1, 0xFE, 0x7F,
  0x87, 0xFF, 0x07, 0xF1, 0xFE, 0x1F, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0xF0,
  0xFF, 0x0F, 0xE3, 0xF7, 0xE3, 0xFC, 0x3F, 0x8F, 0xDF, 0x8F, 0xE0, 0xFF,
  0x3F, 0x7E, 0x3F, 0x83, 0xFC, 0xFD, 0xF9, 0xFE, 0x07, 0xF3, 0xF7, 0xE7,
  0xF8, 0x1F, 0xDF, 0x8F, 0xDF, 0xC0, 0x7F, 0x7E, 0x3F, 0x7F, 0x01, 0xFD,
  0xF8, 0xFD, 0xFC, 0x03, 0xF7, 0xE3, 0xF7, 0xE0, 0x0F, 0xFF, 0x07, 0xDF,
  0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xEF, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0xFF, 0xC1,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F,
  0xEF, 0xF8, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xF7, 0xF8, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE,
  0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3,
  0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFE, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0xFF, 0xD0, 0x01, 0xF8,
};

const GFXglyph NotoSans_Black43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 32, 12, 2, -31 },
  { 37, 17, 11, 23, 3, -31 },
  { 61, 27, 31, 28, 1, -31 },
  { 166, 23, 36, 25, 1, -33 },
  { 270, 39, 31, 41, 1, -31 },
  { 422, 34, 31, 34, 1, -31 },
  { 554, 7, 11, 13, 3, -31 },
  { 564, 12, 39, 15, 2, -32 },
  { 623, 13, 39, 15, 1, -32 },
  { 687, 21, 21, 23, 1, -33 },
  { 743, 21, 21, 25, 2, -26 },
  { 799, 10, 12, 13, 1, -6 },
  { 814, 12, 7, 14, 1, -15 },
  { 825, 9, 9, 12, 2, -8 },
  { 836, 19, 31, 19, 0, -31 },
  { 910, 23, 31, 25, 1, -31 },
  { 1000, 18, 31, 25, 2, -31 },
  { 1070, 23, 31, 25, 1, -31 },
  { 1160, 22, 31, 25, 1, -31 },
  { 1246, 24, 31, 25, 1, -31 },
  { 1339, 21, 31, 25, 2, -31 },
  { 1421, 23, 31, 25, 1, -31 },
  { 1511, 22, 31, 25, 2, -31 },
  { 1597, 23, 31, 25, 1, -31 },
  { 1687, 23, 31, 25, 1, -31 },
  { 1777, 9, 25, 12, 2, -24 },
  { 1806, 10, 30, 13, 1, -24 },
  { 1844, 21, 23, 25, 2, -27 },
  { 1905, 21, 15, 25, 2, -23 },
  { 1945, 21, 23, 25, 2, -27 },
  { 2006, 21, 32, 22, 0, -31 },
  { 2090, 35, 34, 39, 2, -31 },
  { 2239, 31, 31, 31, 0, -31 },
  { 2360, 24, 31, 29, 3, -31 },
  { 2453, 25, 31, 28, 2, -31 },
  { 2550, 26, 31, 32, 3, -31 },
  { 2651, 19, 31, 24, 3, -31 },
  { 2725, 18, 31, 23, 3, -31 },
  { 2795, 27, 31, 32, 2, -31 },
  { 2900, 27, 31, 33, 3, -31 },
  { 3005, 16, 31, 19, 1, -31 },
  { 3067, 15, 41, 15, -3, -31 },
  { 3144, 27, 31, 30, 3, -31 },
  { 3249, 20, 31, 25, 3, -31 },
  { 3327, 35, 31, 42, 3, -31 },
  { 3463, 30, 31, 36, 3, -31 },
  { 3580, 30, 31, 34, 2, -31 },
  { 3697, 23, 31, 27, 3, -31 },
  { 3787, 31, 38, 34, 2, -31 },
  { 3935, 27, 31, 29, 3, -31 },
  { 4040, 21, 31, 25, 2, -31 },
  { 4122, 23, 31, 25, 1, -31 },
  { 4212, 26, 31, 33, 3, -31 },
  { 4313, 30, 31, 30, 0, -31 },
  { 4430, 43, 31, 45, 1, -31 },
  { 4597, 31, 31, 31, 0, -31 },
  { 4718, 29, 31, 29, 0, -31 },
  { 4831, 24, 31, 26, 1, -31 },
  { 4924, 11, 39, 14, 2, -32 },
  { 4978, 19, 31, 19, 0, -31 },
  { 5052, 10, 39, 14, 1, -32 },
  { 5101, 23, 20, 23, 0, -31 },
  { 5159, 22, 5, 22, 0, 3 },
  { 5173, 14, 7, 18, 2, -33 },
  { 5186, 22, 24, 27, 2, -24 },
  { 5252, 23, 33, 28, 3, -33 },
  { 5347, 20, 24, 23, 2, -24 },
  { 5407, 23, 33, 28, 2, -33 },
  { 5502, 23, 24, 27, 2, -24 },
  { 5571, 18, 33, 18, 1, -33 },
  { 5646, 23, 34, 28, 2, -24 },
  { 5744, 23, 33, 29, 3, -33 },
  { 5839, 8, 33, 14, 3, -33 },
  { 5872, 13, 43, 14, -2, -33 },
  { 5942, 25, 33, 28, 3, -33 },
  { 6046, 8, 33, 14, 3, -33 },
  { 6079, 37, 24, 43, 3, -24 },
  { 6190, 23, 24, 29, 3, -24 },
  { 6259, 24, 24, 27, 2, -24 },
  { 6331, 23, 34, 28, 3, -24 },
  { 6429, 23, 34, 28, 2, -24 },
  { 6527, 17, 24, 20, 3, -24 },
  { 6578, 19, 24, 22, 2, -24 },
  { 6635, 17, 29, 20, 1, -29 },
  { 6697, 23, 24, 29, 3, -24 },
  { 6766, 26, 24, 26, 0, -24 },
  { 6844, 38, 24, 39, 1, -24 },
  { 6958, 27, 24, 27, 0, -24 },
  { 7039, 26, 34, 26, 0, -24 },
  { 7150, 20, 24, 22, 1, -24 },
  { 7210, 16, 38, 19, 1, -31 },
  { 7286, 6, 42, 22, 8, -33 },
  { 7318, 16, 38, 19, 1, -31 },
  { 7394, 21, 8, 25, 2, -19 },
};

const GFXfont NotoSans_Black43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black43pt7bBitmaps,
  (GFXglyph *)NotoSans_Black43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_BLACK43PT7B_H_
