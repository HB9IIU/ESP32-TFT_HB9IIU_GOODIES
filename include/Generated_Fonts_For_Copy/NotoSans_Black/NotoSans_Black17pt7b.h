#ifndef _NOTOSANS_BLACK17PT7B_H_
#define _NOTOSANS_BLACK17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0xEF, 0xDF, 0xBF, 0x70, 0x0D, 0xC1,
  0xB0, 0x76, 0x3F, 0xF7, 0xFE, 0x37, 0x06, 0xC7, 0xFE, 0xFF, 0xC6, 0x60,
  0xDC, 0x1B, 0x00, 0x0C, 0x0F, 0x9F, 0xEF, 0xFE, 0xC3, 0xE1, 0xFC, 0x3F,
  0x0F, 0xC6, 0xDF, 0xEF, 0xE1, 0xC0, 0x60, 0x7C, 0x38, 0x7C, 0x70, 0xEC,
  0x60, 0xEE, 0xE0, 0xEC, 0xC0, 0x7D, 0xBE, 0x7F, 0xBF, 0x03, 0x37, 0x07,
  0x37, 0x06, 0x37, 0x0E, 0x3E, 0x1C, 0x1E, 0x3E, 0x03, 0xF8, 0x1D, 0xC0,
  0xEE, 0x07, 0xF0, 0x3F, 0x3B, 0xFB, 0xDD, 0xFC, 0xE7, 0xE7, 0xBE, 0x3F,
  0xF8, 0xFD, 0xF0, 0xFF, 0xF0, 0x7B, 0xB9, 0xCE, 0x73, 0x18, 0xE7, 0x39,
  0xC6, 0x38, 0xE0, 0xF1, 0x8E, 0x73, 0x8C, 0x63, 0x19, 0xCE, 0x73, 0xBB,
  0x80, 0x1C, 0x0E, 0x13, 0x6F, 0xFF, 0xF9, 0xF0, 0xDC, 0xEC, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x77, 0x6E, 0xFF, 0xFE, 0xFF, 0x80,
  0x0E, 0x1C, 0x30, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x00, 0x7E,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0x1E,
  0x7D, 0xFF, 0x75, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0x3F, 0x7F,
  0xDD, 0xE4, 0x70, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3F, 0xDF, 0xEF, 0xF0,
  0xFE, 0xFF, 0x4F, 0x07, 0x1E, 0x7C, 0x7E, 0x0F, 0x07, 0xCF, 0xFF, 0xFC,
  0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x3F, 0x1D, 0xC7, 0x73, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x1C, 0xFE, 0xFE, 0xFE, 0xE0, 0xFC, 0xFE, 0xFF, 0x07, 0x07,
  0xCF, 0xFE, 0xFC, 0x3F, 0x7F, 0xF0, 0xE0, 0xFE, 0xFF, 0xF7, 0xE7, 0xE7,
  0xFF, 0x7F, 0x3E, 0xFF, 0xFF, 0xFF, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0x7E, 0xFF, 0xE7, 0xE7, 0x7E, 0x3C, 0x7E, 0xE7, 0xE7,
  0xE7, 0xFF, 0x7E, 0x7C, 0xFE, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x7F, 0x07,
  0x9E, 0xFE, 0xF8, 0x5F, 0xA0, 0x07, 0xFC, 0x27, 0x72, 0x00, 0x00, 0x77,
  0x6E, 0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xF0, 0x7E, 0x0F, 0x03, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x7E,
  0xF0, 0xC0, 0x80, 0x7E, 0xFF, 0x67, 0x07, 0x0F, 0x1E, 0x38, 0x38, 0x00,
  0x38, 0x3C, 0x38, 0x1F, 0xE0, 0xFF, 0xC7, 0x03, 0xB9, 0xF6, 0xCF, 0xDB,
  0x73, 0x7D, 0x8D, 0xF6, 0x76, 0xDF, 0xFB, 0xBD, 0xC6, 0x00, 0x1F, 0xF8,
  0x1F, 0xE0, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xDC, 0x3D, 0xC3, 0x9C, 0x39,
  0xE7, 0xFE, 0x7F, 0xE7, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0x3F, 0xEF, 0x7B,
  0xCE, 0xF7, 0xBF, 0xCF, 0xFB, 0xCF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFC, 0x1F,
  0xDF, 0xE7, 0x9B, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1F, 0xE7,
  0xF8, 0x7E, 0xFF, 0x1F, 0xF3, 0xFF, 0x78, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8E, 0xF3, 0xDF, 0xFB, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0xFE, 0xFE, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1F,
  0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x80, 0x1F, 0xDF, 0xF7, 0x8B, 0xC0, 0xE0,
  0x39, 0xFE, 0x7F, 0x87, 0xF1, 0xDF, 0xF7, 0xFC, 0x7F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xF0, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xFF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xEF, 0xB8, 0xF1,
  0xFE, 0x7B, 0xDE, 0x7B, 0x8F, 0xE1, 0xFC, 0x3F, 0xC7, 0xB8, 0xF7, 0x9E,
  0x73, 0xCF, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC,
  0xFF, 0xB3, 0xFE, 0xED, 0xFB, 0xB7, 0xE7, 0xDF, 0x9E, 0x7E, 0x79, 0xF9,
  0xE7, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xE7, 0xEE, 0x7E, 0xF7, 0xE7, 0x7E,
  0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0x3F, 0x87, 0xFC, 0x79, 0xEF,
  0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xE7, 0xFE, 0x7F, 0xC1,
  0xF8, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0x3F, 0xFF, 0xFD, 0xFC, 0xF0, 0x78,
  0x3C, 0x1E, 0x00, 0x3F, 0x87, 0xFC, 0x79, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xE7, 0xFE, 0x7F, 0xC1, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0xFF, 0x1F, 0xF3, 0xDE, 0x79, 0xCF, 0x39, 0xFF, 0x3F, 0xC7,
  0xF8, 0xF7, 0x1E, 0x73, 0xCF, 0x78, 0xF0, 0x7F, 0xFF, 0xE2, 0xE0, 0xF8,
  0x7E, 0x3F, 0x0F, 0x87, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xEF, 0xF9,
  0xFF, 0x1F, 0x80, 0xF0, 0xF7, 0x0E, 0x71, 0xE7, 0x9E, 0x39, 0xC3, 0x9C,
  0x3B, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0xF1, 0xE3, 0xB8,
  0xF1, 0xDC, 0x78, 0xEE, 0x7C, 0xF7, 0x3E, 0x71, 0xDF, 0xB8, 0xED, 0xDC,
  0x76, 0x6E, 0x3F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x83, 0xC7, 0xC0, 0xF0,
  0xF7, 0x9E, 0x39, 0xC1, 0xFC, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x3F,
  0xC3, 0x9E, 0x78, 0xEF, 0x0F, 0xF1, 0xEE, 0x39, 0xE7, 0x1D, 0xC3, 0xF8,
  0x3E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0xF0, 0xE0, 0xE1, 0xC3, 0x83,
  0x87, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0xFF, 0xE0, 0x18, 0x0E, 0x0F, 0x06, 0xC7, 0x63, 0x1B,
  0x8D, 0x83, 0xFF, 0xFF, 0xC0, 0xF1, 0xC6, 0x1C, 0x3F, 0x9F, 0xC0, 0xE7,
  0xFF, 0xFF, 0x9F, 0xCF, 0xFF, 0xBD, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xCE,
  0xF7, 0xFF, 0xCF, 0xC7, 0xE3, 0xF1, 0xFD, 0xFF, 0xFE, 0xF0, 0x0C, 0x7F,
  0xFE, 0xF2, 0xE0, 0xE0, 0xE0, 0xF2, 0x7E, 0x3E, 0x03, 0x81, 0xC0, 0xE6,
  0x77, 0xBF, 0xFF, 0x9F, 0xC7, 0xE3, 0xF1, 0xFD, 0xFF, 0xF7, 0xB8, 0x18,
  0x3F, 0xBF, 0xDC, 0x7F, 0xFF, 0xFF, 0x81, 0xE2, 0x7F, 0x1F, 0x80, 0x1E,
  0x7C, 0xE9, 0xCF, 0xFF, 0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x30,
  0x3F, 0xFF, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xEF, 0xFF, 0xBD, 0xC0, 0xFD,
  0xFF, 0xF7, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0xCE, 0xFF, 0xFF, 0xCF, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38, 0xEF, 0x60, 0xEE, 0xEE, 0xEE, 0xEE,
  0xE0, 0x39, 0xC6, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE3, 0xB9, 0xCE, 0xF3, 0xF8, 0xFE, 0x3F,
  0xCE, 0x7B, 0x8E, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0x19,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9E, 0xFE, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1,
  0xC7, 0xE3, 0x8F, 0xC7, 0x1C, 0x06, 0x7F, 0xFF, 0xFE, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x18, 0x3F, 0xBF, 0xDC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xEF, 0x7F, 0x1F, 0x00, 0x06, 0x77, 0xBF, 0xFE, 0x7E, 0x3F, 0x1F,
  0x8F, 0xEF, 0xFF, 0x77, 0xB8, 0x1C, 0x0E, 0x07, 0x00, 0x30, 0x3F, 0xFF,
  0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xEF, 0xFF, 0xBD, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x07, 0xDF, 0xFF, 0xDF, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x19, 0xFF,
  0xFF, 0x0F, 0xCF, 0xC7, 0xC7, 0xFF, 0xF8, 0x38, 0x71, 0xFF, 0xF3, 0x87,
  0x0E, 0x1C, 0x3A, 0x7C, 0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0xDF, 0xFF, 0x7D, 0x80, 0xF1, 0xDC, 0xF7, 0x39, 0xEE, 0x3B, 0x8F, 0xC1,
  0xF0, 0x78, 0x1E, 0x00, 0xF3, 0xCE, 0xE7, 0x9D, 0xDF, 0x73, 0xB6, 0xE3,
  0x6F, 0xC7, 0xDF, 0x8F, 0x9E, 0x1F, 0x3C, 0x1C, 0x78, 0xF3, 0xEF, 0x70,
  0xFE, 0x0F, 0x81, 0xF0, 0x7E, 0x0E, 0xE3, 0xDE, 0xF1, 0xE0, 0xF1, 0xDC,
  0xF7, 0x38, 0xEE, 0x3B, 0x8F, 0xC1, 0xF0, 0x78, 0x0E, 0x07, 0x87, 0xC1,
  0xF0, 0x78, 0x00, 0x7F, 0x7F, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0xFF, 0xFF,
  0x3C, 0xF3, 0x0C, 0x31, 0xCF, 0x38, 0xF1, 0xC3, 0x0C, 0x38, 0xF1, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0xC7, 0x1C, 0x71, 0xC3, 0xCF, 0x7D,
  0xC7, 0x1C, 0xF3, 0xCC, 0x00, 0x61, 0xFF, 0xFF, 0x86,
};

const GFXglyph NotoSans_Black17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 7, 4, 9, 1, -12 },
  { 10, 11, 12, 11, 0, -12 },
  { 27, 9, 14, 10, 0, -13 },
  { 43, 16, 12, 16, 0, -12 },
  { 67, 13, 12, 14, 1, -12 },
  { 87, 3, 4, 5, 1, -12 },
  { 89, 5, 15, 6, 1, -12 },
  { 99, 5, 15, 6, 0, -12 },
  { 109, 9, 8, 9, 0, -13 },
  { 118, 8, 8, 10, 1, -10 },
  { 126, 4, 4, 5, 0, -2 },
  { 128, 5, 3, 5, 0, -6 },
  { 130, 3, 3, 5, 1, -3 },
  { 132, 7, 12, 8, 0, -12 },
  { 143, 8, 12, 10, 1, -12 },
  { 155, 7, 12, 10, 1, -12 },
  { 166, 9, 12, 10, 0, -12 },
  { 180, 8, 12, 10, 1, -12 },
  { 192, 10, 12, 10, 0, -12 },
  { 207, 8, 12, 10, 1, -12 },
  { 219, 8, 12, 10, 1, -12 },
  { 231, 8, 12, 10, 1, -12 },
  { 243, 8, 12, 10, 1, -12 },
  { 255, 8, 12, 10, 1, -12 },
  { 267, 3, 10, 5, 1, -10 },
  { 271, 4, 12, 5, 0, -10 },
  { 277, 8, 10, 10, 1, -11 },
  { 287, 8, 6, 10, 1, -9 },
  { 293, 8, 10, 10, 1, -11 },
  { 303, 8, 12, 9, 0, -12 },
  { 315, 14, 13, 15, 1, -12 },
  { 338, 12, 12, 12, 0, -12 },
  { 356, 10, 12, 11, 1, -12 },
  { 371, 10, 12, 11, 1, -12 },
  { 386, 11, 12, 12, 1, -12 },
  { 403, 8, 12, 9, 1, -12 },
  { 415, 7, 12, 9, 1, -12 },
  { 426, 10, 12, 13, 1, -12 },
  { 441, 11, 12, 13, 1, -12 },
  { 458, 6, 12, 7, 1, -12 },
  { 467, 6, 16, 6, -1, -12 },
  { 479, 11, 12, 12, 1, -12 },
  { 496, 8, 12, 10, 1, -12 },
  { 508, 14, 12, 16, 1, -12 },
  { 529, 12, 12, 14, 1, -12 },
  { 547, 12, 12, 14, 1, -12 },
  { 565, 9, 12, 11, 1, -12 },
  { 579, 12, 15, 14, 1, -12 },
  { 602, 11, 12, 12, 1, -12 },
  { 619, 8, 12, 10, 1, -12 },
  { 631, 10, 12, 10, 0, -12 },
  { 646, 11, 12, 13, 1, -12 },
  { 663, 12, 12, 12, 0, -12 },
  { 681, 17, 12, 18, 0, -12 },
  { 707, 12, 12, 12, 0, -12 },
  { 725, 11, 12, 11, 0, -12 },
  { 742, 9, 12, 10, 1, -12 },
  { 756, 4, 15, 6, 1, -12 },
  { 764, 7, 12, 8, 0, -12 },
  { 775, 5, 15, 6, 0, -12 },
  { 785, 9, 8, 9, 0, -12 },
  { 794, 9, 2, 9, 0, 1 },
  { 797, 5, 3, 7, 1, -13 },
  { 799, 9, 10, 11, 1, -10 },
  { 811, 9, 13, 11, 1, -13 },
  { 826, 8, 10, 9, 1, -10 },
  { 836, 9, 13, 11, 1, -13 },
  { 851, 9, 10, 11, 1, -10 },
  { 863, 7, 13, 7, 0, -13 },
  { 875, 9, 14, 11, 1, -10 },
  { 891, 9, 13, 11, 1, -13 },
  { 906, 4, 13, 6, 1, -13 },
  { 913, 5, 17, 6, -1, -13 },
  { 924, 10, 13, 11, 1, -13 },
  { 941, 3, 13, 5, 1, -13 },
  { 946, 15, 10, 17, 1, -10 },
  { 965, 9, 10, 11, 1, -10 },
  { 977, 9, 10, 11, 1, -10 },
  { 989, 9, 14, 11, 1, -10 },
  { 1005, 9, 14, 11, 1, -10 },
  { 1021, 7, 10, 8, 1, -10 },
  { 1030, 7, 10, 9, 1, -10 },
  { 1039, 7, 11, 8, 0, -11 },
  { 1049, 9, 9, 11, 1, -9 },
  { 1060, 10, 9, 10, 0, -9 },
  { 1072, 15, 9, 15, 0, -9 },
  { 1089, 11, 9, 11, 0, -9 },
  { 1102, 10, 13, 10, 0, -9 },
  { 1119, 8, 9, 9, 0, -9 },
  { 1128, 6, 15, 7, 1, -12 },
  { 1140, 2, 17, 9, 3, -13 },
  { 1145, 6, 15, 7, 1, -12 },
  { 1157, 8, 4, 10, 1, -8 },
};

const GFXfont NotoSans_Black17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black17pt7bBitmaps,
  (GFXglyph *)NotoSans_Black17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_BLACK17PT7B_H_
