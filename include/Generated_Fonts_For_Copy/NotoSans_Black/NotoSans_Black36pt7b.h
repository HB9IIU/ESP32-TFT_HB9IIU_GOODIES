#ifndef _NOTOSANS_BLACK36PT7B_H_
#define _NOTOSANS_BLACK36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7E, 0xFC, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0x01, 0xF1,
  0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x07, 0xCF, 0x80, 0x1E, 0x3E,
  0x00, 0xF8, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x83, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xF7, 0x3C, 0xFC, 0xE0, 0x9F, 0x9C, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0x9F, 0xC0, 0x73, 0xF7, 0x0E, 0xFE,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x80,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0xE0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x80, 0xFF, 0xF0, 0x1F, 0x00, 0xFD,
  0xF0, 0x3E, 0x00, 0xF9, 0xF8, 0x3E, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0xF8,
  0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF9, 0xF8, 0x00, 0xF9,
  0xF9, 0xF1, 0xF0, 0xFD, 0xF3, 0xF3, 0xFC, 0xFF, 0xF3, 0xE7, 0xFE, 0x7F,
  0xE7, 0xCF, 0xFE, 0x3F, 0xE7, 0xCF, 0xFF, 0x1F, 0x8F, 0x9F, 0x9F, 0x00,
  0x1F, 0x9F, 0x9F, 0x00, 0x1F, 0x1F, 0x9F, 0x00, 0x3F, 0x1F, 0x1F, 0x00,
  0x3E, 0x1F, 0x9F, 0x00, 0x7E, 0x1F, 0x9F, 0x00, 0x7C, 0x0F, 0x9F, 0x00,
  0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x07, 0xFC, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x02, 0x0F, 0xFE, 0x1F,
  0xC1, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x3F, 0xC7, 0xFF, 0xFB, 0xF8, 0x7F,
  0x3F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0x0F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xBF, 0xC0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF0, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x41, 0xE1, 0xBF, 0x7B, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0x7C, 0x0F, 0xDF, 0x83, 0xF3, 0xF0, 0x38, 0xF0, 0x02, 0x10,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0x7F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE,
  0x7E, 0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xEF, 0xC1, 0xFD,
  0xFC, 0x3F, 0x3F, 0x8F, 0xE7, 0xF9, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7F, 0x3E, 0x7F, 0x1C, 0xFF, 0x08, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x07,
  0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0x07, 0xF0, 0xC0, 0xFE, 0x10, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x84, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x03, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xBF, 0x81, 0xFB, 0xF8, 0x3F, 0x3F, 0x87,
  0xE3, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xE1, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xCF, 0xC1, 0xFB, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xBF, 0x87, 0xF7, 0xF9, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0x83,
  0xF3, 0xF8, 0x7E, 0x7F, 0x1F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x1F,
  0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0xBF, 0x87, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFD, 0xF9, 0xFF, 0xFF,
  0x1F, 0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xDF, 0xE3, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x08, 0x1F, 0x0F, 0xC3, 0xFF, 0xBE, 0x3E, 0x3F, 0xFE, 0xF9, 0xF1, 0xFF,
  0xF9, 0xF7, 0xCF, 0xE3, 0xE7, 0xDF, 0x3E, 0x0F, 0x9F, 0x78, 0xF8, 0x3C,
  0x7D, 0xE7, 0xC1, 0xF1, 0xFF, 0x9F, 0x07, 0xC7, 0xFE, 0x7C, 0x1F, 0x1F,
  0xF8, 0xF8, 0x7C, 0x79, 0xE3, 0xE3, 0xFB, 0xE7, 0xCF, 0xFF, 0xFF, 0x1F,
  0x1F, 0xFF, 0xFC, 0x7C, 0x3F, 0xDF, 0xE0, 0xF8, 0x3C, 0x1E, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x0F, 0xF8, 0x7F, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xA0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x0F, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xCF, 0xE3, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xC0,
  0xC7, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x02, 0x7F, 0xE3, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0x3F, 0x81, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x83, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFC, 0x03, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0xE0, 0x3F, 0x7F, 0xF1, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE8, 0xFF, 0x7F,
  0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0x87, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xEF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F,
  0x0F, 0xE3, 0xFC, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xFB, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x03, 0xF9, 0xFE, 0x0F, 0xE3, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x3F,
  0x81, 0xFC, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xEF, 0xFF, 0x7C, 0x1F, 0x7F, 0xFB, 0xE0, 0xFB, 0xFF,
  0xDF, 0x8F, 0x9F, 0xFE, 0xFC, 0x7C, 0xFF, 0xF3, 0xE3, 0xE7, 0xFF, 0x9F,
  0xBF, 0x3F, 0xFC, 0xFD, 0xF1, 0xFF, 0xE3, 0xEF, 0x8F, 0xFF, 0x1F, 0x7C,
  0x7F, 0xF8, 0xFF, 0xC3, 0xFF, 0xC7, 0xFE, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF,
  0xF0, 0xFF, 0x87, 0xFF, 0x87, 0xF8, 0x3F, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFD, 0xFC, 0x3F, 0xFD, 0xFC, 0x3F,
  0xFC, 0xFE, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC, 0x7F, 0x3F, 0xFC, 0x7F, 0x3F,
  0xFC, 0x3F, 0xBF, 0xFC, 0x3F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xFE, 0x07, 0xFC, 0xFE, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7,
  0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xF8, 0x1F, 0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x3F,
  0xC0, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00,
  0x7F, 0xBF, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F,
  0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xFC, 0xFE, 0x07, 0xFB, 0xF8,
  0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xE0, 0x33, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFE, 0xFC,
  0x7F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0xDF,
  0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F,
  0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF8,
  0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x03,
  0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0xC0, 0xFE, 0x7E, 0x03, 0xFC, 0x0F, 0xE7,
  0xE0, 0x7F, 0xC0, 0xFE, 0x7F, 0x07, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0xE0,
  0xFC, 0x3F, 0x07, 0xFE, 0x1F, 0xC3, 0xF0, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F,
  0xBE, 0x1F, 0x83, 0xF8, 0xFB, 0xE1, 0xF8, 0x1F, 0x8F, 0xBF, 0x3F, 0x81,
  0xF9, 0xF9, 0xF3, 0xF8, 0x1F, 0x9F, 0x9F, 0x3F, 0x01, 0xFD, 0xF1, 0xF3,
  0xF0, 0x0F, 0xDF, 0x1F, 0xBF, 0x00, 0xFD, 0xF1, 0xFF, 0xF0, 0x0F, 0xDF,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00,
  0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F,
  0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x18, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xFF,
  0x0F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xCF, 0x8F, 0xF1, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE7,
  0xF0, 0xFE, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0x9F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFF, 0x0F, 0xEF, 0xF9, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xEF, 0xF8, 0xFC, 0x7F,
  0x00, 0x07, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE7,
  0xFC, 0x73, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0B, 0xFE, 0x3C, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x7E, 0x7F, 0x3F, 0xEF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFC, 0xFC, 0x7F, 0x1F,
  0x80, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFB,
  0xFD, 0xFC, 0x1F, 0xBF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x23, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0x80, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xC7, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC7, 0xE7, 0xFC, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xBF, 0x8F, 0xE7, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE,
  0x00, 0x3C, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0xFE,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3C,
  0x7E, 0xFE, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0x03, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0x38, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0xFE, 0x0F, 0xF3,
  0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0x8F, 0xF0, 0xFE, 0x7F, 0x83, 0xF9,
  0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xBF, 0xC3, 0xF8, 0xFF, 0x0F,
  0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F, 0xEF, 0xE0,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7F, 0x07, 0xF0, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x9F,
  0xF8, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE, 0x07,
  0xF0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07,
  0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07,
  0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07,
  0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x7F,
  0x0F, 0xCF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD,
  0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0xFC, 0x7F, 0x0F, 0xCF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xF9, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF,
  0x9F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F,
  0xE7, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC7, 0xE7, 0xFC, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xBF, 0x8F, 0xE7,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0xFC, 0x3F,
  0xF3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xEF, 0xDF, 0x81, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x80, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x4F, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFB, 0xF0, 0xFE, 0x3F, 0xFE, 0x01, 0xFD, 0xFC, 0x0F,
  0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x7F, 0x0F, 0xF8, 0x7F, 0x7F, 0x0F,
  0xF8, 0x7F, 0x7F, 0x0F, 0xF8, 0x7E, 0x3F, 0x0F, 0xF8, 0x7E, 0x3F, 0x1F,
  0xF8, 0xFE, 0x3F, 0x9F, 0x7C, 0xFE, 0x3F, 0x9F, 0x7C, 0xFC, 0x1F, 0x9F,
  0x7C, 0xFC, 0x1F, 0x9F, 0x7C, 0xFC, 0x1F, 0xBE, 0x7D, 0xF8, 0x0F, 0xBE,
  0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x83,
  0xFC, 0xFF, 0x07, 0xF0, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFE, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F,
  0x0F, 0xF1, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xF0, 0xFE, 0x01, 0xFD, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x1F,
  0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFE, 0x07,
  0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x70,
};

const GFXglyph NotoSans_Black36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 26, 10, 1, -26 },
  { 27, 15, 10, 19, 2, -26 },
  { 46, 22, 26, 24, 1, -26 },
  { 118, 19, 29, 21, 1, -27 },
  { 187, 32, 26, 34, 1, -26 },
  { 291, 28, 26, 29, 1, -26 },
  { 382, 6, 10, 11, 2, -26 },
  { 390, 11, 32, 13, 1, -26 },
  { 434, 11, 32, 13, 1, -26 },
  { 478, 18, 17, 19, 1, -27 },
  { 517, 17, 17, 21, 2, -21 },
  { 554, 8, 10, 11, 1, -5 },
  { 564, 10, 5, 11, 1, -12 },
  { 571, 7, 6, 10, 2, -6 },
  { 577, 16, 26, 16, 0, -26 },
  { 629, 19, 26, 21, 1, -26 },
  { 691, 16, 26, 21, 1, -26 },
  { 743, 19, 26, 21, 1, -26 },
  { 805, 19, 26, 21, 1, -26 },
  { 867, 20, 26, 21, 1, -26 },
  { 932, 17, 26, 21, 2, -26 },
  { 988, 19, 26, 21, 1, -26 },
  { 1050, 19, 26, 21, 1, -26 },
  { 1112, 19, 26, 21, 1, -26 },
  { 1174, 19, 26, 21, 1, -26 },
  { 1236, 7, 20, 10, 2, -20 },
  { 1254, 8, 25, 11, 1, -20 },
  { 1279, 17, 20, 21, 2, -23 },
  { 1322, 17, 13, 21, 2, -19 },
  { 1350, 17, 20, 21, 2, -23 },
  { 1393, 18, 26, 18, 0, -26 },
  { 1452, 30, 29, 32, 1, -26 },
  { 1561, 26, 26, 26, 0, -26 },
  { 1646, 20, 26, 24, 3, -26 },
  { 1711, 20, 26, 23, 2, -26 },
  { 1776, 22, 26, 26, 3, -26 },
  { 1848, 15, 26, 20, 3, -26 },
  { 1897, 15, 26, 19, 3, -26 },
  { 1946, 22, 26, 27, 2, -26 },
  { 2018, 22, 26, 28, 3, -26 },
  { 2090, 14, 26, 16, 1, -26 },
  { 2136, 13, 34, 13, -3, -26 },
  { 2192, 22, 26, 25, 3, -26 },
  { 2264, 17, 26, 21, 3, -26 },
  { 2320, 29, 26, 35, 3, -26 },
  { 2415, 24, 26, 30, 3, -26 },
  { 2493, 25, 26, 29, 2, -26 },
  { 2575, 18, 26, 23, 3, -26 },
  { 2634, 26, 32, 29, 2, -26 },
  { 2738, 22, 26, 24, 3, -26 },
  { 2810, 18, 26, 21, 2, -26 },
  { 2869, 19, 26, 21, 1, -26 },
  { 2931, 22, 26, 27, 3, -26 },
  { 3003, 25, 26, 25, 0, -26 },
  { 3085, 36, 26, 37, 1, -26 },
  { 3202, 26, 26, 26, 0, -26 },
  { 3287, 24, 26, 24, 0, -26 },
  { 3365, 20, 26, 22, 1, -26 },
  { 3430, 9, 32, 12, 2, -26 },
  { 3466, 16, 26, 16, 0, -26 },
  { 3518, 9, 32, 12, 1, -26 },
  { 3554, 19, 17, 19, 0, -26 },
  { 3595, 18, 5, 18, 0, 2 },
  { 3607, 13, 6, 15, 1, -28 },
  { 3617, 19, 20, 22, 1, -20 },
  { 3665, 20, 27, 23, 2, -27 },
  { 3733, 17, 20, 19, 2, -20 },
  { 3776, 19, 27, 23, 2, -27 },
  { 3841, 19, 20, 22, 2, -20 },
  { 3889, 15, 28, 15, 1, -28 },
  { 3942, 19, 29, 23, 2, -20 },
  { 4011, 20, 27, 24, 2, -27 },
  { 4079, 8, 28, 12, 2, -28 },
  { 4107, 12, 37, 12, -2, -28 },
  { 4163, 22, 27, 24, 2, -27 },
  { 4238, 7, 27, 12, 2, -27 },
  { 4262, 32, 20, 36, 2, -20 },
  { 4342, 20, 20, 24, 2, -20 },
  { 4392, 19, 20, 23, 2, -20 },
  { 4440, 20, 29, 23, 2, -20 },
  { 4513, 19, 29, 23, 2, -20 },
  { 4582, 14, 20, 17, 2, -20 },
  { 4617, 15, 20, 19, 2, -20 },
  { 4655, 14, 24, 17, 1, -24 },
  { 4697, 20, 20, 24, 2, -20 },
  { 4747, 22, 20, 22, 0, -20 },
  { 4802, 32, 20, 33, 0, -20 },
  { 4882, 23, 20, 23, 0, -20 },
  { 4940, 22, 29, 22, 0, -20 },
  { 5020, 16, 20, 18, 1, -20 },
  { 5060, 13, 32, 16, 1, -26 },
  { 5112, 5, 35, 18, 7, -27 },
  { 5134, 14, 32, 16, 1, -26 },
  { 5190, 17, 7, 21, 2, -16 },
};

const GFXfont NotoSans_Black36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black36pt7bBitmaps,
  (GFXglyph *)NotoSans_Black36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_BLACK36PT7B_H_
