#ifndef _NOTOSANS_BLACK20PT7B_H_
#define _NOTOSANS_BLACK20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x4F, 0xFF, 0xF7, 0xF7, 0xE7, 0xE7,
  0x67, 0x0E, 0x60, 0x77, 0x03, 0xB8, 0x19, 0xC7, 0xFF, 0xBF, 0xFC, 0x77,
  0x03, 0xB8, 0xFF, 0xF7, 0xFF, 0x86, 0x60, 0x73, 0x03, 0xB8, 0x1D, 0xC0,
  0x0C, 0x0F, 0xCF, 0xFF, 0xFE, 0xEC, 0xBB, 0x0F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xF0, 0xDF, 0xBF, 0xFF, 0xFF, 0xE1, 0xC0, 0x30, 0x7E, 0x0E, 0x0F, 0xC3,
  0x83, 0x9C, 0xE0, 0x73, 0x9C, 0x0E, 0x77, 0x00, 0xCE, 0xEE, 0x1F, 0xBB,
  0xF1, 0xF7, 0x7E, 0x01, 0xDC, 0xC0, 0x33, 0x9C, 0x0E, 0x73, 0x83, 0x8E,
  0xE0, 0x70, 0xFC, 0x1C, 0x0F, 0x00, 0x3F, 0x80, 0xFF, 0x81, 0xEF, 0x03,
  0xDE, 0x07, 0xBC, 0x07, 0xF0, 0x0F, 0xCF, 0x3F, 0x9E, 0xF7, 0xF9, 0xE7,
  0xF3, 0xC7, 0xC7, 0xFF, 0x87, 0xFF, 0xC7, 0xE7, 0xC0, 0xFF, 0xEE, 0x60,
  0x3C, 0xE7, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xCF, 0x1C,
  0x78, 0xF0, 0xE7, 0x9C, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9D, 0xEE,
  0x77, 0x00, 0x0E, 0x03, 0x84, 0xE5, 0xFF, 0xFF, 0xC7, 0x81, 0xF0, 0xEE,
  0x7B, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xEE, 0xEC, 0xFF, 0xFF, 0xC0, 0x4F, 0xFF, 0x07,
  0x83, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E,
  0x07, 0x07, 0x80, 0x3F, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3D, 0xFE, 0x7F, 0x8F, 0xC0, 0x0F, 0x1F, 0x7F,
  0xFF, 0xFF, 0x6F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x3F,
  0x9F, 0xF9, 0xFF, 0x98, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0xF7, 0xFE, 0xFF, 0xC0, 0xFF, 0x3F, 0xE7, 0xF9, 0x0E,
  0x07, 0x8F, 0xC3, 0xC0, 0xFE, 0x07, 0xC0, 0xF8, 0x3F, 0xFF, 0xFF, 0xBF,
  0xC0, 0x03, 0xC0, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x7F, 0x8E, 0xF3, 0x9E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0x9F, 0xE7,
  0xFB, 0xC0, 0xF0, 0x3F, 0xCF, 0xF9, 0xFF, 0x03, 0xC0, 0xF8, 0x3F, 0xFE,
  0xFF, 0xBF, 0xC0, 0x1F, 0x8F, 0xE7, 0xFB, 0xC0, 0xE2, 0x3B, 0xEF, 0xFF,
  0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFF, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x1E, 0x00, 0x7F, 0xBF, 0xEF, 0x3F, 0xCF, 0xF7, 0x9F, 0xE3, 0xE1,
  0xFE, 0xF7, 0xF8, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xC0, 0x7F, 0x3F, 0xEF,
  0xFB, 0x8F, 0xE3, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0xF0, 0x79, 0xFE,
  0x7F, 0x1F, 0x00, 0xFF, 0xF4, 0x00, 0x04, 0xFF, 0xF0, 0xFF, 0xF4, 0x00,
  0x00, 0xFF, 0xEE, 0xEC, 0x00, 0x40, 0x70, 0x7C, 0x7E, 0x7E, 0x3E, 0x0F,
  0x81, 0xFC, 0x0F, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x7C, 0xFC, 0xFC, 0x3C, 0x0C, 0x00, 0x7F, 0xBF, 0xE7, 0xFD, 0x0F, 0x03,
  0xC3, 0xE1, 0xF0, 0x70, 0x1C, 0x00, 0x00, 0x80, 0x70, 0x3E, 0x07, 0x00,
  0x0F, 0xF8, 0x1F, 0xFC, 0x38, 0x0E, 0x73, 0xE7, 0xE7, 0xF7, 0xEF, 0x77,
  0xEE, 0x73, 0xCC, 0x73, 0xCC, 0x77, 0xEE, 0xF7, 0xEF, 0xFE, 0xE3, 0x9C,
  0x78, 0x08, 0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0xF7, 0x01, 0xEE, 0x03, 0x9E, 0x0F, 0x3C, 0x1E, 0x38, 0x3F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xC0, 0xFF,
  0x9F, 0xFB, 0xFF, 0x71, 0xEE, 0x3D, 0xFF, 0x3F, 0xC7, 0xFE, 0xE3, 0xDC,
  0x3F, 0x8F, 0x7F, 0xEF, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xFD, 0xFF, 0xBC,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0xBF, 0xF3,
  0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE1, 0xEE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE1, 0xEE, 0x1E, 0xE3, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0xF3, 0xFF, 0x7F, 0xE7, 0x80, 0xF0, 0x0F,
  0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x87, 0x78, 0x77, 0xFF, 0x3F, 0xF0,
  0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFD,
  0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xEF, 0xFF, 0xC0, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0E, 0x1E, 0xFE, 0xFE, 0xFC, 0xE1, 0xFE, 0x3E, 0xE3, 0xCE, 0x78, 0xEF,
  0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8E, 0x78, 0xE3, 0xCE, 0x3C, 0xE1,
  0xEE, 0x1F, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1F, 0xFF, 0xFF, 0xFC, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xEE, 0x7F, 0xEE, 0xEF, 0xEE, 0xEF,
  0xEF, 0xEF, 0xE7, 0xCF, 0xE7, 0xCF, 0xE7, 0xCF, 0xE3, 0xCF, 0xF8, 0x3F,
  0xE1, 0xFF, 0x0F, 0xFC, 0x7F, 0xE3, 0xF7, 0x9F, 0xBC, 0xFC, 0xF7, 0xE7,
  0xBF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7C, 0x02, 0x00, 0x7F,
  0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x87, 0xDE, 0x1E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00,
  0xFF, 0x3F, 0xEF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0xFB, 0xFE, 0xFF, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x02, 0x00, 0x7F, 0x83, 0xFF, 0x1F,
  0xFE, 0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x87, 0xDE, 0x1E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xFF,
  0x8F, 0xF0, 0xFF, 0x0E, 0x78, 0xE7, 0x8E, 0x3C, 0xE1, 0xEE, 0x1F, 0x3F,
  0xDF, 0xEF, 0xFB, 0xC2, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8,
  0x3F, 0xFE, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7B, 0xC3, 0xDE, 0x3C, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0,
  0xF8, 0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x07, 0x78, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF0, 0xF0, 0x77, 0x0F, 0x8F, 0x78, 0xF8, 0xF7, 0x8F, 0x8F, 0x78,
  0xF8, 0xE3, 0x9D, 0xDE, 0x39, 0xDD, 0xE3, 0xDD, 0xDE, 0x3D, 0xDD, 0xC1,
  0xF9, 0xDC, 0x1F, 0x8D, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x80, 0xF8, 0xF8,
  0xF8, 0x7D, 0xF1, 0xE3, 0xCF, 0x07, 0xBC, 0x1F, 0xE0, 0x3F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x83, 0xEF, 0x0F, 0x3E, 0x78, 0x7B, 0xE0,
  0xF0, 0xF8, 0x7B, 0xC7, 0x9E, 0x3C, 0x7B, 0xC1, 0xDE, 0x0F, 0xE0, 0x3F,
  0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x0F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x3C,
  0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xC0,
  0x0C, 0x03, 0xC0, 0x78, 0x1F, 0x83, 0xB0, 0xE7, 0x1C, 0x63, 0x0E, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x78, 0x78, 0x7F, 0x9F, 0xF3, 0x3C,
  0x0F, 0x3F, 0xFF, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF, 0xF7, 0xDC, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x79, 0xFF, 0xBF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xBD, 0xE0, 0x3F, 0xBF, 0xFF, 0xFE, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xFF, 0xBF, 0xCF, 0xC0, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF3, 0xDE, 0xFF, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0xFE, 0xFF, 0xCF, 0x78, 0x3F, 0x0F, 0xFB, 0xEF, 0x78, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x1F, 0x9F, 0x8F,
  0xC7, 0x87, 0xF7, 0xFB, 0xFC, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x3D, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xFF, 0xEF, 0xFC, 0xF7, 0x80, 0xFC, 0x3D, 0xFF, 0xBF, 0xE3, 0xF0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x7D, 0xFF, 0xFF, 0xFF, 0xCF, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x78, 0x2F, 0xF7, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0xF3, 0xC7, 0x00, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE, 0xF0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF1, 0xFF, 0x3E, 0xF3, 0xCF, 0x78, 0xFF, 0x0F, 0xF8,
  0xFF, 0x8F, 0xBC, 0xF3, 0xEF, 0x1E, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xDF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7,
  0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3,
  0xFC, 0x78, 0xFF, 0x1E, 0x3C, 0xE7, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0x80, 0x3F, 0x0F, 0xFB,
  0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0x7F, 0xCF, 0xF8, 0xFC,
  0x00, 0xF7, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xFF, 0xFF, 0xFB, 0xDE, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x3D,
  0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xEF,
  0xFC, 0xF7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xE7, 0xFF, 0xFF,
  0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x7F, 0x7F, 0xBC, 0xDE,
  0x0F, 0xE3, 0xF8, 0x7C, 0x0F, 0xFF, 0x7F, 0xBF, 0x80, 0x38, 0x78, 0x7E,
  0xFE, 0xFE, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7F, 0x7F, 0x3F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xEF, 0xFC,
  0xFB, 0x80, 0xF0, 0xF7, 0x0F, 0x79, 0xE7, 0x9E, 0x39, 0xC3, 0xDC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF1, 0xE3, 0xDC, 0x7C, 0xF7,
  0xBF, 0x39, 0xEF, 0xDE, 0x7B, 0xF7, 0x8E, 0xED, 0xC3, 0xB3, 0xF0, 0xFC,
  0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xE1, 0xE0, 0xF8, 0xF3, 0xCF, 0x0F,
  0x78, 0x7F, 0x81, 0xF8, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x3D, 0xE3, 0xCF,
  0xBE, 0x3E, 0xF0, 0xF7, 0x0F, 0x78, 0xE7, 0x9E, 0x39, 0xE3, 0xDC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xE0, 0x7C,
  0x07, 0x80, 0x7F, 0x9F, 0xE7, 0xF8, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1E, 0x7C, 0xF1, 0xC3, 0x87, 0x1E, 0x7C, 0xE1,
  0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x1F, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1F, 0x0E, 0x7C, 0xE3, 0xC7, 0x8F,
  0x1E, 0x78, 0xF0, 0x78, 0x7F, 0xFF, 0xFE, 0x1E,
};

const GFXglyph NotoSans_Black20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 6, 1, -14 },
  { 8, 8, 5, 10, 1, -14 },
  { 13, 13, 14, 13, 0, -14 },
  { 36, 10, 16, 12, 1, -15 },
  { 56, 19, 14, 19, 0, -14 },
  { 90, 15, 14, 16, 1, -14 },
  { 117, 4, 5, 6, 1, -14 },
  { 120, 6, 18, 7, 1, -15 },
  { 134, 5, 18, 7, 1, -15 },
  { 146, 10, 9, 11, 0, -15 },
  { 158, 10, 10, 12, 1, -12 },
  { 171, 4, 6, 6, 1, -3 },
  { 174, 6, 3, 6, 0, -7 },
  { 177, 4, 4, 6, 1, -4 },
  { 179, 9, 14, 9, 0, -14 },
  { 195, 10, 14, 12, 1, -14 },
  { 213, 8, 14, 12, 1, -14 },
  { 227, 11, 14, 12, 0, -14 },
  { 247, 10, 14, 12, 1, -14 },
  { 265, 11, 14, 12, 0, -14 },
  { 285, 10, 14, 12, 1, -14 },
  { 303, 10, 14, 12, 1, -14 },
  { 321, 10, 14, 12, 1, -14 },
  { 339, 10, 14, 12, 1, -14 },
  { 357, 10, 14, 12, 1, -14 },
  { 375, 4, 11, 6, 1, -11 },
  { 381, 4, 14, 6, 1, -11 },
  { 388, 10, 11, 12, 1, -13 },
  { 402, 10, 8, 12, 1, -11 },
  { 412, 10, 11, 12, 1, -13 },
  { 426, 10, 14, 10, 0, -14 },
  { 444, 16, 16, 18, 1, -14 },
  { 476, 15, 14, 15, 0, -14 },
  { 503, 11, 14, 13, 2, -14 },
  { 523, 11, 14, 13, 1, -14 },
  { 543, 12, 14, 15, 2, -14 },
  { 564, 8, 14, 11, 2, -14 },
  { 578, 8, 14, 11, 2, -14 },
  { 592, 12, 14, 15, 1, -14 },
  { 613, 12, 14, 15, 2, -14 },
  { 634, 7, 14, 9, 1, -14 },
  { 647, 8, 18, 7, -2, -14 },
  { 665, 12, 14, 14, 2, -14 },
  { 686, 9, 14, 12, 2, -14 },
  { 702, 16, 14, 19, 2, -14 },
  { 730, 13, 14, 17, 2, -14 },
  { 753, 14, 15, 16, 1, -15 },
  { 780, 10, 14, 13, 2, -14 },
  { 798, 14, 18, 16, 1, -15 },
  { 830, 12, 14, 14, 2, -14 },
  { 851, 10, 14, 12, 1, -14 },
  { 869, 11, 14, 12, 0, -14 },
  { 889, 13, 14, 15, 1, -14 },
  { 912, 14, 14, 14, 0, -14 },
  { 937, 20, 14, 21, 0, -14 },
  { 972, 14, 14, 14, 0, -14 },
  { 997, 13, 14, 13, 0, -14 },
  { 1020, 11, 14, 12, 1, -14 },
  { 1040, 5, 18, 6, 1, -15 },
  { 1052, 9, 14, 9, 0, -14 },
  { 1068, 5, 18, 6, 0, -15 },
  { 1080, 11, 9, 11, 0, -14 },
  { 1093, 10, 3, 10, 0, 1 },
  { 1097, 7, 3, 8, 1, -15 },
  { 1100, 10, 11, 12, 1, -11 },
  { 1114, 11, 15, 13, 1, -15 },
  { 1135, 9, 11, 11, 1, -11 },
  { 1148, 11, 15, 13, 1, -15 },
  { 1169, 11, 11, 12, 1, -11 },
  { 1185, 9, 15, 8, 0, -15 },
  { 1202, 11, 16, 13, 1, -11 },
  { 1224, 11, 15, 13, 1, -15 },
  { 1245, 4, 16, 7, 1, -16 },
  { 1253, 6, 21, 6, -1, -16 },
  { 1269, 12, 15, 13, 1, -15 },
  { 1292, 4, 15, 6, 1, -15 },
  { 1300, 18, 11, 20, 1, -11 },
  { 1325, 11, 11, 13, 1, -11 },
  { 1341, 11, 11, 13, 1, -11 },
  { 1357, 11, 16, 13, 1, -11 },
  { 1379, 11, 16, 13, 1, -11 },
  { 1401, 8, 11, 9, 1, -11 },
  { 1412, 9, 11, 10, 1, -11 },
  { 1425, 8, 13, 9, 1, -13 },
  { 1438, 11, 11, 13, 1, -11 },
  { 1454, 12, 11, 12, 0, -11 },
  { 1471, 18, 11, 18, 0, -11 },
  { 1496, 13, 11, 13, 0, -11 },
  { 1514, 12, 16, 12, 0, -11 },
  { 1538, 10, 11, 10, 0, -11 },
  { 1552, 7, 17, 9, 1, -14 },
  { 1567, 2, 19, 10, 4, -15 },
  { 1572, 7, 17, 9, 1, -14 },
  { 1587, 10, 4, 12, 1, -9 },
};

const GFXfont NotoSans_Black20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black20pt7bBitmaps,
  (GFXglyph *)NotoSans_Black20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_BLACK20PT7B_H_
