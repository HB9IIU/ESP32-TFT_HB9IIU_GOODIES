#ifndef _NOTOSANS_BLACK10PT7B_H_
#define _NOTOSANS_BLACK10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black10pt7bBitmaps[] PROGMEM = {
  0x00, 0xF9, 0x20, 0xB0, 0xBB, 0x3C, 0xA7, 0xCA, 0xFD, 0xE5, 0x00, 0x21,
  0xEF, 0xB8, 0x78, 0xBF, 0x9C, 0x20, 0x62, 0x7B, 0x3D, 0x0D, 0x71, 0xA8,
  0x94, 0xCE, 0x78, 0x68, 0x78, 0x73, 0xDE, 0xEC, 0x7F, 0xC0, 0x6B, 0x6D,
  0x93, 0x20, 0xCD, 0x92, 0xDB, 0xC0, 0x21, 0x3E, 0x65, 0x80, 0x31, 0xBE,
  0x63, 0x00, 0x78, 0xE0, 0x70, 0x33, 0x26, 0x64, 0xC0, 0x79, 0xEC, 0xB3,
  0xC9, 0xE7, 0x80, 0x3F, 0xD6, 0x31, 0x8C, 0x60, 0xFA, 0xC6, 0x73, 0x3F,
  0xE0, 0xFA, 0xC6, 0xF1, 0xCF, 0xE0, 0x18, 0xE7, 0x96, 0xFF, 0xF1, 0x80,
  0x7A, 0x1C, 0xF1, 0xEF, 0xE0, 0x39, 0x8D, 0xBE, 0xCD, 0xE7, 0x80, 0xFC,
  0x61, 0x84, 0x30, 0xC6, 0x00, 0x79, 0x67, 0x9E, 0xDB, 0x37, 0x80, 0x7B,
  0x6C, 0x9F, 0x28, 0x67, 0x00, 0x70, 0x70, 0x58, 0x02, 0xB0, 0x09, 0xB0,
  0x70, 0x80, 0xF8, 0x3E, 0xC3, 0x86, 0xEC, 0x00, 0xFC, 0xCE, 0x64, 0x31,
  0x80, 0x3E, 0x30, 0x97, 0xDE, 0xFF, 0x52, 0xD9, 0x88, 0x38, 0x38, 0x71,
  0xB3, 0x67, 0xDF, 0xF1, 0x80, 0xFE, 0xF7, 0xFD, 0xFF, 0xC0, 0x7E, 0x71,
  0x0C, 0x7D, 0xE0, 0xFB, 0x6C, 0xF3, 0xCF, 0xEF, 0x00, 0xFC, 0xCF, 0xCF,
  0xF0, 0xFC, 0xCF, 0xCC, 0xC0, 0x7F, 0x2C, 0x37, 0xCF, 0xF7, 0xC0, 0xCF,
  0x3C, 0xFF, 0xCF, 0x3C, 0xC0, 0xF6, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33,
  0x33, 0xE0, 0xDF, 0x6F, 0x3C, 0xF3, 0x6D, 0xC0, 0xCC, 0xCC, 0xCF, 0xF0,
  0xE7, 0xE7, 0xA7, 0xAF, 0xBB, 0xBB, 0x9B, 0xE7, 0xCE, 0xDD, 0xB9, 0xF3,
  0xE3, 0x80, 0x7B, 0x3C, 0xF3, 0xCF, 0xF7, 0x80, 0xF6, 0xF7, 0xFE, 0x63,
  0x00, 0x79, 0x9B, 0x36, 0x6C, 0xDF, 0x9E, 0x0E, 0x0E, 0xF3, 0x6D, 0xBC,
  0xF3, 0x6D, 0xC0, 0x7E, 0x58, 0xF1, 0xEF, 0xE0, 0xFC, 0xC3, 0x0C, 0x30,
  0xC3, 0x00, 0xCF, 0x3C, 0xF3, 0xCF, 0xF7, 0x80, 0xC6, 0xD9, 0xB3, 0x62,
  0x87, 0x0E, 0x00, 0xCC, 0xD3, 0x36, 0xED, 0xFA, 0x7B, 0x8E, 0xE3, 0x38,
  0xEE, 0xD8, 0xE1, 0xC3, 0x8D, 0xB9, 0x80, 0xCE, 0xD9, 0xE1, 0xC3, 0x06,
  0x0C, 0x00, 0xFC, 0x61, 0x8C, 0x61, 0xFF, 0xC0, 0xEA, 0xAB, 0xC0, 0xC4,
  0x66, 0x23, 0x30, 0xED, 0xB6, 0xDF, 0xE0, 0x23, 0x95, 0xB8, 0x80, 0xF8,
  0xE3, 0x31, 0xE1, 0xDF, 0xDD, 0xF0, 0xC6, 0x3D, 0xFD, 0xEF, 0x76, 0x33,
  0xF1, 0x86, 0xBC, 0x0C, 0x32, 0xDF, 0xCF, 0x36, 0xDF, 0x31, 0xEC, 0xFF,
  0x65, 0xE0, 0x37, 0x7F, 0x66, 0x66, 0x2D, 0xFC, 0xF3, 0x6D, 0xF8, 0xDE,
  0xC6, 0x3D, 0xFD, 0xEF, 0x7B, 0xBF, 0xFF, 0x23, 0x33, 0x33, 0x33, 0x3E,
  0xC3, 0x0D, 0xB6, 0xF3, 0xCF, 0xB7, 0xFF, 0xFF, 0xB2, 0xFF, 0xDB, 0xDB,
  0xDB, 0xDB, 0xB7, 0xF7, 0xBD, 0xEC, 0x31, 0xEC, 0xF3, 0x6D, 0xE0, 0xB7,
  0xF7, 0xBD, 0xFB, 0x18, 0x2D, 0xFC, 0xF3, 0x6D, 0xF0, 0xC3, 0xBE, 0xCC,
  0xCC, 0x37, 0xF8, 0xF9, 0xF8, 0x27, 0xF6, 0x67, 0x70, 0xDE, 0xF7, 0xBD,
  0xFC, 0xCF, 0x36, 0x9E, 0x38, 0xC0, 0xCD, 0xEE, 0xD5, 0x4E, 0xE7, 0x73,
  0xB8, 0xCD, 0xF7, 0x8E, 0x7B, 0x30, 0xCF, 0x36, 0x9E, 0x38, 0xC3, 0x38,
  0xFF, 0xCC, 0xC6, 0x7C, 0x36, 0x6E, 0xE6, 0x63, 0x30, 0xFF, 0xC0, 0xE6,
  0x67, 0x36, 0x6E, 0xC0, 0xF8,
};

const GFXglyph NotoSans_Black10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 5, 1, -7 },
  { 5, 6, 7, 7, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 9, 7, 9, 0, -7 },
  { 26, 8, 7, 8, 0, -7 },
  { 33, 1, 2, 3, 1, -7 },
  { 34, 3, 9, 4, 0, -7 },
  { 38, 3, 9, 4, 0, -7 },
  { 42, 5, 5, 5, 0, -8 },
  { 46, 5, 5, 6, 0, -6 },
  { 50, 3, 2, 3, 0, -1 },
  { 51, 3, 1, 3, 0, -3 },
  { 52, 2, 2, 3, 0, -2 },
  { 53, 4, 7, 4, 0, -7 },
  { 57, 6, 7, 6, 0, -7 },
  { 63, 5, 7, 6, 0, -7 },
  { 68, 5, 7, 6, 0, -7 },
  { 73, 5, 7, 6, 0, -7 },
  { 78, 6, 7, 6, 0, -7 },
  { 84, 5, 7, 6, 0, -7 },
  { 89, 6, 7, 6, 0, -7 },
  { 95, 6, 7, 6, 0, -7 },
  { 101, 6, 7, 6, 0, -7 },
  { 107, 6, 7, 6, 0, -7 },
  { 113, 2, 6, 3, 0, -6 },
  { 115, 3, 7, 3, 0, -6 },
  { 118, 5, 5, 6, 0, -6 },
  { 122, 5, 3, 6, 0, -5 },
  { 124, 5, 5, 6, 0, -6 },
  { 128, 5, 7, 5, 0, -7 },
  { 133, 9, 8, 9, 0, -7 },
  { 142, 7, 7, 7, 0, -7 },
  { 149, 5, 7, 7, 1, -7 },
  { 154, 5, 7, 6, 1, -7 },
  { 159, 6, 7, 7, 1, -7 },
  { 165, 4, 7, 5, 1, -7 },
  { 169, 4, 7, 5, 1, -7 },
  { 173, 6, 7, 7, 1, -7 },
  { 179, 6, 7, 8, 1, -7 },
  { 185, 4, 7, 4, 0, -7 },
  { 189, 4, 9, 4, -1, -7 },
  { 194, 6, 7, 7, 1, -7 },
  { 200, 4, 7, 6, 1, -7 },
  { 204, 8, 7, 10, 1, -7 },
  { 211, 7, 7, 8, 1, -7 },
  { 218, 6, 7, 8, 1, -7 },
  { 224, 5, 7, 6, 1, -7 },
  { 229, 7, 9, 8, 1, -7 },
  { 237, 6, 7, 7, 1, -7 },
  { 243, 5, 7, 6, 0, -7 },
  { 248, 6, 7, 6, 0, -7 },
  { 254, 6, 7, 8, 1, -7 },
  { 260, 7, 7, 7, 0, -7 },
  { 267, 10, 7, 10, 0, -7 },
  { 276, 7, 7, 7, 0, -7 },
  { 283, 7, 7, 7, 0, -7 },
  { 290, 6, 7, 6, 0, -7 },
  { 296, 2, 9, 3, 1, -7 },
  { 299, 4, 7, 4, 0, -7 },
  { 303, 3, 9, 3, 0, -7 },
  { 307, 5, 5, 5, 0, -7 },
  { 311, 5, 1, 5, 0, 1 },
  { 312, 4, 2, 4, 0, -8 },
  { 313, 6, 6, 6, 0, -6 },
  { 318, 5, 8, 6, 1, -8 },
  { 323, 5, 6, 5, 0, -6 },
  { 327, 6, 8, 6, 0, -8 },
  { 333, 6, 6, 6, 0, -6 },
  { 338, 4, 8, 4, 0, -8 },
  { 342, 6, 8, 6, 0, -6 },
  { 348, 5, 8, 7, 1, -8 },
  { 353, 2, 8, 3, 1, -8 },
  { 355, 4, 10, 3, -1, -8 },
  { 360, 6, 8, 7, 1, -8 },
  { 366, 2, 8, 3, 1, -8 },
  { 368, 8, 6, 10, 1, -6 },
  { 374, 5, 6, 7, 1, -6 },
  { 378, 6, 6, 6, 0, -6 },
  { 383, 5, 8, 6, 1, -6 },
  { 388, 6, 8, 6, 0, -6 },
  { 394, 4, 6, 5, 1, -6 },
  { 397, 5, 6, 5, 0, -6 },
  { 401, 4, 7, 5, 0, -7 },
  { 405, 5, 6, 7, 1, -6 },
  { 409, 6, 6, 6, 0, -6 },
  { 414, 9, 6, 9, 0, -6 },
  { 421, 6, 6, 6, 0, -6 },
  { 426, 6, 8, 6, 0, -6 },
  { 432, 5, 6, 5, 0, -6 },
  { 436, 4, 9, 4, 0, -7 },
  { 441, 1, 10, 5, 2, -8 },
  { 443, 4, 9, 4, 0, -7 },
  { 448, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_Black10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black10pt7bBitmaps,
  (GFXglyph *)NotoSans_Black10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_BLACK10PT7B_H_
