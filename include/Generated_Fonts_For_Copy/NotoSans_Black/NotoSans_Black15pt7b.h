#ifndef _NOTOSANS_BLACK15PT7B_H_
#define _NOTOSANS_BLACK15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xB0, 0xDF, 0x80, 0xFF, 0x7C, 0xF3, 0x19, 0x86, 0xC1,
  0xB1, 0xFF, 0x7F, 0xCC, 0xCF, 0xFB, 0xFE, 0x36, 0x0D, 0x86, 0x60, 0x08,
  0x7F, 0x7F, 0xE8, 0x78, 0x7E, 0x1F, 0x0B, 0x6F, 0x7F, 0x3C, 0x08, 0x30,
  0x61, 0xE3, 0x0F, 0xCC, 0x33, 0x60, 0xED, 0xB1, 0xED, 0xE3, 0x36, 0xC1,
  0xBB, 0x0E, 0xEC, 0x31, 0xF1, 0x87, 0x80, 0x3C, 0x0F, 0xC1, 0x98, 0x37,
  0x07, 0xE0, 0xF3, 0xBF, 0x77, 0x7E, 0xE7, 0x9F, 0xF9, 0xF7, 0x80, 0xFB,
  0x60, 0x76, 0xEC, 0xCC, 0xCC, 0xCC, 0xEE, 0x70, 0xE3, 0x8C, 0x63, 0x9C,
  0xE7, 0x39, 0xCC, 0xEE, 0x00, 0x18, 0x99, 0xFF, 0xFF, 0x3C, 0x7E, 0x24,
  0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x00, 0x76, 0x6E, 0xFF, 0xDF, 0x80,
  0x0E, 0x18, 0x70, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xC3, 0x80, 0x39, 0xFB,
  0xBF, 0x7C, 0xF9, 0xF3, 0xE7, 0xEF, 0xFD, 0xF0, 0x1C, 0xF7, 0xFF, 0x5C,
  0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x3C, 0xFF, 0x7F, 0x47, 0x07, 0x0E, 0x1C,
  0x38, 0x70, 0xFF, 0xFF, 0x79, 0xFF, 0x78, 0x77, 0xCF, 0x1F, 0x87, 0x8F,
  0xFF, 0xF0, 0x06, 0x07, 0x07, 0x83, 0xC3, 0x63, 0xB3, 0x99, 0xFF, 0xFF,
  0x83, 0x01, 0x80, 0xFD, 0xFB, 0xF7, 0x0F, 0xDF, 0xC3, 0x87, 0x8F, 0xFF,
  0xF0, 0x1E, 0xFF, 0xCF, 0x0D, 0xDF, 0xFB, 0xE3, 0xEF, 0xFD, 0xF0, 0xFF,
  0xFF, 0xF8, 0x71, 0xC3, 0x86, 0x1C, 0x38, 0xE1, 0xC0, 0x3C, 0x7F, 0x77,
  0x77, 0x7E, 0x3C, 0x7F, 0x67, 0xE3, 0x7F, 0x3E, 0x3C, 0x7E, 0x77, 0xE7,
  0xE7, 0x7F, 0x7B, 0x07, 0x07, 0x7E, 0x7C, 0xFC, 0x01, 0xBF, 0x77, 0x00,
  0x00, 0x76, 0x6E, 0x02, 0x0C, 0x7B, 0xCE, 0x1F, 0x0F, 0x87, 0x02, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x81, 0x83, 0xC1, 0xE0, 0xE7, 0xFE, 0x60, 0x80,
  0x7D, 0xFD, 0xB8, 0x31, 0xE7, 0x8C, 0x00, 0x10, 0x70, 0xE0, 0x0F, 0x03,
  0xFC, 0x60, 0x6C, 0xFF, 0xDD, 0xBD, 0x9B, 0xD9, 0xBD, 0xBE, 0xDF, 0xEE,
  0x00, 0x7F, 0x81, 0xF8, 0x1E, 0x03, 0xE0, 0x6C, 0x1D, 0x83, 0xB8, 0x77,
  0x1C, 0x63, 0xFE, 0x7F, 0xDE, 0x3B, 0x83, 0x80, 0xFC, 0xFF, 0xEF, 0xE7,
  0xFF, 0xFE, 0xFF, 0xE7, 0xE7, 0xFF, 0xFE, 0x1E, 0x7F, 0x7F, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xF1, 0x7F, 0x3F, 0xFC, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE7, 0xFF, 0xBF, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xDF,
  0xBF, 0x70, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xE3, 0xFF, 0xF8, 0xE3,
  0x8E, 0x00, 0x1F, 0x3F, 0xDF, 0xDC, 0x0E, 0x07, 0x7F, 0xBF, 0xC7, 0xF3,
  0xBF, 0xCF, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xE3, 0xF1, 0xF8, 0xE0, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x77, 0xFE, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xF8, 0xE3, 0xF3, 0xF9, 0xDD,
  0xCF, 0xC7, 0xE3, 0xF9, 0xDC, 0xE7, 0x73, 0xB8, 0xE0, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF,
  0x8F, 0xF9, 0xBF, 0xDB, 0xED, 0xBE, 0xFB, 0xEF, 0x3E, 0xF3, 0xE7, 0x30,
  0xF0, 0xFE, 0x3F, 0x8F, 0xF3, 0xFC, 0xFB, 0xBE, 0xEF, 0x9F, 0xE7, 0xF8,
  0xFE, 0x3C, 0x1E, 0x1F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xF3, 0xDF, 0xE3, 0xF0, 0xFC, 0xFE, 0xFF, 0xE7, 0xE7, 0xFF, 0xFE, 0xE0,
  0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0xFC, 0x7F, 0x3B,
  0xDC, 0xEE, 0x77, 0xF3, 0xF1, 0xDC, 0xE7, 0x73, 0xB8, 0xE0, 0x3D, 0xFF,
  0xBF, 0x0F, 0x0F, 0x8F, 0x87, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xBF, 0x8F, 0x80, 0xE1, 0xFC, 0x77, 0x1D,
  0xCE, 0x73, 0x8E, 0xE3, 0xB0, 0xFC, 0x1F, 0x07, 0x81, 0xE0, 0xE3, 0x86,
  0xC7, 0x1D, 0x8F, 0x3B, 0x9E, 0x77, 0x7C, 0xC6, 0xFB, 0x8D, 0xBF, 0x1F,
  0x3E, 0x3E, 0x78, 0x3C, 0xF0, 0x71, 0xE0, 0xF1, 0xEE, 0x38, 0xEE, 0x1F,
  0xC1, 0xF0, 0x1C, 0x07, 0xC1, 0xF8, 0x3B, 0x8E, 0x3B, 0xC7, 0x80, 0xE1,
  0xDC, 0xE7, 0x38, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x7F, 0xBF, 0xDF, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x7F,
  0xFF, 0xE0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xE0, 0xC1, 0x83,
  0x83, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0xFF, 0x33, 0x33, 0x33, 0x33,
  0x33, 0xFF, 0x10, 0x18, 0x3C, 0x3C, 0x6E, 0x66, 0xC7, 0xFF, 0xFF, 0xF1,
  0xC0, 0xFE, 0xFC, 0x1F, 0xFE, 0x79, 0xFF, 0xFB, 0xE0, 0xE0, 0xE0, 0xFE,
  0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xDE, 0x7F, 0xFB, 0x87, 0x0E, 0x1C,
  0x7F, 0x3E, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0x77, 0x7E, 0xFE, 0xE7, 0xFF, 0xFF, 0xE1, 0xFE, 0x7E, 0x3E, 0x79, 0xC7,
  0xEF, 0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x7F, 0xFF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFF, 0x77, 0x07, 0xFE, 0xFE, 0x38, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x5F, 0x8F, 0xFF, 0xFF, 0xF0, 0x11,
  0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xCC, 0xE0, 0x70, 0x38,
  0x3C, 0xEE, 0xE7, 0xE3, 0xF1, 0xFC, 0xEE, 0x73, 0xB9, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xDE, 0xF7, 0xFF, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3,
  0x9F, 0x9C, 0xFC, 0xE7, 0xDE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0x7E, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0x7C, 0xFE, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFF, 0x77, 0x07, 0x07, 0x07, 0x07, 0xDF, 0xFF, 0x38, 0xE3,
  0x8E, 0x38, 0xFF, 0xFE, 0x3E, 0x3E, 0x7F, 0xFE, 0x30, 0xC7, 0xFF, 0x71,
  0xC7, 0x1C, 0x3C, 0xF0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B,
  0xE3, 0xB1, 0x9D, 0xCE, 0xE3, 0x61, 0xF0, 0x78, 0x38, 0xE7, 0x9B, 0x3D,
  0xDD, 0xEE, 0xFF, 0x67, 0xDB, 0x1E, 0x78, 0xF3, 0xC7, 0x9C, 0xF3, 0xBB,
  0x8F, 0x83, 0xC3, 0xE1, 0xF9, 0xDD, 0xE7, 0xE3, 0xB9, 0x9D, 0xC6, 0xE3,
  0x61, 0xF0, 0x78, 0x38, 0x1C, 0x3C, 0x1E, 0x0C, 0x00, 0x7E, 0xFC, 0x70,
  0xE3, 0x8E, 0x3F, 0xFF, 0x1C, 0xF3, 0x8E, 0x38, 0xEF, 0x3C, 0x38, 0xE3,
  0x8F, 0x1C, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xC3, 0x0C, 0x30, 0xE1,
  0xCF, 0x30, 0xC3, 0x3C, 0xF2, 0x00, 0x63, 0xFE, 0x78,
};

const GFXglyph NotoSans_Black15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 4, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 10, 11, 10, 0, -11 },
  { 23, 8, 12, 9, 0, -11 },
  { 35, 14, 11, 14, 0, -11 },
  { 55, 11, 11, 12, 1, -11 },
  { 71, 3, 4, 4, 1, -11 },
  { 73, 4, 13, 5, 1, -11 },
  { 80, 5, 13, 5, 0, -11 },
  { 89, 8, 7, 8, 0, -11 },
  { 96, 7, 7, 9, 1, -9 },
  { 103, 4, 4, 5, 0, -2 },
  { 105, 4, 2, 5, 0, -5 },
  { 106, 3, 3, 4, 1, -3 },
  { 108, 7, 11, 7, 0, -11 },
  { 118, 7, 11, 9, 1, -11 },
  { 128, 6, 11, 9, 1, -11 },
  { 137, 8, 11, 9, 0, -11 },
  { 148, 7, 11, 9, 1, -11 },
  { 158, 9, 11, 9, 0, -11 },
  { 171, 7, 11, 9, 1, -11 },
  { 181, 7, 11, 9, 1, -11 },
  { 191, 7, 11, 9, 1, -11 },
  { 201, 8, 11, 9, 0, -11 },
  { 212, 8, 11, 9, 0, -11 },
  { 223, 3, 8, 4, 1, -8 },
  { 226, 4, 10, 4, 0, -8 },
  { 231, 7, 9, 9, 1, -10 },
  { 239, 7, 5, 9, 1, -8 },
  { 244, 7, 9, 9, 1, -10 },
  { 252, 7, 11, 8, 0, -11 },
  { 262, 12, 12, 13, 1, -11 },
  { 280, 11, 11, 11, 0, -11 },
  { 296, 8, 11, 10, 1, -11 },
  { 307, 8, 11, 10, 1, -11 },
  { 318, 9, 11, 11, 1, -11 },
  { 331, 7, 11, 8, 1, -11 },
  { 341, 6, 11, 8, 1, -11 },
  { 350, 9, 11, 11, 1, -11 },
  { 363, 9, 11, 11, 1, -11 },
  { 376, 5, 11, 7, 1, -11 },
  { 383, 5, 14, 5, -1, -11 },
  { 392, 9, 11, 10, 1, -11 },
  { 405, 7, 11, 9, 1, -11 },
  { 415, 12, 11, 15, 1, -11 },
  { 432, 10, 11, 13, 1, -11 },
  { 446, 10, 11, 12, 1, -11 },
  { 460, 8, 11, 9, 1, -11 },
  { 471, 10, 14, 12, 1, -11 },
  { 489, 9, 11, 10, 1, -11 },
  { 502, 7, 11, 9, 1, -11 },
  { 512, 8, 11, 9, 0, -11 },
  { 523, 9, 11, 11, 1, -11 },
  { 536, 10, 11, 10, 0, -11 },
  { 550, 15, 11, 16, 0, -11 },
  { 571, 11, 11, 11, 0, -11 },
  { 587, 10, 11, 10, 0, -11 },
  { 601, 9, 11, 9, 0, -11 },
  { 614, 4, 14, 5, 1, -11 },
  { 621, 7, 11, 7, 0, -11 },
  { 631, 4, 14, 5, 0, -11 },
  { 638, 8, 7, 8, 0, -11 },
  { 645, 8, 2, 8, 0, 1 },
  { 647, 5, 2, 6, 1, -11 },
  { 649, 7, 8, 9, 1, -8 },
  { 656, 8, 11, 10, 1, -11 },
  { 667, 7, 8, 8, 1, -8 },
  { 674, 8, 11, 10, 1, -11 },
  { 685, 8, 8, 9, 1, -8 },
  { 693, 7, 11, 6, 0, -11 },
  { 703, 8, 12, 10, 1, -8 },
  { 715, 8, 11, 10, 1, -11 },
  { 726, 3, 12, 5, 1, -12 },
  { 731, 5, 16, 5, -1, -12 },
  { 741, 9, 11, 10, 1, -11 },
  { 754, 3, 11, 5, 1, -11 },
  { 759, 13, 8, 15, 1, -8 },
  { 772, 8, 8, 10, 1, -8 },
  { 780, 8, 8, 10, 1, -8 },
  { 788, 8, 12, 10, 1, -8 },
  { 800, 8, 12, 10, 1, -8 },
  { 812, 6, 8, 7, 1, -8 },
  { 818, 6, 8, 8, 1, -8 },
  { 824, 6, 10, 7, 0, -10 },
  { 832, 8, 8, 10, 1, -8 },
  { 840, 9, 8, 9, 0, -8 },
  { 849, 13, 8, 14, 0, -8 },
  { 862, 9, 8, 9, 0, -8 },
  { 871, 9, 12, 9, 0, -8 },
  { 885, 7, 8, 8, 0, -8 },
  { 892, 6, 14, 7, 0, -11 },
  { 903, 2, 14, 8, 3, -11 },
  { 907, 6, 14, 7, 0, -11 },
  { 918, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_Black15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black15pt7bBitmaps,
  (GFXglyph *)NotoSans_Black15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_BLACK15PT7B_H_
