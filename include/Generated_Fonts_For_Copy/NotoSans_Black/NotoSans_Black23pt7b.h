#ifndef _NOTOSANS_BLACK23PT7B_H_
#define _NOTOSANS_BLACK23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0x80, 0x07, 0x7F, 0xFE, 0xF3,
  0xDC, 0xF7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x73, 0x87, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x87, 0x38, 0x0E, 0xE1,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE1, 0xCE, 0x03, 0xB8, 0x0E, 0x70, 0x1C,
  0xE0, 0x06, 0x03, 0xF8, 0x7F, 0xEF, 0xFE, 0xF6, 0xEE, 0x60, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xF0, 0x6F, 0x86, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFC, 0x06, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xF8, 0x3C, 0x1F, 0xC1, 0xC0,
  0xEF, 0x1C, 0x0F, 0x78, 0xE0, 0x7B, 0xCE, 0x03, 0xDE, 0xF0, 0x0E, 0xF7,
  0x3C, 0x7F, 0x7B, 0xF1, 0xFB, 0xBF, 0xC7, 0x3D, 0xCE, 0x01, 0xCE, 0x70,
  0x1C, 0x73, 0x80, 0xE3, 0x9C, 0x0E, 0x1F, 0xE0, 0xF0, 0x7F, 0x07, 0x01,
  0xF0, 0x07, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xBE, 0x07, 0x8F, 0x01,
  0xEF, 0x00, 0xFF, 0x80, 0x3F, 0x81, 0x3F, 0x8F, 0x3F, 0xE7, 0xBF, 0xFF,
  0xDE, 0x7F, 0xCF, 0x1F, 0xE7, 0xCF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F,
  0xDF, 0x80, 0xF7, 0x77, 0x77, 0x1E, 0x79, 0xE3, 0xC7, 0x9E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x78, 0xF0, 0xE1, 0xE1, 0xE0,
  0xF3, 0xC7, 0x9E, 0x3C, 0xF3, 0xCF, 0x3C, 0x71, 0xC7, 0x3C, 0xF3, 0xCF,
  0x3D, 0xE7, 0xBC, 0xE0, 0x0F, 0x00, 0x70, 0x47, 0x17, 0xFF, 0x7F, 0xFF,
  0xFF, 0x0F, 0x81, 0xFC, 0x3D, 0xE1, 0x9C, 0x09, 0x00, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x00, 0x7F, 0xBD, 0xEE, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xE0,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x0E, 0x03,
  0xF8, 0x7F, 0xC7, 0xFE, 0xF9, 0xEF, 0x1E, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF9, 0xEF, 0xBE, 0x7F, 0xE3, 0xFC, 0x1F, 0x80,
  0x0F, 0xC7, 0xF3, 0xFD, 0xFF, 0xFF, 0xDD, 0xF2, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x01, 0xFF, 0x3F,
  0xFC, 0xFF, 0xE3, 0x8F, 0x10, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8,
  0x1E, 0x07, 0xFC, 0xFF, 0xE7, 0xFE, 0x61, 0xE0, 0x1E, 0x03, 0xC3, 0xF8,
  0x3F, 0x03, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xFC, 0x3E, 0xFF, 0xEF, 0xFC,
  0xFF, 0x80, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xF7, 0x87, 0xBC, 0x79, 0xE7, 0x8F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x07, 0x80, 0x3C, 0x7F, 0xCF, 0xF9, 0xFF, 0x3C, 0x07, 0x80, 0xFE,
  0x3F, 0xF7, 0xFF, 0x7F, 0xE0, 0x3C, 0x07, 0x80, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF7, 0xFC, 0x03, 0xC1, 0xFE, 0x3F, 0xE7, 0xFE, 0x78, 0x0F, 0x00, 0xF7,
  0x8F, 0xFE, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x9E, 0x7F,
  0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xF1, 0xEF,
  0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x87, 0xFC, 0xFB, 0xEF, 0x1F, 0xF0, 0xFF,
  0x1F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x0E, 0x03, 0xF8, 0x7F, 0xCF, 0xFE,
  0xF1, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x7E, 0xE0, 0x9E,
  0x01, 0xE0, 0x7E, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0x77, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xBF, 0xFF, 0x00, 0x77, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xEF, 0x7B, 0x9C, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xF1, 0xFC, 0xFC, 0x3E,
  0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x03, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x3F, 0x1F, 0xDF, 0xE3, 0xF0, 0x70,
  0x08, 0x00, 0x0F, 0x0F, 0xFB, 0xFF, 0xBF, 0xF6, 0x1E, 0x03, 0xC0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0xF8,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x03, 0xC3,
  0x82, 0x3C, 0xE7, 0xFB, 0x9D, 0xFF, 0x7F, 0x38, 0xE7, 0xE7, 0x1C, 0xFD,
  0xE3, 0x9F, 0xBC, 0x73, 0x73, 0x9E, 0xEE, 0x7F, 0xFD, 0xE7, 0xDF, 0x1C,
  0x00, 0x01, 0xE0, 0x10, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xFB,
  0xC0, 0x79, 0xF0, 0x3C, 0x78, 0x3E, 0x3C, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xFF, 0xCF,
  0xFE, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x03, 0xC0,
  0x7F, 0xCF, 0xFE, 0x7F, 0xE7, 0xC1, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x1C, 0xFF, 0xE3, 0xFF,
  0x0F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0x7E, 0xF0, 0xFB, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0xFB, 0xFE, 0xFF, 0xBC, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x01, 0xE0, 0x3F, 0xF3,
  0xFF, 0xCF, 0xFE, 0x7E, 0x09, 0xF0, 0x0F, 0x80, 0x3E, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x9F, 0xFE, 0x0F, 0x7C, 0x3D, 0xFC, 0xF3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFC, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x7E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x9F, 0xFE, 0xFE, 0xFC, 0xF0, 0xFF, 0xC3, 0xEF, 0x1F,
  0x3C, 0xF8, 0xF3, 0xC3, 0xDF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x0F, 0x3E, 0x3C, 0xF8, 0xF1, 0xF3, 0xC7, 0xCF, 0x0F, 0xBC, 0x1F, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xEE, 0x1D, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xDC, 0xFF, 0xF7, 0x3B, 0xFD, 0xEE, 0xFF, 0x7F, 0xBF, 0xCF, 0xCF,
  0xF3, 0xF3, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0xC7, 0x8F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF3, 0xFD, 0xE7, 0xFB, 0xEF,
  0xF3, 0xDF, 0xE7, 0xDF, 0xC7, 0xBF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF8, 0x3F, 0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C,
  0x3E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7F, 0x7E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF0, 0xFF, 0xCF, 0xFE, 0xFF, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFC, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x03, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xE3,
  0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07,
  0xDF, 0x03, 0xE7, 0xC1, 0xF3, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0xFF, 0xC3,
  0xFF, 0x8F, 0xFE, 0x3C, 0x7C, 0xF1, 0xF3, 0xC7, 0xCF, 0x3E, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x0F, 0x3C, 0x3C, 0xF8, 0xF1, 0xF3, 0xC7, 0xCF, 0x0F,
  0xBC, 0x1F, 0x0F, 0x03, 0xFF, 0x7F, 0xEF, 0xFE, 0xF8, 0x4F, 0x80, 0xFC,
  0x07, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xEF, 0x3E, 0xFF,
  0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE,
  0x1F, 0xFD, 0xF9, 0xFF, 0xE7, 0xFF, 0x07, 0xF0, 0xF8, 0x1F, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x3C, 0x1F, 0x78, 0x7C, 0x1E, 0x78, 0x7E,
  0x1E, 0x78, 0x7E, 0x3E, 0x3C, 0x7E, 0x3C, 0x3C, 0x7E, 0x3C, 0x3C, 0xFF,
  0x3C, 0x3C, 0xFF, 0x3C, 0x1E, 0xE7, 0x78, 0x1E, 0xE7, 0x78, 0x1E, 0xE7,
  0x78, 0x1F, 0xE7, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x1E, 0x1F, 0x0F, 0x9F, 0x03, 0xEF,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x03, 0xE7, 0xC1, 0xF1, 0xF1, 0xF0, 0xFD,
  0xF0, 0x3F, 0xF8, 0x3E, 0xF8, 0x78, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x83,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFC,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xFF, 0xFE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x83, 0x9C, 0x39, 0xC7, 0x0E,
  0x70, 0xEE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F,
  0x1F, 0x87, 0xFE, 0x3F, 0xE3, 0x1F, 0x01, 0xF3, 0xFF, 0x7F, 0xFF, 0x9F,
  0xF1, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x7E, 0x70, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF7, 0x8F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0xBE, 0xFF, 0xEF, 0xFE, 0xE7, 0xC0, 0x0F, 0xC7,
  0xFD, 0xFF, 0x3F, 0xEF, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x99,
  0xFF, 0x1F, 0xE1, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF7,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF,
  0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0x70, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x8F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x82, 0x7F, 0xE3, 0xFE,
  0x1F, 0xE0, 0x07, 0x07, 0xF1, 0xFC, 0xFE, 0x3E, 0x0F, 0xEF, 0xFB, 0xFE,
  0xFF, 0x8F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x80, 0x1E, 0xF7, 0xFF, 0x7F, 0xFF, 0xDF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF8, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F, 0x81, 0xF7,
  0xFF, 0x7F, 0xE7, 0xFC, 0x04, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x77, 0xFE, 0xF0, 0x3D,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x1C, 0x7C, 0xF8, 0xF0,
  0x03, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x79, 0xFF, 0xFF, 0xBE, 0x10, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x0F, 0xF8, 0xFB, 0xCF, 0x9E, 0xF8, 0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x8F, 0xFC, 0x79, 0xF3, 0xC7, 0xDE, 0x3E, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xC7, 0x8E, 0xFE, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF,
  0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F,
  0xF1, 0xF1, 0xF0, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F,
  0x81, 0xFF, 0x1F, 0xFC, 0xF3, 0xEF, 0x8F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF8, 0xF7, 0xC7, 0x9F, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0xE7, 0x8F, 0xFC,
  0xFF, 0xEF, 0xFE, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0xBE,
  0xFF, 0xEF, 0xFE, 0xF7, 0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0xF7, 0xFF, 0x7F, 0xFF, 0xDF, 0xF8, 0xFF, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF8, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xE3, 0xF7, 0xBF, 0xDF, 0xEF,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x3F, 0x1F,
  0xFF, 0xFB, 0xC2, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x07, 0xE0, 0xFF, 0xFF,
  0xFE, 0xFF, 0x00, 0x3C, 0x1E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x97, 0xF9, 0xFC, 0x7E, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFB, 0xEF,
  0xDF, 0xFE, 0xFF, 0xF3, 0xF7, 0x80, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0x9F,
  0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x07, 0x80, 0xF8, 0xF8, 0xFB, 0xC7, 0xC7, 0x9E, 0x3E,
  0x3C, 0xF3, 0xF9, 0xE7, 0x9D, 0xDE, 0x1E, 0xEE, 0xF0, 0xF7, 0x77, 0x87,
  0xBB, 0xBC, 0x1F, 0x9F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x80, 0xF0, 0xF8, 0x00, 0xF8, 0x7D, 0xF1, 0xE3, 0xEF, 0x8F, 0xFC, 0x1F,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xCF, 0x9F,
  0x1E, 0xF8, 0x7C, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0x9F, 0x1E, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C,
  0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x1F, 0x1F, 0x3F, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0xFC, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E,
  0x1F, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xF8, 0xF8, 0xF8, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x0F, 0x1F,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0xF8, 0xF8, 0xE0, 0x7C, 0x3F, 0xFF,
  0xFF, 0xC1, 0xF0,
};

const GFXglyph NotoSans_Black23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 16, 7, 1, -16 },
  { 11, 10, 6, 12, 1, -16 },
  { 19, 15, 16, 15, 0, -16 },
  { 49, 12, 18, 13, 1, -17 },
  { 76, 21, 17, 22, 0, -17 },
  { 121, 17, 17, 18, 1, -17 },
  { 158, 4, 6, 7, 1, -16 },
  { 161, 7, 21, 8, 1, -17 },
  { 180, 6, 21, 8, 1, -17 },
  { 196, 12, 11, 12, 0, -17 },
  { 213, 11, 11, 13, 1, -14 },
  { 229, 5, 6, 7, 1, -3 },
  { 233, 7, 4, 7, 0, -8 },
  { 237, 5, 4, 7, 1, -4 },
  { 240, 10, 17, 10, 0, -17 },
  { 262, 12, 17, 13, 1, -17 },
  { 288, 10, 16, 13, 1, -16 },
  { 308, 13, 17, 13, 0, -17 },
  { 336, 12, 17, 13, 1, -17 },
  { 362, 13, 16, 13, 0, -16 },
  { 388, 11, 16, 13, 1, -16 },
  { 410, 12, 17, 13, 1, -17 },
  { 436, 12, 16, 13, 1, -16 },
  { 460, 12, 17, 13, 1, -17 },
  { 486, 12, 17, 13, 1, -17 },
  { 512, 5, 13, 7, 1, -13 },
  { 521, 5, 16, 7, 1, -13 },
  { 531, 11, 13, 13, 1, -15 },
  { 549, 11, 8, 13, 1, -12 },
  { 560, 11, 13, 13, 1, -15 },
  { 578, 11, 17, 12, 0, -17 },
  { 602, 19, 19, 21, 1, -17 },
  { 648, 17, 16, 17, 0, -16 },
  { 682, 12, 16, 16, 2, -16 },
  { 706, 13, 17, 15, 1, -17 },
  { 734, 14, 16, 17, 2, -16 },
  { 762, 10, 16, 13, 2, -16 },
  { 782, 9, 16, 12, 2, -16 },
  { 800, 14, 17, 17, 1, -17 },
  { 830, 14, 16, 18, 2, -16 },
  { 858, 8, 16, 10, 1, -16 },
  { 874, 8, 21, 8, -2, -16 },
  { 895, 14, 16, 16, 2, -16 },
  { 923, 11, 16, 13, 2, -16 },
  { 945, 18, 16, 22, 2, -16 },
  { 981, 15, 16, 19, 2, -16 },
  { 1011, 16, 17, 18, 1, -17 },
  { 1045, 12, 16, 15, 2, -16 },
  { 1069, 17, 21, 18, 1, -17 },
  { 1114, 14, 16, 16, 2, -16 },
  { 1142, 12, 17, 13, 1, -17 },
  { 1168, 12, 16, 14, 1, -16 },
  { 1192, 14, 16, 17, 2, -16 },
  { 1220, 16, 16, 16, 0, -16 },
  { 1252, 24, 16, 24, 0, -16 },
  { 1300, 17, 16, 17, 0, -16 },
  { 1334, 15, 16, 15, 0, -16 },
  { 1364, 12, 16, 14, 1, -16 },
  { 1388, 6, 21, 7, 1, -17 },
  { 1404, 10, 17, 10, 0, -17 },
  { 1426, 5, 21, 7, 1, -17 },
  { 1440, 12, 10, 12, 0, -16 },
  { 1455, 12, 3, 12, 0, 1 },
  { 1460, 8, 4, 10, 1, -18 },
  { 1464, 12, 13, 14, 1, -13 },
  { 1484, 12, 17, 15, 2, -17 },
  { 1510, 11, 13, 12, 1, -13 },
  { 1528, 12, 17, 15, 1, -17 },
  { 1554, 12, 13, 14, 1, -13 },
  { 1574, 10, 18, 10, 0, -18 },
  { 1597, 12, 19, 15, 1, -13 },
  { 1626, 12, 17, 15, 2, -17 },
  { 1652, 5, 18, 7, 1, -18 },
  { 1664, 7, 24, 7, -1, -18 },
  { 1685, 13, 17, 15, 2, -17 },
  { 1713, 4, 17, 7, 2, -17 },
  { 1722, 20, 13, 23, 2, -13 },
  { 1755, 12, 13, 15, 2, -13 },
  { 1775, 13, 13, 15, 1, -13 },
  { 1797, 12, 19, 15, 2, -13 },
  { 1826, 12, 19, 15, 1, -13 },
  { 1855, 9, 13, 11, 2, -13 },
  { 1870, 10, 13, 12, 1, -13 },
  { 1887, 9, 15, 11, 1, -15 },
  { 1904, 13, 13, 15, 1, -13 },
  { 1926, 14, 13, 14, 0, -13 },
  { 1949, 21, 13, 21, 0, -13 },
  { 1984, 14, 13, 14, 0, -13 },
  { 2007, 14, 19, 14, 0, -13 },
  { 2041, 10, 13, 12, 1, -13 },
  { 2058, 8, 21, 10, 1, -17 },
  { 2079, 3, 22, 12, 4, -17 },
  { 2088, 8, 21, 10, 1, -17 },
  { 2109, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_Black23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black23pt7bBitmaps,
  (GFXglyph *)NotoSans_Black23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_BLACK23PT7B_H_
