#ifndef _NOTOSANS_BLACK35PT7B_H_
#define _NOTOSANS_BLACK35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0x7E, 0x7E, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF1,
  0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80,
  0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C,
  0x7C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC1, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3C, 0x0F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC1, 0xF1, 0xE0, 0x07, 0xC7,
  0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80,
  0x3E, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3F, 0xF8,
  0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFD, 0xE1, 0x3F,
  0x78, 0x0F, 0xDE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1E, 0xFE, 0x07, 0x9F,
  0xF1, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F,
  0xFF, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x7F, 0xE0, 0x1F, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xF0, 0x3E,
  0x00, 0xF9, 0xF0, 0x7C, 0x00, 0xF9, 0xF0, 0x7C, 0x00, 0xF9, 0xF0, 0xF8,
  0x00, 0xF9, 0xF8, 0xF8, 0x00, 0xF9, 0xF1, 0xF0, 0x00, 0xF9, 0xF1, 0xF0,
  0x00, 0xF9, 0xF3, 0xE3, 0xF0, 0xFF, 0xF3, 0xEF, 0xFC, 0x7F, 0xE7, 0xCF,
  0xFC, 0x3F, 0xEF, 0xDF, 0xFE, 0x1F, 0x8F, 0x9F, 0x3E, 0x00, 0x1F, 0x1F,
  0x3E, 0x00, 0x1F, 0x1F, 0x3E, 0x00, 0x3E, 0x1F, 0x3F, 0x00, 0x3E, 0x1F,
  0x3E, 0x00, 0x7C, 0x1F, 0x3E, 0x00, 0x7C, 0x1F, 0x3E, 0x00, 0xF8, 0x1F,
  0xFE, 0x01, 0xF8, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0xFC, 0x7F,
  0x1F, 0xFF, 0xCF, 0xE3, 0xFB, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x1F, 0xC3,
  0xFF, 0xC3, 0xF8, 0x3F, 0xF8, 0x7F, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xFE, 0x07, 0xFE,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7C, 0x07, 0xE1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F,
  0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0x1E, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFB, 0xE0, 0xF9, 0xF8, 0x3C, 0x78, 0x06, 0x30, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3C, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xCF, 0xE7, 0xF1, 0xFD,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0x87,
  0xF7, 0xF1, 0xFD, 0xFC, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF1, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3E, 0xFE, 0x79, 0xFC,
  0x63, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0x9F, 0x8F, 0xF3, 0x81, 0xFC, 0x40, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0x8F, 0x0F, 0xE1, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0xC0,
  0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x1F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF,
  0xF8, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x3F, 0xFF, 0x8F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x38,
  0x1F, 0x3F, 0xCF, 0xDF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF7, 0xE0, 0xFD, 0xFC,
  0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x07, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0x87, 0xF7,
  0xE1, 0xFD, 0xFC, 0x7E, 0x7F, 0xBF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFC, 0xFF, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xCF, 0xEF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF, 0x03, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x00, 0x18, 0x7E, 0x7E, 0xFF, 0x7F, 0x7E, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E,
  0x18, 0x7E, 0x7F, 0x7F, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8,
  0xF8, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7,
  0xFF, 0xF9, 0xC1, 0xFC, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x3F, 0xC7, 0xC7, 0xC7,
  0xFF, 0xBE, 0x3C, 0x7F, 0xFC, 0xFB, 0xE7, 0xFF, 0xE7, 0xDF, 0x3E, 0x1F,
  0x3E, 0xF1, 0xF0, 0xF9, 0xF7, 0x9F, 0x07, 0xCF, 0xFC, 0xF8, 0x3E, 0x7F,
  0xE7, 0xC1, 0xF3, 0xFF, 0x3E, 0x0F, 0x9F, 0xF9, 0xF8, 0xFC, 0xF3, 0xC7,
  0xFF, 0xFF, 0x9F, 0x3F, 0xFF, 0xF8, 0xF8, 0xFF, 0xBF, 0x83, 0xE1, 0xF0,
  0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x08, 0x03, 0xFE, 0x0F, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFE, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x7F,
  0xBF, 0x07, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0x8F, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFC,
  0x3C, 0x7F, 0x80, 0x47, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x27, 0xFC, 0x3E,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7E, 0x3F, 0xF3, 0xF0, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xF7, 0xE0, 0x3F,
  0xBF, 0x03, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x83, 0x87, 0xF8, 0x02, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xF7, 0xF8, 0x1F, 0xDF, 0xF8, 0x7F, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFD, 0xBF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF,
  0x1F, 0xF0, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x03, 0xF9,
  0xF8, 0x3F, 0xCF, 0xC1, 0xFC, 0x7E, 0x1F, 0xC3, 0xF1, 0xFE, 0x1F, 0x8F,
  0xE0, 0xFC, 0xFE, 0x07, 0xEF, 0xF0, 0x3F, 0x7F, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0xFE, 0x7F,
  0x07, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xC1, 0xFE, 0x7E,
  0x07, 0xF3, 0xF0, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF8, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xBF, 0xFF,
  0xF0, 0xFB, 0xFF, 0xDF, 0x0F, 0xBF, 0xFD, 0xF0, 0xFB, 0xFF, 0xDF, 0x9F,
  0x3F, 0xFC, 0xF9, 0xF3, 0xFF, 0xCF, 0x9F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xFC, 0x7F, 0xE3, 0xFF, 0xC7, 0xFE, 0x3F, 0xFC, 0x7F,
  0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xF8, 0x3F,
  0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFB, 0xF0, 0x7F, 0xFB, 0xF8, 0x7F, 0xFD, 0xF8, 0x7F, 0xFD, 0xFC,
  0x7F, 0xFC, 0xFE, 0x7F, 0xFC, 0xFE, 0x7F, 0xFC, 0x7F, 0x7F, 0xFC, 0x7F,
  0x3F, 0xFC, 0x3F, 0xBF, 0xFC, 0x3F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3,
  0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFE,
  0x1F, 0xF1, 0xFE, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x1F, 0xE3,
  0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x0F,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F,
  0x0F, 0xC1, 0xFC, 0x7E, 0x0F, 0xF3, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0xFC,
  0x07, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xF0, 0x73, 0xF0, 0x09, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x1F,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F,
  0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F,
  0xC1, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x07,
  0xF7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0x01, 0xFB, 0xF8, 0x1F, 0xE0, 0x3F, 0x7F, 0x03, 0xFC, 0x07, 0xE7, 0xE0,
  0x7F, 0x81, 0xFC, 0xFC, 0x0F, 0xF8, 0x3F, 0x9F, 0x81, 0xFF, 0x07, 0xE3,
  0xF8, 0x7F, 0xE0, 0xFC, 0x3F, 0x0F, 0xFC, 0x3F, 0x87, 0xE1, 0xFF, 0x87,
  0xF0, 0xFC, 0x3E, 0xF8, 0xFC, 0x1F, 0xCF, 0xDF, 0x1F, 0x81, 0xF9, 0xF3,
  0xE3, 0xF0, 0x3F, 0x3E, 0x7C, 0xFE, 0x07, 0xE7, 0xCF, 0xDF, 0x80, 0xFC,
  0xF8, 0xFB, 0xF0, 0x0F, 0xFF, 0x1F, 0x7E, 0x01, 0xFF, 0xC3, 0xEF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x9F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xF7,
  0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x01, 0xF7,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1C, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x0F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xE7,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFE, 0xFC, 0xFF, 0xDF, 0x8F, 0xE1, 0xF0, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF1, 0xE0, 0xFE, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xBF, 0xE3, 0xF1, 0xF8,
  0x00, 0x00, 0x70, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFC, 0x08, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x05, 0xFE, 0x0C, 0xFF, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x1C, 0x3F, 0x0F, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xF0, 0x7E, 0xFF, 0x1F,
  0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFE, 0xFC, 0x3F, 0x8F,
  0x80, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFE, 0x1F, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x13, 0xFF, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF,
  0xC0, 0x01, 0xF0, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0x80, 0x01, 0xFC, 0xFC, 0x7F, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFE, 0x0F, 0xDF, 0xC3,
  0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xDF, 0x87, 0xF3,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xD8, 0x07, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF1, 0xE0, 0xFE, 0xFF, 0x9F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0x80, 0x7D, 0xFF, 0xFF, 0xF7, 0xE7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF3,
  0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF7, 0xF0, 0x7F, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x8F, 0xE7, 0xF8,
  0x7F, 0x3F, 0x83, 0xFB, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x81,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1C, 0x03, 0x81, 0xF9, 0xFF, 0x1F, 0xE3, 0xF7, 0xFF, 0x7F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF,
  0xFC, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF,
  0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8,
  0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x1C, 0x1F, 0x9F, 0xF3,
  0xF7, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x1F,
  0x9F, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0x3F, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFC, 0xFC, 0x7F, 0xDF, 0x9F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0x7E,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFE,
  0x0F, 0xDF, 0xC3, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xDF, 0x87, 0xF3, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x1F, 0xF1, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xC0,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0xFE, 0x0C, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x13, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFE, 0x7C, 0x7F, 0x8F, 0x80, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFC, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0x7E, 0x3F, 0x83,
  0xF1, 0xF8, 0x1F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x0F, 0xBF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x7E, 0xFC,
  0x1F, 0xE0, 0xFD, 0xFC, 0x3F, 0xC3, 0xFB, 0xF8, 0xFF, 0x87, 0xE3, 0xF1,
  0xFF, 0x8F, 0xC7, 0xE3, 0xFF, 0x1F, 0x8F, 0xC7, 0xFE, 0x7F, 0x0F, 0xDF,
  0x7C, 0xFC, 0x1F, 0xBE, 0x79, 0xF8, 0x3F, 0x7C, 0xFB, 0xF0, 0x7E, 0xF9,
  0xF7, 0xC0, 0x7D, 0xF3, 0xEF, 0x80, 0xFB, 0xC7, 0xFF, 0x01, 0xFF, 0x87,
  0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x83, 0xFC,
  0xFE, 0x1F, 0xC3, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFC, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xEF, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFC, 0x7E, 0x0F,
  0xE3, 0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xFC,
  0x7F, 0xC3, 0xFC, 0x1F, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xFC, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0x07, 0xF8, 0x7F, 0xC7, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFE, 0x01, 0xF8,
};

const GFXglyph NotoSans_Black35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 25, 10, 1, -25 },
  { 26, 14, 9, 18, 2, -25 },
  { 42, 22, 25, 23, 1, -25 },
  { 111, 18, 29, 20, 1, -27 },
  { 177, 32, 25, 33, 1, -25 },
  { 277, 27, 25, 28, 1, -25 },
  { 362, 6, 9, 10, 2, -25 },
  { 369, 11, 32, 13, 1, -26 },
  { 413, 10, 32, 13, 1, -26 },
  { 453, 17, 17, 19, 1, -27 },
  { 490, 17, 17, 21, 2, -21 },
  { 527, 8, 10, 11, 1, -5 },
  { 537, 9, 5, 11, 1, -12 },
  { 543, 8, 6, 10, 1, -6 },
  { 549, 15, 25, 15, 0, -25 },
  { 596, 18, 25, 21, 1, -25 },
  { 653, 15, 25, 21, 1, -25 },
  { 700, 18, 25, 21, 1, -25 },
  { 757, 18, 25, 21, 1, -25 },
  { 814, 19, 25, 21, 1, -25 },
  { 874, 17, 25, 21, 2, -25 },
  { 928, 18, 25, 21, 1, -25 },
  { 985, 18, 25, 21, 1, -25 },
  { 1042, 18, 25, 21, 1, -25 },
  { 1099, 18, 25, 21, 1, -25 },
  { 1156, 8, 20, 10, 1, -20 },
  { 1176, 8, 25, 10, 1, -20 },
  { 1201, 17, 19, 21, 2, -22 },
  { 1242, 17, 13, 21, 2, -19 },
  { 1270, 17, 19, 21, 2, -22 },
  { 1311, 17, 25, 18, 0, -25 },
  { 1365, 29, 28, 31, 1, -25 },
  { 1467, 25, 25, 25, 0, -25 },
  { 1546, 19, 25, 24, 3, -25 },
  { 1606, 20, 25, 23, 2, -25 },
  { 1669, 21, 25, 26, 3, -25 },
  { 1735, 15, 25, 19, 3, -25 },
  { 1782, 14, 25, 19, 3, -25 },
  { 1826, 22, 25, 26, 2, -25 },
  { 1895, 21, 25, 27, 3, -25 },
  { 1961, 13, 25, 15, 1, -25 },
  { 2002, 13, 33, 12, -3, -25 },
  { 2056, 21, 25, 24, 3, -25 },
  { 2122, 16, 25, 20, 3, -25 },
  { 2172, 28, 25, 34, 3, -25 },
  { 2260, 24, 25, 29, 3, -25 },
  { 2335, 24, 25, 28, 2, -25 },
  { 2410, 18, 25, 22, 3, -25 },
  { 2467, 25, 31, 28, 2, -25 },
  { 2564, 21, 25, 24, 3, -25 },
  { 2630, 17, 25, 20, 2, -25 },
  { 2684, 19, 25, 21, 1, -25 },
  { 2744, 21, 25, 27, 3, -25 },
  { 2810, 24, 25, 24, 0, -25 },
  { 2885, 35, 25, 36, 1, -25 },
  { 2995, 25, 25, 25, 0, -25 },
  { 3074, 23, 25, 23, 0, -25 },
  { 3146, 20, 25, 21, 1, -25 },
  { 3209, 9, 32, 11, 2, -26 },
  { 3245, 15, 25, 15, 0, -25 },
  { 3292, 8, 32, 11, 1, -26 },
  { 3324, 19, 16, 18, 0, -25 },
  { 3362, 18, 4, 18, 0, 2 },
  { 3371, 12, 6, 15, 1, -27 },
  { 3380, 19, 20, 22, 1, -20 },
  { 3428, 19, 27, 23, 2, -27 },
  { 3493, 17, 20, 19, 1, -20 },
  { 3536, 19, 27, 23, 1, -27 },
  { 3601, 19, 20, 22, 1, -20 },
  { 3649, 14, 27, 14, 1, -27 },
  { 3697, 19, 28, 23, 1, -20 },
  { 3764, 19, 27, 23, 2, -27 },
  { 3829, 7, 27, 11, 2, -27 },
  { 3853, 11, 35, 11, -2, -27 },
  { 3902, 21, 27, 23, 2, -27 },
  { 3973, 7, 27, 11, 2, -27 },
  { 3997, 31, 20, 35, 2, -20 },
  { 4075, 19, 20, 23, 2, -20 },
  { 4123, 20, 20, 22, 1, -20 },
  { 4173, 19, 28, 23, 2, -20 },
  { 4240, 19, 28, 23, 1, -20 },
  { 4307, 14, 20, 16, 2, -20 },
  { 4342, 16, 20, 18, 1, -20 },
  { 4382, 14, 23, 16, 1, -23 },
  { 4423, 19, 19, 23, 2, -19 },
  { 4469, 21, 19, 21, 0, -19 },
  { 4519, 31, 19, 32, 0, -19 },
  { 4593, 22, 19, 22, 0, -19 },
  { 4646, 21, 27, 21, 0, -19 },
  { 4717, 16, 19, 18, 1, -19 },
  { 4755, 13, 31, 15, 1, -25 },
  { 4806, 4, 35, 18, 7, -27 },
  { 4824, 13, 31, 15, 1, -25 },
  { 4875, 17, 7, 21, 2, -16 },
};

const GFXfont NotoSans_Black35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black35pt7bBitmaps,
  (GFXglyph *)NotoSans_Black35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_BLACK35PT7B_H_
