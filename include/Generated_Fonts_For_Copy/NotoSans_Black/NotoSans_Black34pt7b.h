#ifndef _NOTOSANS_BLACK34PT7B_H_
#define _NOTOSANS_BLACK34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFE, 0x7E,
  0x7E, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFB, 0xE3, 0xE7,
  0x8F, 0x9E, 0x3E, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF9,
  0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC1, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x1F, 0x1E,
  0x00, 0xF9, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x87, 0xCF, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3,
  0xF7, 0x3C, 0xF9, 0xC1, 0x3F, 0x70, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x73,
  0xF0, 0x1C, 0xFF, 0x87, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFF,
  0x01, 0xF0, 0x0F, 0xFF, 0x07, 0xC0, 0x1F, 0x3E, 0x0F, 0x80, 0x3E, 0x7C,
  0x3E, 0x00, 0x7C, 0xF8, 0x78, 0x00, 0xF9, 0xF1, 0xF0, 0x01, 0xF3, 0xE7,
  0xC0, 0x03, 0xE7, 0xCF, 0x8F, 0x87, 0xFF, 0xBE, 0x7F, 0x87, 0xFE, 0x7D,
  0xFF, 0x8F, 0xFD, 0xF3, 0xFF, 0x8F, 0xF3, 0xEF, 0xDF, 0x07, 0x0F, 0x9F,
  0x3E, 0x00, 0x1E, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x7C, 0x01, 0xF0, 0xF8,
  0xF8, 0x03, 0xE1, 0xF3, 0xE0, 0x0F, 0x83, 0xE7, 0xC0, 0x1F, 0x03, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x60, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0x3F, 0x8F, 0xFF, 0x0F, 0xC7, 0xFF, 0xE7,
  0xF1, 0xFD, 0xFD, 0xFC, 0xFE, 0x3F, 0xFE, 0x3F, 0x87, 0xFF, 0x8F, 0xE0,
  0xFF, 0xC3, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0x9E, 0x78, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC,
  0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x08, 0x3C, 0x17, 0xDE, 0x7B, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xFC, 0x43, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xF3, 0xE0, 0xF9, 0xF8, 0x18, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F,
  0xFF, 0xE7, 0xF3, 0xF9, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xDF, 0x87, 0xE7, 0xE1, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0x3C, 0xFE, 0x31, 0xFC, 0x43, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xC3, 0xF8, 0x60, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xF7,
  0xF0, 0xF9, 0xFC, 0x7E, 0x7F, 0x3F, 0x1F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x20, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x3F, 0x0F, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE1,
  0xFD, 0xFC, 0x7F, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xCF, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7F, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFC, 0xFE, 0xFE, 0x1F, 0xBF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xEF, 0xE3, 0xFB, 0xF8, 0x7E,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFE, 0xFC, 0xFF, 0xBE, 0x0F, 0x9F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xC0, 0x00, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x9F, 0xFF, 0xFE, 0xFD, 0xF8, 0x3C, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0,
  0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x0F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF8, 0xC0, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0x80,
  0xFC, 0x00, 0xFC, 0x1F, 0x01, 0x03, 0xE3, 0xE1, 0xFF, 0xBE, 0x3E, 0x7F,
  0xF9, 0xF7, 0xCF, 0xFF, 0x9F, 0x7C, 0xFC, 0x78, 0xF7, 0x9F, 0x07, 0x8F,
  0x79, 0xF0, 0xF8, 0xFF, 0x9F, 0x0F, 0x8F, 0xF9, 0xF0, 0xF8, 0xFF, 0x9F,
  0x0F, 0x9F, 0xF9, 0xF0, 0xF9, 0xE7, 0x9F, 0xFF, 0xFE, 0x78, 0xFF, 0xFF,
  0xC7, 0xC7, 0xFB, 0xFC, 0x7C, 0x3F, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x04, 0x01, 0xFE, 0x07, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0,
  0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x1F,
  0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF3, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xE0, 0x63, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x01, 0x3F, 0xC0, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF,
  0xC1, 0xFE, 0xFC, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0x01, 0x8F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFF, 0x83, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF,
  0x03, 0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x3F, 0x07, 0xF9, 0xF8, 0x3F,
  0x8F, 0xC3, 0xF8, 0x7E, 0x3F, 0x83, 0xF1, 0xFC, 0x1F, 0x9F, 0xC0, 0xFD,
  0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x07, 0xE1,
  0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3,
  0xF0, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xDF, 0x07, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF,
  0x7C, 0x1F, 0xFF, 0xEF, 0xC7, 0xDF, 0xFC, 0xF8, 0xFB, 0xFF, 0x9F, 0x1F,
  0x7F, 0xF3, 0xE3, 0xCF, 0xFE, 0x7E, 0xF9, 0xFF, 0xC7, 0xDF, 0x3F, 0xF8,
  0xFB, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xE1, 0xFF, 0x1F, 0xFC, 0x3F, 0xE3,
  0xFF, 0x87, 0xF8, 0x7F, 0xF0, 0xFF, 0x0F, 0xFE, 0x0F, 0xE1, 0xFF, 0xC1,
  0xFC, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFD, 0xF8,
  0x3F, 0xFB, 0xF8, 0x7F, 0xF3, 0xF0, 0xFF, 0xE7, 0xF1, 0xFF, 0xC7, 0xE3,
  0xFF, 0x8F, 0xE7, 0xFF, 0x0F, 0xCF, 0xFE, 0x1F, 0xDF, 0xFC, 0x1F, 0xBF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0x38, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF, 0x7F, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF3, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF,
  0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x83, 0xFC, 0xFF,
  0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F,
  0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xCF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xC3,
  0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x00,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF,
  0xC7, 0xE0, 0x31, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFB, 0xE0, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xF8,
  0x1F, 0xDF, 0xE1, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x83, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F,
  0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xEF, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x01, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0x01, 0xFB, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E, 0x07,
  0xF8, 0x3F, 0x9F, 0x83, 0xFE, 0x0F, 0xC7, 0xE0, 0xFF, 0x83, 0xF1, 0xFC,
  0x3F, 0xE0, 0xFC, 0x3F, 0x0F, 0xFC, 0x3F, 0x0F, 0xC7, 0xDF, 0x1F, 0x83,
  0xF1, 0xF7, 0xC7, 0xE0, 0xFC, 0x7D, 0xF1, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E,
  0x07, 0xEF, 0xCF, 0xBF, 0x01, 0xFB, 0xE3, 0xEF, 0xC0, 0x7E, 0xF8, 0xFB,
  0xF0, 0x0F, 0xBE, 0x3E, 0xFC, 0x03, 0xFF, 0x87, 0xBE, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFF, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F, 0xE7, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F,
  0xC1, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8,
  0x7F, 0x03, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xF7, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x7D, 0xF0,
  0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x0F, 0x9E,
  0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x07,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xBF, 0xC2, 0x07,
  0xF0, 0x00, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xF9, 0xF1, 0xFC, 0x7C, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF9, 0xF0,
  0xFE, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFD, 0xFF, 0x3F, 0x3F, 0x80, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFF, 0x7F, 0xFE, 0x7F, 0x86, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0x7F, 0x03, 0x7F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x3E, 0x7F, 0x1F, 0xEF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xF1, 0xFE, 0xFE, 0x1F, 0xDF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xF0, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xE7, 0xE1, 0xF8, 0xFC, 0x03, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF9, 0xFC, 0xFE, 0x1F, 0x9F,
  0x81, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x9F, 0xF1, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0xFE, 0x03, 0xF8, 0x0F, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xC7, 0xE3, 0xFE, 0xFC, 0xFF, 0xDF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0xFE,
  0xFE, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFD, 0xFC,
  0x3F, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0xE0, 0x3F, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF3, 0xF0, 0xFE, 0xFF, 0x9F, 0xBF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC,
  0x7D, 0xFF, 0xFF, 0xF7, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x9F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE,
  0x3F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x7E, 0x0F, 0xE3, 0xF7, 0xFE, 0x7F, 0xCF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xCF,
  0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE,
  0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83,
  0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC,
  0x1F, 0xC0, 0xF8, 0x7E, 0x1F, 0xBF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xBF, 0x07, 0xF7, 0xE0, 0xFE, 0xFE, 0x1F, 0xDF, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x7E,
  0x3F, 0x3F, 0xCF, 0xDF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xEF, 0xE3, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x0F,
  0xC7, 0xE3, 0xFE, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE,
  0x1F, 0xDF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0xFE, 0xFE, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE3, 0xFD, 0xFC, 0x3F, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xF8, 0x7F, 0xF3, 0xEF, 0xDF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xEF, 0xE3, 0xDF,
  0xC0, 0xBF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF9,
  0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xF9, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFE, 0xFC, 0x7F, 0x1F, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x9F, 0x81,
  0xFC, 0xFE, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0xFE, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0xFC,
  0x1F, 0xC1, 0xF9, 0xF8, 0x7F, 0xC3, 0xF3, 0xF0, 0xFF, 0x8F, 0xE3, 0xF1,
  0xFF, 0x1F, 0x87, 0xE3, 0xDE, 0x3F, 0x0F, 0xCF, 0xBC, 0x7E, 0x1F, 0x9F,
  0x7C, 0xFC, 0x1F, 0xBE, 0xFB, 0xF0, 0x3F, 0x7D, 0xF7, 0xE0, 0x7E, 0xF3,
  0xEF, 0xC0, 0xFD, 0xE3, 0xDF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F,
  0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFB,
  0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0x3F, 0x9F, 0xC1, 0xFD, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x7F,
  0x07, 0xF1, 0xFC, 0x3F, 0x8F, 0xF3, 0xF8, 0x3F, 0xBF, 0xC0, 0xFE, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF0, 0x7E,
  0x1F, 0x87, 0xF0, 0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38,
  0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0x80,
  0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x07,
  0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F,
  0x07, 0xF8, 0x7F, 0xC7, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xC0,
  0x00, 0x7F, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x80,
  0xFE,
};

const GFXglyph NotoSans_Black34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 24, 10, 1, -24 },
  { 25, 14, 9, 18, 2, -24 },
  { 41, 21, 24, 23, 1, -24 },
  { 104, 18, 28, 20, 1, -26 },
  { 167, 31, 25, 32, 1, -25 },
  { 264, 26, 25, 27, 1, -25 },
  { 346, 6, 9, 10, 2, -24 },
  { 353, 10, 30, 12, 1, -25 },
  { 391, 10, 30, 12, 1, -25 },
  { 429, 17, 16, 18, 1, -26 },
  { 463, 16, 16, 20, 2, -20 },
  { 495, 8, 10, 11, 1, -5 },
  { 505, 9, 5, 11, 1, -12 },
  { 511, 7, 6, 10, 1, -6 },
  { 517, 15, 25, 15, 0, -25 },
  { 564, 18, 25, 20, 1, -25 },
  { 621, 15, 24, 20, 1, -24 },
  { 666, 18, 25, 20, 1, -25 },
  { 723, 18, 25, 20, 1, -25 },
  { 780, 18, 24, 20, 1, -24 },
  { 834, 16, 24, 20, 2, -24 },
  { 882, 18, 25, 20, 1, -25 },
  { 939, 18, 24, 20, 1, -24 },
  { 993, 18, 25, 20, 1, -25 },
  { 1050, 18, 25, 20, 1, -25 },
  { 1107, 7, 19, 10, 1, -19 },
  { 1124, 8, 24, 10, 1, -19 },
  { 1148, 16, 19, 20, 2, -22 },
  { 1186, 16, 12, 20, 2, -18 },
  { 1210, 16, 19, 20, 2, -22 },
  { 1248, 17, 25, 17, 0, -25 },
  { 1302, 28, 28, 31, 1, -25 },
  { 1400, 25, 24, 25, 0, -24 },
  { 1475, 18, 24, 23, 3, -24 },
  { 1529, 19, 25, 22, 2, -25 },
  { 1589, 20, 24, 25, 3, -24 },
  { 1649, 14, 24, 19, 3, -24 },
  { 1691, 14, 24, 18, 3, -24 },
  { 1733, 21, 25, 25, 2, -25 },
  { 1799, 20, 24, 26, 3, -24 },
  { 1859, 13, 24, 15, 1, -24 },
  { 1898, 12, 32, 12, -3, -24 },
  { 1946, 21, 24, 23, 3, -24 },
  { 2009, 16, 24, 20, 3, -24 },
  { 2057, 27, 24, 33, 3, -24 },
  { 2138, 23, 24, 28, 3, -24 },
  { 2207, 23, 25, 27, 2, -25 },
  { 2279, 17, 24, 21, 3, -24 },
  { 2330, 24, 31, 27, 2, -25 },
  { 2423, 20, 24, 23, 3, -24 },
  { 2483, 18, 25, 20, 1, -25 },
  { 2540, 18, 24, 20, 1, -24 },
  { 2594, 21, 24, 26, 2, -24 },
  { 2657, 24, 24, 24, 0, -24 },
  { 2729, 34, 24, 35, 1, -24 },
  { 2831, 24, 24, 25, 0, -24 },
  { 2903, 23, 24, 23, 0, -24 },
  { 2972, 19, 24, 21, 1, -24 },
  { 3029, 8, 31, 11, 2, -25 },
  { 3060, 15, 25, 15, 0, -25 },
  { 3107, 8, 31, 11, 1, -25 },
  { 3138, 18, 16, 18, 0, -24 },
  { 3174, 17, 4, 17, 0, 2 },
  { 3183, 12, 5, 14, 1, -26 },
  { 3191, 18, 19, 21, 1, -19 },
  { 3234, 18, 26, 22, 2, -26 },
  { 3293, 16, 19, 18, 1, -19 },
  { 3331, 19, 26, 22, 1, -26 },
  { 3393, 19, 19, 21, 1, -19 },
  { 3439, 14, 26, 14, 1, -26 },
  { 3485, 19, 27, 22, 1, -19 },
  { 3550, 19, 26, 23, 2, -26 },
  { 3612, 7, 26, 11, 2, -26 },
  { 3635, 11, 34, 11, -2, -26 },
  { 3682, 20, 26, 22, 2, -26 },
  { 3747, 7, 26, 11, 2, -26 },
  { 3770, 30, 19, 34, 2, -19 },
  { 3842, 19, 19, 23, 2, -19 },
  { 3888, 19, 19, 22, 1, -19 },
  { 3934, 18, 27, 22, 2, -19 },
  { 3995, 19, 27, 22, 1, -19 },
  { 4060, 14, 19, 16, 2, -19 },
  { 4094, 15, 19, 18, 1, -19 },
  { 4130, 14, 23, 16, 1, -23 },
  { 4171, 19, 19, 23, 2, -19 },
  { 4217, 21, 19, 21, 0, -19 },
  { 4267, 31, 19, 31, 0, -19 },
  { 4341, 21, 19, 21, 0, -19 },
  { 4391, 21, 27, 21, 0, -19 },
  { 4462, 15, 19, 17, 1, -19 },
  { 4498, 13, 31, 15, 1, -25 },
  { 4549, 5, 33, 17, 6, -26 },
  { 4570, 13, 31, 15, 1, -25 },
  { 4621, 16, 6, 20, 2, -15 },
};

const GFXfont NotoSans_Black34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black34pt7bBitmaps,
  (GFXglyph *)NotoSans_Black34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_BLACK34PT7B_H_
