#ifndef _NOTOSANS_BLACK38PT7B_H_
#define _NOTOSANS_BLACK38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x38, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0x7C, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xF8, 0xF8,
  0x01, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFE, 0xF3, 0xCF, 0xCF, 0x04, 0xFC, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0x7F, 0x00, 0xF3, 0xF4, 0x0F,
  0x3F, 0x7E, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x7C,
  0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF8, 0x0F, 0x80, 0x3F, 0x7E, 0x07,
  0xE0, 0x0F, 0x8F, 0x81, 0xF0, 0x03, 0xE3, 0xF0, 0xFC, 0x00, 0xF8, 0xFC,
  0x7E, 0x00, 0x3E, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0xCF, 0xC0, 0x03, 0xE3,
  0xE3, 0xE1, 0xE0, 0xFD, 0xF9, 0xF9, 0xFE, 0x3F, 0xFE, 0x7C, 0xFF, 0xC7,
  0xFF, 0x3F, 0x7F, 0xF8, 0xFF, 0xCF, 0x9F, 0xFF, 0x1F, 0xC7, 0xE7, 0xCF,
  0xC0, 0x83, 0xF3, 0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x7C, 0x00, 0x7E, 0x3F,
  0x1F, 0x00, 0x1F, 0x0F, 0xC7, 0xC0, 0x0F, 0xC3, 0xF1, 0xF0, 0x03, 0xE0,
  0x7C, 0xFC, 0x01, 0xF8, 0x1F, 0xBF, 0x00, 0x7C, 0x07, 0xFF, 0x80, 0x3F,
  0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xF0, 0x07, 0xC0, 0x03, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xC3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xE7, 0xF8, 0x7F,
  0xBF, 0xFF, 0xE1, 0xFC, 0x7F, 0xFF, 0x0F, 0xF0, 0xFF, 0xFC, 0x3F, 0xC1,
  0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F,
  0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E,
  0x7C, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xC3, 0xC3, 0xBF, 0xFB, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xEF, 0xC1, 0xF9, 0xFC, 0x1F, 0x1E, 0x00, 0xC3, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x9F, 0x8F,
  0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xDF, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF0, 0xFF, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x0F,
  0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFC, 0xE3, 0xF8, 0x87, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xE0, 0xFE, 0x18, 0x0F,
  0xE1, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0x3F, 0xE1, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7E, 0xFE,
  0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0x83, 0xFB, 0xFC, 0x1F, 0x9F, 0xE1, 0xF8,
  0xFF, 0x1F, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE8, 0x03, 0xFD, 0xF9,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xF0, 0x23, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x3F, 0x07, 0xEF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xDF, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x9F, 0xEF,
  0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0x7F, 0x07, 0xC7, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x20, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x3E,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x1F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1,
  0xF8, 0xF8, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x01, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0x8F, 0xF1, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x70, 0x3E, 0x1F, 0x0F,
  0xFF, 0x7E, 0x7C, 0x3F, 0xFE, 0x7C, 0xF8, 0xFF, 0xFC, 0xFB, 0xE3, 0xFC,
  0xF9, 0xF7, 0xC7, 0xC1, 0xF1, 0xEF, 0x9F, 0x83, 0xE3, 0xFF, 0x3E, 0x07,
  0xC7, 0xFE, 0x7C, 0x1F, 0x8F, 0x7C, 0xF8, 0x3F, 0x3E, 0xF9, 0xF0, 0x7E,
  0x7D, 0xF3, 0xF0, 0xFC, 0xFB, 0xE7, 0xF7, 0xFB, 0xE7, 0xC7, 0xFF, 0xFF,
  0xCF, 0x87, 0xFF, 0xFF, 0x1F, 0x87, 0xF9, 0xFC, 0x1F, 0x83, 0x80, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x00, 0x3F, 0xF1, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x3F,
  0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x1F, 0xFB, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE,
  0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFE, 0x0F, 0xF7,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF8, 0x06, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x18,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF,
  0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0,
  0x3F, 0xEF, 0xE0, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xC0, 0x08, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80,
  0x7F, 0x7F, 0xC0, 0x7F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F,
  0xE0, 0x70, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x1F, 0xE7,
  0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F,
  0x1F, 0xE0, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xFB, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xFE, 0x7F, 0x03, 0xFC,
  0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFF, 0xF7, 0xE0, 0xFB, 0xFF, 0xEF, 0xC1, 0xF7, 0xFF, 0xCF, 0x87, 0xEF,
  0xFF, 0x9F, 0x8F, 0xDF, 0xFF, 0x3F, 0x1F, 0x3F, 0xFE, 0x7E, 0x3E, 0x7F,
  0xFC, 0x7E, 0xFC, 0xFF, 0xF8, 0xFD, 0xF1, 0xFF, 0xF1, 0xFB, 0xE3, 0xFF,
  0xE1, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x87, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFC, 0x3F, 0xFE, 0x0F, 0xF8, 0x7F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF8,
  0x3F, 0xC1, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xFC, 0x1F,
  0xFF, 0x7F, 0x87, 0xFF, 0xCF, 0xE1, 0xFF, 0xF3, 0xFC, 0x7F, 0xFC, 0x7F,
  0x1F, 0xFF, 0x1F, 0xE7, 0xFF, 0xC3, 0xF9, 0xFF, 0xF0, 0xFF, 0x7F, 0xFC,
  0x1F, 0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0xF9, 0xFF, 0x03,
  0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xF0, 0x3F, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x1F, 0xEF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE,
  0xFF, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xCF, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC,
  0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF1, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFC, 0xFF,
  0x03, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE,
  0x3F, 0x83, 0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xFD, 0xFC, 0x07, 0xFB,
  0xF8, 0x07, 0xF8, 0x00, 0x60, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xE7, 0xE7, 0xF0, 0x0C, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07,
  0xFD, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81,
  0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xBF, 0x80, 0x7F,
  0x80, 0xFE, 0x7F, 0x03, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF8, 0x0F, 0xE7,
  0xF0, 0x3F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xFF,
  0x07, 0xF0, 0xFE, 0x1F, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0xF8, 0xFE, 0x0F,
  0xE1, 0xF7, 0xE3, 0xF8, 0x1F, 0x8F, 0xDF, 0x8F, 0xE0, 0x7F, 0x3F, 0x3E,
  0x3F, 0x81, 0xFC, 0xFC, 0xF8, 0xFC, 0x07, 0xF3, 0xF3, 0xF7, 0xF0, 0x0F,
  0xCF, 0x8F, 0xDF, 0xC0, 0x3F, 0x7E, 0x3F, 0x7F, 0x00, 0xFF, 0xF8, 0x7D,
  0xF8, 0x03, 0xFF, 0xE1, 0xF7, 0xE0, 0x07, 0xFF, 0x07, 0xDF, 0x80, 0x1F,
  0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x0F, 0xF8, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFE, 0x00,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F,
  0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7,
  0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0xFB, 0xE0, 0x0F, 0xBF, 0x01, 0xF9, 0xF0, 0x1F, 0x1F, 0x83, 0xF0, 0xF8,
  0x3E, 0x0F, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0x07, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xFF, 0xF1, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFB, 0xF3,
  0xFF, 0xBF, 0x1F, 0xE1, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x7F, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFB, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xDF, 0xF8, 0xF8, 0x7F, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xF3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xF3, 0xCF, 0xF0, 0x13, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x1B, 0xFF, 0x3E, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xE7, 0xF3, 0xFF, 0x7F, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0x3F, 0x0F, 0xE3, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0E, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x03, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xE4,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF1, 0xFF, 0x7F, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF9, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0x7F,
  0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF4, 0x00, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x7F, 0x8F,
  0xEF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xF0, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x07, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFC, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xE1, 0xFF, 0x3F, 0x87,
  0xF8, 0xFE, 0x3F, 0xC3, 0xF9, 0xFE, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80,
  0xFD, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF8, 0xFE, 0x1F,
  0xE3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0x3F, 0x81, 0xFE, 0xFE, 0x07, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0xFF, 0x87, 0xF8, 0x7E, 0xFF, 0xE7, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC,
  0xFF, 0xE7, 0xFB, 0xFC, 0x3F, 0xE1, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x83, 0xFF,
  0xF8, 0x3F, 0xC1, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0xF8, 0x7F, 0x8F, 0xDF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0x87, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xFC,
  0x1F, 0xCF, 0xF1, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x7F, 0x0F, 0xCF, 0xF8, 0xFD,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFE, 0xFF, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE3, 0xF3,
  0xFF, 0x7F, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF9,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0x7F, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xF8, 0x7F, 0xE3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE,
  0x04, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x31, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xEF, 0xFB, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0x7E, 0x3F, 0xF3, 0xF0, 0xFF,
  0x1F, 0x80, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xFC,
  0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x9F, 0x80, 0x7F, 0x7F,
  0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xDF, 0xC1, 0xFF, 0x07, 0xF7,
  0xF0, 0x7F, 0xC1, 0xF9, 0xFC, 0x1F, 0xF0, 0xFE, 0x3F, 0x8F, 0xFC, 0x3F,
  0x8F, 0xE3, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0xE3, 0xF0, 0xFE, 0x3E, 0xF9,
  0xFC, 0x1F, 0x9F, 0xBE, 0x7F, 0x07, 0xF7, 0xCF, 0x9F, 0xC1, 0xFD, 0xF3,
  0xF7, 0xE0, 0x3F, 0x7C, 0xFD, 0xF8, 0x0F, 0xDF, 0x1F, 0x7E, 0x03, 0xF7,
  0xC7, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE,
  0x7F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF8,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0xFF, 0x81, 0xFF,
  0xFF, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xFC, 0x0F, 0xE3,
  0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7E,
  0xFE, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x04, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x87, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xA0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Black38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 27, 11, 2, -27 },
  { 28, 16, 10, 20, 2, -27 },
  { 48, 23, 27, 25, 1, -27 },
  { 126, 20, 31, 22, 1, -29 },
  { 204, 34, 28, 36, 1, -28 },
  { 323, 30, 27, 30, 1, -27 },
  { 425, 7, 10, 11, 2, -27 },
  { 434, 12, 34, 14, 1, -28 },
  { 485, 11, 34, 14, 1, -28 },
  { 532, 19, 18, 20, 1, -29 },
  { 575, 19, 19, 22, 2, -23 },
  { 621, 9, 11, 12, 1, -6 },
  { 634, 10, 6, 12, 1, -13 },
  { 642, 7, 7, 11, 2, -7 },
  { 649, 17, 28, 17, 0, -28 },
  { 709, 20, 28, 22, 1, -28 },
  { 779, 15, 27, 22, 2, -27 },
  { 830, 20, 28, 22, 1, -28 },
  { 900, 20, 28, 22, 1, -28 },
  { 970, 21, 27, 22, 1, -27 },
  { 1041, 19, 27, 22, 2, -27 },
  { 1106, 20, 28, 22, 1, -28 },
  { 1176, 20, 27, 22, 1, -27 },
  { 1244, 20, 28, 22, 1, -28 },
  { 1314, 20, 28, 22, 1, -28 },
  { 1384, 7, 21, 11, 2, -21 },
  { 1403, 9, 26, 11, 1, -21 },
  { 1433, 18, 21, 22, 2, -24 },
  { 1481, 19, 13, 22, 2, -20 },
  { 1512, 18, 21, 22, 2, -24 },
  { 1560, 19, 28, 19, 0, -28 },
  { 1627, 31, 30, 34, 2, -27 },
  { 1744, 28, 27, 28, 0, -27 },
  { 1839, 21, 27, 26, 3, -27 },
  { 1910, 21, 28, 25, 2, -28 },
  { 1984, 23, 27, 28, 3, -27 },
  { 2062, 16, 27, 21, 3, -27 },
  { 2116, 16, 27, 20, 3, -27 },
  { 2170, 24, 28, 28, 2, -28 },
  { 2254, 23, 27, 29, 3, -27 },
  { 2332, 14, 27, 17, 1, -27 },
  { 2380, 13, 36, 13, -3, -27 },
  { 2439, 23, 27, 26, 3, -27 },
  { 2517, 18, 27, 22, 3, -27 },
  { 2578, 31, 27, 37, 3, -27 },
  { 2683, 26, 27, 32, 3, -27 },
  { 2771, 26, 28, 30, 2, -28 },
  { 2862, 20, 27, 24, 3, -27 },
  { 2930, 27, 34, 30, 2, -28 },
  { 3045, 23, 27, 26, 3, -27 },
  { 3123, 19, 28, 22, 2, -28 },
  { 3190, 21, 27, 22, 1, -27 },
  { 3261, 23, 27, 29, 3, -27 },
  { 3339, 26, 27, 26, 0, -27 },
  { 3427, 38, 27, 39, 1, -27 },
  { 3556, 27, 27, 27, 0, -27 },
  { 3648, 25, 27, 25, 0, -27 },
  { 3733, 21, 27, 23, 1, -27 },
  { 3804, 9, 34, 12, 2, -28 },
  { 3843, 17, 28, 17, 0, -28 },
  { 3903, 9, 34, 12, 1, -28 },
  { 3942, 20, 18, 20, 0, -27 },
  { 3987, 19, 5, 19, 0, 2 },
  { 3999, 12, 6, 16, 2, -29 },
  { 4008, 20, 21, 24, 1, -21 },
  { 4061, 20, 29, 24, 3, -29 },
  { 4134, 18, 21, 20, 2, -21 },
  { 4182, 20, 29, 24, 2, -29 },
  { 4255, 20, 21, 23, 2, -21 },
  { 4308, 16, 29, 16, 1, -29 },
  { 4366, 20, 30, 24, 2, -21 },
  { 4441, 20, 29, 25, 3, -29 },
  { 4514, 8, 29, 12, 2, -29 },
  { 4543, 12, 38, 12, -2, -29 },
  { 4600, 22, 29, 25, 3, -29 },
  { 4680, 7, 29, 12, 3, -29 },
  { 4706, 33, 21, 38, 3, -21 },
  { 4793, 20, 21, 25, 3, -21 },
  { 4846, 21, 21, 24, 2, -21 },
  { 4902, 20, 30, 24, 3, -21 },
  { 4977, 20, 30, 24, 2, -21 },
  { 5052, 14, 21, 18, 3, -21 },
  { 5089, 16, 21, 20, 2, -21 },
  { 5131, 15, 25, 17, 1, -25 },
  { 5178, 21, 21, 25, 2, -21 },
  { 5234, 23, 21, 23, 0, -21 },
  { 5295, 34, 21, 35, 0, -21 },
  { 5385, 24, 21, 24, 0, -21 },
  { 5448, 23, 30, 23, 0, -21 },
  { 5535, 17, 21, 19, 1, -21 },
  { 5580, 14, 34, 16, 1, -28 },
  { 5640, 5, 37, 19, 7, -29 },
  { 5664, 14, 34, 16, 1, -28 },
  { 5724, 19, 7, 22, 2, -17 },
};

const GFXfont NotoSans_Black38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black38pt7bBitmaps,
  (GFXglyph *)NotoSans_Black38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_BLACK38PT7B_H_
