#ifndef _NOTOSANS_BLACK26PT7B_H_
#define _NOTOSANS_BLACK26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x00, 0x02,
  0x3E, 0xFB, 0xE7, 0x80, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3C, 0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x79, 0xC3,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x9C, 0x03, 0x9E,
  0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x79, 0xC0, 0x38, 0xE0, 0x1C,
  0xF0, 0x0E, 0x78, 0x0F, 0x38, 0x00, 0x07, 0x00, 0x38, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xDC, 0x5E, 0xE0, 0xFF, 0x07, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0x83, 0xBE, 0x1D, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF8, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x3F, 0x81, 0xE0,
  0x7F, 0x83, 0xC0, 0x7B, 0xC3, 0xC0, 0x73, 0xC7, 0x80, 0xF3, 0xC7, 0x80,
  0xF3, 0xCF, 0x00, 0x73, 0xCE, 0x00, 0x7B, 0xDE, 0xFC, 0x7F, 0xBC, 0xFE,
  0x3F, 0xBD, 0xFF, 0x0E, 0x79, 0xEF, 0x00, 0x79, 0xCF, 0x00, 0xF1, 0xCF,
  0x00, 0xF1, 0xCF, 0x01, 0xE1, 0xEF, 0x01, 0xC1, 0xFF, 0x03, 0xC0, 0xFE,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xEF,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x3E, 0x7F, 0xE7, 0xCF, 0xFF, 0x7C, 0xF9, 0xFF, 0xCF,
  0x8F, 0xF8, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x3E, 0x3C, 0x7C, 0x78,
  0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8,
  0x78, 0x78, 0x7C, 0x3C, 0x3E, 0x1F, 0xF0, 0xF1, 0xF1, 0xE3, 0xC7, 0xCF,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x7C, 0xF1, 0xE7,
  0xCF, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xF1, 0xF6, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF0, 0x1F, 0x83, 0xFC, 0x79, 0xE3, 0x9C, 0x09, 0x00, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x7D, 0xE7, 0xBE,
  0xF3, 0xCF, 0x38, 0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0xFF, 0xF7, 0x80, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xDF, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xEF, 0xFE, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x03, 0xE0, 0xFC,
  0x3F, 0x8F, 0xF7, 0xFF, 0xFF, 0xDE, 0xF9, 0x9F, 0x23, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0x0F, 0x81, 0xFF, 0x3F, 0xFD, 0xFF, 0xF7, 0x9F, 0x90, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xFF, 0x3F, 0xFC,
  0xFF, 0xF7, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x1F, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xFE, 0x0F, 0x7C, 0x1E, 0xF8, 0x79, 0xF1, 0xF3, 0xE3, 0xC7,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3C, 0x01,
  0xE0, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x03, 0xF0, 0x7F,
  0x87, 0xFC, 0x7F, 0xE7, 0xE0, 0x3C, 0x03, 0xE0, 0x1F, 0x7C, 0xF7, 0xF7,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x7F, 0xE3, 0xEF, 0xFF, 0x7F,
  0xF1, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0x8F, 0xFC, 0x7D, 0xF7, 0xEF, 0xFE,
  0x3F, 0xE0, 0xFE, 0x1F, 0xFC, 0xFB, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF,
  0xBF, 0xFF, 0xFB, 0xFF, 0x8F, 0xF8, 0x0F, 0x01, 0xFF, 0x1F, 0xFD, 0xFF,
  0xEF, 0xDF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xDF, 0xFE,
  0xFE, 0xF1, 0xE7, 0x80, 0x7C, 0x07, 0xCF, 0xFE, 0x7F, 0xE3, 0xFE, 0x1F,
  0xC0, 0x27, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x09, 0xFF, 0xFD, 0xE0, 0x33,
  0xEF, 0xBE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x79, 0xEF, 0xBC, 0xF3,
  0xCE, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7F, 0x0F, 0xE1,
  0xFC, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0x80,
  0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x7F, 0x9F, 0xF1,
  0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x0F, 0x83, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE7, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xE0, 0x1F, 0x80, 0xF8,
  0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x07,
  0xC3, 0xC0, 0x0F, 0x3C, 0x7F, 0xBD, 0xE7, 0xFD, 0xEE, 0x7F, 0xE7, 0xF7,
  0x8F, 0x3F, 0xBC, 0x79, 0xFD, 0xE3, 0xCF, 0xEF, 0x1E, 0x7F, 0x78, 0xF7,
  0xF9, 0xFF, 0xFB, 0xCF, 0xFF, 0xCF, 0x3E, 0x78, 0x7C, 0x00, 0x01, 0xF0,
  0x0C, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x78,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x7E, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0xBE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xE7, 0xF1, 0xCF, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x81, 0x1F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFB, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0x8E,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0x7C, 0x0F, 0x7C, 0x0F, 0x7E, 0x0F, 0x3F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFE, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFF, 0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xF8,
  0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB,
  0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD,
  0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8,
  0x3F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xDC, 0x1D,
  0xFE, 0xF1, 0xEF, 0xF7, 0x8F, 0x7F, 0xBC, 0x7B, 0xFC, 0xF3, 0x9F, 0xE7,
  0xBC, 0xFF, 0x3D, 0xE7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF1, 0xFE, 0x3F, 0x8F,
  0xF1, 0xFC, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1E, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x7C, 0x7F,
  0xDF, 0x1F, 0xF3, 0xE7, 0xFC, 0xF9, 0xFF, 0x1F, 0x7F, 0xC7, 0xDF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7F, 0x3F, 0x9F, 0x83, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xF7, 0xE1,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFE, 0x07,
  0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xCF, 0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xF3, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E,
  0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x1F, 0x9F, 0x87, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC,
  0xF8, 0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFB, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E,
  0xF8, 0x3F, 0x07, 0xC1, 0xFF, 0xDF, 0xFE, 0xFF, 0xEF, 0xC7, 0x7C, 0x03,
  0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x80,
  0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xFC, 0x0F, 0xFF,
  0x03, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7E, 0x1F, 0x8F, 0x87, 0xC3, 0xE1,
  0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x79, 0xF0,
  0x7C, 0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x7C, 0x78, 0x7F, 0x0F,
  0x0F, 0x8F, 0xE3, 0xE1, 0xF1, 0xDC, 0x7C, 0x3E, 0x7B, 0xCF, 0x83, 0xCF,
  0x79, 0xE0, 0x79, 0xEF, 0x3C, 0x0F, 0xBD, 0xEF, 0x81, 0xFF, 0x1D, 0xF0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x07, 0xCF,
  0xC1, 0xF8, 0xF8, 0x7E, 0x1F, 0x8F, 0x81, 0xF3, 0xF0, 0x1F, 0x7C, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xEF, 0xC1, 0xF8, 0xF8, 0x3E,
  0x1F, 0x8F, 0xC1, 0xFB, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xBE, 0x0F, 0xDF,
  0x07, 0xC7, 0xC7, 0xE3, 0xE3, 0xE0, 0xFB, 0xF0, 0x7D, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0xC0, 0x77, 0x01, 0xDE, 0x0F, 0x38, 0x38, 0xF1, 0xE1, 0xC7, 0x07, 0xBC,
  0x0E, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x07, 0xC1,
  0xF0, 0x03, 0x81, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x10, 0xF8, 0x01, 0xF1,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x8F, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xF3, 0xF3, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE6, 0x0F, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xF3, 0xEF, 0x8F, 0xBE,
  0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xBE, 0x3E, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0x3C, 0xF8, 0x03, 0x81, 0xFF, 0x3F, 0xF7, 0xFF, 0x7E, 0x6F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x17, 0xFF, 0x7F, 0xF3, 0xFF,
  0x1F, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x11,
  0xF3, 0xF7, 0xDF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7,
  0xCF, 0x03, 0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x7F, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x8E, 0x7F, 0xF8,
  0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0x87, 0xF3, 0xFC, 0xFF, 0x3E, 0x0F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xDF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x06, 0x00, 0xFC, 0xF7, 0xFF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC7,
  0xDF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xF7, 0xC0, 0x1F, 0x40, 0x7D, 0xFF,
  0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE3, 0x0F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFB, 0xF3, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF7, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x1F, 0x1F, 0x1E, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3F, 0xFF, 0xFE, 0xFE, 0xFC, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x1F, 0x7C, 0x7C, 0xF9,
  0xF1, 0xF7, 0xE3, 0xFF, 0x87, 0xBE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC,
  0x7C, 0xF8, 0xF9, 0xF9, 0xF1, 0xFB, 0xE1, 0xF7, 0xC3, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0xC3, 0xDF, 0xCF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0xFF, 0xE3, 0xF1, 0xFF, 0x87, 0xC7, 0xFE, 0x1F, 0x1F, 0xF8, 0x7C, 0x7F,
  0xE1, 0xF1, 0xFF, 0x87, 0xC7, 0xFE, 0x1F, 0x1F, 0xF8, 0x7C, 0x7F, 0xE1,
  0xF1, 0xFF, 0x87, 0xC7, 0xC0, 0x00, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE,
  0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xC0, 0x03, 0x80, 0x7F, 0x83,
  0xFF, 0x9F, 0xFE, 0x7C, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0xC7, 0xDF, 0xFF, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0x00,
  0x83, 0xDF, 0xCF, 0xFF, 0x3F, 0xFE, 0xFD, 0xFB, 0xE3, 0xEF, 0x8F, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE3, 0xEF, 0x8F, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF,
  0xBE, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0xFC, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC7, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF,
  0xF1, 0xF7, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xFC, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x06, 0x07, 0xFD, 0xFF,
  0xFF, 0xFF, 0x85, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFE, 0x07, 0xF9,
  0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x1C, 0x0F, 0x03, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF7, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xF3, 0xFC,
  0xFF, 0x1F, 0xC0, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFC, 0xFC, 0xF0, 0xF8, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x7E, 0x3E, 0xF8,
  0xFC, 0x7D, 0xF3, 0xF8, 0xFB, 0xE7, 0xF1, 0xE3, 0xCF, 0xF7, 0xC7, 0x9D,
  0xEF, 0x8F, 0xBB, 0xDE, 0x1F, 0xF3, 0xBC, 0x1F, 0xE7, 0x78, 0x3F, 0xCF,
  0xF0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x3E, 0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7C, 0x3E,
  0x7E, 0x7E, 0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C,
  0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x87, 0xC7, 0xE3, 0xF1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x3F, 0x1F, 0x0F, 0xC7, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF8, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x7C, 0x3F, 0x1F, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x87, 0xE0, 0xF1, 0xF8, 0xFC, 0xF8, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x8F, 0xC7, 0xE3, 0xE0, 0x18, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x00,
};

const GFXglyph NotoSans_Black26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 19, 8, 1, -19 },
  { 16, 10, 7, 14, 2, -19 },
  { 25, 17, 19, 17, 0, -19 },
  { 66, 13, 22, 15, 1, -20 },
  { 102, 24, 19, 25, 0, -19 },
  { 159, 20, 19, 21, 1, -19 },
  { 207, 4, 7, 8, 2, -19 },
  { 211, 8, 23, 9, 1, -19 },
  { 234, 7, 23, 9, 1, -19 },
  { 255, 12, 13, 14, 1, -20 },
  { 275, 13, 13, 15, 1, -16 },
  { 297, 6, 8, 8, 1, -4 },
  { 303, 7, 4, 8, 1, -9 },
  { 307, 5, 5, 8, 1, -5 },
  { 311, 11, 19, 11, 0, -19 },
  { 338, 13, 19, 15, 1, -19 },
  { 369, 11, 19, 15, 1, -19 },
  { 396, 13, 19, 15, 1, -19 },
  { 427, 13, 19, 15, 1, -19 },
  { 458, 15, 19, 15, 0, -19 },
  { 494, 13, 19, 15, 1, -19 },
  { 525, 13, 19, 15, 1, -19 },
  { 556, 13, 19, 15, 1, -19 },
  { 587, 13, 19, 15, 1, -19 },
  { 618, 13, 19, 15, 1, -19 },
  { 649, 5, 15, 8, 1, -15 },
  { 659, 6, 19, 8, 1, -15 },
  { 674, 13, 15, 15, 1, -17 },
  { 699, 13, 9, 15, 1, -14 },
  { 714, 13, 15, 15, 1, -17 },
  { 739, 13, 19, 13, 0, -19 },
  { 770, 21, 21, 23, 1, -19 },
  { 826, 19, 19, 19, 0, -19 },
  { 872, 14, 19, 18, 2, -19 },
  { 906, 15, 19, 17, 1, -19 },
  { 942, 16, 19, 19, 2, -19 },
  { 980, 11, 19, 14, 2, -19 },
  { 1007, 11, 19, 14, 2, -19 },
  { 1034, 16, 19, 19, 1, -19 },
  { 1072, 16, 19, 20, 2, -19 },
  { 1110, 10, 19, 11, 1, -19 },
  { 1134, 9, 25, 9, -2, -19 },
  { 1163, 16, 19, 18, 2, -19 },
  { 1201, 12, 19, 15, 2, -19 },
  { 1230, 21, 19, 25, 2, -19 },
  { 1280, 18, 19, 22, 2, -19 },
  { 1323, 18, 19, 21, 1, -19 },
  { 1366, 13, 19, 16, 2, -19 },
  { 1397, 19, 23, 21, 1, -19 },
  { 1452, 16, 19, 18, 2, -19 },
  { 1490, 13, 19, 15, 1, -19 },
  { 1521, 14, 19, 15, 1, -19 },
  { 1555, 16, 19, 20, 2, -19 },
  { 1593, 18, 19, 18, 0, -19 },
  { 1636, 27, 19, 27, 0, -19 },
  { 1701, 19, 19, 19, 0, -19 },
  { 1747, 17, 19, 17, 0, -19 },
  { 1788, 14, 19, 16, 1, -19 },
  { 1822, 7, 23, 8, 1, -19 },
  { 1843, 11, 19, 11, 0, -19 },
  { 1870, 6, 23, 8, 1, -19 },
  { 1888, 14, 13, 14, 0, -19 },
  { 1911, 13, 3, 13, 0, 2 },
  { 1916, 9, 4, 11, 1, -20 },
  { 1921, 14, 15, 16, 1, -15 },
  { 1948, 14, 20, 17, 2, -20 },
  { 1983, 12, 15, 14, 1, -15 },
  { 2006, 14, 20, 17, 1, -20 },
  { 2041, 14, 15, 16, 1, -15 },
  { 2068, 10, 20, 11, 1, -20 },
  { 2093, 14, 21, 17, 1, -15 },
  { 2130, 14, 20, 17, 2, -20 },
  { 2165, 5, 20, 8, 2, -20 },
  { 2178, 8, 26, 8, -1, -20 },
  { 2204, 15, 20, 17, 2, -20 },
  { 2242, 5, 20, 8, 2, -20 },
  { 2255, 22, 15, 26, 2, -15 },
  { 2297, 14, 15, 17, 2, -15 },
  { 2324, 14, 15, 17, 1, -15 },
  { 2351, 14, 21, 17, 2, -15 },
  { 2388, 14, 21, 17, 1, -15 },
  { 2425, 10, 15, 12, 2, -15 },
  { 2444, 11, 15, 13, 1, -15 },
  { 2465, 10, 17, 12, 1, -17 },
  { 2487, 14, 14, 17, 2, -14 },
  { 2512, 16, 14, 16, 0, -14 },
  { 2540, 23, 14, 24, 0, -14 },
  { 2581, 16, 14, 16, 0, -14 },
  { 2609, 16, 20, 16, 0, -14 },
  { 2649, 12, 14, 13, 1, -14 },
  { 2670, 9, 23, 11, 1, -19 },
  { 2696, 3, 26, 13, 5, -20 },
  { 2706, 9, 23, 11, 1, -19 },
  { 2732, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_Black26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black26pt7bBitmaps,
  (GFXglyph *)NotoSans_Black26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_BLACK26PT7B_H_
