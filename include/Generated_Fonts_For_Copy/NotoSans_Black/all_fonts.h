#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Black
// Headers: 67

#include "NotoSans_Black6pt7b.h"
#include "NotoSans_Black7pt7b.h"
#include "NotoSans_Black8pt7b.h"
#include "NotoSans_Black9pt7b.h"
#include "NotoSans_Black10pt7b.h"
#include "NotoSans_Black11pt7b.h"
#include "NotoSans_Black12pt7b.h"
#include "NotoSans_Black13pt7b.h"
#include "NotoSans_Black14pt7b.h"
#include "NotoSans_Black15pt7b.h"
#include "NotoSans_Black16pt7b.h"
#include "NotoSans_Black17pt7b.h"
#include "NotoSans_Black18pt7b.h"
#include "NotoSans_Black19pt7b.h"
#include "NotoSans_Black20pt7b.h"
#include "NotoSans_Black21pt7b.h"
#include "NotoSans_Black22pt7b.h"
#include "NotoSans_Black23pt7b.h"
#include "NotoSans_Black24pt7b.h"
#include "NotoSans_Black25pt7b.h"
#include "NotoSans_Black26pt7b.h"
#include "NotoSans_Black27pt7b.h"
#include "NotoSans_Black28pt7b.h"
#include "NotoSans_Black29pt7b.h"
#include "NotoSans_Black30pt7b.h"
#include "NotoSans_Black31pt7b.h"
#include "NotoSans_Black32pt7b.h"
#include "NotoSans_Black33pt7b.h"
#include "NotoSans_Black34pt7b.h"
#include "NotoSans_Black35pt7b.h"
#include "NotoSans_Black36pt7b.h"
#include "NotoSans_Black37pt7b.h"
#include "NotoSans_Black38pt7b.h"
#include "NotoSans_Black39pt7b.h"
#include "NotoSans_Black40pt7b.h"
#include "NotoSans_Black41pt7b.h"
#include "NotoSans_Black42pt7b.h"
#include "NotoSans_Black43pt7b.h"
#include "NotoSans_Black44pt7b.h"
#include "NotoSans_Black45pt7b.h"
#include "NotoSans_Black46pt7b.h"
#include "NotoSans_Black47pt7b.h"
#include "NotoSans_Black48pt7b.h"
#include "NotoSans_Black49pt7b.h"
#include "NotoSans_Black50pt7b.h"
#include "NotoSans_Black51pt7b.h"
#include "NotoSans_Black52pt7b.h"
#include "NotoSans_Black53pt7b.h"
#include "NotoSans_Black54pt7b.h"
#include "NotoSans_Black55pt7b.h"
#include "NotoSans_Black56pt7b.h"
#include "NotoSans_Black57pt7b.h"
#include "NotoSans_Black58pt7b.h"
#include "NotoSans_Black59pt7b.h"
#include "NotoSans_Black60pt7b.h"
#include "NotoSans_Black61pt7b.h"
#include "NotoSans_Black62pt7b.h"
#include "NotoSans_Black63pt7b.h"
#include "NotoSans_Black64pt7b.h"
#include "NotoSans_Black65pt7b.h"
#include "NotoSans_Black66pt7b.h"
#include "NotoSans_Black67pt7b.h"
#include "NotoSans_Black68pt7b.h"
#include "NotoSans_Black69pt7b.h"
#include "NotoSans_Black70pt7b.h"
#include "NotoSans_Black71pt7b.h"
#include "NotoSans_Black72pt7b.h"
