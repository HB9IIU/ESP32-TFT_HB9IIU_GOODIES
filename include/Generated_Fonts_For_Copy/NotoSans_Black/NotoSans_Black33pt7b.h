#ifndef _NOTOSANS_BLACK33PT7B_H_
#define _NOTOSANS_BLACK33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x00, 0x00, 0xE3, 0xFF, 0xFF, 0xDF, 0xBE, 0xFC, 0xFF,
  0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xEF, 0x1F, 0x78,
  0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x87, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF1, 0xE0,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xFE, 0x07, 0xFF, 0xF7, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xF3, 0x8C, 0xF9, 0xC0, 0x7E, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x01,
  0xDF, 0x80, 0xE7, 0xF0, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xC0, 0x3F, 0xF8,
  0x1F, 0x00, 0xFB, 0xE0, 0xF8, 0x03, 0xE7, 0xC3, 0xE0, 0x0F, 0x1F, 0x1F,
  0x00, 0x3C, 0x7C, 0x7C, 0x00, 0xF1, 0xF3, 0xE0, 0x03, 0xE7, 0xCF, 0x04,
  0x0F, 0xBE, 0x7C, 0xFE, 0x3F, 0xF9, 0xE7, 0xFC, 0x7F, 0xEF, 0xBF, 0xF8,
  0xFF, 0x7C, 0xFB, 0xE0, 0xF1, 0xF3, 0xE7, 0x80, 0x0F, 0x8F, 0x1F, 0x00,
  0x3E, 0x3C, 0x7C, 0x01, 0xF0, 0xF1, 0xF0, 0x07, 0x83, 0xC7, 0xC0, 0x3E,
  0x0F, 0x9E, 0x00, 0xF0, 0x3F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x01,
  0xFF, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0xFC, 0x3F, 0xF8, 0x7F, 0x1F,
  0xFF, 0x9F, 0x87, 0xFF, 0xFF, 0xE3, 0xF9, 0xFF, 0xF8, 0xFE, 0x3F, 0xFC,
  0x3F, 0x87, 0xFF, 0x0F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFB, 0xEF, 0x9E, 0x78, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E,
  0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC,
  0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xC3, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0xFC, 0x7E, 0x7C,
  0x1C, 0x78, 0x04, 0x20, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x7C, 0xF9, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0xFE, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF, 0x1F, 0xDF, 0x8F,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x3E, 0xFC, 0xF3, 0xF1, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0xFE, 0x20, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xE3, 0xF8, 0x80, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x83, 0xF7, 0xE0,
  0xF9, 0xF8, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7B, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x78,
  0x7E, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xDF, 0x87, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xFD,
  0xF8, 0x7E, 0xFC, 0x7E, 0x7F, 0x7F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xFD, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xF8,
  0x1F, 0xF0, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF7, 0xF1, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x7C, 0xFF, 0xFF, 0xF7, 0xE7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x8F, 0xFF, 0xFF, 0x7E, 0xF8, 0x7E, 0xFF, 0xFB,
  0xF7, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0x7C,
  0xF9, 0xF3, 0xEF, 0x9F, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x07, 0xF0, 0x3F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x38, 0x3F,
  0x20, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0x83, 0xF9, 0xF1,
  0xF1, 0xFF, 0xDF, 0x7C, 0x7F, 0xF9, 0xEF, 0x9F, 0xFF, 0x3D, 0xE7, 0xC3,
  0xE7, 0xBC, 0xF8, 0x7C, 0xFF, 0x9E, 0x0F, 0x1F, 0xF3, 0xC1, 0xE3, 0xFE,
  0x78, 0x3C, 0x7F, 0xCF, 0x8F, 0x9F, 0xF9, 0xF3, 0xFB, 0xCF, 0x1F, 0xFF,
  0xF9, 0xF3, 0xFF, 0xFE, 0x3E, 0x3F, 0x9F, 0x83, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x08, 0x07, 0xF8, 0x1F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xEF,
  0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFF, 0x40, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x1F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF,
  0xC3, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0xFE,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xF3, 0xE7,
  0xF0, 0x0B, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x19, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFC, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x1F, 0xEF, 0xC0, 0xFE,
  0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC1,
  0xFE, 0xFC, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xFE, 0x3C, 0x7F, 0x00, 0x4F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x7F, 0x83,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFC, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00,
  0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F,
  0x8F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xCF, 0xE0, 0xFD, 0xFC, 0x0F, 0xDF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xEF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F,
  0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xF7, 0xFE, 0xF8, 0x7D, 0xFF, 0xBE, 0x1F, 0x7F, 0xEF, 0x87, 0x9F,
  0xF9, 0xF3, 0xE7, 0xFE, 0x7C, 0xF9, 0xFF, 0x9F, 0x3E, 0x7F, 0xE7, 0xCF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xE1,
  0xFE, 0x1F, 0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0xE1, 0xFF, 0x87, 0xF0, 0x7F,
  0xE0, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFB, 0xF0, 0xFF, 0xEF, 0xE3, 0xFF, 0x9F, 0x8F, 0xFE, 0x7F, 0x3F,
  0xF8, 0xFC, 0xFF, 0xE3, 0xFB, 0xFF, 0x87, 0xEF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0x7F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xF9, 0xFF, 0x1F, 0xC0, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFE, 0x03,
  0xF9, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xF9, 0xFF, 0x1F, 0xC0, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFE, 0x03,
  0xF9, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xC7, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3,
  0xF8, 0xFC, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0xFE, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F,
  0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF,
  0x03, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF8,
  0xF1, 0xF8, 0x08, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF,
  0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0x9F, 0xC1, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xF0,
  0x0F, 0xDF, 0x80, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x81, 0xF9, 0xF8, 0x1F,
  0xE0, 0x7E, 0x3F, 0x07, 0xF8, 0x1F, 0x8F, 0xC1, 0xFE, 0x07, 0xE3, 0xF0,
  0x7F, 0xC3, 0xF0, 0xFC, 0x1F, 0xF0, 0xFC, 0x3F, 0x0F, 0xFC, 0x3F, 0x07,
  0xE3, 0xFF, 0x0F, 0xC1, 0xF8, 0xFB, 0xC7, 0xE0, 0x7E, 0x3E, 0xF9, 0xF8,
  0x1F, 0x9F, 0x3E, 0x7E, 0x03, 0xE7, 0xCF, 0x9F, 0x80, 0xFD, 0xF3, 0xE7,
  0xC0, 0x3F, 0x7C, 0x7B, 0xF0, 0x0F, 0xDF, 0x1F, 0xFC, 0x01, 0xF7, 0x87,
  0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x8F,
  0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xFC, 0xFE, 0x03, 0xF3,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3D, 0xE0, 0x1F, 0x7C, 0x07, 0x8F, 0x03, 0xE3, 0xE0, 0xF0, 0x78,
  0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0x00, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8,
  0x60, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xF7, 0xC7, 0xF1, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0x03, 0xF3, 0xF8,
  0xFD, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xF7, 0xF8,
  0xF8, 0xFC, 0x00, 0x00, 0x70, 0x07, 0xFE, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7F, 0x9E, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x02, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x30, 0xFC, 0x3F, 0xBF, 0x3F,
  0xEF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF7, 0xE0, 0xFD,
  0xFC, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF, 0x0F,
  0xC7, 0xC0, 0x00, 0x40, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0xFF, 0x9F, 0xC3, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x1F, 0x80, 0x27, 0xF8, 0x38,
  0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x7F,
  0xC7, 0xFE, 0x3F, 0xF3, 0xFD, 0x1F, 0xC0, 0xFC, 0x0F, 0xFE, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFC, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0x03, 0x00, 0x03, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xEF, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xC3, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFB, 0xF0, 0xFC, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xDC, 0x0F, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x81, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0x03, 0xF3, 0xF8, 0xFD, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0,
  0x39, 0xFB, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x81, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE1, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xDF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x06, 0x07,
  0xCF, 0xF0, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFB, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8,
  0x7F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0x7F,
  0xF8, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0xFF, 0xF0,
  0x7F, 0x07, 0xFF, 0x83, 0xF8, 0x3F, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE,
  0x0F, 0xFF, 0x07, 0xF0, 0x7E, 0x00, 0x10, 0x3E, 0x3F, 0xCF, 0xDF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC,
  0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFE, 0x3F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xF7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0xEF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x10,
  0x3F, 0x3F, 0x8F, 0xDF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0x7F, 0x8F, 0xCF, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0x00, 0x03, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xEF,
  0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xC3, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFB, 0xF0, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x37, 0xC7, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0x80, 0x3F, 0xF0, 0xFF,
  0xFB, 0xFF, 0xE7, 0xFF, 0xDF, 0x81, 0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xE7, 0xC7, 0xF1, 0xF0,
  0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xF9,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x1F, 0xE1,
  0xFD, 0xF8, 0x7F, 0x87, 0xE7, 0xE1, 0xFE, 0x1F, 0x9F, 0x87, 0xF8, 0x7E,
  0x3F, 0x3F, 0xF3, 0xF0, 0xFC, 0xFF, 0xCF, 0xC3, 0xF3, 0xFF, 0x3F, 0x07,
  0xCF, 0x7C, 0xFC, 0x1F, 0x3C, 0xF3, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF,
  0xCF, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1,
  0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x3F, 0xBF, 0x81, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0xFE, 0x3F, 0x07, 0xF1, 0xFC, 0x7F,
  0x07, 0xF7, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xF0, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9,
  0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0xFF, 0x8F, 0xF0, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xF0,
  0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x08, 0x00, 0x1E, 0x00,
  0xBF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFA, 0x00,
  0x00,
};

const GFXglyph NotoSans_Black33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 24, 10, 1, -24 },
  { 22, 13, 9, 17, 2, -24 },
  { 37, 20, 24, 22, 1, -24 },
  { 97, 17, 27, 19, 1, -25 },
  { 155, 30, 24, 31, 1, -24 },
  { 245, 26, 24, 26, 1, -24 },
  { 323, 6, 9, 10, 2, -24 },
  { 330, 10, 29, 12, 1, -24 },
  { 367, 10, 29, 12, 1, -24 },
  { 404, 16, 16, 18, 1, -25 },
  { 436, 17, 16, 19, 1, -20 },
  { 470, 7, 10, 10, 1, -5 },
  { 479, 9, 5, 11, 1, -11 },
  { 485, 7, 6, 10, 1, -6 },
  { 491, 15, 24, 15, 0, -24 },
  { 536, 17, 24, 19, 1, -24 },
  { 587, 14, 24, 19, 1, -24 },
  { 629, 17, 24, 19, 1, -24 },
  { 680, 17, 24, 19, 1, -24 },
  { 731, 18, 24, 19, 1, -24 },
  { 785, 16, 24, 19, 2, -24 },
  { 833, 17, 24, 19, 1, -24 },
  { 884, 17, 24, 19, 1, -24 },
  { 935, 17, 24, 19, 1, -24 },
  { 986, 17, 24, 19, 1, -24 },
  { 1037, 7, 18, 10, 1, -18 },
  { 1053, 7, 23, 10, 1, -18 },
  { 1074, 17, 18, 19, 1, -21 },
  { 1113, 17, 11, 19, 1, -17 },
  { 1137, 17, 18, 19, 1, -21 },
  { 1176, 16, 24, 17, 0, -24 },
  { 1224, 27, 26, 30, 1, -24 },
  { 1312, 24, 24, 24, 0, -24 },
  { 1384, 18, 24, 22, 3, -24 },
  { 1438, 18, 24, 21, 2, -24 },
  { 1492, 20, 24, 24, 3, -24 },
  { 1552, 14, 24, 18, 3, -24 },
  { 1594, 13, 24, 18, 3, -24 },
  { 1633, 20, 24, 24, 2, -24 },
  { 1693, 20, 24, 25, 3, -24 },
  { 1753, 12, 24, 15, 1, -24 },
  { 1789, 12, 31, 12, -3, -24 },
  { 1836, 20, 24, 23, 3, -24 },
  { 1896, 15, 24, 19, 3, -24 },
  { 1941, 26, 24, 32, 3, -24 },
  { 2019, 22, 24, 28, 3, -24 },
  { 2085, 23, 24, 26, 2, -24 },
  { 2154, 17, 24, 21, 3, -24 },
  { 2205, 23, 30, 26, 2, -24 },
  { 2292, 20, 24, 22, 3, -24 },
  { 2352, 17, 24, 19, 1, -24 },
  { 2403, 18, 24, 20, 1, -24 },
  { 2457, 21, 24, 25, 2, -24 },
  { 2520, 23, 24, 23, 0, -24 },
  { 2589, 34, 24, 34, 0, -24 },
  { 2691, 24, 24, 24, 0, -24 },
  { 2763, 22, 24, 22, 0, -24 },
  { 2829, 18, 24, 20, 1, -24 },
  { 2883, 8, 30, 11, 2, -24 },
  { 2913, 14, 24, 15, 0, -24 },
  { 2955, 8, 30, 11, 1, -24 },
  { 2985, 18, 16, 17, 0, -24 },
  { 3021, 17, 4, 17, 0, 2 },
  { 3030, 11, 5, 14, 1, -25 },
  { 3037, 17, 19, 21, 1, -19 },
  { 3078, 18, 25, 21, 2, -25 },
  { 3135, 16, 19, 18, 1, -19 },
  { 3173, 18, 25, 21, 1, -25 },
  { 3230, 18, 19, 20, 1, -19 },
  { 3273, 13, 25, 14, 1, -25 },
  { 3314, 18, 27, 21, 1, -19 },
  { 3375, 18, 25, 22, 2, -25 },
  { 3432, 7, 26, 11, 2, -26 },
  { 3455, 11, 34, 11, -2, -26 },
  { 3502, 20, 25, 22, 2, -25 },
  { 3565, 6, 25, 11, 2, -25 },
  { 3584, 29, 19, 33, 2, -19 },
  { 3653, 18, 19, 22, 2, -19 },
  { 3696, 19, 19, 21, 1, -19 },
  { 3742, 18, 27, 21, 2, -19 },
  { 3803, 18, 27, 21, 1, -19 },
  { 3864, 13, 19, 15, 2, -19 },
  { 3895, 15, 19, 17, 1, -19 },
  { 3931, 13, 22, 15, 1, -22 },
  { 3967, 18, 18, 22, 2, -18 },
  { 4008, 20, 18, 20, 0, -18 },
  { 4053, 30, 18, 30, 0, -18 },
  { 4121, 21, 18, 21, 0, -18 },
  { 4169, 20, 26, 20, 0, -18 },
  { 4234, 15, 18, 17, 1, -18 },
  { 4268, 12, 30, 14, 1, -24 },
  { 4313, 5, 32, 17, 6, -25 },
  { 4333, 12, 30, 14, 1, -24 },
  { 4378, 17, 7, 19, 1, -15 },
};

const GFXfont NotoSans_Black33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black33pt7bBitmaps,
  (GFXglyph *)NotoSans_Black33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_BLACK33PT7B_H_
