#ifndef _NOTOSANS_BLACK44PT7B_H_
#define _NOTOSANS_BLACK44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xEF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x7F, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC,
  0x30, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x07,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFE, 0x78, 0x73, 0xF8, 0xF0, 0x07, 0xF1, 0xE0, 0x0F, 0xFB, 0xC0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0x3F, 0xC0, 0x1E, 0x7F, 0x70, 0x3C, 0xFE, 0xFE, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x00, 0x1F,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0xFE, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x7F,
  0x07, 0xE0, 0x00, 0xFC, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0x0F, 0xC0,
  0x00, 0xFC, 0x7F, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x1F, 0x80, 0x00, 0xFE,
  0x7F, 0x3F, 0x0F, 0xE0, 0xFE, 0xFE, 0x3F, 0x3F, 0xF8, 0x7F, 0xFE, 0x7E,
  0x3F, 0xFC, 0x7F, 0xFC, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0xFC, 0xFF, 0xFE,
  0x1F, 0xF9, 0xFC, 0xFE, 0x7E, 0x07, 0xC1, 0xF8, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0xFC,
  0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x7F, 0x00,
  0x1F, 0xC0, 0xFC, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x7E, 0x00, 0x3F, 0x80,
  0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xFE, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF,
  0xC7, 0xF8, 0x7F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF0, 0x07, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0x83, 0xE0, 0x67, 0xCF, 0x9F, 0x9F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xF0,
  0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x80, 0xF8, 0x7C, 0x00, 0xE1, 0xC0, 0x01,
  0x04, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F,
  0x87, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x08,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x9F, 0xE3, 0xFE, 0xFF, 0x87, 0xFB, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0x7F,
  0x87, 0xF9, 0xFF, 0x3F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xF3, 0xF3, 0xFC, 0xF8, 0xFF,
  0x1C, 0x3F, 0xC2, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x1F, 0xE7, 0xFE, 0x1E, 0x03, 0xFE, 0x18, 0x07, 0xF8,
  0x20, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0x03, 0xFE, 0x08, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F,
  0xEF, 0xF8, 0x1F, 0xEF, 0xF8, 0x1F, 0xCF, 0xF8, 0x3F, 0x8F, 0xF8, 0x7F,
  0x8F, 0xF8, 0x7F, 0x0F, 0xF8, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFB, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x60, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0,
  0x03, 0xFE, 0xFC, 0x3F, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x7E, 0x07, 0xF3, 0xFF, 0x0F,
  0xEF, 0xFF, 0x1F, 0xDF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0,
  0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0xC3, 0xFE, 0x7F, 0xCF,
  0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xF9, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x87,
  0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0xE7, 0xFC, 0x3F, 0xEF, 0xF0, 0x3F, 0xDF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xE3, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0xF1, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFB, 0xF8, 0xFF,
  0xEF, 0xF0, 0x7F, 0x9F, 0xE0, 0x08, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x40, 0x7F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x18, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x04, 0x00, 0x0E, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFC, 0xFE, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xC0, 0xFF,
  0x10, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xC3, 0xF8,
  0x7F, 0xFE, 0xFE, 0x3F, 0x0F, 0xFF, 0xE7, 0xE7, 0xE1, 0xFF, 0xFE, 0x7E,
  0x7E, 0x3F, 0xFF, 0xE3, 0xEF, 0xC7, 0xF8, 0x7E, 0x3F, 0xFC, 0x7E, 0x07,
  0xE3, 0xFF, 0xC7, 0xE0, 0x7E, 0x3F, 0xFC, 0xFE, 0x07, 0xE3, 0xFF, 0xCF,
  0xC0, 0xFE, 0x3F, 0xFC, 0xFC, 0x0F, 0xE3, 0xEF, 0xCF, 0xC0, 0xFC, 0x3E,
  0xFC, 0xFE, 0x0F, 0xC7, 0xEF, 0xC7, 0xE1, 0xFE, 0x7E, 0xFC, 0x7F, 0xFF,
  0xFF, 0xCF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0x87, 0xE1,
  0xFF, 0x9F, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFE,
  0x0F, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF,
  0xE0, 0x7F, 0x9F, 0xF0, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xBF, 0xE0, 0xFF, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x7F, 0xF0, 0x7C, 0x3F, 0xF0, 0x06, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xE7, 0xFC, 0x0F, 0xFE,
  0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF,
  0xE0, 0x3F, 0xF7, 0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xC0, 0x78, 0x3F, 0xF0, 0x01, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7,
  0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xFE, 0x00, 0xFF, 0x3F, 0xF0,
  0x0F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFB, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xCF,
  0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F,
  0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F,
  0xDF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE3, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFD,
  0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0xFC, 0x03, 0xF7, 0xFF, 0xFF, 0xE0,
  0x3F, 0x7F, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF,
  0x7E, 0x07, 0xEF, 0xFF, 0xF7, 0xF0, 0x7E, 0xFF, 0xFF, 0x7F, 0x07, 0xEF,
  0xFF, 0xF3, 0xF0, 0xFE, 0xFF, 0xFF, 0x3F, 0x8F, 0xCF, 0xFF, 0xF3, 0xF8,
  0xFC, 0xFF, 0xFF, 0x1F, 0x9F, 0xCF, 0xFF, 0xF1, 0xFD, 0xF8, 0xFF, 0xFF,
  0x1F, 0xDF, 0x8F, 0xFF, 0xF1, 0xFD, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xF0, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF,
  0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xF7, 0xF8, 0x1F, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0x3F,
  0xC1, 0xFF, 0xFC, 0xFF, 0x87, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xC7, 0xFC,
  0x7F, 0xFF, 0x0F, 0xF1, 0xFF, 0xFC, 0x3F, 0xE7, 0xFF, 0xF0, 0x7F, 0x9F,
  0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0x03, 0xFD, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F,
  0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC,
  0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xE3,
  0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFD, 0xFF, 0x00,
  0xFF, 0xBF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xE0, 0x7C, 0xFF, 0x80, 0x33, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB,
  0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF9, 0xFF,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFF,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xFE, 0x01,
  0xFE, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x3F,
  0xC1, 0xFF, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xFF, 0x87, 0xF8, 0x1F, 0xE1,
  0xFB, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0x9F, 0x87, 0xF8, 0x1F, 0xE3, 0xF9,
  0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x9F, 0x8F, 0xF0, 0x0F, 0xF3, 0xF9, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0x1F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF0, 0xFC, 0xFE,
  0x00, 0x7F, 0x7F, 0x0F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0xFD, 0xFE, 0x00,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x3F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xCF,
  0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0x83,
  0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x7E, 0x00,
  0xFC, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xE1, 0xFF, 0x06, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0x9F, 0xFC, 0x7F, 0x1F, 0xF0, 0x7E, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0x81, 0xFE, 0x7F, 0xC3, 0xFD, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0x3F, 0xF8, 0xFE, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF8, 0x18, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0x9F, 0xF8, 0x7C,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x01, 0xC1, 0xFE, 0x1F, 0xF3, 0xFC, 0x7F, 0xF7, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0x8F, 0xFE, 0x7F,
  0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0xBF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x33, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xF1, 0xFC, 0x7F, 0xF3, 0xF9, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFA, 0x00, 0x1F, 0xF7, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0x03, 0x40, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0xFF, 0x3F, 0xF0, 0xFF, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x7E, 0x7F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x80, 0x03, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xFA, 0x3F, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF,
  0xFE, 0x3F, 0xE0, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0xEF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x3F,
  0xC3, 0xFF, 0x0F, 0xF1, 0xFF, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0,
  0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xF0, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0,
  0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07,
  0xFE, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x1F, 0x03, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F,
  0xE7, 0xFF, 0x9F, 0xFF, 0x3F, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF,
  0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xC0, 0xFE, 0x3F, 0xF0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xC3,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x81, 0xFC, 0x7F,
  0xC3, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xBF, 0xF8, 0xFF, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF1, 0xFC, 0x7F, 0xF3, 0xF9,
  0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF,
  0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xC1, 0xE7, 0xF8, 0x04,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x8C, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0x3F, 0xFC, 0x7F, 0x0F, 0xF8, 0x7F, 0xFF,
  0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xFC, 0x0F, 0xF3, 0xFC,
  0x1F, 0xFC, 0x1F, 0xC7, 0xF8, 0x7F, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFF, 0xE1, 0xFE, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x3F,
  0xCF, 0xFF, 0xCF, 0xF0, 0x7F, 0x9F, 0x9F, 0x9F, 0xE0, 0xFF, 0x3F, 0x3F,
  0x3F, 0xC0, 0xFE, 0x7E, 0x7E, 0x7F, 0x01, 0xFC, 0xFC, 0xFC, 0xFE, 0x03,
  0xFF, 0xF9, 0xFF, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE3, 0xFE, 0x07, 0xFC,
  0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF,
  0xBF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF9, 0xFF, 0x01,
  0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x7F, 0xE0,
  0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0xC1,
  0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0E,
  0x00, 0x05, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xFC, 0x80, 0x01, 0xC0,
};

const GFXglyph NotoSans_Black44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 32, 13, 2, -31 },
  { 37, 17, 11, 23, 3, -31 },
  { 61, 27, 31, 29, 1, -31 },
  { 166, 23, 36, 25, 1, -33 },
  { 270, 40, 32, 42, 1, -32 },
  { 430, 33, 32, 35, 2, -32 },
  { 562, 7, 11, 13, 3, -31 },
  { 572, 13, 39, 16, 2, -32 },
  { 636, 13, 39, 16, 1, -32 },
  { 700, 22, 21, 24, 1, -33 },
  { 758, 22, 21, 26, 2, -26 },
  { 816, 10, 12, 14, 1, -6 },
  { 831, 12, 7, 14, 1, -15 },
  { 842, 9, 9, 13, 2, -8 },
  { 853, 19, 32, 19, 0, -32 },
  { 929, 22, 32, 26, 2, -32 },
  { 1017, 18, 31, 26, 2, -31 },
  { 1087, 23, 32, 26, 1, -32 },
  { 1179, 23, 32, 26, 1, -32 },
  { 1271, 24, 31, 26, 1, -31 },
  { 1364, 22, 31, 26, 2, -31 },
  { 1450, 23, 32, 26, 1, -32 },
  { 1542, 22, 31, 26, 2, -31 },
  { 1628, 23, 32, 26, 1, -32 },
  { 1720, 23, 32, 26, 1, -32 },
  { 1812, 9, 26, 13, 2, -25 },
  { 1842, 10, 31, 13, 1, -25 },
  { 1881, 22, 24, 26, 2, -28 },
  { 1947, 22, 15, 26, 2, -23 },
  { 1989, 22, 24, 26, 2, -28 },
  { 2055, 21, 33, 22, 0, -32 },
  { 2142, 36, 35, 39, 2, -32 },
  { 2300, 32, 32, 32, 0, -32 },
  { 2428, 25, 31, 30, 3, -31 },
  { 2525, 25, 32, 29, 2, -32 },
  { 2625, 27, 31, 32, 3, -31 },
  { 2730, 19, 31, 24, 3, -31 },
  { 2804, 19, 31, 24, 3, -31 },
  { 2878, 28, 32, 33, 2, -32 },
  { 2990, 27, 31, 34, 3, -31 },
  { 3095, 17, 31, 19, 1, -31 },
  { 3161, 15, 41, 15, -3, -31 },
  { 3238, 27, 31, 30, 3, -31 },
  { 3343, 21, 31, 26, 3, -31 },
  { 3425, 36, 31, 43, 3, -31 },
  { 3565, 30, 31, 37, 3, -31 },
  { 3682, 31, 32, 35, 2, -32 },
  { 3806, 23, 31, 28, 3, -31 },
  { 3896, 32, 39, 35, 2, -32 },
  { 4052, 27, 31, 30, 3, -31 },
  { 4157, 22, 32, 25, 2, -32 },
  { 4245, 24, 31, 26, 1, -31 },
  { 4338, 27, 31, 33, 3, -31 },
  { 4443, 31, 31, 31, 0, -31 },
  { 4564, 44, 31, 46, 1, -31 },
  { 4735, 32, 31, 32, 0, -31 },
  { 4859, 29, 31, 29, 0, -31 },
  { 4972, 25, 31, 27, 1, -31 },
  { 5069, 10, 39, 14, 3, -32 },
  { 5118, 19, 32, 19, 0, -32 },
  { 5194, 11, 39, 14, 1, -32 },
  { 5248, 24, 21, 23, 0, -32 },
  { 5311, 22, 5, 22, 0, 3 },
  { 5325, 15, 7, 18, 2, -34 },
  { 5339, 23, 25, 27, 2, -25 },
  { 5411, 23, 33, 28, 3, -33 },
  { 5506, 21, 25, 24, 2, -25 },
  { 5572, 23, 33, 28, 2, -33 },
  { 5667, 23, 25, 27, 2, -25 },
  { 5739, 18, 34, 18, 1, -34 },
  { 5816, 23, 36, 28, 2, -25 },
  { 5920, 24, 33, 29, 3, -33 },
  { 6019, 9, 34, 14, 3, -34 },
  { 6058, 14, 45, 14, -2, -34 },
  { 6137, 26, 33, 29, 3, -33 },
  { 6245, 8, 33, 14, 3, -33 },
  { 6278, 38, 25, 44, 3, -25 },
  { 6397, 24, 25, 29, 3, -25 },
  { 6472, 24, 25, 28, 2, -25 },
  { 6547, 23, 36, 28, 3, -25 },
  { 6651, 23, 36, 28, 2, -25 },
  { 6755, 17, 25, 21, 3, -25 },
  { 6809, 19, 25, 23, 2, -25 },
  { 6869, 18, 29, 20, 1, -29 },
  { 6935, 24, 24, 29, 3, -24 },
  { 7007, 27, 24, 27, 0, -24 },
  { 7088, 39, 24, 40, 1, -24 },
  { 7205, 28, 24, 28, 0, -24 },
  { 7289, 27, 35, 27, 0, -24 },
  { 7408, 20, 24, 22, 1, -24 },
  { 7468, 17, 39, 19, 1, -32 },
  { 7551, 6, 43, 22, 8, -33 },
  { 7584, 17, 39, 19, 1, -32 },
  { 7667, 22, 9, 26, 2, -20 },
};

const GFXfont NotoSans_Black44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black44pt7bBitmaps,
  (GFXglyph *)NotoSans_Black44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_BLACK44PT7B_H_
