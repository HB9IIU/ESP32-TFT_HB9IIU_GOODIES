#ifndef _NOTOSANS_BLACK42PT7B_H_
#define _NOTOSANS_BLACK42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF3, 0xF0, 0x20,
  0xFF, 0x3F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x1F, 0x9F,
  0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xC3, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xF9, 0xE1, 0xCF, 0xE7, 0x81, 0x3F, 0x9E, 0x00,
  0xFF, 0x78, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xE7, 0xF0, 0x07, 0x9F, 0xD0, 0x1E, 0x7F, 0x7C, 0x7B, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xF0,
  0x03, 0xF1, 0xF8, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0xFE, 0x00, 0x3F, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x7E, 0x00,
  0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E,
  0x7E, 0x3F, 0xC3, 0xFF, 0xF9, 0xF9, 0xFF, 0x87, 0xFF, 0xCF, 0xCF, 0xFF,
  0x0F, 0xFF, 0x7F, 0x3F, 0xFE, 0x3F, 0xF9, 0xF9, 0xFF, 0xF8, 0x3F, 0x8F,
  0xC7, 0xE7, 0xF0, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x3F,
  0x00, 0x07, 0xE1, 0xF8, 0xFC, 0x00, 0x3F, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x1F, 0x8F, 0xC0, 0x07, 0xE0, 0x7E, 0x3F, 0x00, 0x3F, 0x81, 0xF9, 0xFC,
  0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0x80,
  0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE,
  0x0F, 0xF8, 0x3F, 0xFF, 0x87, 0xF8, 0x3F, 0xFF, 0xE3, 0xFC, 0x1F, 0xFF,
  0xFB, 0xFE, 0x1F, 0xF7, 0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0x07, 0xF8,
  0x7F, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x7F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFC, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x20, 0x7C, 0x09, 0xE3, 0xE7, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0xC1, 0xFC,
  0x7E, 0x03, 0xC3, 0xC0, 0x06, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0x9F,
  0xE1, 0xFE, 0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0,
  0xFF, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F,
  0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xDF, 0xDF, 0xE7, 0x8F, 0xF1, 0x87, 0xF8, 0x83, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFD, 0xFF, 0x87, 0x81, 0xFE, 0x1C, 0x07, 0xF8, 0x20, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xE0,
  0xFF, 0x86, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x7F, 0x80, 0xFE, 0xFF, 0x03, 0xF9, 0xFE, 0x0F, 0xE3, 0xFC,
  0x1F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xDE,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xDE, 0x03, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x1F, 0xCF, 0xF8,
  0x7F, 0x7F, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x83,
  0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xF1, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0xBF, 0xE7, 0xF8, 0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFC,
  0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE7, 0xFC, 0x7F, 0x9F, 0xE1, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x3F, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xF7, 0xF0, 0xFF, 0x9F,
  0xC0, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x04, 0x0F, 0xC7, 0xF9,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3E, 0x0F, 0xF1, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xDF,
  0x9F, 0x87, 0xFF, 0xF3, 0xE7, 0xE3, 0xFF, 0xFC, 0xFD, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFC, 0x7E, 0x0F, 0x8F, 0xFF, 0x3F, 0x03, 0xE1, 0xFF, 0xCF, 0xC0,
  0xF8, 0x7F, 0xE3, 0xF0, 0x3E, 0x1F, 0xF8, 0xFC, 0x1F, 0x8F, 0xFE, 0x3F,
  0x07, 0xE3, 0xFF, 0x8F, 0xC1, 0xF8, 0xFB, 0xE3, 0xF0, 0x7E, 0x3E, 0xFC,
  0xFE, 0x7F, 0xDF, 0xBF, 0x1F, 0xFF, 0xFF, 0xCF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xF8, 0xFF, 0xCF, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0x9F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0xFF, 0xEF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFD, 0xFE, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x7C,
  0x3F, 0xE0, 0x0C, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x06,
  0x3F, 0xF8, 0x3E, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xFC, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xCF, 0xF0, 0x3F, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xC3, 0xF0, 0xFF, 0xC0, 0x08, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0xC0, 0x1F, 0xDF,
  0xF0, 0x07, 0xF7, 0xFE, 0x01, 0xFC, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFD, 0xFF, 0xFB, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x03,
  0xFE, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF,
  0x1F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFD, 0xFF, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F,
  0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xEF, 0xC0, 0x7F,
  0xFF, 0xFB, 0xF0, 0x3F, 0x7F, 0xFE, 0xFE, 0x0F, 0xDF, 0xFF, 0x9F, 0x83,
  0xF7, 0xFF, 0xE7, 0xE1, 0xF9, 0xFF, 0xF9, 0xFC, 0x7E, 0x7F, 0xFE, 0x7F,
  0x1F, 0x9F, 0xFF, 0x8F, 0xC7, 0xE7, 0xFF, 0xE3, 0xF3, 0xF1, 0xFF, 0xF8,
  0xFE, 0xFC, 0x7F, 0xFE, 0x1F, 0xBF, 0x1F, 0xFF, 0x87, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xF0,
  0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xF7, 0xF8, 0x1F, 0xFF, 0xBF,
  0xC0, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xE7, 0xF8, 0x3F, 0xFF, 0x1F, 0xE1,
  0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xC3, 0xFC, 0x7F, 0xFE, 0x1F, 0xE3, 0xFF,
  0xF0, 0x7F, 0x9F, 0xFF, 0x83, 0xFE, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF,
  0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xDF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x87,
  0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFB,
  0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE, 0xFF,
  0x80, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x9F, 0xE0,
  0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x03,
  0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x0F, 0xF0, 0xFF, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x0F, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF,
  0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xF3, 0xFC, 0x07,
  0xFC, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFE, 0x0F, 0x9F, 0xE0, 0x0C, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F,
  0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03,
  0xFB, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xFC, 0x07, 0xF1, 0xFE, 0x07,
  0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFF, 0x83, 0xF8,
  0x1F, 0xC3, 0xF7, 0xE1, 0xFE, 0x07, 0xF0, 0xFD, 0xFC, 0x7F, 0x81, 0xFE,
  0x3F, 0x3F, 0x1F, 0xC0, 0x7F, 0x8F, 0xCF, 0xC7, 0xF0, 0x0F, 0xE7, 0xF3,
  0xF1, 0xFC, 0x03, 0xF9, 0xF8, 0xFC, 0xFF, 0x00, 0xFE, 0x7E, 0x1F, 0xBF,
  0x80, 0x3F, 0xDF, 0x87, 0xEF, 0xE0, 0x07, 0xF7, 0xE1, 0xFB, 0xF8, 0x01,
  0xFF, 0xF8, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x87,
  0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xCF,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x03, 0xFE, 0x7F,
  0xC0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF9, 0xFE, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3C, 0x3F, 0xE1, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFD, 0xFF, 0xE7, 0xE3, 0xFC, 0x1F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x06,
  0x03, 0xFC, 0xFF, 0x0F, 0xF7, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xE7,
  0xFE, 0x3F, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFC, 0x08,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x2F, 0xFC,
  0x1E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x01, 0x83, 0xFC, 0x3F, 0xCF, 0xF1, 0xFF, 0xBF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xF7, 0xF1, 0xFF, 0x9F, 0xC3, 0xFC, 0x3F, 0x00, 0x3C, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xF8, 0x3F, 0xBF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x67, 0xFE, 0x1F,
  0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xC0,
  0x00, 0x3F, 0xC7, 0xF1, 0xFF, 0xDF, 0xCF, 0xFF, 0x7F, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xBF, 0xC3, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF4, 0x00, 0x7F,
  0xDF, 0x03, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0x03, 0xFC, 0xFF, 0x8F,
  0xF7, 0xFF, 0x3F, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0x18, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x3F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0xBF, 0xC0, 0xFF, 0x9F, 0xE0, 0xFF, 0x8F, 0xF0, 0xFF, 0x87,
  0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xC1, 0xFE, 0x7F, 0xC0, 0xFF, 0x7F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F,
  0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0,
  0x7F, 0xC7, 0xF8, 0x1F, 0xF3, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x3C, 0x0F,
  0xC7, 0xFE, 0x0F, 0xF8, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0x03, 0xF0, 0xFF,
  0x8F, 0xCF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFB, 0xFF, 0x7F, 0xC1, 0xFE,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFC, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0x03, 0xF8, 0xFF, 0x0F, 0xE7, 0xFE, 0x3F, 0xBF, 0xFC, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xCF, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xC7, 0xF1, 0xFF, 0xDF, 0xCF, 0xFF, 0x7F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xBF, 0xC3,
  0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xC3, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE0, 0x73, 0xFC, 0x04,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0xF0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x84, 0x7F,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xF3,
  0xF0, 0xFF, 0x0F, 0xC0, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8,
  0x0F, 0xF9, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF,
  0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0x07, 0xF7, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFD,
  0xFE, 0x0F, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF,
  0xC1, 0xFE, 0x3F, 0x83, 0xFF, 0x87, 0xF0, 0xFF, 0x1F, 0xFE, 0x1F, 0xC3,
  0xFC, 0x7F, 0xF8, 0xFF, 0x07, 0xF1, 0xFF, 0xE3, 0xFC, 0x1F, 0xC7, 0xEF,
  0x8F, 0xE0, 0x7F, 0x1F, 0x3F, 0x3F, 0x81, 0xFE, 0xFC, 0xFC, 0xFE, 0x03,
  0xFB, 0xF3, 0xF7, 0xF8, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0x3F, 0xBF, 0x3F,
  0x7F, 0x00, 0x7E, 0xF8, 0x7F, 0xFC, 0x01, 0xFB, 0xE1, 0xFF, 0xE0, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0xCF, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF3,
  0xFE, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xEF, 0xFC, 0x07, 0xFC,
  0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x02, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFC,
  0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xD0, 0x03, 0xFC,
};

const GFXglyph NotoSans_Black42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 31, 12, 2, -30 },
  { 36, 18, 11, 22, 2, -30 },
  { 61, 26, 30, 28, 1, -30 },
  { 159, 22, 34, 24, 1, -32 },
  { 253, 38, 30, 40, 1, -30 },
  { 396, 33, 30, 34, 1, -30 },
  { 520, 8, 11, 12, 2, -30 },
  { 531, 12, 38, 15, 2, -31 },
  { 588, 13, 38, 15, 1, -31 },
  { 650, 21, 20, 23, 1, -32 },
  { 703, 21, 20, 25, 2, -25 },
  { 756, 10, 12, 13, 1, -6 },
  { 771, 11, 6, 13, 1, -14 },
  { 780, 8, 8, 12, 2, -7 },
  { 788, 18, 30, 19, 0, -30 },
  { 856, 22, 30, 25, 1, -30 },
  { 939, 17, 30, 25, 2, -30 },
  { 1003, 22, 30, 25, 1, -30 },
  { 1086, 22, 30, 25, 1, -30 },
  { 1169, 23, 30, 25, 1, -30 },
  { 1256, 21, 30, 25, 2, -30 },
  { 1335, 22, 30, 25, 1, -30 },
  { 1418, 21, 30, 25, 2, -30 },
  { 1497, 22, 30, 25, 1, -30 },
  { 1580, 22, 30, 25, 1, -30 },
  { 1663, 8, 25, 12, 2, -24 },
  { 1688, 10, 30, 12, 1, -24 },
  { 1726, 21, 23, 25, 2, -27 },
  { 1787, 21, 15, 25, 2, -22 },
  { 1827, 21, 23, 25, 2, -27 },
  { 1888, 20, 31, 21, 0, -30 },
  { 1966, 34, 33, 38, 2, -30 },
  { 2107, 30, 30, 30, 0, -30 },
  { 2220, 23, 30, 28, 3, -30 },
  { 2307, 24, 30, 27, 2, -30 },
  { 2397, 26, 30, 31, 3, -30 },
  { 2495, 18, 30, 23, 3, -30 },
  { 2563, 18, 30, 23, 3, -30 },
  { 2631, 26, 30, 31, 2, -30 },
  { 2729, 26, 30, 32, 3, -30 },
  { 2827, 16, 30, 18, 1, -30 },
  { 2887, 15, 39, 15, -3, -30 },
  { 2961, 26, 30, 29, 3, -30 },
  { 3059, 20, 30, 24, 3, -30 },
  { 3134, 34, 30, 41, 3, -30 },
  { 3262, 29, 30, 35, 3, -30 },
  { 3371, 29, 30, 33, 2, -30 },
  { 3480, 22, 30, 27, 3, -30 },
  { 3563, 30, 37, 33, 2, -30 },
  { 3702, 26, 30, 28, 3, -30 },
  { 3800, 21, 30, 24, 2, -30 },
  { 3879, 23, 30, 25, 1, -30 },
  { 3966, 26, 30, 32, 3, -30 },
  { 4064, 29, 30, 29, 0, -30 },
  { 4173, 42, 30, 44, 1, -30 },
  { 4331, 30, 30, 30, 0, -30 },
  { 4444, 28, 30, 28, 0, -30 },
  { 4549, 24, 30, 26, 1, -30 },
  { 4639, 11, 38, 14, 2, -31 },
  { 4692, 18, 30, 19, 0, -30 },
  { 4760, 10, 38, 14, 1, -31 },
  { 4808, 23, 20, 22, 0, -30 },
  { 4866, 21, 5, 21, 0, 3 },
  { 4880, 14, 7, 18, 2, -32 },
  { 4893, 21, 24, 26, 2, -24 },
  { 4956, 22, 32, 27, 3, -32 },
  { 5044, 20, 24, 23, 2, -24 },
  { 5104, 22, 32, 27, 2, -32 },
  { 5192, 22, 24, 26, 2, -24 },
  { 5258, 17, 32, 17, 1, -32 },
  { 5326, 22, 34, 27, 2, -24 },
  { 5420, 22, 32, 28, 3, -32 },
  { 5508, 8, 33, 14, 3, -33 },
  { 5541, 13, 43, 14, -2, -33 },
  { 5611, 25, 32, 28, 3, -32 },
  { 5711, 8, 32, 14, 3, -32 },
  { 5743, 36, 24, 42, 3, -24 },
  { 5851, 22, 24, 28, 3, -24 },
  { 5917, 23, 24, 27, 2, -24 },
  { 5986, 22, 34, 27, 3, -24 },
  { 6080, 22, 34, 27, 2, -24 },
  { 6174, 16, 24, 20, 3, -24 },
  { 6222, 18, 24, 22, 2, -24 },
  { 6276, 17, 28, 19, 1, -28 },
  { 6336, 22, 23, 28, 3, -23 },
  { 6400, 26, 23, 26, 0, -23 },
  { 6475, 38, 23, 38, 0, -23 },
  { 6585, 26, 23, 26, 0, -23 },
  { 6660, 26, 33, 26, 0, -23 },
  { 6768, 19, 23, 21, 1, -23 },
  { 6823, 16, 37, 18, 1, -30 },
  { 6897, 5, 41, 21, 8, -32 },
  { 6923, 16, 37, 18, 1, -30 },
  { 6997, 21, 8, 25, 2, -19 },
};

const GFXfont NotoSans_Black42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black42pt7bBitmaps,
  (GFXglyph *)NotoSans_Black42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_BLACK42PT7B_H_
