#ifndef _NOTOSANS_BLACK8PT7B_H_
#define _NOTOSANS_BLACK8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x30, 0xF7, 0x39, 0xBF, 0xF5, 0x38, 0x2F, 0xE7, 0xBF, 0x45,
  0x52, 0xB3, 0xB3, 0xE4, 0xC0, 0x71, 0x47, 0x1F, 0xD9, 0xF0, 0xD0, 0x6B,
  0x6D, 0x98, 0xC9, 0x36, 0xB0, 0x2F, 0x67, 0x22, 0xF2, 0x70, 0xC0, 0xC0,
  0x32, 0x64, 0x4C, 0x6D, 0xDD, 0xD7, 0x3F, 0x73, 0x33, 0x7F, 0x12, 0x4F,
  0xF7, 0x77, 0x9F, 0x31, 0x9D, 0xEF, 0x98, 0x77, 0x7F, 0x9F, 0x36, 0xFD,
  0xD7, 0xFF, 0x32, 0x66, 0x7D, 0x77, 0xD7, 0x6D, 0xD7, 0x16, 0xC3, 0xC1,
  0xC0, 0x16, 0xE1, 0xF0, 0xF0, 0xC7, 0x3C, 0x6B, 0x34, 0x06, 0x38, 0x8B,
  0xED, 0x5F, 0xC8, 0x8E, 0x00, 0x31, 0xC7, 0x96, 0xFB, 0x30, 0xEB, 0xFF,
  0xBE, 0x3B, 0x71, 0x84, 0xBC, 0xEF, 0x99, 0xBE, 0xFF, 0xF9, 0xC0, 0xFE,
  0x79, 0x00, 0x3B, 0x71, 0xB4, 0xBC, 0x9C, 0xFF, 0xF9, 0xCC, 0xED, 0xB7,
  0xC0, 0x24, 0x92, 0x5E, 0x9D, 0xB9, 0xCB, 0x5C, 0x92, 0x49, 0xC0, 0xCF,
  0x3D, 0xFD, 0xB6, 0xD0, 0xCE, 0x7B, 0x5B, 0xCC, 0x39, 0xFC, 0xF3, 0x4D,
  0xE0, 0xEF, 0xBE, 0x88, 0x39, 0xFC, 0xF3, 0x4D, 0xE0, 0xC0, 0xE5, 0xAD,
  0xCB, 0x5C, 0x7D, 0xE7, 0x9F, 0xFF, 0xC8, 0x42, 0x10, 0x99, 0x99, 0x9F,
  0xCF, 0x65, 0x9E, 0x70, 0xC0, 0xD9, 0xDB, 0x5B, 0x5E, 0x56, 0x66, 0xCD,
  0xE3, 0x0C, 0x7B, 0x30, 0xCA, 0xDC, 0x62, 0x10, 0xFF, 0x8C, 0xC4, 0x7C,
  0xFF, 0xFC, 0x84, 0x46, 0x23, 0xD5, 0x5C, 0x46, 0x69, 0xF0, 0xE0, 0x27,
  0x7D, 0xF0, 0x8A, 0xFB, 0xBE, 0x27, 0xCD, 0x70, 0x1A, 0xDF, 0xBD, 0xBC,
  0x23, 0xBF, 0x87, 0x00, 0x74, 0xE4, 0x44, 0x43, 0xF7, 0xB7, 0xCD, 0xC0,
  0x8A, 0xFB, 0xBB, 0xC5, 0x50, 0xC5, 0x5F, 0x89, 0xAE, 0xAB, 0xFC, 0x2B,
  0xFB, 0x6D, 0xB4, 0x2F, 0xBB, 0xB0, 0x23, 0xB7, 0xB7, 0x00, 0x2F, 0xBB,
  0xE8, 0x80, 0x43, 0xF7, 0xB7, 0x8C, 0x60, 0x3E, 0x48, 0x2F, 0x63, 0xF0,
  0x5D, 0x26, 0xBB, 0xBD, 0xDA, 0x9C, 0xC0, 0xDE, 0xDD, 0xB3, 0x60, 0xDB,
  0x9D, 0xB0, 0xDA, 0x9C, 0x46, 0x60, 0xF6, 0x4F, 0x2D, 0x64, 0x98, 0xFF,
  0xC9, 0x36, 0xB0, 0x5B,
};

const GFXglyph NotoSans_Black8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 5, 0, -6 },
  { 11, 7, 6, 8, 0, -6 },
  { 17, 6, 6, 6, 0, -6 },
  { 22, 2, 2, 2, 0, -6 },
  { 23, 3, 7, 3, 0, -6 },
  { 26, 3, 7, 3, 0, -6 },
  { 29, 4, 4, 4, 0, -6 },
  { 31, 4, 4, 5, 0, -5 },
  { 33, 2, 2, 2, 0, -1 },
  { 34, 2, 1, 3, 0, -3 },
  { 35, 2, 1, 2, 0, -1 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 4, 6, 5, 0, -6 },
  { 42, 4, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 4, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 4, 6, 5, 0, -6 },
  { 67, 4, 6, 5, 0, -6 },
  { 70, 2, 4, 2, 0, -4 },
  { 71, 2, 5, 2, 0, -4 },
  { 73, 4, 4, 5, 0, -5 },
  { 75, 4, 3, 5, 0, -4 },
  { 77, 4, 4, 5, 0, -5 },
  { 79, 4, 6, 4, 0, -6 },
  { 82, 7, 7, 7, 0, -6 },
  { 89, 6, 6, 6, 0, -6 },
  { 94, 4, 6, 5, 1, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 4, 6, 6, 1, -6 },
  { 104, 3, 6, 4, 1, -6 },
  { 107, 3, 6, 4, 1, -6 },
  { 110, 5, 6, 6, 0, -6 },
  { 114, 5, 6, 6, 1, -6 },
  { 118, 3, 6, 4, 0, -6 },
  { 121, 3, 8, 3, -1, -6 },
  { 124, 5, 6, 6, 1, -6 },
  { 128, 3, 6, 5, 1, -6 },
  { 131, 6, 6, 8, 1, -6 },
  { 136, 5, 6, 7, 1, -6 },
  { 140, 6, 6, 6, 0, -6 },
  { 145, 4, 6, 5, 1, -6 },
  { 148, 6, 7, 6, 0, -6 },
  { 154, 5, 6, 5, 1, -6 },
  { 158, 4, 6, 5, 0, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 4, 6, 6, 1, -6 },
  { 168, 6, 6, 6, 0, -6 },
  { 173, 8, 6, 8, 0, -6 },
  { 179, 6, 6, 6, 0, -6 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 2, 7, 3, 0, -6 },
  { 194, 4, 6, 4, 0, -6 },
  { 197, 2, 7, 3, 0, -6 },
  { 199, 4, 4, 4, 0, -6 },
  { 201, 4, 1, 4, 0, 0 },
  { 202, 3, 1, 3, 0, -6 },
  { 203, 4, 5, 5, 0, -5 },
  { 206, 4, 6, 5, 1, -6 },
  { 209, 4, 5, 4, 0, -5 },
  { 212, 5, 6, 5, 0, -6 },
  { 216, 5, 5, 5, 0, -5 },
  { 220, 4, 6, 3, 0, -6 },
  { 223, 5, 7, 5, 0, -5 },
  { 228, 4, 6, 5, 1, -6 },
  { 231, 2, 6, 3, 0, -6 },
  { 233, 2, 8, 3, 0, -6 },
  { 235, 4, 6, 5, 1, -6 },
  { 238, 1, 6, 3, 1, -6 },
  { 239, 6, 5, 8, 1, -5 },
  { 243, 4, 5, 5, 1, -5 },
  { 246, 5, 5, 5, 0, -5 },
  { 250, 4, 7, 5, 1, -5 },
  { 254, 5, 7, 5, 0, -5 },
  { 259, 3, 5, 4, 1, -5 },
  { 261, 4, 5, 4, 0, -5 },
  { 264, 3, 5, 4, 0, -5 },
  { 266, 4, 4, 5, 1, -4 },
  { 268, 5, 4, 5, 0, -4 },
  { 271, 7, 4, 7, 0, -4 },
  { 275, 5, 4, 5, 0, -4 },
  { 278, 5, 6, 5, 0, -4 },
  { 282, 4, 4, 4, 0, -4 },
  { 284, 3, 7, 3, 0, -6 },
  { 287, 1, 8, 4, 2, -6 },
  { 288, 3, 7, 3, 0, -6 },
  { 291, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_Black8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black8pt7bBitmaps,
  (GFXglyph *)NotoSans_Black8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_BLACK8PT7B_H_
