#ifndef _NOTOSANS_BLACK37PT7B_H_
#define _NOTOSANS_BLACK37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x7F,
  0x7F, 0x7F, 0x3E, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xF7, 0xC7,
  0xEF, 0x8F, 0xDF, 0x1F, 0xBE, 0x3F, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF8, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF0, 0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFC, 0xE0, 0x8F, 0xCE, 0x00,
  0xFE, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xEF, 0xE0, 0x0E,
  0x7F, 0x40, 0xE7, 0xE7, 0xCE, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xE0, 0x1F, 0xF8,
  0x03, 0xE0, 0x0F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x07, 0xCF,
  0xC1, 0xF8, 0x03, 0xE3, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0xFC, 0x00, 0xF8,
  0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x1F,
  0x3F, 0x3E, 0x3F, 0x8F, 0xFF, 0xBF, 0x3F, 0xE3, 0xFF, 0x9F, 0x3F, 0xF9,
  0xFF, 0xDF, 0x9F, 0xFE, 0x7F, 0xCF, 0x9F, 0xBF, 0x0F, 0x0F, 0xCF, 0x8F,
  0x80, 0x07, 0xC7, 0xC7, 0xC0, 0x07, 0xE3, 0xE3, 0xE0, 0x03, 0xE1, 0xF1,
  0xF0, 0x03, 0xE0, 0xF8, 0xF8, 0x03, 0xF0, 0x7C, 0x7C, 0x01, 0xF0, 0x3F,
  0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x01,
  0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0xFF, 0xFC, 0x7F,
  0x87, 0xFF, 0xF3, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xF9, 0xFF, 0xFC, 0x3F,
  0xC7, 0xFF, 0xE1, 0xFE, 0x1F, 0xFE, 0x0F, 0xF0, 0x7F, 0xF0, 0x3F, 0xC7,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0xFF, 0xFB, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x81, 0xE0, 0x7C,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xDF, 0x83, 0xF3, 0xF0, 0xFC, 0xFC,
  0x0E, 0x1C, 0x00, 0x84, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x3F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xE7, 0xF3, 0xF8, 0x7F, 0x7F,
  0x0F, 0xEF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC,
  0x3F, 0xBF, 0x87, 0xF7, 0xF1, 0xFE, 0xFF, 0x3F, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0xFE, 0x79, 0xFC, 0xC3, 0xF8, 0x87, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xCF, 0xF9, 0xE0, 0x7F, 0x10, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0x07, 0xF0, 0x80, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xBF, 0x83,
  0xFB, 0xF8, 0x3F, 0x3F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE3, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE1,
  0x80, 0x7E, 0xFF, 0x07, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF9,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC3, 0xF9, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xFC, 0x7F, 0xBF, 0xC7, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F,
  0xFE, 0x07, 0xEF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xFB,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xF7, 0xE1, 0xF8,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x39,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x1C, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0x81, 0xFC, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x01, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x83, 0xFE, 0x7E,
  0x3F, 0x1F, 0xFE, 0x7C, 0x7C, 0x7F, 0xFC, 0xF9, 0xF1, 0xFF, 0xF8, 0xF3,
  0xE7, 0xF1, 0xF1, 0xF7, 0xCF, 0xC3, 0xE3, 0xEF, 0x9F, 0x07, 0xC7, 0xDE,
  0x3E, 0x0F, 0x8F, 0xFC, 0x7C, 0x1F, 0x1F, 0xF8, 0xF8, 0x3E, 0x3C, 0xF1,
  0xF0, 0xFC, 0xF9, 0xF3, 0xF3, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0xC7, 0xC7,
  0xFF, 0xFF, 0x0F, 0xC7, 0xF9, 0xFC, 0x0F, 0x83, 0xC0, 0xF0, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0x80, 0x1F, 0xF8, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC1,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F,
  0x80, 0x3F, 0xDF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x83, 0x8F, 0xF0, 0x04,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0xFF, 0xEF, 0xE0, 0x7F, 0xBF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xBF, 0x83, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x1F, 0xF8, 0x1C, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF8,
  0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xE7, 0xF0, 0x7F, 0x8F, 0xE1, 0xFE,
  0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0x3F, 0xC0, 0xFE, 0x7F, 0x01,
  0xFD, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x7F, 0x81, 0xFC,
  0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xFD, 0xFC, 0x07,
  0xF8, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xBF, 0xFF, 0xF0, 0x3E, 0xFF, 0xF7, 0xC0, 0xFF, 0xFF, 0xDF,
  0x87, 0xFF, 0xFF, 0x7E, 0x1F, 0x7F, 0xFC, 0xF8, 0x7D, 0xFF, 0xF3, 0xE3,
  0xF7, 0xFF, 0xCF, 0xCF, 0x9F, 0xFF, 0x3F, 0x3E, 0x7F, 0xFC, 0x7C, 0xF9,
  0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0x0F, 0xFC, 0x7F,
  0xFC, 0x3F, 0xF1, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xC3, 0xFE, 0x1F, 0xFF,
  0x07, 0xF8, 0x7F, 0xFC, 0x1F, 0xE1, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFD, 0xFC, 0x1F, 0xFE, 0xFE, 0x0F, 0xFF, 0x3F, 0x87, 0xFF, 0x9F, 0xC3,
  0xFF, 0xC7, 0xF1, 0xFF, 0xE3, 0xF8, 0xFF, 0xF0, 0xFE, 0x7F, 0xF8, 0x7F,
  0xBF, 0xFC, 0x1F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFC, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x7F,
  0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFC,
  0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF,
  0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x0F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x03, 0xFC,
  0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xE3, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xE0, 0x73, 0xF8, 0x04,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x8F, 0xF0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xBF, 0x80,
  0xFF, 0x01, 0xFC, 0xFC, 0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xE0, 0x7F,
  0x3F, 0x81, 0xFF, 0x03, 0xF1, 0xFC, 0x1F, 0xF8, 0x3F, 0x87, 0xE0, 0xFF,
  0xC1, 0xFC, 0x3F, 0x07, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0xF8, 0x7E, 0x0F,
  0xE3, 0xF7, 0xC3, 0xF0, 0x3F, 0x1F, 0xBE, 0x3F, 0x81, 0xF8, 0xFD, 0xF1,
  0xFC, 0x0F, 0xC7, 0xCF, 0xCF, 0xC0, 0x7F, 0x3E, 0x7E, 0x7E, 0x01, 0xFB,
  0xF1, 0xF3, 0xF0, 0x0F, 0xDF, 0x8F, 0xBF, 0x80, 0x7E, 0xF8, 0x7D, 0xF8,
  0x03, 0xF7, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0xDF, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x7F,
  0x8F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x7C, 0x07,
  0xC7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF0, 0xFE, 0x08, 0x0F, 0xF0,
  0x00, 0x7F, 0x03, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFB, 0xF3, 0xFF, 0x3F, 0x1F, 0xE1, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE1, 0xE0, 0xFE, 0x7F, 0x8F, 0xEF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F, 0xC7, 0xF0, 0x01, 0xFC, 0x07,
  0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFC, 0x09,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x05, 0xFF, 0x1E, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x3C,
  0x7F, 0x1F, 0xEF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFE, 0xFC, 0xFF, 0x9F, 0x87, 0xE1,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF,
  0xFD, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x06, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF,
  0xC3, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xFC,
  0xFC, 0xFF, 0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xF7, 0xF0, 0xFC, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE1, 0xF0, 0xFE, 0x7F, 0xCF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E,
  0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xCF,
  0xF0, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F, 0xC3, 0xF9, 0xFE, 0x0F, 0xE7,
  0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x01, 0xF0, 0x7E, 0x7F, 0xE3,
  0xFE, 0x3F, 0xFF, 0xFB, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0xE1, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xF8,
  0x3F, 0x81, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF,
  0x07, 0xF0, 0x3F, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x1E, 0x0F, 0xC7,
  0xFC, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFB, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x0F, 0xE7, 0xF8, 0xFE,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xEF, 0xF8, 0xFE, 0x7F, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x03,
  0xFC, 0xFC, 0xFF, 0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xF7, 0xF0, 0xFC, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xC0,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFE,
  0x1C, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x31, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x3F, 0xFB, 0xF0, 0xFE, 0x1F, 0xFF, 0x01, 0xFE, 0xFE,
  0x03, 0xF9, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0,
  0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0x9F,
  0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xBF, 0x83,
  0xFC, 0x1F, 0xDF, 0xC3, 0xFE, 0x0F, 0xC7, 0xE1, 0xFF, 0x8F, 0xE3, 0xF0,
  0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFE, 0x7D, 0xF1, 0xF8, 0x3F,
  0x3E, 0xF8, 0xFC, 0x1F, 0x9F, 0x7E, 0xFE, 0x0F, 0xCF, 0x9F, 0x7F, 0x07,
  0xF7, 0xCF, 0xBF, 0x01, 0xFF, 0xE7, 0xDF, 0x80, 0xFF, 0xE3, 0xEF, 0xC0,
  0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x7F, 0x87, 0xF8, 0xFF,
  0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xFC,
  0x0F, 0xF3, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xF7,
  0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F,
  0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0xBF, 0x80, 0x3F,
  0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x07, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0xC1, 0xFF, 0x00,
  0xFC, 0x0F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x08, 0x00, 0x5F, 0xE0, 0x1F, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xF8,
};

const GFXglyph NotoSans_Black37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 26, 11, 1, -26 },
  { 27, 15, 9, 19, 2, -26 },
  { 44, 23, 26, 25, 1, -26 },
  { 119, 20, 30, 21, 1, -28 },
  { 194, 33, 27, 35, 1, -27 },
  { 306, 29, 27, 30, 1, -27 },
  { 404, 7, 9, 11, 2, -26 },
  { 412, 11, 33, 13, 1, -27 },
  { 458, 11, 33, 13, 1, -27 },
  { 504, 18, 18, 20, 1, -28 },
  { 545, 18, 18, 22, 2, -22 },
  { 586, 8, 10, 11, 1, -5 },
  { 596, 10, 6, 12, 1, -13 },
  { 604, 7, 6, 11, 2, -6 },
  { 610, 16, 27, 16, 0, -27 },
  { 664, 19, 27, 22, 1, -27 },
  { 729, 15, 26, 22, 2, -26 },
  { 778, 19, 27, 22, 1, -27 },
  { 843, 19, 27, 22, 1, -27 },
  { 908, 20, 26, 22, 1, -26 },
  { 973, 18, 26, 22, 2, -26 },
  { 1032, 20, 27, 22, 1, -27 },
  { 1100, 19, 26, 22, 1, -26 },
  { 1162, 20, 27, 22, 1, -27 },
  { 1230, 19, 27, 22, 1, -27 },
  { 1295, 7, 21, 11, 2, -21 },
  { 1314, 8, 26, 11, 1, -21 },
  { 1340, 18, 21, 22, 2, -24 },
  { 1388, 18, 14, 22, 2, -20 },
  { 1420, 18, 21, 22, 2, -24 },
  { 1468, 18, 27, 19, 0, -27 },
  { 1529, 31, 30, 33, 1, -27 },
  { 1646, 27, 27, 27, 0, -27 },
  { 1738, 20, 26, 25, 3, -26 },
  { 1803, 21, 27, 24, 2, -27 },
  { 1874, 22, 26, 27, 3, -26 },
  { 1946, 16, 26, 20, 3, -26 },
  { 1998, 15, 26, 20, 3, -26 },
  { 2047, 23, 27, 27, 2, -27 },
  { 2125, 23, 26, 28, 3, -26 },
  { 2200, 14, 26, 16, 1, -26 },
  { 2246, 13, 34, 13, -3, -26 },
  { 2302, 23, 26, 25, 3, -26 },
  { 2377, 17, 26, 22, 3, -26 },
  { 2433, 30, 26, 36, 3, -26 },
  { 2531, 25, 26, 31, 3, -26 },
  { 2613, 26, 27, 29, 2, -27 },
  { 2701, 19, 26, 23, 3, -26 },
  { 2763, 26, 33, 29, 2, -27 },
  { 2871, 23, 26, 25, 3, -26 },
  { 2946, 18, 27, 21, 2, -27 },
  { 3007, 20, 26, 22, 1, -26 },
  { 3072, 22, 26, 28, 3, -26 },
  { 3144, 26, 26, 26, 0, -26 },
  { 3229, 37, 26, 38, 1, -26 },
  { 3350, 27, 26, 27, 0, -26 },
  { 3438, 25, 26, 25, 0, -26 },
  { 3520, 21, 26, 23, 1, -26 },
  { 3589, 9, 33, 12, 2, -27 },
  { 3627, 16, 27, 16, 0, -27 },
  { 3681, 9, 33, 12, 1, -27 },
  { 3719, 20, 18, 19, 0, -27 },
  { 3764, 19, 5, 19, 0, 2 },
  { 3776, 13, 6, 15, 1, -28 },
  { 3786, 20, 21, 23, 1, -21 },
  { 3839, 20, 28, 24, 2, -28 },
  { 3909, 17, 21, 20, 2, -21 },
  { 3954, 19, 28, 24, 2, -28 },
  { 4021, 19, 21, 23, 2, -21 },
  { 4071, 15, 28, 15, 1, -28 },
  { 4124, 19, 30, 24, 2, -21 },
  { 4196, 20, 28, 25, 2, -28 },
  { 4266, 8, 29, 12, 2, -29 },
  { 4295, 12, 38, 12, -2, -29 },
  { 4352, 22, 28, 24, 2, -28 },
  { 4429, 8, 28, 12, 2, -28 },
  { 4457, 33, 21, 37, 2, -21 },
  { 4544, 20, 21, 25, 2, -21 },
  { 4597, 20, 21, 24, 2, -21 },
  { 4650, 20, 30, 24, 2, -21 },
  { 4725, 19, 30, 24, 2, -21 },
  { 4797, 15, 21, 17, 2, -21 },
  { 4837, 16, 21, 19, 2, -21 },
  { 4879, 15, 25, 17, 1, -25 },
  { 4926, 20, 20, 25, 2, -20 },
  { 4976, 23, 20, 23, 0, -20 },
  { 5034, 33, 20, 34, 0, -20 },
  { 5117, 23, 20, 23, 0, -20 },
  { 5175, 23, 29, 23, 0, -20 },
  { 5259, 17, 20, 19, 1, -20 },
  { 5302, 14, 33, 16, 1, -27 },
  { 5360, 5, 36, 19, 7, -28 },
  { 5383, 14, 33, 16, 1, -27 },
  { 5441, 18, 7, 22, 2, -17 },
};

const GFXfont NotoSans_Black37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black37pt7bBitmaps,
  (GFXglyph *)NotoSans_Black37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_BLACK37PT7B_H_
