#ifndef _NOTOSANS_BLACK19PT7B_H_
#define _NOTOSANS_BLACK19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x0E, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0x0E, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x1D, 0xC1,
  0x98, 0xFF, 0xFF, 0xFF, 0x3B, 0x83, 0xB8, 0x3B, 0x83, 0x30, 0x04, 0x07,
  0xF9, 0xFF, 0x3F, 0xEF, 0x40, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xC0, 0xBD,
  0x97, 0x3F, 0xE7, 0xF8, 0x3C, 0x01, 0x00, 0x38, 0x1C, 0x1F, 0x07, 0x07,
  0xE3, 0x83, 0xB8, 0xC0, 0xE6, 0x70, 0x3B, 0x98, 0x07, 0xEE, 0xF1, 0xFF,
  0x7E, 0x39, 0xDD, 0xC0, 0xE6, 0x70, 0x39, 0x9C, 0x1C, 0x76, 0x06, 0x1F,
  0x83, 0x83, 0xC0, 0x1E, 0x00, 0xFE, 0x07, 0xF8, 0x1C, 0xE0, 0x7B, 0x81,
  0xFE, 0x03, 0xF3, 0xDF, 0x9E, 0xFF, 0x7B, 0x9F, 0xCF, 0x3F, 0x3F, 0xFC,
  0xFF, 0xF8, 0xFD, 0xF0, 0xFF, 0xFE, 0x3B, 0x9D, 0xEE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x79, 0xCE, 0x38, 0xE7, 0x9C, 0xE7, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0xB9, 0xDE, 0xE0, 0x0E, 0x03, 0x06, 0xDD, 0xFF, 0xFF, 0xC7, 0x83,
  0xF1, 0xCE, 0x12, 0x00, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xFF, 0xFC, 0x70,
  0x38, 0x1C, 0x00, 0xFE, 0xEE, 0xEC, 0xFF, 0xFF, 0xC0, 0xEF, 0xE0, 0x07,
  0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70,
  0xF0, 0x1C, 0x3F, 0x9F, 0xFE, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xFD, 0xFF, 0xF7, 0xF1, 0xF0, 0x0F, 0x1F, 0x3F, 0x7F, 0xFF, 0x6F, 0x4F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0xEF, 0xFD, 0xCF,
  0x21, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0x7F, 0xDF,
  0xF0, 0x3C, 0x7F, 0xBF, 0xE8, 0xF0, 0x78, 0x78, 0xF8, 0x7E, 0x0F, 0x83,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC1, 0xF8,
  0x3F, 0x0E, 0xE3, 0x9C, 0xF3, 0x9F, 0xFF, 0xFF, 0x81, 0xC0, 0x38, 0x07,
  0x00, 0x7F, 0x3F, 0xBF, 0xDF, 0xEF, 0x07, 0xF3, 0xFD, 0xFF, 0x07, 0x81,
  0xE1, 0xFF, 0xFF, 0xF7, 0xF0, 0x0F, 0x8F, 0xE7, 0xF9, 0xE0, 0xE0, 0x3B,
  0xCF, 0xFB, 0xFE, 0xE3, 0xB8, 0xFF, 0x3B, 0xFE, 0x7F, 0x8F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x38, 0x1E, 0x00, 0x1E, 0x1F, 0xCF, 0xFB, 0xCE, 0xF3, 0x9F,
  0xE3, 0xE1, 0xFC, 0xF7, 0xB8, 0xEE, 0x3F, 0xDE, 0xFF, 0x9F, 0xC0, 0x1C,
  0x3F, 0xBF, 0xFE, 0xFE, 0x3F, 0x1F, 0xDF, 0xFF, 0x7F, 0x81, 0xC1, 0xFF,
  0xEF, 0xE7, 0xE0, 0x6F, 0xFE, 0x00, 0x00, 0xEF, 0xE0, 0x6F, 0xFE, 0x00,
  0x00, 0xFE, 0xEE, 0xEC, 0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x87, 0x81, 0xF0,
  0x3F, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x80, 0x70, 0x3E, 0x07, 0xC0, 0xF8, 0x3C, 0x7F, 0xF8, 0xF0, 0x60, 0x00,
  0x1E, 0x7F, 0xBF, 0xEC, 0x70, 0x38, 0x3C, 0x7C, 0x38, 0x1C, 0x00, 0x00,
  0x03, 0x83, 0xC0, 0xE0, 0x03, 0xC0, 0x3F, 0xF0, 0xF0, 0xF3, 0x80, 0x66,
  0x7F, 0xFD, 0xFC, 0xF3, 0x19, 0xEE, 0x33, 0xDC, 0x67, 0x99, 0xDF, 0xBF,
  0xF7, 0x39, 0xC7, 0x01, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1D, 0xE0, 0x73, 0x83, 0xCE, 0x0F, 0x3C, 0x3F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x7B, 0xC0, 0xF0, 0xFE, 0x1F,
  0xFB, 0xFF, 0x79, 0xFF, 0x1F, 0xE7, 0xBF, 0xE7, 0xFE, 0xF3, 0xFE, 0x3F,
  0xC7, 0xFF, 0xFF, 0xFD, 0xFF, 0x00, 0x0F, 0x87, 0xFD, 0xFF, 0x3C, 0x6F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE1, 0x3F, 0xE3, 0xFC,
  0x3F, 0x80, 0xFC, 0x0F, 0xF8, 0xFF, 0xEF, 0x3E, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0xFB, 0xFD, 0xFE, 0xF0, 0x78, 0x3C, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x07, 0xC1, 0xFE, 0x7F, 0xE7, 0xC6, 0xF0,
  0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0x78, 0xF7, 0xFF, 0x3F,
  0xF1, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFB, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xEF, 0xFF, 0xC0,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC7, 0xFF, 0xFD, 0xF0, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF7, 0x8F,
  0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x3C, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF,
  0x0F, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFC, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFE, 0x37, 0xFE, 0x77, 0xF6, 0x77, 0xF7, 0x67, 0xF7,
  0xE7, 0xF7, 0xE7, 0xF3, 0xE7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF8, 0x3F, 0xE1,
  0xFF, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0xDC, 0xFE, 0xF7, 0xF3, 0xBF,
  0x9F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x7C, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xDE, 0x3E, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0xFC, 0x3F, 0xEF, 0xFF, 0xCF,
  0xF1, 0xFC, 0x7F, 0x7F, 0xFF, 0xFF, 0xBE, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x00, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1E, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF,
  0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xE7, 0x8F, 0x9F, 0xFC, 0x3F, 0xE0,
  0x7F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFC, 0xFC, 0x0F, 0xF8, 0xFF, 0xCF,
  0x3C, 0xF1, 0xCF, 0x1C, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0x78, 0xF3, 0xCF,
  0x3C, 0xF1, 0xEF, 0x0F, 0x1E, 0x3F, 0xFF, 0xFE, 0x2F, 0x07, 0xC1, 0xF8,
  0x7F, 0x1F, 0x83, 0xE0, 0xFF, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7, 0xFE, 0x3F, 0xE1,
  0xF8, 0xF0, 0x7F, 0x83, 0xDE, 0x1E, 0xF1, 0xE7, 0x8F, 0x1C, 0x78, 0xF7,
  0x87, 0xBC, 0x1D, 0xE0, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0xF0, 0xF0, 0xEE, 0x1E, 0x1D, 0xC3, 0xC7, 0xB8, 0xF8, 0xF7, 0x9F, 0x9C,
  0x73, 0xF3, 0x8E, 0x7E, 0x71, 0xCD, 0xDE, 0x3F, 0x9B, 0x83, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF0, 0x1E, 0x1E, 0x00, 0xF0, 0x79,
  0xE1, 0xE3, 0xCF, 0x0F, 0x78, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xC0, 0x7F, 0x83, 0xDE, 0x0F, 0x3C, 0x78, 0x7B, 0xC1, 0xF0, 0xF0,
  0x7B, 0x87, 0x9E, 0x38, 0x73, 0xC3, 0xDC, 0x0F, 0xE0, 0x7E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9F, 0xF8, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x1C, 0x1C,
  0x1E, 0x0E, 0x0E, 0x0F, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xFF, 0xF8, 0x0C, 0x07, 0x01, 0xE0, 0x78, 0x3F, 0x0C, 0xC7,
  0x39, 0x86, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0xC0, 0x1E,
  0x1F, 0xE7, 0xF9, 0x0F, 0x1F, 0xDF, 0xFF, 0x3F, 0x8F, 0xF7, 0xFF, 0xF7,
  0x9C, 0xF0, 0x3C, 0x0F, 0x03, 0xDC, 0xFF, 0xBF, 0xFF, 0x3F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x3F, 0xFF, 0xFF, 0xFB, 0xE0, 0x0E, 0x1F, 0xDF, 0xDE, 0x2F,
  0x07, 0x03, 0xC1, 0xE1, 0xFF, 0x3F, 0x8F, 0xC0, 0x03, 0xC0, 0xF0, 0x3C,
  0xEF, 0x7F, 0xFF, 0xFF, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x3F, 0xFF, 0x7F,
  0xCF, 0x70, 0x1E, 0x1F, 0xE7, 0xFB, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF9, 0x9F, 0xE3, 0xF8, 0x04, 0x1F, 0x3F, 0x3C, 0x3F, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0xDF, 0x7F, 0xFF, 0xCF,
  0xF1, 0xF8, 0x7F, 0x1F, 0xCF, 0xFF, 0xDF, 0xF3, 0xFC, 0x0F, 0xC3, 0xFF,
  0xEF, 0xF0, 0x70, 0xF0, 0x1E, 0x03, 0xC0, 0x7B, 0x8F, 0xFD, 0xFF, 0xBE,
  0xF7, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0x6F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xC0, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xBF, 0xFF, 0x98, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x1E, 0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xFF, 0x8F, 0x3C, 0xF3, 0xEF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0x0E, 0x77, 0xFF, 0xBF, 0xFF, 0xFF, 0x7C, 0xFF, 0x1C,
  0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC,
  0x71, 0xE0, 0xE7, 0x1D, 0xFB, 0xFF, 0x7D, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0x80, 0x1E, 0x1F, 0xE7, 0xFB, 0xCF, 0xF1,
  0xF8, 0x7F, 0x1F, 0xCF, 0xFF, 0xDF, 0xE3, 0xF0, 0xE7, 0x3F, 0xEF, 0xFF,
  0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFB, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x39, 0xDF, 0x7F, 0xFF, 0xCF, 0xF1, 0xF8, 0x7F,
  0x1F, 0xCF, 0xFF, 0xDF, 0xF3, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xE3, 0xEF, 0xFF, 0xFE, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x3C,
  0xFF, 0xFE, 0xE2, 0xFC, 0x7E, 0x3F, 0x0F, 0xEF, 0xFF, 0xFE, 0x18, 0x18,
  0x3F, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xFF, 0xDF, 0xF3,
  0xCC, 0xF0, 0xFF, 0x0E, 0x71, 0xE7, 0x9C, 0x39, 0xC3, 0xBC, 0x3F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF1, 0xE3, 0xB9, 0xF3, 0xDC, 0xF9,
  0xEE, 0x7C, 0xE7, 0xB7, 0x71, 0xDB, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F,
  0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x00, 0xF0, 0xF7, 0x9E, 0x39, 0xC3, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0x3F, 0xC7, 0x9E, 0xF1, 0xF0, 0xF0,
  0xFF, 0x0E, 0x71, 0xE7, 0x9C, 0x39, 0xC3, 0xBC, 0x3F, 0x81, 0xF8, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x07, 0xE0, 0x7C, 0x06, 0x00, 0x7F,
  0xBF, 0xDF, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0E, 0x7C, 0xF9, 0xC3, 0x87, 0x0E, 0x7C, 0xE1, 0xE1, 0xE1, 0xC3, 0x87,
  0x0F, 0x1F, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xE3, 0xC3, 0x87,
  0x0E, 0x1E, 0x1F, 0x1E, 0x7D, 0xE3, 0x87, 0x0E, 0x1C, 0x78, 0xE0, 0x20,
  0xFE, 0x7F, 0xF1, 0xF0,
};

const GFXglyph NotoSans_Black19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 6, 1, -14 },
  { 8, 8, 5, 10, 1, -14 },
  { 13, 12, 14, 13, 0, -14 },
  { 34, 11, 15, 11, 0, -14 },
  { 55, 18, 14, 18, 0, -14 },
  { 87, 14, 14, 15, 1, -14 },
  { 112, 3, 5, 6, 1, -14 },
  { 114, 5, 17, 7, 1, -14 },
  { 125, 5, 17, 7, 1, -14 },
  { 136, 10, 9, 10, 0, -14 },
  { 148, 9, 9, 11, 1, -11 },
  { 159, 4, 6, 6, 1, -3 },
  { 162, 6, 3, 6, 0, -7 },
  { 165, 4, 3, 5, 1, -3 },
  { 167, 8, 14, 8, 0, -14 },
  { 181, 9, 14, 11, 1, -14 },
  { 197, 8, 14, 11, 1, -14 },
  { 211, 10, 14, 11, 0, -14 },
  { 229, 9, 14, 11, 1, -14 },
  { 245, 11, 14, 11, 0, -14 },
  { 265, 9, 14, 11, 1, -14 },
  { 281, 10, 14, 11, 1, -14 },
  { 299, 10, 14, 11, 1, -14 },
  { 317, 10, 14, 11, 1, -14 },
  { 335, 9, 14, 11, 1, -14 },
  { 351, 4, 11, 5, 1, -11 },
  { 357, 4, 14, 6, 1, -11 },
  { 364, 9, 10, 11, 1, -12 },
  { 376, 9, 7, 11, 1, -10 },
  { 384, 9, 10, 11, 1, -12 },
  { 396, 9, 14, 10, 0, -14 },
  { 412, 15, 15, 17, 1, -14 },
  { 441, 14, 14, 14, 0, -14 },
  { 466, 11, 14, 13, 1, -14 },
  { 486, 11, 14, 12, 1, -14 },
  { 506, 12, 14, 14, 1, -14 },
  { 527, 9, 14, 10, 1, -14 },
  { 543, 8, 14, 10, 1, -14 },
  { 557, 12, 14, 14, 1, -14 },
  { 578, 12, 14, 15, 1, -14 },
  { 599, 7, 14, 8, 1, -14 },
  { 612, 7, 18, 7, -2, -14 },
  { 628, 12, 14, 13, 1, -14 },
  { 649, 9, 14, 11, 1, -14 },
  { 665, 16, 14, 18, 1, -14 },
  { 693, 13, 14, 16, 1, -14 },
  { 716, 13, 14, 15, 1, -14 },
  { 739, 10, 14, 12, 1, -14 },
  { 757, 14, 17, 15, 1, -14 },
  { 787, 12, 14, 13, 1, -14 },
  { 808, 9, 14, 11, 1, -14 },
  { 824, 11, 14, 11, 0, -14 },
  { 844, 12, 14, 14, 1, -14 },
  { 865, 13, 14, 13, 0, -14 },
  { 888, 19, 14, 20, 0, -14 },
  { 922, 14, 14, 14, 0, -14 },
  { 947, 13, 14, 13, 0, -14 },
  { 970, 10, 14, 12, 1, -14 },
  { 988, 5, 17, 6, 1, -14 },
  { 999, 8, 14, 8, 0, -14 },
  { 1013, 5, 17, 6, 0, -14 },
  { 1024, 10, 9, 10, 0, -14 },
  { 1036, 10, 3, 10, 0, 1 },
  { 1040, 6, 3, 8, 1, -15 },
  { 1043, 10, 11, 12, 1, -11 },
  { 1057, 10, 14, 12, 1, -14 },
  { 1075, 9, 11, 10, 1, -11 },
  { 1088, 10, 14, 12, 1, -14 },
  { 1106, 10, 11, 12, 1, -11 },
  { 1120, 8, 15, 8, 0, -15 },
  { 1135, 10, 16, 12, 1, -11 },
  { 1155, 11, 14, 13, 1, -14 },
  { 1175, 4, 15, 6, 1, -15 },
  { 1183, 6, 20, 6, -1, -15 },
  { 1198, 12, 14, 13, 1, -14 },
  { 1219, 4, 14, 6, 1, -14 },
  { 1226, 17, 11, 19, 1, -11 },
  { 1250, 11, 11, 13, 1, -11 },
  { 1266, 10, 11, 12, 1, -11 },
  { 1280, 10, 16, 12, 1, -11 },
  { 1300, 10, 16, 12, 1, -11 },
  { 1320, 8, 11, 9, 1, -11 },
  { 1331, 8, 11, 10, 1, -11 },
  { 1342, 8, 13, 9, 0, -13 },
  { 1355, 10, 11, 13, 1, -11 },
  { 1369, 12, 11, 12, 0, -11 },
  { 1386, 17, 11, 17, 0, -11 },
  { 1410, 12, 11, 12, 0, -11 },
  { 1427, 12, 16, 12, 0, -11 },
  { 1451, 9, 11, 10, 0, -11 },
  { 1464, 7, 17, 8, 1, -14 },
  { 1479, 2, 18, 10, 4, -14 },
  { 1484, 7, 17, 8, 1, -14 },
  { 1499, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_Black19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black19pt7bBitmaps,
  (GFXglyph *)NotoSans_Black19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_BLACK19PT7B_H_
