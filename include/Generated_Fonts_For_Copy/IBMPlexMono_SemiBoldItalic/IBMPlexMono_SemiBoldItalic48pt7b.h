#ifndef _IBMPLEXMONO_SEMIBOLDITALIC48PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7,
  0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xF0, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xEF, 0x3F, 0x07, 0xF1, 0xE1, 0xC0, 0xFC, 0x3C, 0x10,
  0x1F, 0x87, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0xC7,
  0x80, 0x01, 0xF8, 0xF0, 0x00, 0x3F, 0xDE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0xFE, 0x00,
  0x07, 0x8F, 0xE0, 0x01, 0xE1, 0xFC, 0x00, 0x3C, 0x1F, 0x80, 0x07, 0x87,
  0xE0, 0x80, 0xF0, 0xFC, 0x38, 0x1E, 0x1F, 0x8F, 0x83, 0xC7, 0xF3, 0xFC,
  0x7B, 0xFC, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x1F, 0xFE, 0x00,
  0xF0, 0x07, 0xFF, 0x80, 0x7C, 0x03, 0xE1, 0xE0, 0x3E, 0x00, 0xF0, 0x7C,
  0x0F, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC3, 0xE0, 0x07, 0x81,
  0xF0, 0xF8, 0x01, 0xE0, 0x7C, 0x7C, 0x00, 0x78, 0x1E, 0x3E, 0x00, 0x1E,
  0x07, 0x8F, 0x80, 0x07, 0x83, 0xE7, 0xC0, 0x01, 0xF1, 0xF3, 0xE0, 0x00,
  0x7F, 0xFC, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3E, 0x7F, 0xF8, 0x00, 0x1F, 0x3E, 0x1E, 0x00, 0x0F, 0x8F,
  0x07, 0xC0, 0x03, 0xC7, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x7C, 0x00, 0xF8,
  0x78, 0x1F, 0x00, 0x3C, 0x1E, 0x07, 0xC0, 0x1F, 0x07, 0x81, 0xE0, 0x0F,
  0x81, 0xE0, 0x78, 0x07, 0xC0, 0x78, 0x3E, 0x01, 0xF0, 0x1F, 0x1F, 0x00,
  0xF8, 0x07, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x1F, 0xF0,
  0x08, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x02, 0x3F, 0x00, 0xFC, 0x3D, 0xFC, 0x0F, 0xE3, 0xFF, 0xE0,
  0x5F, 0x1F, 0x3F, 0x8E, 0xFD, 0xF1, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0x1F,
  0xF8, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0x83, 0xF8, 0x01, 0xF0, 0x07, 0x80,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0xFC, 0xFC, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x02, 0x01, 0xF0, 0x08, 0xF0, 0x7C, 0x1E,
  0x7F, 0x9F, 0x3F, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFD, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x7F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x1E,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F,
  0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xBF, 0xEF, 0xF9, 0xFC, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xE1, 0xE0, 0xFD,
  0xF8, 0xFC, 0x3F, 0x7E, 0x3F, 0x1F, 0xFF, 0x8F, 0xC7, 0xFF, 0xE3, 0xF1,
  0xFF, 0xF8, 0x78, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF,
  0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0xE0, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFB, 0xF0, 0x07,
  0xF3, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0xE3, 0xF0, 0x3F, 0xC7, 0xF0, 0x3F,
  0x87, 0xE0, 0x1F, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x04, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0x17, 0x80, 0x0F, 0xC0, 0x60, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xF0, 0x7C, 0x01,
  0xFC, 0x0E, 0x00, 0x3F, 0x01, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC1, 0x80, 0x07, 0xF0, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0xFE,
  0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x1F,
  0x3F, 0xF8, 0x03, 0xEF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0x7F, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x7E, 0x00, 0xFE, 0x00, 0x80, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x30, 0x00, 0xFE, 0x1E, 0x00,
  0x3F, 0x87, 0xE0, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0xFF, 0xC0, 0xFE, 0xFF,
  0xF0, 0x7E, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0,
  0x1F, 0xCF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xFC, 0x1F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xE0, 0x01, 0xF9, 0xF0,
  0x01, 0xFC, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3E,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F,
  0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0xFE, 0x00, 0xFC,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01,
  0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xFF, 0xDF, 0x8F, 0xFF,
  0xDF, 0x83, 0xFF, 0xCF, 0xC0, 0xFF, 0xCF, 0xE0, 0x1F, 0x8F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x3F, 0x87, 0xFC, 0x7F, 0xCF, 0xF8, 0xFF, 0x8F,
  0xF8, 0x7F, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF9, 0xFE, 0x0F, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0x1C, 0x01,
  0xFC, 0x20, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x3C,
  0x7C, 0xF8, 0x3F, 0x9F, 0x3E, 0x1F, 0xF7, 0xCF, 0x8F, 0xFD, 0xF7, 0xC3,
  0xF1, 0xF9, 0xF1, 0xF8, 0x3E, 0x7C, 0x7C, 0x0F, 0x9F, 0x1F, 0x03, 0xE7,
  0xC7, 0xC0, 0xFB, 0xF3, 0xF0, 0x3E, 0xF8, 0xF8, 0x0F, 0x3E, 0x3E, 0x07,
  0xCF, 0x8F, 0x81, 0xF3, 0xE3, 0xE0, 0x7C, 0xF8, 0xF8, 0x3F, 0x3E, 0x3E,
  0x1F, 0xCF, 0x8F, 0xFD, 0xE3, 0xE1, 0xFF, 0xF8, 0xF8, 0x7F, 0xBE, 0x3E,
  0x0F, 0xCF, 0x8F, 0x80, 0x40, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x7E, 0x00,
  0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xE3, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x01,
  0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xC3, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFC,
  0x1F, 0xE0, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xF0, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1,
  0xF8, 0x07, 0xF0, 0x7E, 0x07, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xC3, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xFF, 0x9F, 0x81, 0xFF, 0xE7,
  0xE0, 0x7F, 0xF1, 0xF8, 0x1F, 0xFC, 0xFE, 0x0F, 0xFF, 0x3F, 0x80, 0x0F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xE0, 0xFF, 0x83, 0xFF, 0xF7, 0xC0, 0xFF, 0xFD, 0xF0, 0x1F, 0xFE, 0x7C,
  0x03, 0xFF, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF8,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x10,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0xC3, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x1F,
  0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F,
  0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x80,
  0x07, 0xE3, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF,
  0xE0, 0x00, 0xFF, 0x1F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3E,
  0xF8, 0xF7, 0xE0, 0xFB, 0xE7, 0xDF, 0x03, 0xE7, 0x9E, 0x7C, 0x0F, 0x9F,
  0xF9, 0xF0, 0x3E, 0x7F, 0xCF, 0xC1, 0xF9, 0xFF, 0x3F, 0x07, 0xE3, 0xF8,
  0xFC, 0x1F, 0x8F, 0xE3, 0xE0, 0x7C, 0x3F, 0x0F, 0x81, 0xF0, 0xFC, 0x3E,
  0x07, 0xC3, 0xE1, 0xF8, 0x3F, 0x07, 0x87, 0xE0, 0xFC, 0x1C, 0x1F, 0x83,
  0xF0, 0x70, 0x7C, 0x0F, 0x81, 0x81, 0xF0, 0x3E, 0x06, 0x07, 0xC0, 0xF8,
  0x10, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x01,
  0xF0, 0x3F, 0xC0, 0x3F, 0x07, 0xFC, 0x03, 0xF0, 0x7F, 0xC0, 0x3F, 0x07,
  0xFC, 0x03, 0xE0, 0x7F, 0xE0, 0x3E, 0x07, 0xFE, 0x03, 0xE0, 0x7F, 0xE0,
  0x7E, 0x0F, 0xFE, 0x07, 0xE0, 0xFF, 0xE0, 0x7E, 0x0F, 0xBE, 0x07, 0xC0,
  0xF9, 0xF0, 0x7C, 0x0F, 0x9F, 0x07, 0xC0, 0xF9, 0xF0, 0xFC, 0x1F, 0x9F,
  0x0F, 0xC1, 0xF9, 0xF0, 0xFC, 0x1F, 0x8F, 0x8F, 0x81, 0xF0, 0xF8, 0xF8,
  0x1F, 0x0F, 0x8F, 0x81, 0xF0, 0xF9, 0xF8, 0x3F, 0x0F, 0x9F, 0x83, 0xF0,
  0xFD, 0xF8, 0x3F, 0x07, 0xDF, 0x03, 0xE0, 0x7D, 0xF0, 0x3E, 0x07, 0xDF,
  0x03, 0xE0, 0x7F, 0xF0, 0x7E, 0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xF0, 0x7E,
  0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x3F,
  0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F,
  0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xE1,
  0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xF8, 0x0F, 0xF0, 0xFE, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF1,
  0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x1F,
  0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0,
  0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF,
  0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x08, 0x00, 0x3F, 0x07, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xF9, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xF8, 0x0F, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x07, 0xF1, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07,
  0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x18, 0x0F, 0xC0,
  0x02, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x40,
  0x00, 0xFE, 0x1C, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF1, 0xFF, 0x03, 0xFC,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03,
  0xF8, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F,
  0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x07, 0xE1, 0xF0,
  0xFC, 0x3F, 0x87, 0xC3, 0xF0, 0xFE, 0x1F, 0x0F, 0x83, 0xF8, 0x7C, 0x3E,
  0x1F, 0xE3, 0xF0, 0xF8, 0x7F, 0x8F, 0x83, 0xE1, 0xFE, 0x3E, 0x0F, 0x8F,
  0x78, 0xF8, 0x3E, 0x3D, 0xE3, 0xE0, 0xF8, 0xE7, 0x9F, 0x03, 0xE7, 0x9E,
  0x7C, 0x1F, 0x9E, 0x79, 0xF0, 0x7E, 0x71, 0xE7, 0xC1, 0xF3, 0xC7, 0x9E,
  0x07, 0xCF, 0x1E, 0xF8, 0x1F, 0x3C, 0x7B, 0xE0, 0x7D, 0xE1, 0xEF, 0x81,
  0xF7, 0x87, 0xBE, 0x07, 0xDE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0,
  0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x1F,
  0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xCF, 0x80,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xEF,
  0xC0, 0x00, 0xFC, 0xE0, 0x00, 0x3C, 0x08, 0x00, 0x08, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x04, 0x0E, 0x1F, 0x1F, 0xC7, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87,
  0xC1, 0x00, 0x00, 0xFC, 0x1F, 0x81, 0xFF, 0x9F, 0xC1, 0xFF, 0xEF, 0xC1,
  0xFF, 0xF7, 0xE1, 0xFE, 0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x03,
  0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00,
  0x7F, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x6F, 0xC3, 0xF8, 0x7F, 0xF9, 0xFF,
  0xF7, 0xFC, 0x7F, 0xF1, 0xFE, 0x1F, 0xF0, 0x7F, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x87, 0xE0, 0x0F, 0xC7, 0xFE, 0x03, 0xF3, 0xFF, 0xC0, 0xFD, 0xFF,
  0xF0, 0x3F, 0x70, 0xFE, 0x0F, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xE1, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F,
  0xBF, 0xFF, 0x07, 0xEF, 0xFF, 0x81, 0xF9, 0xFF, 0xC0, 0x80, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1C, 0x1F, 0x80, 0x20,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x63, 0xF0, 0x01, 0xE7, 0xF0, 0x07, 0xE7, 0xE0,
  0x1F, 0x8F, 0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0xF9, 0xF8,
  0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0xF7, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0x80,
  0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03,
  0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x0E, 0xFC, 0x0F, 0xFF, 0x9F, 0x80, 0xFF,
  0xF7, 0xE0, 0x0F, 0xF8, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xE3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC,
  0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0xFF, 0xEF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x43, 0xF0, 0x01, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x7F,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x1F, 0x80, 0x00,
  0x78, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x7F, 0xF3, 0xF0, 0x3F,
  0xFC, 0xFC, 0x1F, 0xFF, 0xBF, 0x0F, 0xF0, 0x7F, 0xC3, 0xF0, 0x0F, 0xE1,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF8, 0x3F, 0x87, 0x7E,
  0x0F, 0xFF, 0xDF, 0x81, 0xFF, 0xE7, 0xE0, 0x3F, 0xF1, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x10,
  0x01, 0xF8, 0x0E, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7,
  0xFC, 0x1F, 0x9F, 0xFE, 0x1F, 0x9F, 0xFE, 0x1F, 0xB8, 0x7F, 0x1F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x80, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x40, 0x1F, 0xC0, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F,
  0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x10, 0x0F, 0xC0,
  0x38, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x0F, 0xC7, 0xFC, 0x07, 0xE7, 0xFF, 0x81, 0xF9, 0xFF, 0xF0, 0x7E, 0xE1,
  0xFC, 0x1F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE,
  0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x3F, 0x0F, 0xF0, 0x1F, 0x8F, 0xF0, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x02, 0x1F, 0x8F, 0xC0, 0xE7, 0xE1,
  0xF8, 0x7F, 0xF0, 0x7E, 0x3E, 0xFC, 0x1F, 0x9F, 0x3F, 0x03, 0xFF, 0x8F,
  0xC0, 0xFF, 0xC3, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x08, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x02, 0x03, 0xF0, 0x1C, 0x1F, 0x81, 0xF0,
  0xFC, 0x1F, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x03, 0xF9, 0xF0, 0x0F, 0x9F,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x8F, 0x07, 0xC0, 0xFB, 0xF8, 0xFE, 0x1F, 0xBF, 0x9F, 0xF1, 0xF7,
  0xFD, 0xFF, 0x1F, 0x4F, 0xF3, 0xF1, 0xF8, 0x7E, 0x1F, 0x1F, 0x07, 0xC1,
  0xF1, 0xF0, 0x7C, 0x1F, 0x3F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x3F, 0x3E,
  0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0xF8,
  0x3E, 0x7C, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x7E, 0x7C, 0x1F, 0x07, 0xC7,
  0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0xFC, 0x1F,
  0x07, 0xCF, 0x83, 0xE0, 0xFC, 0xF8, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0xF8,
  0xF8, 0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xFC, 0x1F, 0x9F,
  0xFE, 0x1F, 0x9F, 0xFE, 0x1F, 0xB8, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0,
  0x7E, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x7C, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x3F, 0x83,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0xE0, 0x1F, 0x9F, 0xFE, 0x03,
  0xF7, 0xFF, 0xC0, 0x7E, 0xE1, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xFC, 0x03,
  0xF0, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0,
  0x7F, 0xC1, 0xFE, 0x0F, 0xDF, 0xFF, 0x81, 0xFB, 0xFF, 0xE0, 0x3F, 0x3F,
  0xF8, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x1F, 0x81, 0xFF, 0xCF, 0xC1, 0xFF, 0xE7, 0xE1, 0xFF, 0xFB,
  0xF1, 0xFE, 0x0F, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0,
  0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F,
  0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0xC3, 0xF8, 0x77, 0xE1, 0xFF, 0xF3, 0xF0,
  0x7F, 0xF9, 0xF0, 0x1F, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0xFF, 0xF1, 0xFE, 0xFF,
  0xF3, 0xFE, 0x03, 0xF7, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x1C, 0x1F,
  0x80, 0x08, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x10,
  0x00, 0xFC, 0x10, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFF, 0x03, 0xF8, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x10, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF8, 0xFC, 0x05, 0xF8, 0xFE,
  0x1D, 0xF8, 0x7F, 0xFB, 0xF0, 0x7F, 0xF3, 0xF0, 0x3F, 0xE3, 0xF0, 0x0F,
  0x80, 0x00, 0x7F, 0xE0, 0x06, 0x7F, 0xE0, 0x3E, 0xFF, 0xE0, 0x7E, 0xFF,
  0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x83, 0xF0, 0x1F, 0x0F, 0xF0, 0x1F, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x83,
  0xE0, 0xF8, 0xF8, 0x7C, 0x1E, 0x1F, 0x0F, 0x07, 0xC3, 0xE3, 0xE0, 0xF8,
  0x7C, 0x7C, 0x1F, 0x07, 0x8F, 0x83, 0xE0, 0xF9, 0xF0, 0x7C, 0x1F, 0x3E,
  0x0F, 0x83, 0xE7, 0x81, 0xE0, 0x7D, 0xF0, 0x7C, 0x0F, 0x3E, 0x0F, 0x83,
  0xE7, 0xC1, 0xF0, 0x7C, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xC1, 0xF3, 0xE0,
  0xF0, 0x3E, 0xF8, 0x3E, 0x07, 0x9F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x3E,
  0x7C, 0x1F, 0x07, 0x8F, 0x85, 0xE1, 0xF1, 0xF1, 0xBC, 0x3C, 0x3F, 0xF7,
  0x8F, 0x03, 0xFC, 0xFF, 0xC0, 0x7F, 0x0F, 0xF0, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xC7, 0xFC, 0x1F,
  0xFE, 0x7F, 0xF1, 0xFC, 0xF3, 0x9F, 0x9F, 0xC7, 0xB8, 0x7C, 0x78, 0x3F,
  0x83, 0xE1, 0x81, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xC1, 0xFC, 0x04, 0x3E, 0x0F, 0xE0, 0x71, 0xF0, 0x7F, 0x07,
  0x8F, 0x86, 0xF8, 0xFE, 0x7E, 0x73, 0xCF, 0xE3, 0xFF, 0x9F, 0xFE, 0x0F,
  0xF8, 0xFF, 0xE0, 0x7F, 0x83, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F,
  0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x87, 0x7E, 0x07, 0xFF, 0x9F, 0x81, 0xFF,
  0xEF, 0xC0, 0x3F, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x20, 0x01, 0xF8, 0x0C, 0x00, 0xFC,
  0x07, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0xF8,
  0x1F, 0xFF, 0x9F, 0x07, 0xFF, 0xFB, 0xE0, 0xF8, 0x3F, 0xFC, 0x3E, 0x01,
  0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0xF8, 0x07, 0xF0, 0x1F, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x0F, 0xE0, 0x70, 0x03,
  0xF8, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x3F, 0x80, 0x3E, 0x0F, 0xE0, 0x07,
  0xC3, 0xFF, 0x80, 0xF8, 0xFB, 0xFF, 0x9F, 0x1F, 0x1F, 0xFF, 0xC3, 0xE0,
  0xFF, 0xF8, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0x80, 0xFF, 0x00, 0x7C, 0x3F, 0xF0,
  0x0F, 0x8F, 0xFF, 0x03, 0xE1, 0xFF, 0xF0, 0x7C, 0x7E, 0x7E, 0x1F, 0x0F,
  0x87, 0xE3, 0xE3, 0xE0, 0x7F, 0xF8, 0x7C, 0x0F, 0xFF, 0x0F, 0x00, 0xFF,
  0xC3, 0xE0, 0x0F, 0xF0, 0x1C, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 13, 35, 29, 8, -34 },
  { 58, 18, 15, 29, 8, -36 },
  { 92, 30, 34, 29, 0, -34 },
  { 220, 27, 45, 29, 1, -39 },
  { 372, 34, 35, 29, -2, -34 },
  { 521, 29, 35, 29, 0, -34 },
  { 648, 8, 15, 29, 13, -36 },
  { 663, 19, 43, 29, 9, -36 },
  { 766, 20, 43, 29, 1, -36 },
  { 874, 26, 24, 29, 2, -26 },
  { 952, 24, 22, 29, 3, -26 },
  { 1018, 14, 15, 29, 5, -8 },
  { 1045, 16, 5, 29, 7, -17 },
  { 1055, 10, 9, 29, 8, -8 },
  { 1067, 29, 43, 29, 0, -36 },
  { 1223, 26, 35, 29, 2, -34 },
  { 1337, 24, 34, 29, 2, -34 },
  { 1439, 26, 34, 29, 1, -34 },
  { 1550, 26, 35, 29, 1, -34 },
  { 1664, 27, 34, 29, 0, -34 },
  { 1779, 27, 35, 29, 1, -34 },
  { 1898, 25, 35, 29, 2, -34 },
  { 2008, 25, 34, 29, 4, -34 },
  { 2115, 27, 35, 29, 1, -34 },
  { 2234, 25, 34, 29, 3, -34 },
  { 2341, 12, 26, 29, 8, -25 },
  { 2380, 15, 32, 29, 5, -25 },
  { 2440, 23, 28, 29, 4, -29 },
  { 2521, 25, 15, 29, 2, -22 },
  { 2568, 24, 28, 29, 2, -29 },
  { 2652, 22, 35, 29, 5, -34 },
  { 2749, 26, 39, 29, 2, -34 },
  { 2876, 27, 34, 29, -1, -34 },
  { 2991, 25, 34, 29, 2, -34 },
  { 3098, 26, 35, 29, 3, -34 },
  { 3212, 26, 34, 29, 2, -34 },
  { 3323, 27, 34, 29, 2, -34 },
  { 3438, 27, 34, 29, 2, -34 },
  { 3553, 26, 35, 29, 2, -34 },
  { 3667, 28, 34, 29, 1, -34 },
  { 3786, 27, 34, 29, 2, -34 },
  { 3901, 26, 35, 29, 2, -34 },
  { 4015, 30, 34, 29, 2, -34 },
  { 4143, 22, 34, 29, 3, -34 },
  { 4237, 30, 34, 29, 0, -34 },
  { 4365, 28, 34, 29, 1, -34 },
  { 4484, 26, 35, 29, 2, -34 },
  { 4598, 26, 34, 29, 2, -34 },
  { 4709, 26, 44, 29, 2, -34 },
  { 4852, 26, 34, 29, 2, -34 },
  { 4963, 27, 35, 29, 1, -34 },
  { 5082, 27, 34, 29, 4, -34 },
  { 5197, 26, 35, 29, 3, -34 },
  { 5311, 27, 34, 29, 4, -34 },
  { 5426, 30, 34, 29, 1, -34 },
  { 5554, 32, 34, 29, -1, -34 },
  { 5690, 28, 34, 29, 4, -34 },
  { 5809, 29, 34, 29, 0, -34 },
  { 5933, 22, 43, 29, 6, -36 },
  { 6052, 13, 43, 29, 8, -36 },
  { 6122, 22, 43, 29, 1, -36 },
  { 6241, 26, 21, 29, 2, -34 },
  { 6310, 23, 5, 29, 0, 4 },
  { 6325, 9, 11, 29, 9, -39 },
  { 6338, 25, 26, 29, 2, -25 },
  { 6420, 26, 37, 29, 1, -36 },
  { 6541, 23, 26, 29, 3, -25 },
  { 6616, 27, 37, 29, 2, -36 },
  { 6741, 23, 26, 29, 3, -25 },
  { 6816, 32, 46, 29, -1, -36 },
  { 7000, 26, 35, 29, 1, -25 },
  { 7114, 24, 36, 29, 2, -36 },
  { 7222, 23, 38, 29, 3, -37 },
  { 7332, 24, 47, 29, 1, -37 },
  { 7473, 26, 37, 29, 2, -36 },
  { 7594, 21, 37, 29, 4, -36 },
  { 7692, 28, 25, 29, 0, -25 },
  { 7780, 24, 25, 29, 2, -25 },
  { 7855, 24, 26, 29, 2, -25 },
  { 7933, 27, 35, 29, 0, -25 },
  { 8052, 25, 35, 29, 2, -25 },
  { 8162, 24, 25, 29, 5, -25 },
  { 8237, 24, 26, 29, 2, -25 },
  { 8315, 24, 35, 29, 3, -34 },
  { 8420, 24, 26, 29, 3, -25 },
  { 8498, 24, 26, 29, 2, -25 },
  { 8576, 27, 26, 29, 1, -25 },
  { 8664, 29, 26, 29, 0, -25 },
  { 8759, 26, 35, 29, 1, -25 },
  { 8873, 27, 26, 29, 1, -25 },
  { 8961, 23, 43, 29, 5, -36 },
  { 9085, 12, 43, 29, 9, -36 },
  { 9150, 24, 43, 29, 1, -36 },
  { 9279, 27, 12, 29, 1, -21 },
};

const GFXfont IBMPlexMono_SemiBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC48PT7B_H_
