#ifndef _IBMPLEXMONO_SEMIBOLDITALIC47PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x0F, 0xDF, 0x87, 0xEF, 0xC3,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0x83,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xF0, 0x78, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xCF, 0x7F, 0x07, 0xF1,
  0xE3, 0xC0, 0xFC, 0x3C, 0x30, 0x1F, 0x07, 0x00, 0x07, 0xE1, 0xE0, 0x00,
  0xFC, 0x3C, 0x00, 0x1F, 0xC7, 0x80, 0x01, 0xFC, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xCF,
  0xF0, 0x00, 0x78, 0xFE, 0x00, 0x0F, 0x0F, 0xC0, 0x01, 0xE1, 0xF8, 0x00,
  0x3C, 0x3F, 0x04, 0x07, 0x87, 0xE1, 0xC0, 0xE1, 0xFC, 0x7C, 0x3C, 0x7F,
  0x1F, 0xE7, 0x9F, 0xE3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x07, 0x80, 0x7F,
  0xF0, 0x07, 0xC0, 0x7F, 0xFC, 0x07, 0xC0, 0x3E, 0x3E, 0x03, 0xC0, 0x3E,
  0x0F, 0x03, 0xE0, 0x1F, 0x07, 0x83, 0xE0, 0x0F, 0x03, 0xC1, 0xE0, 0x07,
  0x81, 0xE1, 0xF0, 0x03, 0xC0, 0xF1, 0xF0, 0x01, 0xE0, 0xF8, 0xF0, 0x00,
  0xF0, 0x7C, 0xF8, 0x00, 0x7C, 0x7C, 0xF8, 0x00, 0x3F, 0xFE, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0xFF,
  0x00, 0x07, 0xCF, 0x8F, 0x80, 0x07, 0xCF, 0x83, 0xC0, 0x03, 0xC7, 0x81,
  0xE0, 0x03, 0xE3, 0xC0, 0xF0, 0x03, 0xE3, 0xE0, 0x78, 0x01, 0xE1, 0xF0,
  0x3C, 0x01, 0xE0, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x1F, 0x01, 0xF0, 0x3E,
  0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0x80, 0xF8, 0x03,
  0xFF, 0x80, 0x78, 0x00, 0xFF, 0x80, 0x40, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFB,
  0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC,
  0x07, 0xE0, 0x8F, 0xC0, 0x7E, 0x0E, 0xFC, 0x07, 0xE1, 0xFF, 0xE0, 0xFF,
  0x3E, 0x7F, 0x1D, 0xF3, 0xE7, 0xFF, 0x9F, 0xFC, 0x7F, 0xF8, 0xFF, 0x83,
  0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x3E,
  0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0xC0, 0x7C, 0x04, 0x78, 0x7E, 0x1E, 0x7F, 0xBE, 0x7F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xF7, 0xE0, 0x07, 0xF1, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x0F, 0x00, 0x30, 0x07, 0x00, 0x10, 0x02, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x00,
  0xF9, 0xFC, 0x00, 0x3E, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x78, 0x7E, 0xFE, 0x3F, 0x1F, 0xBF, 0x8F, 0xC7, 0xEF,
  0xC3, 0xE1, 0xFB, 0xF0, 0xF8, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFB, 0xF0, 0x07, 0xF3,
  0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F, 0xC7, 0xE0, 0x3F, 0x87,
  0xE0, 0x3F, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x0C, 0x0F, 0xC0, 0x08, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x07, 0x80, 0x1F,
  0xC0, 0x60, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83,
  0xFC, 0x1F, 0xF0, 0x7C, 0x01, 0xFC, 0x0E, 0x00, 0x7F, 0x01, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x06, 0x00, 0x1F, 0xC3, 0x80, 0x07, 0xE3, 0xF0,
  0x03, 0xF8, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x3F,
  0xF0, 0x03, 0xEF, 0xFF, 0x80, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x81, 0x00, 0x07, 0xE0, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x7F,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0,
  0x3F, 0x9F, 0xF8, 0x3F, 0x3F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7E, 0xFF, 0xFE,
  0x7F, 0xC1, 0xFF, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7F, 0x83, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xE0, 0x03, 0xF9, 0xF0, 0x01,
  0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x3E, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xE7, 0xE0,
  0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0x7F, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7F,
  0x00, 0xFF, 0x7F, 0x83, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0x7E, 0x1F,
  0xFE, 0xFC, 0x0F, 0xFD, 0xFC, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFE, 0x1F, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x87, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0xBF, 0x83, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0x18, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF0, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x83, 0xE3,
  0xCF, 0x83, 0xFB, 0xE7, 0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFB, 0xE1, 0xF0,
  0xFD, 0xF1, 0xF8, 0x3E, 0xF8, 0xF8, 0x1F, 0x7C, 0x7C, 0x0F, 0x3E, 0x7C,
  0x0F, 0xBE, 0x3E, 0x07, 0xDF, 0x1F, 0x03, 0xEF, 0x8F, 0x81, 0xF7, 0xC7,
  0xC0, 0xFB, 0xE3, 0xE0, 0xF9, 0xF1, 0xF0, 0x7C, 0xF8, 0xF8, 0x7E, 0x7C,
  0x7E, 0xFF, 0x3E, 0x1F, 0xEF, 0x9F, 0x0F, 0xF7, 0xCF, 0x83, 0xF3, 0xC7,
  0xC0, 0x40, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7E, 0x03, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x7F, 0x87,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x40, 0xFC, 0x00, 0x7C, 0x7E, 0x00,
  0x7F, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x7F, 0x83, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7E, 0x07, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9,
  0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7F,
  0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xFC, 0x3F, 0x80,
  0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0x3F, 0x07, 0xFF, 0x9F,
  0x83, 0xFF, 0xDF, 0xC1, 0xFF, 0xEF, 0xE0, 0xFF, 0xE7, 0xF0, 0x01, 0xF3,
  0xF8, 0x00, 0xF9, 0xFC, 0x00, 0x7C, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x3F, 0xC1, 0xFF, 0xFB,
  0xE0, 0xFF, 0xFB, 0xF0, 0x3F, 0xF9, 0xF8, 0x0F, 0xF8, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x80,
  0x3F, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x18, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xF0, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x1F,
  0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xE1, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF1,
  0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0xFF, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xBE, 0x3D, 0xF0, 0x7D, 0xF3, 0xEF,
  0x83, 0xEF, 0x9E, 0x7C, 0x1F, 0x3D, 0xF7, 0xE0, 0xF9, 0xFF, 0x3E, 0x0F,
  0xCF, 0xF9, 0xF0, 0x7E, 0x7F, 0x8F, 0x83, 0xE3, 0xFC, 0x7C, 0x1F, 0x0F,
  0xC7, 0xE0, 0xF8, 0x7E, 0x3F, 0x07, 0xC3, 0xE1, 0xF0, 0x7E, 0x1E, 0x0F,
  0x83, 0xF0, 0xF0, 0x7C, 0x1F, 0x83, 0x03, 0xE0, 0xF8, 0x18, 0x3F, 0x07,
  0xC0, 0x81, 0xF8, 0x3E, 0x04, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x03, 0xE0, 0xFF, 0x00, 0x7C, 0x1F, 0xF0, 0x0F, 0x83, 0xFE,
  0x01, 0xF0, 0x7F, 0xC0, 0x7E, 0x0F, 0xF8, 0x0F, 0xC1, 0xFF, 0x01, 0xF0,
  0x7F, 0xF0, 0x3E, 0x0F, 0xFE, 0x07, 0xC1, 0xF7, 0xC0, 0xF8, 0x3E, 0xF8,
  0x3F, 0x07, 0xDF, 0x07, 0xE0, 0xF9, 0xF0, 0xF8, 0x3F, 0x3E, 0x1F, 0x07,
  0xE7, 0xC3, 0xE0, 0xF8, 0xF8, 0x7C, 0x1F, 0x1F, 0x1F, 0x83, 0xE1, 0xF3,
  0xF0, 0x7C, 0x3E, 0x7C, 0x1F, 0x87, 0xCF, 0x83, 0xF0, 0xF9, 0xF0, 0x7C,
  0x1F, 0x3E, 0x0F, 0x81, 0xFF, 0xC1, 0xF0, 0x3F, 0xF8, 0x3E, 0x07, 0xFE,
  0x0F, 0xC0, 0xFF, 0xC1, 0xF8, 0x1F, 0xF8, 0x3E, 0x03, 0xFF, 0x07, 0xC0,
  0x3F, 0xE0, 0xF8, 0x07, 0xFC, 0x1F, 0x00, 0xFF, 0x07, 0xE0, 0x1F, 0xE0,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F,
  0x87, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7F, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFE,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xC1, 0xFE,
  0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0x00, 0x07, 0xE0,
  0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x07,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x01, 0xE0,
  0x7E, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x02, 0x00, 0x07, 0xE0, 0xE0, 0x01, 0xFC, 0x3E, 0x00, 0x3F, 0x8F, 0xF8,
  0x1F, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F,
  0x87, 0xF0, 0xF8, 0x3E, 0x1F, 0xC3, 0xE0, 0xF8, 0x7F, 0x0F, 0x83, 0xE3,
  0xFC, 0x7C, 0x0F, 0x8F, 0xF1, 0xF0, 0x3E, 0x3B, 0xC7, 0xC0, 0xF9, 0xEF,
  0x1F, 0x07, 0xE7, 0xBC, 0x78, 0x1F, 0x1C, 0xF3, 0xE0, 0x7C, 0xF3, 0xCF,
  0x81, 0xF3, 0xCF, 0x3E, 0x07, 0xCE, 0x3C, 0xF8, 0x1F, 0x78, 0xF7, 0xC0,
  0x7D, 0xE3, 0xDF, 0x01, 0xF7, 0x0F, 0x7C, 0x07, 0xFC, 0x3D, 0xF0, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x02, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF1, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE3, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0x1C, 0x3E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x82, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0x07, 0xFF, 0xBF, 0x0F,
  0xFF, 0xBF, 0x1F, 0xC1, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x1D, 0xFF, 0x7F, 0xFD, 0xFE, 0x3F,
  0xF8, 0xFE, 0x1F, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0xFF, 0xC0, 0xFC, 0xFF,
  0xE0, 0x7E, 0xFF, 0xF8, 0x3F, 0xE1, 0xFC, 0x1F, 0x60, 0x7F, 0x1F, 0xE0,
  0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0x83, 0xF8,
  0x7E, 0xFF, 0xF8, 0x3F, 0x7F, 0xF8, 0x1F, 0x9F, 0xF8, 0x10, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xC1, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x06, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x01, 0x8F, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0x7E, 0x01, 0xF9, 0xFC,
  0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x0F, 0xFC, 0x7E, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0xFF, 0x0F, 0xE0, 0x6F, 0x81, 0xFC, 0x3F, 0xE0, 0x7F, 0xFD, 0xF8,
  0x0F, 0xFE, 0x7E, 0x01, 0xFF, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFE, 0x0F,
  0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7C,
  0xFC, 0x01, 0xFB, 0xF8, 0x0F, 0xF7, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x83, 0xF0, 0x01, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xE0,
  0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x78, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE3, 0xF0, 0x3F, 0xFC, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87,
  0xF0, 0x1F, 0xE0, 0xFC, 0x07, 0xF8, 0x3F, 0x87, 0x7E, 0x0F, 0xFF, 0x9F,
  0x01, 0xFF, 0xEF, 0xC0, 0x3F, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x20, 0x01, 0xF8, 0x0C,
  0x00, 0xFC, 0x07, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x7C, 0x7F, 0xC1, 0xF9, 0xFF, 0xC3, 0xF7, 0xFF, 0xC7,
  0xEC, 0x3F, 0x8F, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBF, 0x00, 0x3E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x30, 0x0F, 0xC0, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0x80,
  0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x04, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x10,
  0x0F, 0xC0, 0x38, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xDF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x01, 0xF1, 0xFF,
  0x81, 0xF9, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0, 0x7E, 0xC3, 0xF8, 0x3F, 0xC0,
  0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7C,
  0x1F, 0xC0, 0x7E, 0x7F, 0x80, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xC7, 0xE0, 0x47, 0xE3, 0xF0, 0x73, 0xE1, 0xF8, 0x7F, 0xF0, 0x7E, 0x7D,
  0xF8, 0x3F, 0x7C, 0xFC, 0x0F, 0xFE, 0x7E, 0x07, 0xFE, 0x3F, 0x01, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0x03, 0xF0, 0x7C, 0x1F, 0x87, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E,
  0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0xFB, 0xF8, 0xFE, 0x0F, 0x3F,
  0x9F, 0xE1, 0xF7, 0xFB, 0xFE, 0x1F, 0xCF, 0xA3, 0xE1, 0xF8, 0xFE, 0x3F,
  0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E, 0x1E, 0x0F, 0x83, 0xE3, 0xE0,
  0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x83,
  0xC3, 0xE1, 0xF0, 0x7C, 0x3C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0x87, 0xC1, 0xE0,
  0xF8, 0x78, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F,
  0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x9F,
  0xF0, 0x7E, 0x7F, 0xF0, 0xFD, 0xFF, 0xF1, 0xFB, 0x0F, 0xE3, 0xFC, 0x0F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xDF,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x3F, 0x87,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0xFF, 0xC0, 0x7E, 0x7F, 0xF0, 0x1F,
  0xBF, 0xFE, 0x07, 0xFC, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0xFC,
  0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xF8, 0x3F,
  0x83, 0xF7, 0xFF, 0xC0, 0xFD, 0xFF, 0xE0, 0x7F, 0x3F, 0xF0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xC1, 0xFF,
  0xEF, 0xE1, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFC,
  0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x8F, 0xE0, 0x6F, 0x83, 0xF8, 0x7F,
  0xC1, 0xFF, 0xF7, 0xE0, 0x7F, 0xF3, 0xF0, 0x1F, 0xF1, 0xF8, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xF7,
  0xFF, 0xBF, 0xE0, 0x7F, 0x7F, 0xC0, 0xFD, 0xC0, 0x01, 0xFA, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0xFE, 0x07, 0xC3, 0xF0, 0x07, 0x07, 0xE0, 0x04, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x40, 0x03, 0xF1, 0x80, 0x07, 0xE7, 0x80, 0x1F,
  0x9F, 0xE0, 0x7F, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x30, 0x0F, 0xC0, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x1F, 0x80,
  0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFE, 0x1B, 0xF0, 0xFF, 0xFB, 0xF0, 0x7F,
  0xF3, 0xF0, 0x3F, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x7F,
  0xE0, 0x3E, 0x7F, 0xE0, 0xFE, 0xFF, 0xE0, 0x7E, 0xFF, 0xE0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0x87, 0xC1, 0xE3, 0xE1, 0xF0, 0xF8, 0x78,
  0x78, 0x3E, 0x1F, 0x3E, 0x0F, 0x87, 0xCF, 0x83, 0xE1, 0xF3, 0xE0, 0xF8,
  0x7C, 0xF8, 0x3C, 0x1F, 0x3E, 0x0F, 0x07, 0xCF, 0x07, 0xC1, 0xF7, 0xC1,
  0xF0, 0x7D, 0xF0, 0x7C, 0x1F, 0x7C, 0x1F, 0x07, 0xDF, 0x07, 0x81, 0xE7,
  0xC1, 0xE0, 0x79, 0xE0, 0xF8, 0x3E, 0xF8, 0x3E, 0x0F, 0xBE, 0x0F, 0x83,
  0xCF, 0x83, 0xE0, 0xF3, 0xE1, 0xF8, 0x7C, 0xF8, 0x5E, 0x1E, 0x3E, 0x37,
  0x8F, 0x0F, 0xF9, 0xE7, 0xC3, 0xFE, 0x7F, 0xE0, 0x7F, 0x0F, 0xF0, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0xE1, 0xFE, 0x07, 0xFE,
  0x1F, 0xF0, 0xFF, 0xF3, 0xFF, 0x3F, 0xDF, 0x71, 0xF3, 0xF1, 0xF6, 0x1F,
  0x1E, 0x1F, 0x61, 0xF1, 0x80, 0xF4, 0x1F, 0x00, 0x1F, 0xC1, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0x83, 0xF8, 0x10, 0xF8, 0x3F, 0x81, 0x8F, 0x86, 0xF8,
  0x7C, 0xF8, 0x6F, 0x8F, 0xCF, 0x8E, 0xFB, 0xFE, 0xFF, 0xC7, 0xFF, 0x07,
  0xFC, 0x7F, 0xE0, 0x7F, 0x87, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x37, 0xC0,
  0xFE, 0x1F, 0xF0, 0x1F, 0xFE, 0xFC, 0x07, 0xFF, 0x3F, 0x00, 0xFF, 0x8F,
  0xC0, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x80, 0x0F, 0xC0, 0x30, 0x03, 0xF0, 0x1F, 0x03, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x7C, 0x3F,
  0xFF, 0xBF, 0x0F, 0x87, 0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x07, 0xF0,
  0x78, 0x07, 0xF8, 0x1E, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x40, 0x07, 0xF0, 0x38, 0x03, 0xF8, 0x1E, 0x01, 0xFC, 0x07, 0xC0,
  0xFE, 0x01, 0xF0, 0x7F, 0x00, 0x3C, 0x3F, 0xF8, 0x0F, 0x1F, 0xFF, 0xE3,
  0xC7, 0xCF, 0xFF, 0xF1, 0xF0, 0x7F, 0xF8, 0xFC, 0x07, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xF0, 0x03, 0x81, 0xFE, 0x00, 0xF0, 0xFF, 0xC0, 0x7C, 0x7F,
  0xF8, 0x1F, 0x3E, 0x3E, 0x07, 0x8F, 0x87, 0xC3, 0xE7, 0xC1, 0xF9, 0xF1,
  0xF0, 0x3F, 0xFC, 0x78, 0x07, 0xFE, 0x3E, 0x01, 0xFF, 0x03, 0x80, 0x1F,
  0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 34, 28, 8, -33 },
  { 57, 17, 15, 28, 8, -35 },
  { 89, 30, 33, 28, 0, -33 },
  { 213, 27, 44, 28, 1, -38 },
  { 362, 33, 34, 28, -2, -33 },
  { 503, 28, 34, 28, 0, -33 },
  { 622, 8, 15, 28, 13, -35 },
  { 637, 20, 42, 28, 8, -36 },
  { 742, 20, 42, 28, 1, -36 },
  { 847, 25, 24, 28, 2, -26 },
  { 922, 23, 22, 28, 3, -25 },
  { 986, 13, 15, 28, 5, -8 },
  { 1011, 15, 5, 28, 7, -17 },
  { 1021, 9, 8, 28, 8, -7 },
  { 1030, 28, 42, 28, 0, -36 },
  { 1177, 26, 34, 28, 2, -33 },
  { 1288, 24, 33, 28, 2, -33 },
  { 1387, 26, 33, 28, 1, -33 },
  { 1495, 26, 34, 28, 1, -33 },
  { 1606, 27, 33, 28, 0, -33 },
  { 1718, 27, 34, 28, 1, -33 },
  { 1833, 24, 34, 28, 2, -33 },
  { 1935, 25, 33, 28, 4, -33 },
  { 2039, 26, 34, 28, 1, -33 },
  { 2150, 24, 33, 28, 3, -33 },
  { 2249, 12, 25, 28, 8, -24 },
  { 2287, 15, 31, 28, 5, -24 },
  { 2346, 23, 28, 28, 4, -28 },
  { 2427, 25, 15, 28, 2, -22 },
  { 2474, 23, 28, 28, 2, -28 },
  { 2555, 21, 34, 28, 5, -33 },
  { 2645, 25, 38, 28, 2, -33 },
  { 2764, 27, 33, 28, -1, -33 },
  { 2876, 25, 33, 28, 2, -33 },
  { 2980, 25, 34, 28, 3, -33 },
  { 3087, 25, 33, 28, 2, -33 },
  { 3191, 26, 33, 28, 2, -33 },
  { 3299, 27, 33, 28, 2, -33 },
  { 3411, 25, 34, 28, 2, -33 },
  { 3518, 27, 33, 28, 1, -33 },
  { 3630, 26, 33, 28, 2, -33 },
  { 3738, 25, 34, 28, 2, -33 },
  { 3845, 30, 33, 28, 1, -33 },
  { 3969, 21, 33, 28, 3, -33 },
  { 4056, 29, 33, 28, 0, -33 },
  { 4176, 27, 33, 28, 1, -33 },
  { 4288, 26, 34, 28, 2, -33 },
  { 4399, 26, 33, 28, 2, -33 },
  { 4507, 26, 42, 28, 2, -33 },
  { 4644, 26, 33, 28, 2, -33 },
  { 4752, 27, 34, 28, 1, -33 },
  { 4867, 27, 33, 28, 4, -33 },
  { 4979, 26, 34, 28, 3, -33 },
  { 5090, 27, 33, 28, 4, -33 },
  { 5202, 30, 33, 28, 1, -33 },
  { 5326, 31, 33, 28, -1, -33 },
  { 5454, 27, 33, 28, 4, -33 },
  { 5566, 29, 33, 28, 0, -33 },
  { 5686, 22, 42, 28, 6, -36 },
  { 5802, 13, 42, 28, 8, -36 },
  { 5871, 22, 42, 28, 1, -36 },
  { 5987, 25, 20, 28, 2, -33 },
  { 6050, 23, 4, 28, 0, 4 },
  { 6062, 9, 10, 28, 9, -37 },
  { 6074, 24, 26, 28, 2, -25 },
  { 6152, 25, 36, 28, 1, -35 },
  { 6265, 22, 26, 28, 3, -25 },
  { 6337, 26, 36, 28, 2, -35 },
  { 6454, 23, 26, 28, 3, -25 },
  { 6529, 32, 45, 28, -1, -35 },
  { 6709, 26, 35, 28, 1, -25 },
  { 6823, 23, 35, 28, 2, -35 },
  { 6924, 23, 36, 28, 3, -35 },
  { 7028, 24, 45, 28, 1, -35 },
  { 7163, 25, 36, 28, 2, -35 },
  { 7276, 21, 36, 28, 4, -35 },
  { 7371, 28, 25, 28, 0, -25 },
  { 7459, 23, 25, 28, 2, -25 },
  { 7531, 24, 26, 28, 2, -25 },
  { 7609, 26, 34, 28, 0, -25 },
  { 7720, 25, 34, 28, 2, -25 },
  { 7827, 23, 24, 28, 5, -24 },
  { 7896, 23, 26, 28, 2, -25 },
  { 7971, 23, 34, 28, 3, -33 },
  { 8069, 24, 25, 28, 3, -24 },
  { 8144, 24, 26, 28, 2, -25 },
  { 8222, 26, 26, 28, 1, -25 },
  { 8307, 28, 26, 28, 0, -25 },
  { 8398, 26, 34, 28, 1, -24 },
  { 8509, 26, 26, 28, 1, -25 },
  { 8594, 23, 42, 28, 5, -36 },
  { 8715, 13, 42, 28, 8, -36 },
  { 8784, 23, 42, 28, 1, -36 },
  { 8905, 26, 11, 28, 1, -19 },
};

const GFXfont IBMPlexMono_SemiBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC47PT7B_H_
