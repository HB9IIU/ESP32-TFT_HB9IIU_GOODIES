#ifndef _IBMPLEXMONO_SEMIBOLDITALIC26PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCF, 0x3C, 0xE3, 0x8E, 0x30, 0xC2, 0x00, 0x01, 0xCF,
  0x3C, 0xF3, 0x80, 0x39, 0xDC, 0x77, 0x1D, 0xC7, 0x73, 0x9C, 0xE7, 0x3B,
  0x8E, 0x01, 0xCE, 0x01, 0xCE, 0x01, 0x8C, 0x03, 0x9C, 0x03, 0x9C, 0x3F,
  0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x06, 0x30, 0x0E, 0x70, 0xFE, 0x7E, 0xFC,
  0xFC, 0xFC, 0xFC, 0x1C, 0xE0, 0x19, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x73,
  0x80, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x01, 0xF8, 0x1F, 0xF8, 0xFF, 0xF3,
  0xD9, 0xCE, 0x62, 0x79, 0x80, 0xE6, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x33, 0x80, 0xCE, 0x47, 0x3B, 0xD9, 0xEF, 0xFF, 0x1F, 0xF8,
  0x1F, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x81, 0xC3, 0xF0, 0x61,
  0xFE, 0x38, 0x63, 0x9C, 0x38, 0xE6, 0x0E, 0x33, 0x83, 0xFD, 0xC0, 0x7E,
  0x60, 0x0F, 0x20, 0x00, 0x0F, 0x80, 0x77, 0xF0, 0x3B, 0xFC, 0x0C, 0xE3,
  0x07, 0x30, 0xC3, 0x8C, 0x70, 0xC3, 0xF8, 0x70, 0xFE, 0x38, 0x1E, 0x00,
  0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x07, 0x1C, 0x07, 0x38, 0x3F, 0xF0, 0x7F, 0xE0, 0x73, 0x80, 0xF3, 0xC0,
  0xE1, 0xC4, 0xE1, 0xE6, 0xF1, 0xEF, 0xFE, 0xFE, 0x7E, 0x7C, 0x3C, 0x38,
  0x77, 0x77, 0x7E, 0xEE, 0x03, 0xC1, 0xE0, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E,
  0x07, 0x03, 0x83, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x10, 0xE2, 0x7B,
  0xBF, 0xFF, 0xF3, 0xFF, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x03, 0x9E, 0x1C,
  0x38, 0x30, 0x40, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x1E,
  0x78, 0xF3, 0xC7, 0x8E, 0x38, 0x70, 0xFF, 0xFF, 0xFF, 0x39, 0xE7, 0xFE,
  0x70, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x77,
  0x01, 0xDC, 0xE7, 0xF3, 0x9F, 0xDE, 0xFF, 0x33, 0xF8, 0x0F, 0xE0, 0x3B,
  0xC1, 0xE7, 0x0F, 0x1F, 0xF8, 0x3F, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x3F,
  0x03, 0xF8, 0x3D, 0xC1, 0xDE, 0x1E, 0xF1, 0xE7, 0x06, 0x38, 0x21, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0, 0xF3, 0xC1,
  0xE1, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x3F, 0xFE, 0x7F, 0xF9, 0xFF,
  0xF0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF0, 0x81, 0xE0, 0x03,
  0xC0, 0x0F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC4, 0x07, 0xBE, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x77, 0x01, 0xCE,
  0x07, 0x1C, 0x1C, 0x38, 0x38, 0xF0, 0xE1, 0xE3, 0x83, 0x87, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC6, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xBE, 0x0D, 0xFC, 0x7F,
  0xF9, 0xE1, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x39, 0x81, 0xEF, 0x0F, 0x3F,
  0xFC, 0x7F, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xE7, 0x8F, 0xFE, 0x77, 0xFF, 0xC3, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x3F, 0xC3, 0xEF, 0xFE, 0x3F, 0xE0, 0xFC, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xDC, 0x0E, 0xE0, 0x73, 0x81, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0x87, 0xFC, 0x0F, 0xC0, 0xFF,
  0xC7, 0x87, 0xBC, 0x0E, 0xE0, 0x3B, 0x81, 0xEF, 0x0F, 0xBF, 0xFC, 0x7F,
  0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF0, 0xFF, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0x9F, 0xFC, 0x7D, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x00, 0x1E, 0x7C, 0xF9,
  0xF3, 0xC0, 0x00, 0x00, 0x00, 0x71, 0xE3, 0xEF, 0x8E, 0x00, 0x0F, 0x1F,
  0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0x70, 0xE0, 0xE0, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0xE0, 0xFC,
  0x1F, 0x81, 0xF0, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x70, 0x01, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x10, 0x01, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x07, 0x80, 0x70, 0x02, 0x00, 0x00, 0x0F, 0x83, 0xFE, 0x7F,
  0xEF, 0x1F, 0xE0, 0xF0, 0x0E, 0x01, 0xE0, 0x7C, 0x1F, 0x81, 0xC0, 0x1C,
  0x02, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x03,
  0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x07, 0x38, 0x1D, 0xC7, 0x77, 0x3F, 0xDD,
  0xFF, 0x67, 0x1F, 0x9C, 0x7E, 0x61, 0xB9, 0x8E, 0xE6, 0x3B, 0x9F, 0xEE,
  0x7F, 0xB9, 0xEE, 0xE0, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x73, 0x81,
  0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xFF, 0xE1, 0xFF,
  0xE7, 0xFF, 0xCE, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xE0, 0x1C, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xF3, 0x87, 0x8F, 0xFC,
  0x3F, 0xC1, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07,
  0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F,
  0x1E, 0x78, 0x39, 0xC0, 0xDF, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x73, 0x83, 0xCF, 0x0E, 0x3F, 0xF8, 0x7F, 0xC0,
  0x7C, 0x00, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x0F, 0x3C, 0x3C, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xDC, 0x0F, 0x70,
  0x39, 0xC1, 0xEF, 0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xF1, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xE1, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0x8F, 0x3C, 0x1D, 0xE0, 0x67, 0x80, 0x1C, 0x00, 0x71, 0xFB, 0xC7, 0xEF,
  0x1F, 0xBC, 0x0E, 0xF0, 0x3B, 0xC1, 0xE7, 0x8F, 0x1F, 0xFC, 0x3F, 0x70,
  0x79, 0xC0, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7,
  0x07, 0x8E, 0x0F, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xC0, 0xE3, 0x83,
  0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xE0,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x20, 0xF3, 0x83, 0xCF, 0x1E, 0x1F, 0xF8,
  0x7F, 0xC0, 0x7C, 0x00, 0x1C, 0x0F, 0x1C, 0x1E, 0x3C, 0x3C, 0x3C, 0x78,
  0x38, 0xF0, 0x39, 0xE0, 0x3B, 0xC0, 0x3B, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x7D, 0xC0, 0x79, 0xE0, 0x71, 0xE0, 0x70, 0xE0, 0xF0, 0xF0, 0xF0, 0x70,
  0xE0, 0x78, 0xE0, 0x78, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x1E, 0x0F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x3F, 0x3F, 0x3B, 0x76, 0x3B, 0x6E, 0x3B, 0xEE, 0x3B, 0xCE, 0x3B,
  0xCE, 0x71, 0x8E, 0x71, 0x9C, 0x71, 0x1C, 0x71, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x1E, 0x0E, 0x7C, 0x1C, 0xF8, 0x71, 0xF8,
  0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x39, 0x8E, 0x73, 0xB8, 0xE7, 0x71,
  0xCE, 0xE3, 0x9D, 0xC7, 0x1B, 0x9C, 0x3F, 0x38, 0x7C, 0x70, 0xF8, 0xE1,
  0xF1, 0xC3, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38, 0x1D,
  0xE0, 0x77, 0x01, 0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3B, 0xC1, 0xE7, 0x0F, 0x1F, 0xFC, 0x3F, 0xC0, 0x7E, 0x00, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0x0F, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xCE,
  0x0F, 0x3F, 0xF9, 0xFF, 0xC7, 0xFE, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF,
  0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xE7, 0x0F, 0x1F, 0xFC, 0x3F,
  0xE0, 0x7E, 0x00, 0x70, 0x80, 0xEF, 0x03, 0xF8, 0x07, 0xC0, 0x0E, 0x00,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0x0F, 0x3C, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x0F, 0x3F, 0xF9, 0xFF, 0xC7, 0xFC, 0x1C, 0x70, 0x71, 0xC1, 0xC7,
  0x87, 0x0E, 0x3C, 0x3C, 0xF0, 0xF3, 0x81, 0xC0, 0x03, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF8, 0xF0, 0xF1, 0xC0, 0x43, 0x80, 0x07, 0x80, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xC4, 0x07, 0x9E, 0x1F,
  0x7F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC0,
  0xE3, 0x81, 0xCF, 0x07, 0x9E, 0x0E, 0x1C, 0x3C, 0x3F, 0xF8, 0x7F, 0xE0,
  0x3F, 0x00, 0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x8E,
  0x0F, 0x1C, 0x1C, 0x3C, 0x78, 0x78, 0xE0, 0xF3, 0xC0, 0xE7, 0x01, 0xCE,
  0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x73, 0xCE, 0x73, 0xCE,
  0x73, 0xCC, 0x67, 0xDC, 0xE7, 0xDC, 0xE7, 0xDC, 0xED, 0xDC, 0xED, 0xD8,
  0xED, 0xF8, 0xF9, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0, 0xF1, 0xF0, 0xF1, 0xF0,
  0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0x70, 0xF0, 0x1E, 0x38, 0x07, 0x9E, 0x00,
  0xEF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x03, 0x8E, 0x01, 0xE3, 0xC0, 0xF0, 0x70,
  0x78, 0x1E, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF3, 0xC3,
  0xC3, 0x87, 0x07, 0x1C, 0x0F, 0x78, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xE0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xF8,
  0x7F, 0x8F, 0xF0, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30, 0x30, 0x38,
  0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x06, 0x07, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xFC, 0x0E, 0x70,
  0x71, 0xC3, 0xC3, 0x8E, 0x0E, 0x70, 0x3B, 0xC0, 0x76, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFC, 0x27, 0x1C, 0xE3, 0x1C, 0x0F, 0x3C, 0xFE, 0xE3,
  0xFF, 0x9E, 0x1E, 0x70, 0x7B, 0xC1, 0xEF, 0x07, 0x38, 0x1C, 0xE0, 0xF3,
  0xC5, 0xCF, 0xFF, 0x9F, 0x9E, 0x3C, 0x78, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE7, 0xC7, 0x7F, 0x3B, 0xFB, 0xE1, 0xDE,
  0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xFE, 0x1F, 0xEF, 0xF7, 0x7F,
  0x39, 0xF0, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x8F, 0xF0, 0x4E, 0x00, 0xE0,
  0x0E, 0x04, 0xE0, 0xFF, 0x1E, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x83, 0xC7, 0x0F,
  0xDE, 0x3F, 0xF8, 0xF0, 0xF1, 0xC0, 0xE7, 0x81, 0xCF, 0x07, 0x9C, 0x0F,
  0x38, 0x3C, 0x78, 0xB8, 0xFF, 0x70, 0xFD, 0xE0, 0xF3, 0xC0, 0x0F, 0xC3,
  0xFE, 0x7F, 0xF7, 0x87, 0xF0, 0x7E, 0x1F, 0xFF, 0xCF, 0xF0, 0xE0, 0x4E,
  0x0F, 0xFF, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x3C,
  0x03, 0xCF, 0x00, 0x7B, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x07, 0x9E, 0x1F, 0xBC, 0x7F, 0xF1, 0xE1, 0xE3, 0x81, 0xCF, 0x03, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF1, 0xF0, 0xFE, 0xE1, 0xFB, 0xC1, 0xE7,
  0x80, 0x0E, 0x0C, 0x3C, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE3, 0x87, 0x7F, 0x3B,
  0xFB, 0xE3, 0xDE, 0x0E, 0xF0, 0x77, 0x07, 0xB8, 0x3D, 0xC1, 0xDE, 0x0E,
  0xF0, 0x77, 0x03, 0xB8, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x41, 0xC6, 0x1C, 0xF1, 0xDE, 0x1F, 0xC1, 0xF8, 0x0F, 0x00, 0x00, 0x70,
  0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC2, 0x1C, 0x38, 0xE1, 0xE7, 0x0F, 0xF8, 0x3F, 0xC0, 0xFC, 0x03,
  0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x8F, 0x0E, 0xFE, 0x3B, 0xF9, 0xF1, 0xE7, 0x83, 0x9E, 0x1C, 0x71, 0xE1,
  0xDC, 0x07, 0x78, 0xBC, 0xE7, 0xF3, 0xFF, 0x87, 0xCE, 0x0E, 0x00, 0x7F,
  0x07, 0xF0, 0xFF, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x41, 0xCE, 0x39, 0xF3, 0xBC, 0x3F,
  0x83, 0xF0, 0x1E, 0x00, 0x3B, 0x9E, 0x7F, 0x7C, 0xFF, 0xF9, 0xCE, 0x77,
  0x1C, 0xEE, 0x31, 0xDC, 0x63, 0xB9, 0xC6, 0x63, 0x8D, 0xC7, 0x3B, 0x8E,
  0x77, 0x18, 0xEE, 0x71, 0xC0, 0x38, 0xE1, 0xDF, 0xCE, 0xFE, 0x78, 0xF7,
  0x83, 0xBC, 0x1D, 0xC1, 0xEE, 0x0F, 0x70, 0x73, 0x83, 0xBC, 0x1D, 0xC0,
  0xEE, 0x0F, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0xF0, 0xF7, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7B, 0x87, 0x9F, 0xFC, 0x7F, 0xC1, 0xF8,
  0x00, 0x1C, 0xF8, 0x77, 0xF1, 0xDF, 0xCF, 0x87, 0x3C, 0x1C, 0xE0, 0x73,
  0x81, 0xCE, 0x07, 0x38, 0x3D, 0xE1, 0xF7, 0x7F, 0x9D, 0xFC, 0x73, 0xE1,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x3C, 0x7E,
  0xF3, 0xFF, 0x9E, 0x1E, 0x70, 0x3B, 0xC0, 0xEF, 0x07, 0xB8, 0x1E, 0xE0,
  0xF3, 0xC7, 0xCF, 0xF7, 0x1F, 0xBC, 0x3C, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0xFE, 0x7F, 0xCF, 0xFD, 0xF1, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x00, 0x07, 0xE0, 0xFF, 0xCF, 0xFC, 0x70, 0x43, 0xC0, 0x1F, 0xE0, 0xFF,
  0xC1, 0xFE, 0x00, 0x73, 0x03, 0xBF, 0xFC, 0xFF, 0xC3, 0xF8, 0x00, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x63, 0xCE, 0x39, 0xF3, 0xFC, 0x3F,
  0x81, 0xE0, 0x70, 0x7B, 0x83, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x7B,
  0x83, 0xDC, 0x1C, 0xE1, 0xE7, 0x17, 0x3F, 0xF9, 0xFB, 0xC7, 0x9E, 0x00,
  0x7C, 0x37, 0xE3, 0xFF, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xE7,
  0x0F, 0x38, 0xF1, 0xDF, 0x1F, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x73, 0x99,
  0xCE, 0x76, 0x39, 0xD8, 0xE7, 0xE3, 0x1F, 0x8C, 0x7E, 0x71, 0xF1, 0xC6,
  0xC7, 0x3B, 0x3C, 0xEF, 0xF7, 0x3E, 0xF8, 0xF3, 0xC0, 0x07, 0x1C, 0x1F,
  0xBE, 0x3F, 0xBE, 0x7B, 0xE7, 0x33, 0xC7, 0x03, 0xC6, 0x03, 0x80, 0x63,
  0x88, 0xE3, 0x8C, 0xE5, 0xBE, 0xFD, 0xF8, 0xFD, 0xF0, 0x78, 0xE0, 0x1C,
  0x1E, 0x38, 0x38, 0x70, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0F,
  0x1C, 0x1C, 0x38, 0x78, 0x71, 0x70, 0xFF, 0xE1, 0xFB, 0xC1, 0xE7, 0x00,
  0x0E, 0x18, 0x3C, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0x1C, 0xFF,
  0x77, 0xFF, 0xDC, 0x3E, 0x70, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x84, 0x3C,
  0x3B, 0xF8, 0x6F, 0xFF, 0xBB, 0xFE, 0xE3, 0xF0, 0x03, 0xF0, 0x7F, 0x0F,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x70, 0xFE,
  0x0F, 0x80, 0xFE, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0xF8, 0x7F, 0x83, 0xF0, 0x0C, 0x71, 0xC7, 0x1C,
  0x71, 0x8E, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE3,
  0x8E, 0x38, 0x0F, 0xC1, 0xFE, 0x1F, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0x07, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xF0, 0xFE,
  0x0F, 0xC0, 0x1C, 0x0C, 0xF8, 0x77, 0xF1, 0xD9, 0xEE, 0xE3, 0xFB, 0x0F,
  0xCC, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 18, 16, 5, -18 },
  { 15, 10, 8, 16, 4, -19 },
  { 25, 16, 18, 16, 0, -18 },
  { 61, 14, 24, 16, 1, -21 },
  { 103, 18, 18, 16, -1, -18 },
  { 144, 16, 18, 16, 0, -18 },
  { 180, 4, 8, 16, 7, -19 },
  { 184, 10, 24, 16, 5, -20 },
  { 214, 10, 24, 16, 1, -20 },
  { 244, 14, 13, 16, 1, -14 },
  { 267, 12, 13, 16, 2, -14 },
  { 287, 7, 8, 16, 3, -4 },
  { 294, 8, 3, 16, 4, -9 },
  { 297, 6, 5, 16, 4, -5 },
  { 301, 16, 24, 16, 0, -20 },
  { 349, 14, 18, 16, 1, -18 },
  { 381, 13, 18, 16, 1, -18 },
  { 411, 15, 18, 16, 0, -18 },
  { 445, 15, 18, 16, 0, -18 },
  { 479, 15, 18, 16, 0, -18 },
  { 513, 14, 18, 16, 1, -18 },
  { 545, 13, 18, 16, 1, -18 },
  { 575, 14, 18, 16, 2, -18 },
  { 607, 14, 18, 16, 1, -18 },
  { 639, 13, 18, 16, 2, -18 },
  { 669, 7, 14, 16, 4, -14 },
  { 682, 8, 18, 16, 3, -14 },
  { 700, 13, 15, 16, 2, -15 },
  { 725, 14, 8, 16, 1, -12 },
  { 739, 13, 15, 16, 1, -15 },
  { 764, 12, 18, 16, 3, -18 },
  { 791, 14, 21, 16, 1, -18 },
  { 828, 15, 18, 16, -1, -18 },
  { 862, 14, 18, 16, 1, -18 },
  { 894, 14, 18, 16, 2, -18 },
  { 926, 14, 18, 16, 1, -18 },
  { 958, 15, 18, 16, 1, -18 },
  { 992, 15, 18, 16, 1, -18 },
  { 1026, 14, 18, 16, 1, -18 },
  { 1058, 15, 18, 16, 1, -18 },
  { 1092, 14, 18, 16, 1, -18 },
  { 1124, 14, 18, 16, 1, -18 },
  { 1156, 16, 18, 16, 1, -18 },
  { 1192, 11, 18, 16, 2, -18 },
  { 1217, 16, 18, 16, 0, -18 },
  { 1253, 15, 18, 16, 1, -18 },
  { 1287, 14, 18, 16, 1, -18 },
  { 1319, 14, 18, 16, 1, -18 },
  { 1351, 14, 23, 16, 1, -18 },
  { 1392, 14, 18, 16, 1, -18 },
  { 1424, 15, 18, 16, 0, -18 },
  { 1458, 15, 18, 16, 2, -18 },
  { 1492, 15, 18, 16, 1, -18 },
  { 1526, 15, 18, 16, 2, -18 },
  { 1560, 16, 18, 16, 1, -18 },
  { 1596, 18, 18, 16, -1, -18 },
  { 1637, 15, 18, 16, 2, -18 },
  { 1671, 16, 18, 16, 0, -18 },
  { 1707, 12, 24, 16, 3, -20 },
  { 1743, 8, 24, 16, 4, -20 },
  { 1767, 12, 24, 16, 1, -20 },
  { 1803, 14, 11, 16, 1, -18 },
  { 1823, 13, 3, 16, 0, 2 },
  { 1828, 5, 6, 16, 5, -21 },
  { 1832, 14, 13, 16, 1, -13 },
  { 1855, 13, 19, 16, 1, -19 },
  { 1886, 12, 13, 16, 2, -13 },
  { 1906, 15, 19, 16, 1, -19 },
  { 1942, 12, 13, 16, 2, -13 },
  { 1962, 18, 24, 16, -1, -19 },
  { 2016, 15, 18, 16, 0, -13 },
  { 2050, 13, 19, 16, 1, -19 },
  { 2081, 12, 19, 16, 2, -19 },
  { 2110, 13, 24, 16, 1, -19 },
  { 2149, 14, 19, 16, 1, -19 },
  { 2183, 12, 19, 16, 2, -19 },
  { 2212, 15, 13, 16, 0, -13 },
  { 2237, 13, 13, 16, 1, -13 },
  { 2259, 13, 13, 16, 1, -13 },
  { 2281, 14, 18, 16, 0, -13 },
  { 2313, 14, 18, 16, 1, -13 },
  { 2345, 12, 13, 16, 3, -13 },
  { 2365, 13, 13, 16, 1, -13 },
  { 2387, 12, 18, 16, 2, -18 },
  { 2414, 13, 13, 16, 2, -13 },
  { 2436, 13, 13, 16, 1, -13 },
  { 2458, 14, 13, 16, 1, -13 },
  { 2481, 16, 13, 16, 0, -13 },
  { 2507, 15, 18, 16, 0, -13 },
  { 2541, 14, 13, 16, 1, -13 },
  { 2564, 12, 24, 16, 3, -20 },
  { 2600, 6, 24, 16, 5, -20 },
  { 2618, 12, 24, 16, 1, -20 },
  { 2654, 14, 7, 16, 1, -11 },
};

const GFXfont IBMPlexMono_SemiBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC26PT7B_H_
