#ifndef _IBMPLEXMONO_SEMIBOLDITALIC29PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x10, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0x70, 0x79, 0xEE, 0x39,
  0xC7, 0x38, 0xE7, 0x1D, 0xE7, 0xBC, 0xF7, 0x1C, 0xE3, 0x80, 0x00, 0xE3,
  0x80, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0xCE, 0x0F, 0xE3, 0xF3,
  0xF8, 0xFC, 0xFE, 0x7F, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x38,
  0xE0, 0xFE, 0x3F, 0x3F, 0x9F, 0xCF, 0xC7, 0xF0, 0x71, 0xC0, 0x1C, 0xE0,
  0x0E, 0x38, 0x03, 0x9E, 0x01, 0xE7, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0x3E, 0xEE, 0x3C, 0xC4, 0x38,
  0xC0, 0x38, 0xC0, 0x3E, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x01, 0x9E, 0x01, 0x9E, 0x03, 0x9E, 0x63, 0x9E, 0xF3, 0x3C, 0xFF,
  0xFC, 0x7F, 0xF8, 0x1F, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x70, 0xFE, 0x0E, 0x1F, 0xF0, 0xE1, 0xC7, 0x1C, 0x1C, 0x71, 0x81,
  0x87, 0x38, 0x18, 0xE7, 0x01, 0xFE, 0x60, 0x1F, 0xCE, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x3B, 0xF8, 0x07, 0x7F, 0xC0, 0xE7, 0x1C, 0x0C, 0x71,
  0xC1, 0xC6, 0x1C, 0x38, 0x63, 0x83, 0x87, 0xF8, 0x70, 0x7F, 0x0E, 0x03,
  0xE0, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xF1, 0xC0, 0x70, 0xF0,
  0x38, 0x78, 0x1C, 0x38, 0x0F, 0x1C, 0x03, 0x9C, 0x0F, 0xFC, 0x0F, 0xF8,
  0x0F, 0x38, 0x07, 0x1E, 0x07, 0x87, 0x03, 0xC3, 0xC5, 0xE1, 0xE7, 0xF1,
  0xF7, 0xBF, 0xBF, 0x9F, 0xCF, 0x87, 0x83, 0x80, 0x7B, 0x9C, 0xE7, 0x7B,
  0xDC, 0xE0, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x71, 0xC6, 0x7F, 0xFE, 0xFF, 0xFF, 0x1F, 0xF8,
  0x07, 0xC0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xF0, 0x78, 0x78, 0x30, 0x70,
  0x10, 0x40, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78,
  0x70, 0xE0, 0x7F, 0xFF, 0xEF, 0xF8, 0x7B, 0xFF, 0xFE, 0x70, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x79, 0xCF,
  0x73, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x7B, 0x81, 0xE7, 0x07, 0xDE, 0x1F, 0x3C, 0x1C,
  0x78, 0x30, 0xF0, 0x21, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xE0,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0x60,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xE1, 0xE0, 0xC0, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x80, 0x78, 0x60, 0x3C, 0xF8, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xEE,
  0x01, 0xDE, 0x03, 0x9E, 0x07, 0x9E, 0x0F, 0x1C, 0x1E, 0x1C, 0x1C, 0x1C,
  0x38, 0x3C, 0x70, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x39, 0xF0, 0x3B, 0xFC,
  0x3F, 0xFC, 0x7C, 0x3E, 0x10, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x20, 0x1E,
  0x60, 0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x78, 0x7B, 0xFC, 0xFF, 0xF9, 0xF0, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x1E, 0x78, 0x7C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C,
  0xF0, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x1C, 0x1E, 0x1F, 0xF8, 0x07, 0xF0,
  0x3F, 0xFC, 0x78, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E,
  0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF9, 0xFF, 0xF3, 0xFD, 0xE1, 0xF7, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1E, 0x7C,
  0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xEF, 0xDF, 0x1C, 0x00,
  0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0x70, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x10, 0x3F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xFC, 0x10, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0F, 0xC1,
  0xFF, 0x9F, 0xFE, 0xF0, 0xFF, 0x07, 0x90, 0x3C, 0x01, 0xE0, 0x1E, 0x0F,
  0xE0, 0x7C, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38, 0xE7, 0x71, 0xF7, 0x73,
  0xFE, 0x73, 0x8E, 0x77, 0x8E, 0xF7, 0x0E, 0xE7, 0x0E, 0xE7, 0x1E, 0xE7,
  0xFC, 0xE7, 0xFC, 0xE3, 0xDC, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x9C, 0x07, 0x8E,
  0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x78, 0x1E, 0x3C, 0x07, 0x3C, 0x03, 0xDE, 0x01, 0xFE, 0x00, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0F, 0x1C, 0x0E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF8, 0x38, 0x3C,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x3C, 0x70, 0x7C, 0x7F, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0xF3,
  0xC1, 0xEF, 0x01, 0xDE, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x04, 0x38, 0x0F, 0x78, 0x1C, 0xF8, 0xF8,
  0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1C, 0x1E, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x38, 0x0F, 0x38, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x70, 0x3C, 0x70, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0xFE, 0x78, 0xFE, 0x70, 0xFE, 0xF0, 0x1E, 0xF0,
  0x1C, 0x70, 0x1C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x3F, 0xBC, 0x1F,
  0x3C, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF,
  0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x08, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x70, 0x78, 0xF0, 0x78, 0xF8, 0xF0, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0x80, 0x1E, 0x07, 0xC7, 0x83, 0xE1, 0xE1, 0xF0, 0x70,
  0x78, 0x1C, 0x3C, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0xF0, 0x1E, 0x3C, 0x07,
  0x87, 0x81, 0xC1, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0x78, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x87, 0xE7, 0xE3,
  0xFB, 0xB8, 0xE7, 0xEE, 0x39, 0xF7, 0x8E, 0x79, 0xE3, 0x9E, 0x70, 0xE7,
  0x1C, 0x78, 0xC7, 0x1E, 0x21, 0xC7, 0x08, 0xF1, 0xC0, 0x3C, 0x70, 0x0E,
  0x1C, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x38, 0x1F, 0x07, 0x8F, 0x83, 0x87,
  0xC1, 0xC3, 0xE0, 0xE3, 0xF8, 0x71, 0xFC, 0x78, 0xEE, 0x3C, 0x77, 0x1C,
  0x3B, 0x8E, 0x1C, 0xE7, 0x1E, 0x73, 0x8E, 0x3B, 0xC7, 0x1D, 0xC3, 0x8E,
  0xE1, 0xC7, 0xF1, 0xE1, 0xF8, 0xF0, 0xFC, 0x70, 0x7E, 0x38, 0x3E, 0x1C,
  0x1F, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x7C,
  0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xC0, 0x03, 0x80, 0x03, 0xC6, 0x01, 0xEF, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x70, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x1C, 0x0F,
  0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xF0, 0x78, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x70, 0x70, 0x78,
  0x70, 0x78, 0xF0, 0x38, 0xF0, 0x3C, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xE0, 0xF1, 0xE0, 0x20, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x60, 0x3C, 0x78, 0x3E, 0x7F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x38, 0x0E,
  0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C,
  0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x38,
  0xE0, 0x78, 0xE0, 0x78, 0xF0, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0x80,
  0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0x78, 0x70, 0xF0, 0x70, 0xF0, 0x70, 0xE0, 0x79, 0xE0,
  0x79, 0xC0, 0x7B, 0xC0, 0x7B, 0xC0, 0x7B, 0x80, 0x7F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x38, 0x01, 0xDE, 0x00, 0xF7, 0x80, 0x39, 0xC0,
  0x0E, 0x70, 0x03, 0x9C, 0x78, 0xE7, 0x1E, 0x71, 0xCF, 0x9C, 0x73, 0xE7,
  0x1C, 0xD9, 0xC7, 0x7E, 0xE3, 0xDB, 0xB8, 0xE6, 0xEE, 0x3B, 0xBB, 0x8E,
  0xCE, 0xE3, 0xB3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0xC3, 0xE3,
  0xE0, 0x0F, 0x01, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7B, 0xC0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xC0, 0xF0, 0x78, 0x0F,
  0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xBC, 0x07, 0x9E, 0x07, 0xC7, 0x83, 0xC3,
  0xC3, 0xC1, 0xE3, 0xC0, 0x71, 0xE0, 0x3D, 0xE0, 0x1E, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x40, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x00, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x07, 0x07, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0x38, 0x0F, 0x3C, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0x20,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x67, 0x9C, 0xE3, 0x98, 0x07,
  0x9E, 0x3F, 0xBC, 0xFF, 0xF9, 0xE1, 0xF7, 0x81, 0xCF, 0x03, 0xBC, 0x0F,
  0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0xC5, 0xC7, 0xFF, 0xEF,
  0xE7, 0xCF, 0x8F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x3E, 0x1E, 0xFE, 0x3F, 0xFE, 0x7C, 0x3C, 0xF0,
  0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xB8, 0x0F, 0x70, 0x3D,
  0xF0, 0xFB, 0xFF, 0xE7, 0xBF, 0x8F, 0x3E, 0x00, 0x07, 0xE0, 0x7F, 0xC3,
  0xFF, 0x9F, 0x1E, 0x78, 0x37, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0xCF, 0x07, 0xBE, 0x3C, 0x7F, 0xF1, 0xFF, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x1E, 0x38, 0x3F, 0x9C, 0x3F, 0xFE, 0x1E, 0x1F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x7C,
  0x7E, 0x1F, 0xEE, 0x0F, 0xE7, 0x03, 0xE7, 0x80, 0x07, 0xE0, 0x7F, 0xE3,
  0xFF, 0xDF, 0x0F, 0x70, 0x3F, 0xC3, 0xEF, 0xFF, 0xBF, 0xF8, 0xFF, 0x03,
  0x80, 0x0F, 0x03, 0x3C, 0x1E, 0x7F, 0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x21, 0xE0, 0x07, 0x1E, 0x00, 0xF9, 0xC0, 0x03, 0xDC, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x1F, 0xEE, 0x3F,
  0xFE, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0x78, 0xFC, 0x7F, 0xB8, 0x7F, 0x38, 0x1E,
  0x78, 0x00, 0x78, 0x40, 0x78, 0x60, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x3E, 0x1E, 0xFE, 0x3D, 0xFC, 0x7C, 0x7C, 0xF0, 0x79, 0xE0, 0xF7,
  0x81, 0xCF, 0x03, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x3C, 0xE0, 0x7B, 0xC0,
  0xE7, 0x81, 0xCF, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x86, 0x0E, 0x3C, 0x79,
  0xE1, 0xEF, 0x07, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x7F, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x41, 0xE1, 0x87, 0x0F, 0x1C,
  0x3E, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x78, 0x3D,
  0xFC, 0x3D, 0xFE, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x78, 0x3C, 0x78,
  0xF0, 0x7F, 0xC0, 0x7B, 0xC4, 0x73, 0xC6, 0x71, 0xEF, 0xF1, 0xFE, 0xF0,
  0xFC, 0xF0, 0x70, 0xFF, 0x8F, 0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x63, 0xCF, 0x39, 0xE3, 0xBC, 0x3F, 0x83, 0xF0, 0x1E, 0x00, 0x39,
  0xC7, 0x1D, 0xF7, 0xCF, 0xFF, 0xE7, 0x9E, 0x73, 0x8E, 0x3B, 0xC7, 0x1D,
  0xC7, 0x0E, 0xE3, 0x8E, 0x71, 0xC7, 0x38, 0xE3, 0x9C, 0x71, 0xDC, 0x38,
  0xEE, 0x38, 0xE7, 0x1C, 0x73, 0x8E, 0x38, 0x3C, 0xF8, 0x7B, 0xF8, 0xF7,
  0xF1, 0xF1, 0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0x3C, 0x0E, 0x78, 0x3C,
  0xF0, 0x79, 0xC0, 0xF3, 0x81, 0xEF, 0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x00,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE1, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x39, 0xC0, 0xF3, 0xC3, 0xE7, 0xFF,
  0x87, 0xFE, 0x03, 0xF0, 0x00, 0x1E, 0x7C, 0x1E, 0xFE, 0x1F, 0xFF, 0x1F,
  0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38,
  0x0F, 0x38, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x7B, 0xF8, 0x79, 0xF0, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0x8F, 0x1F, 0xCE, 0x3F, 0xFE, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x70,
  0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xFC, 0x7F,
  0xB8, 0x7F, 0x38, 0x3E, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0xFF, 0x3F, 0xF9, 0xFF, 0xEF, 0xC7, 0xE0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xF8,
  0x7F, 0xF9, 0xE0, 0xC3, 0xC0, 0x07, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xF8, 0x00, 0xF9, 0x00, 0xF3, 0x83, 0xCF, 0xFF, 0x8F, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x41, 0xE3, 0x87, 0x1F, 0x3D, 0xF0, 0x7F, 0x81, 0xFC, 0x03, 0xC0,
  0x78, 0x1D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x3F, 0xC0, 0xEF, 0x03,
  0xBC, 0x1E, 0xF0, 0x7B, 0x81, 0xEE, 0x0F, 0xBC, 0x5C, 0xFF, 0x73, 0xFB,
  0xC3, 0xCF, 0x00, 0x7E, 0x0C, 0xFC, 0x7B, 0xF8, 0x78, 0xF0, 0xF1, 0xC1,
  0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xE1, 0xE1,
  0xCF, 0x83, 0xFE, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0x71, 0xC6, 0x71, 0xCE,
  0x71, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x61, 0x87, 0xE3, 0x87, 0xE3, 0x8E,
  0xE3, 0x8E, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x9C, 0xFB, 0x98, 0xF9, 0xF8,
  0x71, 0xE0, 0x07, 0x87, 0x07, 0xEF, 0xCF, 0xF7, 0xEF, 0xBE, 0x73, 0x1E,
  0x39, 0x0F, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x71, 0xE1, 0x38,
  0xF1, 0xDC, 0xF9, 0xEF, 0xEF, 0xE3, 0xE7, 0xE1, 0xE1, 0xC0, 0x1E, 0x07,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x3C, 0x3E, 0x3C, 0x5C, 0x3F, 0xDC,
  0x1F, 0xBC, 0x0F, 0x3C, 0x00, 0x3C, 0x20, 0x78, 0x30, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0x8F, 0x3F, 0xEE, 0x3F, 0xFE, 0x38, 0x7E,
  0x70, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x88, 0x1E, 0x1C,
  0x3C, 0x0C, 0xFF, 0x8E, 0xFF, 0xFE, 0xE7, 0xFC, 0xE1, 0xF8, 0x01, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x38, 0x3F, 0xE0, 0xFC, 0x03, 0xFC, 0x00, 0x78,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x1E, 0x07, 0x3F, 0x07,
  0x7F, 0x8E, 0x73, 0xCE, 0xE1, 0xFC, 0xE1, 0xFC, 0xE0, 0xF0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 20, 17, 5, -20 },
  { 21, 11, 9, 17, 5, -21 },
  { 34, 18, 20, 17, 0, -20 },
  { 79, 16, 26, 17, 1, -23 },
  { 131, 20, 20, 17, -1, -20 },
  { 181, 17, 20, 17, 0, -20 },
  { 224, 5, 9, 17, 8, -21 },
  { 230, 12, 26, 17, 5, -22 },
  { 269, 12, 26, 17, 1, -22 },
  { 308, 16, 15, 17, 1, -16 },
  { 338, 14, 15, 17, 2, -16 },
  { 365, 8, 9, 17, 3, -5 },
  { 374, 10, 3, 17, 4, -10 },
  { 378, 6, 5, 17, 5, -5 },
  { 382, 17, 26, 17, 0, -22 },
  { 438, 16, 20, 17, 1, -20 },
  { 478, 15, 20, 17, 1, -20 },
  { 516, 17, 20, 17, 0, -20 },
  { 559, 17, 20, 17, 0, -20 },
  { 602, 16, 20, 17, 0, -20 },
  { 642, 16, 20, 17, 1, -20 },
  { 682, 15, 20, 17, 1, -20 },
  { 720, 16, 20, 17, 2, -20 },
  { 760, 16, 20, 17, 1, -20 },
  { 800, 15, 20, 17, 2, -20 },
  { 838, 7, 15, 17, 5, -15 },
  { 852, 9, 19, 17, 3, -15 },
  { 874, 15, 17, 17, 2, -17 },
  { 906, 16, 10, 17, 1, -14 },
  { 926, 15, 17, 17, 1, -17 },
  { 958, 13, 20, 17, 3, -20 },
  { 991, 16, 23, 17, 1, -20 },
  { 1037, 17, 20, 17, -1, -20 },
  { 1080, 16, 20, 17, 1, -20 },
  { 1120, 15, 20, 17, 2, -20 },
  { 1158, 16, 20, 17, 1, -20 },
  { 1198, 16, 20, 17, 1, -20 },
  { 1238, 17, 20, 17, 1, -20 },
  { 1281, 16, 20, 17, 1, -20 },
  { 1321, 17, 20, 17, 1, -20 },
  { 1364, 16, 20, 17, 1, -20 },
  { 1404, 16, 20, 17, 1, -20 },
  { 1444, 18, 20, 17, 1, -20 },
  { 1489, 13, 20, 17, 2, -20 },
  { 1522, 18, 20, 17, 0, -20 },
  { 1567, 17, 20, 17, 1, -20 },
  { 1610, 16, 20, 17, 1, -20 },
  { 1650, 16, 20, 17, 1, -20 },
  { 1690, 16, 26, 17, 1, -20 },
  { 1742, 16, 20, 17, 1, -20 },
  { 1782, 17, 20, 17, 0, -20 },
  { 1825, 17, 20, 17, 2, -20 },
  { 1868, 16, 20, 17, 2, -20 },
  { 1908, 16, 20, 17, 3, -20 },
  { 1948, 18, 20, 17, 1, -20 },
  { 1993, 20, 20, 17, -1, -20 },
  { 2043, 17, 20, 17, 2, -20 },
  { 2086, 18, 20, 17, 0, -20 },
  { 2131, 13, 26, 17, 4, -22 },
  { 2174, 8, 26, 17, 5, -22 },
  { 2200, 13, 26, 17, 1, -22 },
  { 2243, 16, 13, 17, 1, -20 },
  { 2269, 14, 3, 17, 0, 2 },
  { 2275, 5, 6, 17, 6, -23 },
  { 2279, 15, 15, 17, 1, -15 },
  { 2308, 15, 21, 17, 1, -21 },
  { 2348, 14, 15, 17, 2, -15 },
  { 2375, 17, 21, 17, 1, -21 },
  { 2420, 14, 15, 17, 2, -15 },
  { 2447, 20, 27, 17, -1, -21 },
  { 2515, 16, 21, 17, 1, -15 },
  { 2557, 15, 21, 17, 1, -21 },
  { 2597, 14, 22, 17, 2, -22 },
  { 2636, 14, 28, 17, 1, -22 },
  { 2685, 16, 21, 17, 1, -21 },
  { 2727, 12, 21, 17, 3, -21 },
  { 2759, 17, 15, 17, 0, -15 },
  { 2791, 15, 15, 17, 1, -15 },
  { 2820, 15, 15, 17, 1, -15 },
  { 2849, 16, 21, 17, 0, -15 },
  { 2891, 16, 21, 17, 1, -15 },
  { 2933, 14, 15, 17, 3, -15 },
  { 2960, 15, 15, 17, 1, -15 },
  { 2989, 14, 20, 17, 2, -20 },
  { 3024, 14, 15, 17, 2, -15 },
  { 3051, 15, 15, 17, 1, -15 },
  { 3080, 16, 15, 17, 1, -15 },
  { 3110, 17, 15, 17, 0, -15 },
  { 3142, 16, 21, 17, 0, -15 },
  { 3184, 16, 15, 17, 1, -15 },
  { 3214, 14, 26, 17, 3, -22 },
  { 3260, 8, 26, 17, 5, -22 },
  { 3286, 14, 26, 17, 1, -22 },
  { 3332, 16, 7, 17, 1, -12 },
};

const GFXfont IBMPlexMono_SemiBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC29PT7B_H_
