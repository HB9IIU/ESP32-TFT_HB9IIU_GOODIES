#ifndef _IBMPLEXMONO_SEMIBOLDITALIC62PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF9, 0xF7, 0xFF, 0x03,
  0xFE, 0x1F, 0x1F, 0xC0, 0x7F, 0xC1, 0xF0, 0x70, 0x07, 0xF8, 0x3E, 0x02,
  0x00, 0x7F, 0x83, 0xE0, 0x00, 0x07, 0xF8, 0x3E, 0x00, 0x00, 0x7F, 0x83,
  0xE0, 0x00, 0x07, 0xF8, 0x3E, 0x00, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0x07,
  0xFE, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x00, 0x1F,
  0x07, 0xF8, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0x03, 0xF8, 0x00,
  0x01, 0xF0, 0x7F, 0x80, 0xC0, 0x1F, 0x07, 0xF8, 0x1E, 0x03, 0xE0, 0x7F,
  0x83, 0xF0, 0x3E, 0x0F, 0xF0, 0x7F, 0x83, 0xE1, 0xFF, 0x0F, 0xFF, 0x3E,
  0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0x0F,
  0xFF, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC0, 0x3E, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC7,
  0xE0, 0x00, 0x0F, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x9F,
  0xFF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x20, 0xFF, 0x00, 0x7F, 0x80, 0xC7,
  0xF8, 0x01, 0xFC, 0x0F, 0xBF, 0xC0, 0x1F, 0xF0, 0xFE, 0xFF, 0x00, 0xFF,
  0x87, 0xE7, 0xF8, 0x0D, 0xFC, 0x7F, 0x3F, 0xE0, 0xEF, 0xF7, 0xF1, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF,
  0x80, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0xC7, 0xF1, 0xFC,
  0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x30, 0x03, 0xF8, 0x03, 0x1F, 0x03, 0xF8, 0x0F, 0x9F, 0xF1,
  0xFC, 0x3F, 0xCF, 0xFE, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFA, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0xC3, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE,
  0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF,
  0xF0, 0x7C, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x3F, 0xC3, 0xFF,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x07, 0xF0, 0xFF,
  0xFF, 0x81, 0xF0, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF8,
  0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0x07,
  0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xC0, 0x7F,
  0x80, 0x07, 0x00, 0xFF, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x04, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x1F, 0xF0,
  0x07, 0x00, 0x03, 0xFC, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x04, 0x00, 0x01,
  0xFF, 0x03, 0x00, 0x00, 0x7F, 0xC1, 0xE0, 0x00, 0x3F, 0xE1, 0xFC, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x1F,
  0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE1, 0xFF, 0xE0, 0x01, 0xF9, 0xFF, 0xFC,
  0x00, 0xFE, 0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x10, 0x00, 0x07, 0xFC,
  0x0E, 0x00, 0x01, 0xFE, 0x07, 0x80, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xF1, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF,
  0xE0, 0xFF, 0xBF, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xC7, 0xFD, 0xFF, 0xFF,
  0xCF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xC7, 0xFE,
  0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0xFF, 0x87,
  0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC,
  0x07, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFE,
  0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xFF, 0xFD, 0xFE,
  0x3F, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0xF7, 0xFC,
  0x0F, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0x8F, 0xF8, 0x00, 0xFE, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0x7F, 0x00, 0x1F, 0xF1, 0xE0, 0x01, 0xFF, 0x04, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x03, 0xE1, 0xF8, 0xFC, 0x07,
  0xF8, 0xFC, 0xFE, 0x07, 0xFE, 0x7E, 0x7F, 0x07, 0xFF, 0xFF, 0x3F, 0x07,
  0xFF, 0xFF, 0x9F, 0x83, 0xF8, 0x7F, 0x9F, 0xC3, 0xF8, 0x1F, 0xCF, 0xE1,
  0xF8, 0x07, 0xE7, 0xF1, 0xFC, 0x03, 0xF3, 0xF0, 0xFE, 0x01, 0xF9, 0xF8,
  0x7E, 0x01, 0xFD, 0xFC, 0x3F, 0x00, 0xFC, 0xFE, 0x3F, 0x80, 0x7E, 0x7F,
  0x1F, 0xC0, 0x3F, 0x3F, 0x8F, 0xE0, 0x1F, 0x9F, 0x87, 0xF0, 0x0F, 0xCF,
  0xC3, 0xF8, 0x0F, 0xE7, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0xFC, 0x07, 0xF1,
  0xF8, 0x7F, 0x03, 0xF8, 0xFC, 0x3F, 0x83, 0xFC, 0x7E, 0x0F, 0xE7, 0x7E,
  0x3F, 0x07, 0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0xBF, 0x0F, 0xC0, 0xFF, 0x9F,
  0x87, 0xE0, 0x3F, 0x8F, 0xC3, 0xF0, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x87, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x03, 0x80, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03,
  0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xC1, 0xFE, 0x01,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x03, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x80,
  0xFF, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0x9F, 0xE0,
  0x1F, 0xFF, 0xCF, 0xF0, 0x10, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x81, 0xDF, 0xC0, 0xFF, 0xFF, 0xEF, 0xE0,
  0x7F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xF3, 0xF8,
  0x01, 0xFF, 0xF1, 0xFC, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x7C, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFD, 0xFF,
  0x00, 0x00, 0x7F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x1F, 0xBF, 0x0F, 0xDF, 0xC0, 0x7F, 0x7F, 0x1F, 0xBF, 0x80,
  0xFE, 0x7E, 0x7E, 0x7F, 0x01, 0xFC, 0xFC, 0xFC, 0xFC, 0x03, 0xF9, 0xFB,
  0xF3, 0xF8, 0x07, 0xF3, 0xFF, 0xE7, 0xF0, 0x0F, 0xE7, 0xFF, 0x8F, 0xE0,
  0x3F, 0x87, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xC0, 0xFE,
  0x01, 0xFC, 0x07, 0x01, 0xFC, 0x03, 0xF8, 0x0E, 0x03, 0xF8, 0x0F, 0xE0,
  0x18, 0x07, 0xF0, 0x1F, 0xC0, 0x30, 0x0F, 0xE0, 0x3F, 0x80, 0x40, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x0F,
  0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xFC,
  0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07,
  0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xF7, 0xE0, 0x3F,
  0xC0, 0x7F, 0x7E, 0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0xFE, 0x7F,
  0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xF8, 0x0F,
  0xE3, 0xF0, 0x7F, 0x80, 0xFE, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x7F, 0x01, 0xFC, 0x1F,
  0x87, 0xF0, 0x1F, 0xC1, 0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F,
  0x81, 0xFC, 0xFE, 0x03, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0xFC, 0xFE,
  0x03, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x03, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x7F,
  0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xF8,
  0x07, 0xF0, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x03,
  0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE,
  0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0x1F, 0xE0,
  0x7C, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0xF8, 0x03, 0xFC, 0x00,
  0x07, 0x00, 0x7F, 0xC0, 0x00, 0x40, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xFF, 0x03, 0xF0, 0x1F, 0xC1,
  0xFF, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x07, 0xF0, 0x1F, 0xC3, 0xFF, 0x07,
  0xF0, 0x1F, 0xC3, 0xFF, 0x07, 0xE0, 0x1F, 0xC3, 0xFF, 0x07, 0xE0, 0x1F,
  0x87, 0xFF, 0x0F, 0xE0, 0x1F, 0x87, 0xDF, 0x0F, 0xE0, 0x3F, 0x87, 0xDF,
  0x0F, 0xE0, 0x3F, 0x8F, 0xDF, 0x0F, 0xC0, 0x3F, 0x8F, 0x9F, 0x0F, 0xC0,
  0x3F, 0x8F, 0x9F, 0x1F, 0xC0, 0x3F, 0x9F, 0x9F, 0x1F, 0xC0, 0x3F, 0x9F,
  0x1F, 0x1F, 0x80, 0x3F, 0x9F, 0x1F, 0x1F, 0x80, 0x3F, 0x3F, 0x1F, 0x3F,
  0x80, 0x3F, 0x3E, 0x1F, 0x3F, 0x80, 0x3F, 0x3E, 0x1F, 0x3F, 0x00, 0x7F,
  0x3E, 0x1F, 0x3F, 0x00, 0x7F, 0x7C, 0x1F, 0x3F, 0x00, 0x7F, 0x7C, 0x1F,
  0x7F, 0x00, 0x7F, 0x7C, 0x1F, 0x7E, 0x00, 0x7F, 0xF8, 0x1F, 0x7E, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0x3F, 0x8E, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x01, 0xC0, 0xFC, 0x7F, 0x87, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7C, 0x06,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xF8,
  0xFE, 0x03, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xFD,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0xEF,
  0xF0, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFC, 0x3F, 0xFE, 0x07, 0xFC, 0x1F, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x7E, 0x00, 0x1F, 0xE1, 0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0xF8, 0x07,
  0xF9, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0x81,
  0xFE, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xF8,
  0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xCF,
  0xFF, 0xF8, 0x1F, 0xE7, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0xF8, 0x07, 0xF8,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF,
  0x1F, 0xE0, 0x03, 0xE1, 0xFE, 0x00, 0x1C, 0x0F, 0xF0, 0x00, 0x80, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xC3, 0xFC, 0x00, 0x0F, 0x1F, 0xE0, 0x00, 0x7E, 0xFF, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF8, 0xFF, 0xC0, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xFC,
  0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xFB, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC,
  0x0F, 0xF0, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC1, 0xEF, 0xF0, 0x0F, 0xFF,
  0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0xC7, 0xF0, 0x01,
  0xFF, 0xF1, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0xFF,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x18, 0x3F, 0xC0, 0x00, 0xF8, 0xFF, 0x00, 0x03, 0xF3, 0xFE,
  0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x04, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xF0,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0x7F, 0x01, 0xFF, 0x07,
  0xBF, 0xC0, 0x7F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xF3, 0xFC, 0x03, 0xFF,
  0xF8, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0x80, 0x0F, 0xFE, 0x1F, 0xE0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0x00, 0x07, 0xF8,
  0x01, 0xE0, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0xF0, 0x07,
  0xF8, 0x7F, 0xF8, 0x07, 0xF8, 0xFF, 0xFC, 0x07, 0xF9, 0xFF, 0xFE, 0x07,
  0xFB, 0xFF, 0xFE, 0x07, 0xF3, 0x83, 0xFE, 0x0F, 0xF7, 0x01, 0xFE, 0x0F,
  0xF4, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x10, 0x00, 0xFF, 0x00, 0x60, 0x03, 0xFC, 0x07, 0xC0, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFE, 0x0F, 0xF8, 0x07, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x20,
  0x07, 0xF8, 0x00, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x83, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xF0, 0x07, 0xF9, 0xFF,
  0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0x80, 0x7F, 0x78, 0x3F, 0xE0, 0x1F, 0xD8,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0x1F, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x08, 0x3F, 0xC3,
  0xFC, 0x07, 0x0F, 0xE0, 0xFF, 0x03, 0xE7, 0xF8, 0x3F, 0xC1, 0xFD, 0xFE,
  0x07, 0xF8, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x1F, 0xE0, 0x3F, 0xFF, 0x87,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x10, 0x07, 0xF8, 0x06, 0x01, 0xFE, 0x03, 0xE0,
  0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE7, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7E,
  0x3F, 0xC1, 0xFE, 0x07, 0xE7, 0xFC, 0x3F, 0xF0, 0x7E, 0x7F, 0xE7, 0xFF,
  0x0F, 0xEF, 0xFE, 0xFF, 0xF0, 0xFF, 0x8F, 0xEC, 0x7F, 0x0F, 0xF0, 0xFF,
  0x87, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0xFC,
  0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x7F,
  0x1F, 0x80, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x07, 0xE1, 0xF8, 0x1F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0xFC, 0x7F, 0x03, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0x1F, 0xC7, 0xE0,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x01, 0xF8,
  0xFE, 0x07, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF0,
  0x3F, 0x8F, 0xC0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0xF0, 0x07, 0xF8, 0x7F, 0xF8, 0x07,
  0xF8, 0xFF, 0xFC, 0x07, 0xF9, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x07,
  0xF3, 0x83, 0xFE, 0x0F, 0xF7, 0x01, 0xFE, 0x0F, 0xF4, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC3, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xFC,
  0x00, 0xFF, 0x3F, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xF8, 0x07, 0xF9, 0xFF,
  0xFF, 0x00, 0xFF, 0x78, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0xF0, 0x0F, 0xF3,
  0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xFF, 0x00, 0x3F, 0xC3, 0xFF, 0xC0, 0x07,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0xFF,
  0x01, 0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFC, 0xFF,
  0x0F, 0xFF, 0xFE, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x03, 0xFE,
  0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC,
  0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC1, 0xEF, 0xF0, 0x7F, 0xFF, 0xEF, 0xF0,
  0x7F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x1F, 0xE0,
  0x0F, 0xFE, 0x1F, 0xE0, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0x07, 0xFD,
  0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xDF,
  0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0x00, 0x7F, 0x78, 0x00, 0x00,
  0xFE, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0x03, 0xFC,
  0x00, 0x38, 0x0F, 0xE0, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x10, 0x00, 0x07, 0xF0, 0x60, 0x00, 0x3F, 0xC3, 0xC0, 0x00,
  0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0C,
  0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xF8, 0xFF, 0xC0, 0x0F,
  0xE7, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07,
  0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00,
  0x7F, 0xE1, 0xFE, 0x01, 0xBF, 0xC3, 0xFE, 0x0F, 0x7F, 0x87, 0xFF, 0xFC,
  0xFE, 0x07, 0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0x8F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0xFF, 0xF8, 0x01, 0xF1, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xE0, 0x1F,
  0xEF, 0xFF, 0xC0, 0x3F, 0xDF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x00, 0xFE, 0x0F, 0xF8, 0x01, 0xFC, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7E,
  0x01, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x01, 0xF8, 0x7F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x87,
  0xE0, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0x0F,
  0xE3, 0xF0, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF0, 0x3F, 0x9F, 0xC0, 0xFC,
  0x07, 0xF3, 0xF8, 0x1F, 0x80, 0xFE, 0x7E, 0x03, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0x0F, 0xCF,
  0xE0, 0x7F, 0x01, 0xF9, 0xFC, 0x0F, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE0, 0x3F, 0x1F, 0x81, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F, 0xC1,
  0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0xC3, 0xF0, 0x7F, 0xFD, 0xF8, 0xFE, 0x07,
  0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF8,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFC, 0xFC,
  0xF1, 0xFC, 0xFF, 0xC7, 0xE7, 0x0F, 0xE3, 0xF8, 0x3F, 0x70, 0x3F, 0x0F,
  0x81, 0xFB, 0x81, 0xF8, 0x30, 0x0F, 0xD8, 0x0F, 0xC1, 0x00, 0x7F, 0xC0,
  0x7E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x80,
  0x20, 0xFC, 0x06, 0xFC, 0x03, 0x87, 0xE0, 0x37, 0xE0, 0x7E, 0x3F, 0x83,
  0xBF, 0x07, 0xF9, 0xFC, 0x39, 0xF8, 0xFF, 0xCF, 0xE3, 0xCF, 0xCF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x1B, 0xFC, 0x07, 0xFE,
  0x1E, 0xFF, 0x01, 0xFF, 0xFF, 0x3F, 0xC0, 0x3F, 0xFF, 0xCF, 0xE0, 0x0F,
  0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0x80,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x08, 0x00, 0x1F,
  0xE0, 0x07, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0x83,
  0xF8, 0x1F, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0xFF,
  0xEF, 0xE0, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x00, 0x7F, 0xFC, 0x1F, 0xC0,
  0x07, 0xFE, 0x07, 0xE0, 0x01, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x7E,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x60, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0xE0,
  0x0F, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x7E, 0x0F, 0xFE,
  0x00, 0x1F, 0x87, 0xFF, 0xFC, 0x03, 0xE1, 0xFF, 0xFF, 0xF8, 0xF8, 0xFE,
  0xFF, 0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xC3,
  0xF8, 0x07, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x0E, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x7F, 0xF8, 0x00,
  0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0x0F, 0xFF, 0xE0, 0x1F, 0x87, 0xFF, 0xF8,
  0x07, 0xE1, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x3F, 0xE1, 0xFC, 0x3F, 0x07,
  0xFC, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0xFF, 0xE1, 0xF8,
  0x07, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0xFC, 0x0F,
  0xC0, 0x03, 0xFE, 0x00, 0x60, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 16, 44, 37, 11, -43 },
  { 89, 24, 19, 37, 10, -46 },
  { 146, 39, 43, 37, 0, -43 },
  { 356, 36, 57, 37, 1, -50 },
  { 613, 43, 45, 37, -2, -44 },
  { 855, 37, 45, 37, 0, -44 },
  { 1064, 10, 19, 37, 17, -46 },
  { 1088, 26, 56, 37, 11, -47 },
  { 1270, 25, 56, 37, 2, -47 },
  { 1445, 33, 31, 37, 3, -34 },
  { 1573, 30, 30, 37, 4, -34 },
  { 1686, 17, 19, 37, 7, -10 },
  { 1727, 20, 7, 37, 9, -22 },
  { 1745, 12, 11, 37, 11, -10 },
  { 1762, 37, 56, 37, 0, -47 },
  { 2021, 33, 45, 37, 3, -44 },
  { 2207, 31, 43, 37, 3, -43 },
  { 2374, 34, 44, 37, 1, -44 },
  { 2561, 34, 45, 37, 1, -44 },
  { 2753, 34, 43, 37, 1, -43 },
  { 2936, 34, 44, 37, 2, -43 },
  { 3123, 31, 44, 37, 3, -43 },
  { 3294, 33, 43, 37, 5, -43 },
  { 3472, 34, 45, 37, 2, -44 },
  { 3664, 32, 44, 37, 4, -44 },
  { 3840, 15, 33, 37, 11, -32 },
  { 3902, 19, 41, 37, 7, -32 },
  { 4000, 30, 37, 37, 5, -37 },
  { 4139, 32, 20, 37, 3, -29 },
  { 4219, 30, 37, 37, 3, -37 },
  { 4358, 28, 45, 37, 7, -44 },
  { 4516, 33, 51, 37, 3, -44 },
  { 4727, 36, 43, 37, -2, -43 },
  { 4921, 33, 43, 37, 2, -43 },
  { 5099, 33, 45, 37, 4, -44 },
  { 5285, 34, 43, 37, 2, -43 },
  { 5468, 35, 43, 37, 2, -43 },
  { 5657, 36, 43, 37, 2, -43 },
  { 5851, 33, 45, 37, 3, -44 },
  { 6037, 36, 43, 37, 2, -43 },
  { 6231, 35, 43, 37, 2, -43 },
  { 6420, 34, 44, 37, 2, -43 },
  { 6607, 39, 43, 37, 2, -43 },
  { 6817, 28, 43, 37, 4, -43 },
  { 6968, 39, 43, 37, 0, -43 },
  { 7178, 36, 43, 37, 2, -43 },
  { 7372, 33, 45, 37, 3, -44 },
  { 7558, 35, 43, 37, 2, -43 },
  { 7747, 33, 57, 37, 3, -44 },
  { 7983, 35, 43, 37, 2, -43 },
  { 8172, 36, 45, 37, 1, -44 },
  { 8375, 35, 43, 37, 5, -43 },
  { 8564, 35, 44, 37, 3, -43 },
  { 8757, 34, 43, 37, 6, -43 },
  { 8940, 40, 43, 37, 1, -43 },
  { 9155, 42, 43, 37, -2, -43 },
  { 9381, 36, 43, 37, 5, -43 },
  { 9575, 38, 43, 37, 0, -43 },
  { 9780, 28, 56, 37, 8, -47 },
  { 9976, 18, 56, 37, 10, -47 },
  { 10102, 29, 56, 37, 1, -47 },
  { 10305, 33, 27, 37, 3, -43 },
  { 10417, 31, 7, 37, -1, 5 },
  { 10445, 11, 14, 37, 12, -50 },
  { 10465, 32, 34, 37, 3, -33 },
  { 10601, 33, 47, 37, 2, -46 },
  { 10795, 29, 34, 37, 4, -33 },
  { 10919, 35, 47, 37, 3, -46 },
  { 11125, 30, 34, 37, 4, -33 },
  { 11253, 42, 59, 37, -2, -46 },
  { 11563, 34, 46, 37, 1, -33 },
  { 11759, 32, 46, 37, 2, -46 },
  { 11943, 30, 47, 37, 4, -46 },
  { 12120, 31, 59, 37, 1, -46 },
  { 12349, 34, 47, 37, 2, -46 },
  { 12549, 26, 47, 37, 6, -46 },
  { 12702, 36, 33, 37, 0, -33 },
  { 12851, 32, 33, 37, 2, -33 },
  { 12983, 31, 34, 37, 3, -33 },
  { 13115, 35, 45, 37, 0, -33 },
  { 13312, 32, 45, 37, 3, -33 },
  { 13492, 31, 32, 37, 6, -32 },
  { 13616, 30, 34, 37, 3, -33 },
  { 13744, 30, 44, 37, 4, -43 },
  { 13909, 31, 33, 37, 4, -32 },
  { 14037, 31, 34, 37, 3, -33 },
  { 14169, 35, 33, 37, 1, -32 },
  { 14314, 37, 34, 37, 0, -33 },
  { 14472, 34, 45, 37, 1, -32 },
  { 14664, 34, 34, 37, 2, -33 },
  { 14809, 31, 56, 37, 6, -47 },
  { 15026, 16, 56, 37, 11, -47 },
  { 15138, 30, 56, 37, 2, -47 },
  { 15348, 34, 16, 37, 2, -27 },
};

const GFXfont IBMPlexMono_SemiBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic62pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC62PT7B_H_
