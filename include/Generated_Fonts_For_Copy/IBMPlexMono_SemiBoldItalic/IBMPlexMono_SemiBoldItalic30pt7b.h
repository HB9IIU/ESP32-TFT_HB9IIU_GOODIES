#ifndef _IBMPLEXMONO_SEMIBOLDITALIC30PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x78, 0x7C, 0xFC, 0xF8, 0x78, 0x38, 0xEF,
  0x1D, 0xE7, 0xB8, 0xF7, 0x1E, 0xE3, 0x9C, 0x77, 0x8E, 0xF3, 0xC0, 0x00,
  0xF3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x03,
  0x8E, 0x07, 0xF3, 0xF9, 0xFC, 0x7F, 0x3F, 0x9F, 0xC0, 0xF3, 0x80, 0x1C,
  0x70, 0x03, 0x9E, 0x0F, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x9F, 0xC0, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x9C,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xF9, 0xBE, 0x79, 0xC4, 0x3C, 0xE0, 0x1E, 0x70, 0x0F, 0x30,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0x7C, 0x01,
  0x8F, 0x00, 0xC7, 0x90, 0x63, 0xCC, 0x73, 0xCF, 0xBB, 0xE7, 0xFF, 0xE1,
  0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x38, 0x7F, 0x03, 0x83, 0xFC, 0x38, 0x38, 0xE1, 0xC1, 0xC7, 0x1C,
  0x0E, 0x39, 0xC0, 0x61, 0xCE, 0x03, 0x9E, 0xE0, 0x1F, 0xEE, 0x00, 0xFE,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3F, 0x80, 0x3B, 0xFC, 0x03, 0xBC, 0xE0,
  0x39, 0xC3, 0x01, 0xCE, 0x38, 0x1C, 0x71, 0xC1, 0xC3, 0x8E, 0x0E, 0x1F,
  0xE0, 0xE0, 0x7F, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0x78, 0x70, 0x1E,
  0x3C, 0x03, 0x8E, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xE7, 0x00, 0x71, 0xE0,
  0x3C, 0x38, 0x0F, 0x0F, 0x03, 0xC3, 0xC6, 0xF0, 0xF1, 0xFE, 0x3E, 0xE7,
  0xF3, 0xF1, 0xFC, 0xFC, 0x3E, 0x1E, 0x00, 0x3B, 0xDE, 0xF7, 0x39, 0xDE,
  0xF0, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x71, 0xC3,
  0x7D, 0xDF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1E, 0xF0, 0x3C, 0x78, 0x78, 0x78, 0x10, 0x20, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFC, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x1F, 0x8F, 0x87, 0x87, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x00,
  0x7F, 0xDF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x83, 0xE1, 0xE3, 0xC0, 0xF1, 0xE0, 0x39, 0xE0, 0x1C,
  0xF0, 0x0F, 0x78, 0x07, 0xBC, 0xE7, 0xBE, 0x73, 0xDE, 0x79, 0xEF, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x79, 0xE0, 0x3C, 0x70, 0x3E, 0x3C, 0x3E, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x7B, 0xC1, 0xF7, 0x87, 0xCF, 0x1F, 0x1C, 0x1C, 0x78, 0x10, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC1, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x18, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE1,
  0xF0, 0xC0, 0x78, 0x40, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x40, 0x1E, 0x30, 0x1F, 0x7C, 0x1F, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x38, 0x07, 0x1C, 0x07, 0x9E, 0x07, 0x8F, 0x07, 0x87,
  0x87, 0x83, 0xC3, 0x81, 0xC3, 0xC0, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x71, 0xE0, 0x3B, 0xFC, 0x1F, 0xFF, 0x0F, 0x0F, 0x89, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x40, 0x3C, 0x70, 0x3E, 0x7C, 0x3E,
  0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8, 0x3F,
  0xFC, 0x7B, 0xFE, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x70, 0x0F, 0x70, 0x1E, 0x70,
  0x3E, 0x70, 0x3C, 0x80, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0xFF, 0x1E, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x1E,
  0x1E, 0x0F, 0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F,
  0xE0, 0x03, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0xEF, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE1, 0xFB, 0xFE, 0xF3,
  0xFB, 0xC3, 0xE7, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x1E, 0x3F, 0x3F, 0x3E, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xFC, 0x78, 0x07, 0x83, 0xF0,
  0xFC, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x05, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x20, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFE, 0x10, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x7C, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x01,
  0x00, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1F, 0xF0, 0x3C, 0x40,
  0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x0F, 0x1C,
  0x07, 0x3C, 0x07, 0x38, 0xF7, 0x79, 0xFF, 0x71, 0xFF, 0x73, 0xC7, 0x73,
  0x87, 0x73, 0x87, 0xF7, 0x8E, 0xE7, 0x0E, 0xE7, 0x1E, 0xE7, 0xFE, 0xE3,
  0xEE, 0xE3, 0xEE, 0xF0, 0x10, 0x70, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0E, 0xE0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0x8F, 0x03, 0xC7,
  0x81, 0xC3, 0xC1, 0xE0, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x38,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x78,
  0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xFC,
  0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E,
  0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFC, 0x1F, 0xFE,
  0x3E, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x10,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1F, 0x1E, 0x0F, 0x1C, 0x0F,
  0x3C, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x70, 0x7C,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0x83, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xF1, 0xF3, 0xC1, 0xEF, 0x01, 0xDE,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xFF, 0x8F, 0xEF, 0x1F,
  0xDC, 0x03, 0xB8, 0x07, 0x78, 0x1E, 0xF0, 0x3D, 0xF1, 0xF1, 0xFE, 0xE3,
  0xFD, 0xC1, 0xE7, 0x80, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1F,
  0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x70, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC0, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF8, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0x80, 0x1E, 0x03, 0xE3, 0xC0, 0xF0, 0x78, 0x3E, 0x0F,
  0x0F, 0x81, 0xE3, 0xE0, 0x38, 0xF8, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3D,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xEF, 0x00, 0xF9,
  0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x0E, 0x07, 0x83, 0xC0,
  0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x03, 0xE3, 0xE0, 0xFC, 0x7E, 0x1F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3B, 0x87, 0x77, 0xF1, 0xEF, 0xDE,
  0x3D, 0xFB, 0x87, 0x3E, 0x70, 0xE7, 0xCE, 0x1C, 0x73, 0xC3, 0x8C, 0x78,
  0xF1, 0x8F, 0x1E, 0x21, 0xC3, 0x84, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE0, 0x1F, 0x03, 0x8F, 0x81, 0xC7,
  0xE1, 0xE3, 0xF0, 0xF3, 0xF8, 0x71, 0xFC, 0x38, 0xFE, 0x1C, 0x77, 0x8E,
  0x3B, 0xCF, 0x1C, 0xE7, 0x8E, 0x73, 0x8F, 0x39, 0xC7, 0x9C, 0xE3, 0x8F,
  0x71, 0xC3, 0xF8, 0xE1, 0xFC, 0x70, 0xFC, 0x78, 0x7E, 0x3C, 0x3F, 0x1C,
  0x0F, 0x8E, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE3,
  0xE3, 0xE0, 0xF1, 0xE0, 0x39, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC,
  0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x79,
  0xE0, 0x3C, 0x78, 0x3E, 0x3C, 0x3E, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFC,
  0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xE1, 0xE0, 0x78,
  0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x39, 0xF0,
  0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x79, 0xE0, 0x3C, 0x78, 0x3E, 0x3C, 0x3E,
  0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x1E, 0x20, 0x07, 0x1C, 0x03,
  0xDE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x78,
  0x1F, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3C, 0x1F, 0x1E, 0x01, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x80, 0x3C, 0x30, 0x0F, 0x1F, 0x07, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x3C, 0xF0, 0x78,
  0xF0, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0xF0, 0x0F, 0xF8, 0x07,
  0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF0, 0xE0,
  0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x38, 0x01, 0xE7, 0x00, 0x39, 0xE0, 0x07,
  0x3C, 0x00, 0xE7, 0x80, 0x3C, 0xE3, 0xC7, 0x1C, 0x78, 0xE3, 0x8F, 0x1C,
  0x73, 0xE7, 0x8E, 0x6C, 0xE1, 0xCD, 0x9C, 0x3B, 0xB3, 0x8F, 0x76, 0x71,
  0xEC, 0xDE, 0x3F, 0x9B, 0x87, 0x73, 0x70, 0xEC, 0x6E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC0, 0x0F, 0x00, 0xF0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0x7C, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x01, 0xEF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x1F,
  0x1F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0x78, 0xF8, 0x07, 0x80,
  0xF8, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x0E, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x00,
  0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x00,
  0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0xBC, 0x0F, 0x3C, 0x0E,
  0x1C, 0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0F, 0xF0, 0x07, 0x20,
  0x04, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x27, 0xBC, 0xE7, 0x9C, 0x40,
  0x07, 0xCF, 0x1F, 0xEF, 0x3F, 0xEE, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xFC,
  0x7F, 0xBE, 0x7F, 0x3E, 0x3E, 0x1E, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x78, 0x3D, 0xFE,
  0x3D, 0xFE, 0x3F, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x7C, 0xF7, 0xFC, 0xF7, 0xF8,
  0xF3, 0xE0, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0xDF, 0x0F, 0x78, 0x1B, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x6F, 0x03, 0xFE, 0x1E, 0x7F,
  0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x0F, 0x9E, 0x1F, 0xEF,
  0x1F, 0xF7, 0x8F, 0x87, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0x78, 0x1E, 0x3E, 0x3F, 0x0F, 0xF7, 0x87,
  0xFB, 0xC0, 0xF1, 0xE0, 0x03, 0xF0, 0x7F, 0xE3, 0xFF, 0xDF, 0x0F, 0x78,
  0x1F, 0xC1, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0x83, 0xC0, 0x0F, 0x01, 0xBE,
  0x1F, 0x7F, 0xF8, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x10, 0xF0, 0x01, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x3D, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xCF, 0x1F,
  0xEF, 0x3F, 0xEF, 0x3E, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0xFC, 0x7F, 0xBC, 0x3F,
  0xBC, 0x1E, 0x3C, 0x00, 0x78, 0x40, 0x78, 0x60, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0x3F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x3C, 0x3C, 0xFC, 0x7B, 0xFC, 0xFC, 0x79,
  0xF0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x39, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x80, 0x01, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x83, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x18, 0x3C, 0xF0, 0xE7, 0xC7, 0xBE, 0x1F, 0xF0, 0x3F, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x08, 0x3C, 0x18, 0x78, 0x78, 0xF0, 0xF9,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x7C, 0x3C, 0xFE, 0x3D, 0xFE, 0x3F, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x78,
  0x3C, 0x78, 0x78, 0x7B, 0xC0, 0x7B, 0xC2, 0x79, 0xE7, 0x71, 0xEF, 0xF1,
  0xFE, 0xF0, 0xFC, 0xF0, 0x78, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x86, 0x3C, 0x79, 0xEF, 0x8E, 0xF8,
  0x7F, 0x83, 0xF8, 0x0F, 0x00, 0x3D, 0xC7, 0x8E, 0xFB, 0xE3, 0xFF, 0xFC,
  0xF3, 0xCF, 0x38, 0xE3, 0x9E, 0x38, 0xE7, 0x8E, 0x39, 0xC7, 0x8E, 0x71,
  0xC3, 0x9C, 0x71, 0xE7, 0x1C, 0x73, 0xC7, 0x1C, 0xE1, 0xC7, 0x38, 0xF1,
  0xCE, 0x38, 0xF0, 0x1C, 0x78, 0x79, 0xF8, 0xF7, 0xF9, 0xF8, 0xF3, 0xE1,
  0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x73,
  0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x3E, 0x1E, 0x7C, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x3E, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xC0, 0x1E, 0x3C, 0x0F, 0x7F, 0x87, 0xBF, 0xC3, 0xF1, 0xE1, 0xE0,
  0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x87, 0xC7, 0xBF, 0xE3, 0xDF, 0xE1, 0xE7, 0xC0, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xCF, 0x1F, 0xEF, 0x3F, 0xEF, 0x3E, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xFC, 0x7F,
  0xBC, 0x7F, 0xBC, 0x1E, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0xFF, 0x1F, 0xFE, 0xFF, 0xFF, 0xF0, 0x74,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0x63, 0xC0, 0x07, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x78, 0x80, 0xF3, 0x81, 0xEF, 0xFF, 0x8F, 0xFE,
  0x07, 0xF0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x84, 0x0F, 0x0C, 0x1E, 0x7C, 0x39,
  0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC0, 0xE7, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x39,
  0xE0, 0xF3, 0xC3, 0xE7, 0x8F, 0xCF, 0xF7, 0x8F, 0xCF, 0x0F, 0x1C, 0x00,
  0x7E, 0x04, 0xFC, 0x3F, 0xF8, 0x78, 0xF0, 0x71, 0xE0, 0xE3, 0x81, 0xC7,
  0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x78, 0xF1, 0xF1, 0xCF, 0xC3, 0xFF,
  0x07, 0xF8, 0x07, 0xC0, 0x00, 0x78, 0xE3, 0x71, 0xE7, 0x71, 0xC7, 0x71,
  0xC7, 0x71, 0xC7, 0x71, 0xC7, 0xE1, 0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xE3,
  0x8E, 0xE3, 0x8E, 0xE7, 0x8E, 0xFD, 0x9C, 0xF9, 0xF8, 0x70, 0xF0, 0x07,
  0x87, 0x83, 0xF3, 0xE1, 0xFD, 0xFD, 0xF7, 0x67, 0x39, 0xF1, 0xC8, 0x78,
  0x70, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x78, 0x4E, 0x3E, 0x73,
  0x9B, 0xBE, 0xFE, 0xFF, 0x1F, 0x3F, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0x8B, 0xC3, 0xFD,
  0xE0, 0xFC, 0xF0, 0x3C, 0x70, 0x00, 0x78, 0x20, 0x3C, 0x18, 0x3C, 0x1F,
  0xFE, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC7, 0x3F, 0xE7, 0x3F, 0xFF,
  0x38, 0x7F, 0x70, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x84,
  0x1F, 0x0C, 0x3C, 0x0E, 0xFF, 0x8E, 0xFF, 0xFE, 0xE7, 0xFE, 0xE0, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x0F, 0xF8,
  0x1F, 0x80, 0x3F, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x7F, 0x00, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xFC, 0x03, 0xF0, 0x3F, 0xC1, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x00, 0x1E, 0x03, 0x3F, 0x87, 0x7F, 0x87,
  0x73, 0xCE, 0xE1, 0xFE, 0xE0, 0xFC, 0xE0, 0x78,
};

const GFXglyph IBMPlexMono_SemiBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 21, 18, 5, -21 },
  { 22, 11, 9, 18, 5, -22 },
  { 35, 19, 21, 18, 0, -21 },
  { 85, 17, 27, 18, 1, -24 },
  { 143, 21, 21, 18, -1, -21 },
  { 199, 18, 21, 18, 0, -21 },
  { 247, 5, 9, 18, 8, -22 },
  { 253, 13, 27, 18, 5, -23 },
  { 297, 12, 27, 18, 1, -23 },
  { 338, 16, 15, 18, 1, -16 },
  { 368, 15, 15, 18, 2, -17 },
  { 397, 9, 9, 18, 3, -5 },
  { 408, 10, 3, 18, 4, -11 },
  { 412, 6, 5, 18, 5, -5 },
  { 416, 18, 27, 18, 0, -23 },
  { 477, 17, 21, 18, 1, -21 },
  { 522, 15, 21, 18, 1, -21 },
  { 562, 16, 21, 18, 1, -21 },
  { 604, 17, 21, 18, 0, -21 },
  { 649, 17, 21, 18, 0, -21 },
  { 694, 17, 21, 18, 1, -21 },
  { 739, 16, 21, 18, 1, -21 },
  { 781, 16, 21, 18, 2, -21 },
  { 823, 16, 21, 18, 1, -21 },
  { 865, 15, 21, 18, 2, -21 },
  { 905, 8, 16, 18, 5, -16 },
  { 921, 10, 20, 18, 3, -16 },
  { 946, 15, 18, 18, 2, -18 },
  { 980, 16, 10, 18, 1, -14 },
  { 1000, 15, 18, 18, 1, -18 },
  { 1034, 14, 21, 18, 3, -21 },
  { 1071, 16, 24, 18, 1, -21 },
  { 1119, 17, 21, 18, -1, -21 },
  { 1164, 16, 21, 18, 1, -21 },
  { 1206, 16, 21, 18, 2, -21 },
  { 1248, 16, 21, 18, 1, -21 },
  { 1290, 17, 21, 18, 1, -21 },
  { 1335, 17, 21, 18, 1, -21 },
  { 1380, 15, 21, 18, 2, -21 },
  { 1420, 17, 21, 18, 1, -21 },
  { 1465, 17, 21, 18, 1, -21 },
  { 1510, 16, 21, 18, 1, -21 },
  { 1552, 19, 21, 18, 1, -21 },
  { 1602, 13, 21, 18, 2, -21 },
  { 1637, 19, 21, 18, 0, -21 },
  { 1687, 17, 21, 18, 1, -21 },
  { 1732, 17, 21, 18, 1, -21 },
  { 1777, 17, 21, 18, 1, -21 },
  { 1822, 17, 27, 18, 1, -21 },
  { 1880, 17, 21, 18, 1, -21 },
  { 1925, 18, 21, 18, 0, -21 },
  { 1973, 17, 21, 18, 2, -21 },
  { 2018, 16, 21, 18, 2, -21 },
  { 2060, 17, 21, 18, 3, -21 },
  { 2105, 19, 21, 18, 1, -21 },
  { 2155, 20, 21, 18, -1, -21 },
  { 2208, 18, 21, 18, 2, -21 },
  { 2256, 18, 21, 18, 0, -21 },
  { 2304, 14, 27, 18, 4, -23 },
  { 2352, 8, 27, 18, 5, -23 },
  { 2379, 13, 27, 18, 1, -23 },
  { 2423, 16, 13, 18, 1, -21 },
  { 2449, 15, 3, 18, 0, 2 },
  { 2455, 5, 7, 18, 6, -24 },
  { 2460, 16, 15, 18, 1, -15 },
  { 2490, 16, 22, 18, 1, -22 },
  { 2534, 14, 15, 18, 2, -15 },
  { 2561, 17, 22, 18, 1, -22 },
  { 2608, 14, 15, 18, 2, -15 },
  { 2635, 21, 28, 18, -1, -22 },
  { 2709, 16, 21, 18, 1, -15 },
  { 2751, 15, 22, 18, 1, -22 },
  { 2793, 14, 23, 18, 2, -23 },
  { 2834, 15, 29, 18, 1, -23 },
  { 2889, 16, 22, 18, 1, -22 },
  { 2933, 13, 22, 18, 3, -22 },
  { 2969, 18, 15, 18, 0, -15 },
  { 3003, 15, 15, 18, 1, -15 },
  { 3032, 16, 15, 18, 1, -15 },
  { 3062, 17, 21, 18, 0, -15 },
  { 3107, 16, 21, 18, 1, -15 },
  { 3149, 15, 15, 18, 3, -15 },
  { 3178, 15, 15, 18, 1, -15 },
  { 3207, 15, 21, 18, 2, -21 },
  { 3247, 15, 15, 18, 2, -15 },
  { 3276, 15, 15, 18, 1, -15 },
  { 3305, 16, 15, 18, 1, -15 },
  { 3335, 18, 15, 18, 0, -15 },
  { 3369, 17, 21, 18, 0, -15 },
  { 3414, 16, 15, 18, 1, -15 },
  { 3444, 15, 27, 18, 3, -23 },
  { 3495, 8, 27, 18, 5, -23 },
  { 3522, 14, 27, 18, 1, -23 },
  { 3570, 16, 7, 18, 1, -13 },
};

const GFXfont IBMPlexMono_SemiBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC30PT7B_H_
