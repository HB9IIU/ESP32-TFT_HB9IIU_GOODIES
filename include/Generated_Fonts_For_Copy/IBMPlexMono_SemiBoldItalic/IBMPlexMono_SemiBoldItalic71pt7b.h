#ifndef _IBMPLEXMONO_SEMIBOLDITALIC71PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xF1, 0xFE,
  0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0,
  0x7F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xE7, 0xEF, 0xFE, 0x01, 0xFF, 0x83, 0xE1, 0xFE,
  0x01, 0xFF, 0x83, 0xF0, 0x3E, 0x00, 0xFF, 0x81, 0xF8, 0x0E, 0x00, 0x7F,
  0xC0, 0xFC, 0x02, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0x80, 0x00,
  0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x87, 0xE0, 0x00, 0x00, 0xFF,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x81,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0x80, 0x20, 0x07, 0xE0, 0x7F, 0xC0,
  0x30, 0x03, 0xF0, 0x3F, 0xE0, 0x3C, 0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0x81,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFC, 0x3F, 0xF8, 0x7F, 0xFE, 0x7E, 0x7F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC3,
  0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xC7, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x08, 0x3F, 0xE0,
  0x03, 0xFC, 0x03, 0x8F, 0xF8, 0x00, 0xFF, 0x80, 0xF9, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0x7F, 0xC0, 0x1B, 0xFC, 0x3F, 0xDF, 0xF0, 0x06, 0xFF, 0x0F,
  0xE7, 0xFE, 0x03, 0xBF, 0xC7, 0xF1, 0xFF, 0xC1, 0xE7, 0xFB, 0xFC, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x60, 0x03, 0xFC, 0x00, 0x61, 0xE0, 0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x3F, 0xF8, 0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFD, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0xDF, 0xFF, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x1F,
  0xF8, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x1F, 0x81, 0xFF, 0x3F,
  0xF0, 0x7F, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFE,
  0x1F, 0xFB, 0xFF, 0x07, 0xFC, 0x3F, 0xF7, 0xFE, 0x0F, 0xF0, 0x7F, 0xEF,
  0xFC, 0x1F, 0xE0, 0xFF, 0xDF, 0xF0, 0x1F, 0x81, 0xFF, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x0F, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x7C, 0x01, 0xFF,
  0x00, 0x01, 0x80, 0x1F, 0xF0, 0x00, 0x10, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00,
  0x38, 0x00, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x00,
  0x3F, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x7F, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x00, 0x07, 0xF9,
  0xFF, 0xFF, 0x80, 0x07, 0xF3, 0xFF, 0xFF, 0xC0, 0x07, 0xF7, 0xFF, 0xFF,
  0xE0, 0x07, 0xF7, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x60, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0x00, 0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x00,
  0x7F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0x00, 0xFF,
  0xCF, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xFC,
  0x1F, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x0F, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xF1, 0xFF,
  0xE0, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE,
  0x7F, 0xFC, 0x07, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x7F, 0xC3, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF,
  0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0xF1, 0xFF, 0x80, 0x3F, 0xFE, 0x3F, 0xF0,
  0x00, 0x7F, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0x00, 0x03,
  0xFF, 0x0F, 0x00, 0x03, 0xFF, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x7C, 0x1F, 0xC3, 0xF8, 0x07, 0xFC,
  0x7F, 0x1F, 0xE0, 0x3F, 0xF9, 0xFC, 0x7F, 0x81, 0xFF, 0xF7, 0xF1, 0xFC,
  0x0F, 0xFF, 0xDF, 0xCF, 0xF0, 0x7F, 0xC3, 0x7F, 0x3F, 0xC1, 0xFE, 0x07,
  0xFC, 0xFE, 0x0F, 0xF0, 0x0F, 0xE3, 0xF8, 0x3F, 0x80, 0x3F, 0x9F, 0xE0,
  0xFE, 0x00, 0xFE, 0x7F, 0x87, 0xF8, 0x03, 0xF9, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE7, 0xF8, 0x7F, 0x00, 0x7F, 0x9F, 0xC1, 0xFC, 0x01, 0xFC, 0x7F, 0x0F,
  0xF0, 0x07, 0xF1, 0xFC, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0xFF, 0x00, 0x7F,
  0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0xFF, 0x0F, 0xE0, 0x0F, 0xF3, 0xF8, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0xFE, 0x01, 0xFE, 0x3F, 0x83, 0xF8, 0x07, 0xF8,
  0xFE, 0x0F, 0xF0, 0x3F, 0xE3, 0xF8, 0x3F, 0xC1, 0xFF, 0x8F, 0xE0, 0xFF,
  0x8F, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xDF, 0xC3,
  0xF8, 0x1F, 0xFE, 0x7F, 0x0F, 0xE0, 0x3F, 0xF9, 0xFC, 0x3F, 0x80, 0x7F,
  0xC7, 0xF0, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F,
  0xC7, 0xFE, 0x00, 0x00, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF7, 0xFE,
  0x01, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0xF9, 0xFF, 0x80, 0x7F, 0xFF,
  0xCF, 0xF8, 0x03, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xF3, 0xFE, 0x01,
  0xFF, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xFE, 0x7F, 0x80,
  0x7F, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0xE1,
  0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xCF,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x1F,
  0xDF, 0xC0, 0x3F, 0xDF, 0xC1, 0xFD, 0xFC, 0x03, 0xFD, 0xFC, 0x3F, 0xBF,
  0xC0, 0x3F, 0xCF, 0xE3, 0xF3, 0xFC, 0x03, 0xFC, 0xFE, 0x7F, 0x3F, 0xC0,
  0x3F, 0xCF, 0xEF, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0xFE, 0x3F, 0x80, 0x7F,
  0x8F, 0xFF, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0xFC, 0x7F, 0x80, 0x7F, 0x87,
  0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xF0, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1E, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1C,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x08, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xFF,
  0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF7, 0xF0, 0x07, 0xF8, 0x07, 0xFB, 0xF8, 0x07, 0xF8, 0x07,
  0xF9, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF1, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x7F,
  0x80, 0xFE, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x0F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF0, 0x0F, 0xF7, 0xF8,
  0x07, 0xF8, 0x03, 0xFB, 0xFC, 0x03, 0xFC, 0x01, 0xFD, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x07, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0xE0,
  0x3E, 0x00, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x10, 0x00, 0x00,
  0x7F, 0xC0, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xFF, 0x81,
  0xFC, 0x03, 0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xE0, 0xFF,
  0x01, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0x80,
  0x7F, 0x83, 0xFF, 0xC1, 0xFC, 0x03, 0xFC, 0x3F, 0x7E, 0x0F, 0xE0, 0x1F,
  0xE1, 0xFB, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xDF, 0x87, 0xF8, 0x07, 0xF8,
  0xFC, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x3F, 0x1F, 0xE0, 0x0F, 0xE3, 0xF1, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0x8F,
  0xC7, 0xF0, 0x07, 0xF8, 0xFC, 0x7E, 0x3F, 0x80, 0x3F, 0xCF, 0xC3, 0xF1,
  0xFC, 0x01, 0xFE, 0x7E, 0x1F, 0x9F, 0xE0, 0x0F, 0xF3, 0xF0, 0xFC, 0xFE,
  0x00, 0x7F, 0xBF, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xF8, 0x3F, 0x3F, 0x80,
  0x1F, 0xCF, 0xC1, 0xF9, 0xFC, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xE0, 0x07,
  0xF7, 0xE0, 0x7E, 0xFE, 0x00, 0x7F, 0xBF, 0x03, 0xF7, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x70, 0x3F, 0x0F,
  0xF8, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x07, 0xF0, 0x3F, 0x03, 0xE0, 0x10, 0x00, 0x07, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xFE,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xFF, 0xEF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x0E,
  0xFF, 0x81, 0xFF, 0xC1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 0x8F,
  0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0xFF, 0xC0,
  0x7F, 0xCF, 0xFF, 0xFF, 0x01, 0xFF, 0x7C, 0x1F, 0xFE, 0x07, 0xFD, 0xC0,
  0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0x83,
  0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xF7,
  0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xFF, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0xF8,
  0x07, 0xFC, 0xFF, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0xFE, 0x00, 0xFF, 0x83,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x03, 0xC0, 0x7F, 0xC0, 0x00, 0xC0, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x60, 0xFF, 0xC0, 0x00, 0x3C, 0x1F, 0xF0, 0x00, 0x0F, 0xC7, 0xFC,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xFF, 0xCF, 0xF8, 0x03,
  0xFF, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F,
  0xE0, 0x1E, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0x00,
  0x1F, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0x00, 0x07, 0xFF,
  0x83, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0x87, 0xFC,
  0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x0F, 0xF8, 0x03, 0xFF,
  0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1D, 0xFF, 0x01,
  0xFF, 0xC0, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xFF,
  0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xFC, 0x7F, 0xC0,
  0x07, 0xFF, 0xF0, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x08, 0x00, 0x07, 0xFE, 0x00, 0x38, 0x00, 0x1F, 0xF8,
  0x00, 0x78, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x03, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F,
  0xE3, 0xFF, 0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xE7, 0xFF, 0xFE,
  0x07, 0xFE, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0x07, 0xFF, 0x07, 0xFD, 0xC0,
  0x3F, 0xF0, 0x7F, 0xD8, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x02, 0x00, 0x07, 0xFC, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x60, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x3F, 0xE0,
  0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0xFF, 0x00, 0x7F, 0xCF, 0xFF, 0xFE,
  0x01, 0xFF, 0xBF, 0xFF, 0xFC, 0x03, 0xFE, 0x78, 0x3F, 0xFC, 0x07, 0xFD,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x20, 0x7F, 0xC1, 0xFF,
  0x00, 0x60, 0xFF, 0x83, 0xFE, 0x01, 0xE1, 0xFF, 0x07, 0xFE, 0x07, 0xE3,
  0xFE, 0x07, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F, 0xF8, 0x7F, 0x8F, 0xF8, 0x0F,
  0xFB, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0,
  0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x10, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x40, 0x1F, 0xF0, 0x03, 0x80,
  0x7F, 0xC0, 0x1F, 0x01, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x3E, 0x00, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x9F, 0xF8, 0x3F, 0xF8, 0x1F, 0xEF, 0xFF, 0x1F, 0xFE, 0x07, 0xF3, 0xFF,
  0xCF, 0xFF, 0x81, 0xFD, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0x7F, 0xFD, 0xFF,
  0xFC, 0x3F, 0xF8, 0xFF, 0x71, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x83,
  0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x01, 0xFC,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xF0,
  0x03, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0xFC, 0x03, 0xFE, 0x3F,
  0xFF, 0xE0, 0x3F, 0xE7, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xF0, 0x7F,
  0xCF, 0x07, 0xFF, 0x07, 0xFD, 0xC0, 0x3F, 0xF0, 0x7F, 0xD8, 0x01, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0xFF, 0x8F, 0xFF,
  0xF8, 0x00, 0xFF, 0x9F, 0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x7C, 0x1F, 0xFE, 0x01, 0xFF, 0x70,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFE,
  0x03, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xFF, 0x00,
  0x3F, 0xE1, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0xC3, 0xFE, 0x01, 0xFF,
  0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xE7, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xF0,
  0x0F, 0x7F, 0xC1, 0xFF, 0xC0, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0xBF, 0xE0,
  0x3F, 0xFF, 0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xFC,
  0x7F, 0xC0, 0x1F, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xFC, 0x0F,
  0xFD, 0xFF, 0xFF, 0x87, 0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xF0, 0x03,
  0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x00,
  0x1F, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x1F, 0xE0, 0x00, 0x10, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x02, 0x00, 0x00, 0x7F,
  0xC1, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x03,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x80, 0x07, 0xFC, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x80,
  0x0F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xBF,
  0xE0, 0x7F, 0xF0, 0x7B, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF,
  0xF3, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xC7, 0xFC, 0x01,
  0xFF, 0xF8, 0x7F, 0xC0, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0x87, 0xFF, 0xF8, 0x00, 0xFC, 0x7F, 0xFF,
  0x00, 0x7F, 0xC7, 0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0xEF,
  0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xFC, 0x00,
  0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x18, 0x1F, 0xC0, 0x7F,
  0x81, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFC, 0x07, 0xF9, 0xFC, 0x03,
  0xF8, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE0, 0x3F,
  0xCF, 0xE0, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0x00, 0xFF, 0x7F, 0x80,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0x07,
  0xF3, 0xF8, 0x07, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x1F, 0xCF, 0xE0,
  0x3F, 0x80, 0x7F, 0xBF, 0xC0, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xF8, 0x0F, 0xE3, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0x80,
  0xFE, 0x1F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC7, 0xBF, 0x07, 0xF0, 0x7F,
  0xFF, 0x7E, 0x3F, 0xC0, 0xFF, 0xFC, 0xFF, 0xFF, 0x81, 0xFF, 0xF9, 0xFF,
  0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0,
  0x7F, 0xF3, 0xF9, 0xF1, 0xFF, 0x1F, 0xFC, 0x7F, 0x3C, 0x1F, 0xE3, 0xFE,
  0x0F, 0xEF, 0x03, 0xFC, 0x3F, 0x81, 0xFD, 0xC0, 0x7F, 0x83, 0xC0, 0x3F,
  0xF8, 0x0F, 0xF0, 0x70, 0x07, 0xFE, 0x01, 0xFE, 0x08, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x08,
  0x1F, 0xC0, 0x3F, 0xF0, 0x03, 0x03, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x7F,
  0x01, 0xFF, 0xC0, 0x7F, 0x0F, 0xF0, 0x3B, 0xF8, 0x3F, 0xF1, 0xFE, 0x0F,
  0x7F, 0x0F, 0xFE, 0x3F, 0xE3, 0xEF, 0xF7, 0xFF, 0x87, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x0D, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC1, 0xEF,
  0xF8, 0x03, 0xFF, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0x3F, 0xE0, 0x07,
  0xFF, 0xFC, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xC3,
  0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x07, 0xFE, 0x00,
  0x38, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xBF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x30,
  0x00, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x01, 0xFF,
  0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0x83, 0xFF, 0xF0, 0x00, 0x7F, 0x0F, 0xFF,
  0xFF, 0x80, 0x7E, 0x1F, 0xFF, 0xFF, 0xF9, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0x9F, 0xFF, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC,
  0x07, 0xFF, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x01,
  0xFC, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xFF, 0xC0, 0x07, 0xF0, 0x7F,
  0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0xFF, 0x80, 0x3F, 0x87, 0xFF, 0xFF, 0x80,
  0x7F, 0x0F, 0xF1, 0xFF, 0x01, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F,
  0x01, 0xFF, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0xFF, 0xC3, 0xF8, 0x03, 0xFF,
  0xFF, 0x07, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0x3F,
  0x80, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x01,
  0xF8, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 19, 51, 43, 12, -50 },
  { 123, 26, 22, 43, 12, -53 },
  { 195, 45, 50, 43, 0, -50 },
  { 477, 41, 65, 43, 1, -57 },
  { 811, 49, 51, 43, -2, -50 },
  { 1124, 42, 51, 43, 0, -50 },
  { 1392, 12, 22, 43, 19, -53 },
  { 1425, 29, 64, 43, 13, -54 },
  { 1657, 29, 64, 43, 2, -54 },
  { 1889, 38, 36, 43, 3, -39 },
  { 2060, 35, 35, 43, 4, -39 },
  { 2214, 20, 23, 43, 8, -12 },
  { 2272, 24, 8, 43, 10, -26 },
  { 2296, 14, 13, 43, 12, -12 },
  { 2319, 41, 64, 43, 1, -54 },
  { 2647, 39, 51, 43, 3, -50 },
  { 2896, 36, 50, 43, 3, -50 },
  { 3121, 40, 50, 43, 1, -50 },
  { 3371, 40, 51, 43, 1, -50 },
  { 3626, 39, 50, 43, 1, -50 },
  { 3870, 40, 51, 43, 2, -50 },
  { 4125, 36, 51, 43, 3, -50 },
  { 4355, 37, 50, 43, 6, -50 },
  { 4587, 39, 51, 43, 2, -50 },
  { 4836, 36, 50, 43, 5, -50 },
  { 5061, 18, 38, 43, 12, -37 },
  { 5147, 22, 48, 43, 8, -37 },
  { 5279, 35, 42, 43, 6, -43 },
  { 5463, 38, 23, 43, 3, -33 },
  { 5573, 35, 42, 43, 3, -43 },
  { 5757, 32, 51, 43, 8, -50 },
  { 5961, 38, 58, 43, 3, -50 },
  { 6237, 41, 50, 43, -2, -50 },
  { 6494, 37, 50, 43, 3, -50 },
  { 6726, 38, 51, 43, 4, -50 },
  { 6969, 39, 50, 43, 2, -50 },
  { 7213, 39, 50, 43, 3, -50 },
  { 7457, 40, 50, 43, 3, -50 },
  { 7707, 37, 51, 43, 4, -50 },
  { 7943, 41, 50, 43, 2, -50 },
  { 8200, 40, 50, 43, 2, -50 },
  { 8450, 38, 51, 43, 3, -50 },
  { 8693, 45, 50, 43, 2, -50 },
  { 8975, 33, 50, 43, 4, -50 },
  { 9182, 44, 50, 43, 0, -50 },
  { 9457, 41, 50, 43, 2, -50 },
  { 9714, 39, 51, 43, 3, -50 },
  { 9963, 39, 50, 43, 3, -50 },
  { 10207, 39, 64, 43, 3, -50 },
  { 10519, 39, 50, 43, 3, -50 },
  { 10763, 41, 51, 43, 1, -50 },
  { 11025, 40, 50, 43, 6, -50 },
  { 11275, 39, 51, 43, 4, -50 },
  { 11524, 39, 50, 43, 7, -50 },
  { 11768, 45, 50, 43, 1, -50 },
  { 12050, 48, 50, 43, -2, -50 },
  { 12350, 41, 50, 43, 6, -50 },
  { 12607, 43, 50, 43, 0, -50 },
  { 12876, 33, 64, 43, 9, -54 },
  { 13140, 20, 64, 43, 12, -54 },
  { 13300, 32, 64, 43, 2, -54 },
  { 13556, 38, 31, 43, 3, -50 },
  { 13704, 35, 7, 43, -1, 6 },
  { 13735, 12, 16, 43, 14, -57 },
  { 13759, 37, 38, 43, 3, -37 },
  { 13935, 38, 54, 43, 2, -53 },
  { 14192, 34, 38, 43, 4, -37 },
  { 14354, 40, 54, 43, 3, -53 },
  { 14624, 35, 38, 43, 4, -37 },
  { 14791, 48, 68, 43, -2, -53 },
  { 15199, 39, 52, 43, 1, -37 },
  { 15453, 36, 53, 43, 2, -53 },
  { 15692, 34, 55, 43, 5, -54 },
  { 15926, 36, 69, 43, 1, -54 },
  { 16237, 39, 54, 43, 2, -53 },
  { 16501, 30, 54, 43, 7, -53 },
  { 16704, 42, 37, 43, 0, -37 },
  { 16899, 36, 37, 43, 2, -37 },
  { 17066, 36, 38, 43, 3, -37 },
  { 17237, 40, 51, 43, 0, -37 },
  { 17492, 37, 51, 43, 3, -37 },
  { 17728, 35, 37, 43, 7, -37 },
  { 17890, 35, 38, 43, 3, -37 },
  { 18057, 34, 51, 43, 5, -50 },
  { 18274, 36, 38, 43, 4, -37 },
  { 18445, 36, 38, 43, 3, -37 },
  { 18616, 39, 38, 43, 2, -37 },
  { 18802, 43, 38, 43, 0, -37 },
  { 19007, 39, 52, 43, 1, -37 },
  { 19261, 39, 38, 43, 2, -37 },
  { 19447, 35, 64, 43, 7, -54 },
  { 19727, 18, 64, 43, 13, -54 },
  { 19871, 35, 64, 43, 2, -54 },
  { 20151, 39, 17, 43, 2, -30 },
};

const GFXfont IBMPlexMono_SemiBoldItalic71pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic71pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic71pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC71PT7B_H_
