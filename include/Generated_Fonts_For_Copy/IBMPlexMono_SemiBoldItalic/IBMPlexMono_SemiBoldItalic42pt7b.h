#ifndef _IBMPLEXMONO_SEMIBOLDITALIC42PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x7C, 0x03, 0xFE, 0x1F, 0xF1, 0xFF, 0x87, 0xFC, 0x7F,
  0xC3, 0xFF, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x1F, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F,
  0xE3, 0xFF, 0x1F, 0xF8, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xEF,
  0x7E, 0x0F, 0x8F, 0x1C, 0x1F, 0x8F, 0x08, 0x1F, 0x0E, 0x00, 0x1F, 0x0E,
  0x00, 0x1F, 0x0E, 0x00, 0x1F, 0x9E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3D, 0xFC, 0x00, 0x38, 0x7C, 0x00, 0x38, 0x7C, 0x00, 0x38,
  0x7C, 0x20, 0x38, 0x7C, 0x30, 0x78, 0xFC, 0x78, 0x78, 0xF8, 0xFE, 0x7B,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0xF8, 0x1F, 0xF0, 0x07, 0x81, 0xFF, 0xC0, 0x78,
  0x0F, 0x1E, 0x07, 0xC0, 0xF0, 0x70, 0x3C, 0x07, 0x83, 0xC3, 0xC0, 0x7C,
  0x1E, 0x3C, 0x03, 0xC1, 0xE1, 0xE0, 0x1E, 0x0F, 0x1E, 0x00, 0xF0, 0x79,
  0xE0, 0x07, 0x83, 0xDF, 0x00, 0x1E, 0x3C, 0xF0, 0x00, 0xFF, 0xC8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xBE, 0x3C, 0x00, 0x79, 0xE1, 0xE0, 0x07, 0x8E,
  0x07, 0x00, 0x3C, 0xF0, 0x78, 0x03, 0xC7, 0x83, 0xC0, 0x3C, 0x3C, 0x1E,
  0x03, 0xE1, 0xE0, 0xF0, 0x1E, 0x0F, 0x0F, 0x01, 0xE0, 0x7C, 0x78, 0x1F,
  0x01, 0xFF, 0x80, 0xF0, 0x07, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x9F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x0F, 0xC0, 0xF8, 0x67, 0xE0, 0x7C, 0x3B, 0xF0, 0x7F, 0x3F, 0xFC,
  0x6F, 0xBE, 0x7F, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0x0F, 0xF8, 0xFF, 0x07,
  0xFC, 0x3F, 0x80, 0xF8, 0x0F, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xCF, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x01, 0x01, 0xF0, 0x27, 0x87, 0xC3, 0xDF, 0xDF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0xFC,
  0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x18, 0x02, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7C,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF8, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0xC3, 0x87, 0xDF,
  0x8F, 0x8F, 0xBF, 0x1F, 0x1F, 0x7E, 0x7E, 0x7E, 0xF8, 0x78, 0xFD, 0xF0,
  0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00,
  0x3E, 0x3E, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xF8, 0x07,
  0xE7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0xFC,
  0x07, 0x07, 0xC0, 0x10, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x83,
  0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0xE0, 0xF0, 0x0F, 0xC0, 0x80, 0x1F, 0x81,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x82, 0x00, 0x3F, 0x0C, 0x00, 0x7E, 0x7C, 0x01, 0xF8,
  0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC1, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x1F, 0x80, 0x1F, 0x3F, 0xE0, 0x1F, 0x7F, 0xF0, 0x1E, 0xFF, 0xF8,
  0x1F, 0x83, 0xFC, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x08, 0x00, 0xFC,
  0x38, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x7E, 0xFF, 0xC7, 0xEF, 0xFF, 0x3E, 0xFF, 0xF9, 0xFE, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x80, 0x7E,
  0x7E, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3C, 0x01,
  0xF8, 0x78, 0x03, 0xF1, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7E, 0x07,
  0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0x81, 0xF8, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0x7F,
  0x07, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE3, 0xF8, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFD, 0xFC, 0x1F, 0xEF, 0xFF, 0xBE, 0x3F, 0xFF, 0xF0, 0xFF,
  0x9F, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0,
  0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE1, 0xFD,
  0xF8, 0x0F, 0xDE, 0x01, 0xF8, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8, 0x3E, 0x0F, 0x80, 0x7C, 0x3C,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x0F, 0x3C, 0xF0, 0xFE,
  0xF7, 0xC7, 0xFB, 0xDF, 0x1F, 0x1F, 0x78, 0xF8, 0x7D, 0xE3, 0xC1, 0xF7,
  0x9F, 0x07, 0xBE, 0x7C, 0x1E, 0xF9, 0xF0, 0x7B, 0xE7, 0x81, 0xEF, 0x1E,
  0x07, 0xBC, 0x78, 0x3E, 0xF1, 0xE0, 0xF3, 0xC7, 0x87, 0xCF, 0x1F, 0xEF,
  0x3C, 0x3F, 0xBC, 0xF0, 0xFC, 0xF3, 0xC0, 0x84, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x81, 0xFC,
  0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C,
  0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0,
  0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x20, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0E, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x7E,
  0x3F, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7C, 0x1F, 0xC1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x80, 0x7E,
  0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x7E,
  0x03, 0xF1, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x60, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC1, 0xFF, 0xBF, 0x07, 0xFE, 0xFC, 0x1F, 0xFB, 0xF0, 0x7F, 0xEF, 0xC0,
  0x0F, 0xBF, 0x00, 0x3C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F,
  0x1F, 0x80, 0xFC, 0x7F, 0x0F, 0xF0, 0xFF, 0xF7, 0x83, 0xFF, 0xBE, 0x07,
  0xFC, 0xF8, 0x07, 0xE3, 0xE0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFE, 0x1F, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0,
  0x1F, 0x83, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x87,
  0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFB, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3D, 0xE3, 0xDE,
  0x0F, 0x79, 0xFF, 0x83, 0xDE, 0x7B, 0xE1, 0xF7, 0xFC, 0xF8, 0x7C, 0xFF,
  0x3C, 0x1F, 0x3F, 0x8F, 0x07, 0xCF, 0xE7, 0xC1, 0xE3, 0xF1, 0xF0, 0xF8,
  0x7C, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x87, 0x83, 0xE1, 0xC3, 0xE0,
  0xF8, 0x60, 0xF8, 0x3C, 0x08, 0x3E, 0x1F, 0x04, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x0F,
  0x07, 0xF0, 0x1F, 0x07, 0xF0, 0x1F, 0x0F, 0xF0, 0x1F, 0x0F, 0xF8, 0x1F,
  0x0F, 0xF8, 0x1F, 0x0F, 0xF8, 0x1E, 0x0F, 0xF8, 0x3E, 0x0F, 0x78, 0x3E,
  0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x3C, 0x3C,
  0x1E, 0x3C, 0x7C, 0x1E, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C,
  0x3E, 0x1E, 0x7C, 0x3E, 0x1E, 0x78, 0x3C, 0x1E, 0xF8, 0x3C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF0,
  0x78, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E,
  0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F,
  0x9F, 0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xF0,
  0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E,
  0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F,
  0x9F, 0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0x04, 0x00, 0x3F, 0x0E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00,
  0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x1F,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7C, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF8,
  0x0F, 0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xE0, 0x7F, 0x0F, 0xC0, 0x1C, 0x1F, 0x80, 0x08, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x20, 0x00, 0xFC, 0x30, 0x00, 0xF8, 0x78, 0x01, 0xF8, 0xFE,
  0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E,
  0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F, 0x80,
  0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07,
  0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0,
  0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x3F,
  0x0F, 0x0F, 0x0F, 0xC3, 0xC3, 0xC3, 0xF0, 0xF0, 0xF1, 0xFC, 0x7C, 0x3C,
  0x7F, 0x1F, 0x1F, 0x1D, 0xC7, 0x87, 0xCF, 0x71, 0xE1, 0xF3, 0xDC, 0xF8,
  0x7C, 0xE7, 0x3E, 0x1F, 0x79, 0xCF, 0x07, 0x9E, 0x73, 0xC1, 0xE7, 0x1C,
  0xF0, 0x7B, 0xC7, 0x7C, 0x1E, 0xF1, 0xDE, 0x07, 0xB8, 0x77, 0x83, 0xFE,
  0x1D, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x87, 0xC0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01,
  0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xDF, 0x00, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x00, 0xF8, 0xF8, 0x03,
  0xE7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x78, 0x00, 0x7C, 0xC0, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x78,
  0xFC, 0x7C, 0x3E, 0x3E, 0x1E, 0x0F, 0x0C, 0x01, 0xF0, 0xF8, 0x3F, 0xE7,
  0xC3, 0xFF, 0xBE, 0x3F, 0xFD, 0xF3, 0xF8, 0x3F, 0x9F, 0x80, 0xFD, 0xF8,
  0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0xFD,
  0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00,
  0xFC, 0xFC, 0x0F, 0xE7, 0xE1, 0xFF, 0x1F, 0xFD, 0xF8, 0xFF, 0xCF, 0xF3,
  0xFC, 0x3F, 0x8F, 0xC0, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0xF9, 0xFF, 0x03,
  0xEF, 0xFE, 0x1F, 0xBF, 0xFC, 0x7F, 0xC3, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0,
  0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0x7F, 0xF8, 0x7D, 0xFF,
  0xE1, 0xF3, 0xFE, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x87, 0xE3, 0xE0, 0x3F, 0x7E, 0x01,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x10, 0xF8, 0x01, 0xCF, 0x80, 0x3E, 0xFC,
  0x07, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0xF8, 0x1F, 0xF3, 0xF0, 0x7F, 0xF7,
  0xE1, 0xFF, 0xEF, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8,
  0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF8, 0x6F, 0x83, 0xFF, 0xDF, 0x07, 0xFF,
  0x7E, 0x07, 0xFC, 0xFC, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xE0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0x83, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0x8F, 0x80, 0x1C,
  0xFC, 0x03, 0xEF, 0xE0, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0x03, 0xE0, 0x00,
  0x78, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x07,
  0xFC, 0xFC, 0x1F, 0xFD, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x01,
  0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFE, 0x1B, 0xE0,
  0xFF, 0xF7, 0xC1, 0xFF, 0xDF, 0x81, 0xFF, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x30, 0x0F, 0xC0, 0xF0, 0x3F, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x1F, 0x80, 0xF8, 0xFF, 0x03, 0xE7, 0xFE, 0x0F, 0xBF, 0xF8, 0x7F,
  0xC7, 0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03,
  0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xE0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x0C, 0x07, 0xC1, 0xE0, 0x7C,
  0x3F, 0x07, 0xC7, 0xE0, 0x7C, 0xFC, 0x07, 0xDF, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0x03, 0xF0, 0x18,
  0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x3E, 0x01, 0xF9, 0xF0,
  0x0F, 0xDF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x3E, 0x7F, 0xC0, 0x7D, 0xFF,
  0xC0, 0xFF, 0x1F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x1F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0xE3, 0xF8, 0x07, 0xDF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3F, 0x04, 0x3E,
  0x3E, 0x1C, 0xFC, 0x7E, 0x7D, 0xF0, 0x7D, 0xF3, 0xE0, 0xFF, 0xC7, 0xC1,
  0xFF, 0x0F, 0x81, 0xFC, 0x3F, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0xC1, 0xF0, 0x78,
  0x7C, 0x3F, 0x1F, 0x1F, 0x87, 0xCF, 0xC1, 0xF7, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x3C, 0x1E, 0x0F, 0xBF, 0x1F,
  0x87, 0xBF, 0x9F, 0xC3, 0xE3, 0xD1, 0xF1, 0xF1, 0xF0, 0xF9, 0xF0, 0xF8,
  0x7C, 0xF8, 0x7C, 0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x0F, 0x1E, 0x0F,
  0x0F, 0x8F, 0x0F, 0x87, 0xC7, 0x87, 0xC3, 0xE7, 0xC3, 0xE1, 0xE3, 0xE1,
  0xE0, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x7C, 0x78, 0x7C, 0x3E, 0x3C,
  0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x1F, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7,
  0x83, 0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0x3E, 0x3F, 0xC0, 0xF9, 0xFF, 0x87,
  0xEF, 0xFE, 0x1F, 0xF1, 0xFC, 0x7F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x7E,
  0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03,
  0xF3, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8,
  0x3F, 0x07, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x7E, 0x7C, 0x03,
  0xE3, 0xE0, 0x3F, 0x0F, 0x83, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x0F, 0x9F, 0xF0, 0x3F, 0x7F, 0xF0, 0x7E,
  0xFF, 0xF0, 0xFB, 0x87, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0xFB, 0xFF, 0xC1, 0xF7, 0xFF, 0x87,
  0xE7, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x1F, 0xF3, 0xF0, 0xFF,
  0xEF, 0x87, 0xFF, 0xBE, 0x3F, 0x83, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x01,
  0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x6F, 0x87, 0xFF, 0xFE, 0x1F, 0xFD, 0xF8,
  0x3F, 0xE7, 0xE0, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0xFB, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xDF, 0xE0, 0x7E, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0x40, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0x03,
  0xF1, 0xF0, 0x0E, 0x0F, 0x80, 0x20, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x20, 0x03, 0xE3, 0xC0,
  0x3F, 0x3F, 0x03, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x08, 0x0F, 0x80, 0xC0, 0xF8, 0x3E, 0x0F, 0x87, 0xF0, 0xF8, 0xFC,
  0x0F, 0xBF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x7E,
  0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x7C, 0x0B, 0xE1,
  0xF8, 0x7F, 0x87, 0xFF, 0x7E, 0x1F, 0xF9, 0xF8, 0x3F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0x7F, 0xC0, 0x37, 0xFE, 0x0F, 0xBF, 0xE0, 0xFD, 0xFF, 0x03,
  0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0,
  0xFC, 0x0F, 0x9F, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x1E, 0x1E, 0x0C, 0x7C, 0x3C, 0x78, 0xF0, 0x78, 0xF9, 0xE0, 0xF0, 0xF3,
  0xC3, 0xE1, 0xE7, 0x87, 0xC3, 0xCF, 0x0F, 0x07, 0xBE, 0x1E, 0x0F, 0x78,
  0x3C, 0x1E, 0xF0, 0x78, 0x3D, 0xE1, 0xF0, 0x7B, 0xC3, 0xE1, 0xFF, 0x87,
  0x83, 0xDF, 0x0F, 0x07, 0xBC, 0x1E, 0x0F, 0x78, 0x7C, 0x3C, 0xF0, 0xF8,
  0x79, 0xF3, 0xF1, 0xE3, 0xFF, 0xE7, 0xC7, 0xF9, 0xFF, 0x07, 0xE3, 0xFC,
  0x07, 0x83, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x3F, 0x83, 0xFF,
  0x3F, 0xE7, 0xF7, 0x99, 0xF3, 0xE3, 0xD8, 0x78, 0xE1, 0xEC, 0x3C, 0x40,
  0xFC, 0x1E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x01, 0xE0, 0xFC, 0x08, 0xF0, 0x5E, 0x1E, 0x78, 0x6F, 0x1F,
  0xBE, 0x67, 0xBF, 0x9F, 0xF3, 0xFF, 0x87, 0xF0, 0xFF, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80,
  0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01,
  0xF8, 0x1F, 0x02, 0xF8, 0x1F, 0x86, 0xF8, 0x1F, 0xFD, 0xF8, 0x0F, 0xFD,
  0xF0, 0x0F, 0xF9, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x10, 0x07, 0xE0, 0x3C, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3E, 0x0F, 0xFC,
  0x7C, 0x3F, 0xFE, 0xF8, 0xFF, 0xFF, 0xF1, 0xF0, 0xFF, 0xC3, 0xC0, 0x7F,
  0x8F, 0x80, 0xFC, 0x1E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0x00, 0xFE, 0x0E, 0x03,
  0xF8, 0x1E, 0x0F, 0xC0, 0x3C, 0x3F, 0xC0, 0x3C, 0xFF, 0xFC, 0x79, 0xFF,
  0xFF, 0xE3, 0xCF, 0xFF, 0xCF, 0x87, 0xFF, 0x1F, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x1F, 0xE0,
  0x3C, 0x7F, 0xE0, 0x79, 0xFF, 0xC1, 0xF3, 0xE7, 0xC3, 0xCF, 0x87, 0xCF,
  0x9E, 0x0F, 0xFE, 0x3C, 0x0F, 0xF8, 0xF0, 0x0F, 0xE0, 0x60, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_SemiBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 12, 29, 25, 7, -29 },
  { 45, 16, 13, 25, 7, -31 },
  { 71, 26, 29, 25, 0, -29 },
  { 166, 24, 37, 25, 1, -33 },
  { 277, 29, 29, 25, -1, -29 },
  { 383, 25, 29, 25, 0, -29 },
  { 474, 7, 13, 25, 11, -31 },
  { 486, 17, 38, 25, 8, -32 },
  { 567, 17, 38, 25, 1, -32 },
  { 648, 22, 21, 25, 2, -23 },
  { 706, 20, 20, 25, 3, -23 },
  { 756, 11, 13, 25, 5, -7 },
  { 774, 14, 5, 25, 6, -15 },
  { 783, 8, 8, 25, 7, -8 },
  { 791, 25, 38, 25, 0, -32 },
  { 910, 23, 29, 25, 2, -29 },
  { 994, 21, 29, 25, 2, -29 },
  { 1071, 23, 29, 25, 1, -29 },
  { 1155, 23, 29, 25, 1, -29 },
  { 1239, 24, 29, 25, 0, -29 },
  { 1326, 24, 29, 25, 1, -29 },
  { 1413, 21, 29, 25, 2, -29 },
  { 1490, 23, 29, 25, 3, -29 },
  { 1574, 23, 29, 25, 1, -29 },
  { 1658, 21, 29, 25, 3, -29 },
  { 1735, 11, 23, 25, 7, -23 },
  { 1767, 13, 29, 25, 5, -23 },
  { 1815, 21, 25, 25, 3, -25 },
  { 1881, 22, 13, 25, 2, -19 },
  { 1917, 20, 25, 25, 2, -25 },
  { 1980, 19, 29, 25, 5, -29 },
  { 2049, 22, 34, 25, 2, -29 },
  { 2143, 24, 29, 25, -1, -29 },
  { 2230, 22, 29, 25, 2, -29 },
  { 2310, 23, 29, 25, 2, -29 },
  { 2394, 23, 29, 25, 1, -29 },
  { 2478, 23, 29, 25, 2, -29 },
  { 2562, 24, 29, 25, 2, -29 },
  { 2649, 22, 29, 25, 2, -29 },
  { 2729, 24, 29, 25, 1, -29 },
  { 2816, 24, 29, 25, 1, -29 },
  { 2903, 22, 29, 25, 2, -29 },
  { 2983, 27, 29, 25, 1, -29 },
  { 3081, 20, 29, 25, 2, -29 },
  { 3154, 26, 29, 25, 0, -29 },
  { 3249, 24, 29, 25, 1, -29 },
  { 3336, 23, 29, 25, 2, -29 },
  { 3420, 23, 29, 25, 2, -29 },
  { 3504, 23, 37, 25, 2, -29 },
  { 3611, 23, 29, 25, 2, -29 },
  { 3695, 24, 29, 25, 1, -29 },
  { 3782, 24, 29, 25, 3, -29 },
  { 3869, 24, 29, 25, 2, -29 },
  { 3956, 23, 29, 25, 4, -29 },
  { 4040, 26, 29, 25, 1, -29 },
  { 4135, 28, 29, 25, -1, -29 },
  { 4237, 25, 29, 25, 3, -29 },
  { 4328, 26, 29, 25, 0, -29 },
  { 4423, 20, 38, 25, 5, -32 },
  { 4518, 12, 38, 25, 7, -32 },
  { 4575, 19, 38, 25, 1, -32 },
  { 4666, 22, 18, 25, 2, -29 },
  { 4716, 20, 4, 25, 0, 4 },
  { 4726, 8, 9, 25, 8, -33 },
  { 4735, 21, 22, 25, 2, -22 },
  { 4793, 22, 31, 25, 1, -31 },
  { 4879, 20, 22, 25, 3, -22 },
  { 4934, 23, 31, 25, 2, -31 },
  { 5024, 20, 22, 25, 3, -22 },
  { 5079, 28, 39, 25, -1, -31 },
  { 5216, 23, 30, 25, 1, -22 },
  { 5303, 22, 31, 25, 1, -31 },
  { 5389, 20, 31, 25, 3, -31 },
  { 5467, 21, 39, 25, 1, -31 },
  { 5570, 23, 31, 25, 1, -31 },
  { 5660, 18, 31, 25, 4, -31 },
  { 5730, 25, 22, 25, 0, -22 },
  { 5799, 22, 22, 25, 1, -22 },
  { 5860, 21, 22, 25, 2, -22 },
  { 5918, 23, 30, 25, 0, -22 },
  { 6005, 22, 30, 25, 2, -22 },
  { 6088, 21, 22, 25, 4, -22 },
  { 6146, 21, 22, 25, 2, -22 },
  { 6204, 20, 29, 25, 3, -29 },
  { 6277, 22, 22, 25, 2, -22 },
  { 6338, 21, 22, 25, 2, -22 },
  { 6396, 23, 22, 25, 1, -22 },
  { 6460, 25, 22, 25, 0, -22 },
  { 6529, 24, 30, 25, 0, -22 },
  { 6619, 23, 22, 25, 1, -22 },
  { 6683, 21, 38, 25, 4, -32 },
  { 6783, 10, 38, 25, 8, -32 },
  { 6831, 21, 38, 25, 1, -32 },
  { 6931, 23, 10, 25, 1, -18 },
};

const GFXfont IBMPlexMono_SemiBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC42PT7B_H_
