#ifndef _IBMPLEXMONO_SEMIBOLDITALIC8PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0x76, 0x80, 0x29, 0x96, 0xAE, 0x50, 0x33, 0xD8,
  0x63, 0x79, 0x00, 0x6D, 0x6C, 0xA6, 0xD8, 0x32, 0x95, 0x4B, 0x6C, 0xE8,
  0x34, 0x48, 0x84, 0x60, 0x62, 0x12, 0x22, 0xC0, 0x27, 0xD9, 0x60, 0x27,
  0xA2, 0xE0, 0xE0, 0xC0, 0x18, 0x88, 0x44, 0x22, 0x00, 0x32, 0x53, 0x59,
  0x38, 0x35, 0xB2, 0x2F, 0x32, 0xC4, 0x64, 0x78, 0x32, 0xC4, 0x61, 0x78,
  0x11, 0x94, 0xAF, 0x98, 0x7A, 0x18, 0xA1, 0x78, 0x12, 0x6D, 0x97, 0xF9,
  0x24, 0x48, 0x32, 0x54, 0xE9, 0x38, 0x69, 0x9E, 0x2C, 0x43, 0x43, 0x80,
  0x16, 0x8C, 0x20, 0x78, 0x3C, 0x42, 0x16, 0x80, 0x6A, 0x34, 0x0C, 0x32,
  0x6F, 0x6B, 0x41, 0x80, 0x33, 0x55, 0xF9, 0x72, 0xD4, 0xE5, 0x78, 0x32,
  0x51, 0x85, 0x38, 0x62, 0x92, 0xB5, 0x78, 0x7A, 0x10, 0xE4, 0x78, 0x7A,
  0x10, 0xE4, 0x40, 0x32, 0x51, 0xE9, 0x38, 0x4A, 0x56, 0xE9, 0x48, 0x79,
  0x08, 0x42, 0x78, 0x3A, 0x84, 0x29, 0x30, 0x4A, 0x98, 0xC5, 0x48, 0x44,
  0x44, 0x4F, 0x4A, 0xDB, 0x6D, 0x48, 0x4B, 0x5A, 0xEB, 0x48, 0x32, 0xD3,
  0x39, 0x38, 0x72, 0x52, 0xE4, 0x40, 0x32, 0xD3, 0x39, 0x38, 0xA2, 0x72,
  0x52, 0xE5, 0x48, 0x32, 0xD0, 0x61, 0x78, 0xF4, 0x44, 0x44, 0x4A, 0x52,
  0xA9, 0x38, 0x99, 0xAA, 0xCC, 0x4C, 0x6B, 0xDD, 0x68, 0x4A, 0x8C, 0x45,
  0x48, 0x9B, 0xA4, 0x44, 0x78, 0xCC, 0x44, 0x78, 0x74, 0x48, 0x88, 0xE0,
  0x91, 0x24, 0x98, 0x71, 0x22, 0x22, 0xE0, 0x31, 0x95, 0x10, 0xF0, 0x80,
  0x7D, 0x97, 0x44, 0x75, 0xDB, 0x74, 0xD7, 0x08, 0x5D, 0xA9, 0x38, 0x75,
  0xE7, 0x19, 0x1E, 0x42, 0x12, 0x88, 0x7E, 0xA4, 0xE9, 0x30, 0x44, 0x75,
  0x59, 0x43, 0x27, 0xC0, 0x10, 0x71, 0x22, 0xE6, 0x42, 0x1C, 0xA6, 0x5C,
  0xC9, 0x2B, 0x80, 0x7D, 0x6D, 0x60, 0x75, 0x59, 0x7D, 0x97, 0x75, 0xDB,
  0x88, 0x7E, 0xA4, 0xE1, 0x08, 0xF4, 0xC8, 0x76, 0x1F, 0x4B, 0xAB, 0x80,
  0x5A, 0xA4, 0xE0, 0xD5, 0x56, 0xAD, 0x6D, 0xE0, 0x7D, 0x09, 0xF0, 0x5A,
  0x95, 0xE9, 0x30, 0x79, 0x95, 0xE0, 0x74, 0x48, 0x48, 0xE0, 0x69, 0x24,
  0xA0, 0x72, 0x21, 0x62, 0xE0, 0xF8, 0x80,
};

const GFXglyph IBMPlexMono_SemiBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 6, 5, 1, -6 },
  { 4, 3, 3, 5, 1, -6 },
  { 6, 5, 6, 5, 0, -6 },
  { 10, 5, 7, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 5, 6, 5, 0, -6 },
  { 23, 2, 3, 5, 2, -6 },
  { 24, 4, 7, 5, 1, -6 },
  { 28, 4, 7, 5, 0, -6 },
  { 32, 5, 4, 5, 0, -4 },
  { 35, 4, 4, 5, 0, -4 },
  { 37, 2, 2, 5, 1, -1 },
  { 38, 3, 1, 5, 1, -3 },
  { 39, 2, 1, 5, 1, -1 },
  { 40, 5, 7, 5, 0, -6 },
  { 45, 5, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 5, 6, 5, 0, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 4, 6, 5, 0, -6 },
  { 71, 4, 6, 5, 1, -6 },
  { 74, 5, 6, 5, 0, -6 },
  { 78, 4, 6, 5, 1, -6 },
  { 81, 2, 4, 5, 1, -4 },
  { 82, 2, 5, 5, 1, -4 },
  { 84, 4, 5, 5, 1, -5 },
  { 87, 5, 3, 5, 0, -4 },
  { 89, 4, 5, 5, 0, -5 },
  { 92, 4, 6, 5, 1, -6 },
  { 95, 5, 7, 5, 0, -6 },
  { 100, 4, 6, 5, 0, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 5, 6, 5, 0, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 5, 6, 5, 0, -6 },
  { 143, 4, 6, 5, 0, -6 },
  { 146, 5, 6, 5, 0, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 5, 8, 5, 0, -6 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 4, 6, 5, 1, -6 },
  { 178, 5, 6, 5, 0, -6 },
  { 182, 4, 6, 5, 1, -6 },
  { 185, 5, 6, 5, 0, -6 },
  { 189, 5, 6, 5, 0, -6 },
  { 193, 4, 6, 5, 1, -6 },
  { 196, 5, 6, 5, 0, -6 },
  { 200, 4, 7, 5, 1, -6 },
  { 204, 3, 7, 5, 1, -6 },
  { 207, 4, 7, 5, 0, -6 },
  { 211, 5, 4, 5, 0, -6 },
  { 214, 4, 1, 5, 0, 1 },
  { 215, 1, 1, 5, 2, -6 },
  { 216, 4, 4, 5, 0, -4 },
  { 218, 4, 6, 5, 0, -6 },
  { 221, 4, 4, 5, 0, -4 },
  { 223, 5, 6, 5, 0, -6 },
  { 227, 4, 4, 5, 0, -4 },
  { 229, 5, 8, 5, 0, -6 },
  { 234, 5, 6, 5, 0, -4 },
  { 238, 4, 6, 5, 0, -6 },
  { 241, 3, 6, 5, 1, -6 },
  { 244, 4, 8, 5, 0, -6 },
  { 248, 5, 6, 5, 0, -6 },
  { 252, 3, 6, 5, 1, -6 },
  { 255, 5, 4, 5, 0, -4 },
  { 258, 4, 4, 5, 0, -4 },
  { 260, 4, 4, 5, 0, -4 },
  { 262, 4, 6, 5, 0, -4 },
  { 265, 5, 6, 5, 0, -4 },
  { 269, 4, 4, 5, 1, -4 },
  { 271, 4, 4, 5, 0, -4 },
  { 273, 3, 6, 5, 1, -6 },
  { 276, 5, 4, 5, 0, -4 },
  { 279, 4, 4, 5, 0, -4 },
  { 281, 5, 4, 5, 0, -4 },
  { 284, 5, 4, 5, 0, -4 },
  { 287, 5, 6, 5, 0, -4 },
  { 291, 5, 4, 5, 0, -4 },
  { 294, 4, 7, 5, 1, -6 },
  { 298, 3, 7, 5, 1, -6 },
  { 301, 4, 7, 5, 0, -6 },
  { 305, 5, 2, 5, 0, -3 },
};

const GFXfont IBMPlexMono_SemiBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC8PT7B_H_
