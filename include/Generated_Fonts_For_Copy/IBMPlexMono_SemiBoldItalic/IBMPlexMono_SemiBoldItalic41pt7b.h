#ifndef _IBMPLEXMONO_SEMIBOLDITALIC41PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x1F,
  0xE3, 0xF8, 0x7F, 0x07, 0xC0, 0x3E, 0x3E, 0x78, 0x7C, 0xF0, 0xFB, 0xE1,
  0xF7, 0xC3, 0xCF, 0x87, 0x9F, 0x1F, 0x3C, 0x3E, 0x78, 0x7D, 0xF0, 0xFB,
  0xE1, 0xE7, 0xC3, 0xCF, 0x8F, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x78, 0x07,
  0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xF1, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC3,
  0xC0, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0x07,
  0x87, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xCF, 0x7C, 0x3F, 0x1C, 0x30, 0x7C, 0x38,
  0x40, 0xF8, 0x70, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xE7, 0x80,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0x3F, 0x00, 0x0E, 0x3F, 0x00,
  0x1C, 0x7E, 0x00, 0x78, 0x7C, 0x00, 0xF1, 0xF8, 0xC1, 0xE3, 0xE3, 0xC3,
  0x8F, 0xCF, 0xE7, 0x3F, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x3F, 0xE0, 0x1E, 0x07,
  0xFE, 0x01, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x0F, 0x07, 0x80, 0xF0, 0xF0,
  0xF8, 0x1E, 0x0F, 0x0F, 0x01, 0xE0, 0xF1, 0xE0, 0x1E, 0x0F, 0x3C, 0x01,
  0xE0, 0xF3, 0xC0, 0x1E, 0x1E, 0x78, 0x00, 0xF1, 0xEF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0x78, 0xF0, 0x01, 0xE7, 0x87, 0x80, 0x3C,
  0xF0, 0x78, 0x07, 0xCF, 0x07, 0x80, 0x78, 0xF0, 0x78, 0x0F, 0x0F, 0x07,
  0x01, 0xE0, 0xE0, 0xF0, 0x1E, 0x0F, 0x0F, 0x03, 0xC0, 0xF1, 0xE0, 0x78,
  0x07, 0xFE, 0x07, 0x80, 0x7F, 0xC0, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0xF8, 0x01, 0xFB,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x04, 0xF8, 0x1F, 0x8F, 0xFC, 0x1F, 0x8F, 0xFC, 0x37, 0xDF, 0x7F, 0xF7,
  0xFE, 0x7F, 0xF7, 0xFC, 0x7F, 0xE3, 0xFC, 0x3F, 0xC1, 0xF8, 0x0F, 0x80,
  0xF0, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF,
  0x80, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x01, 0x01, 0xF0, 0x27, 0x87, 0x87, 0x9F, 0xDE,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xE7, 0xC0, 0x3F,
  0x1F, 0x01, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x06, 0x01, 0x80, 0x10, 0x04,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F,
  0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0x80, 0x1F,
  0x7E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xFC,
  0x78, 0x7F, 0xF1, 0xF3, 0xFF, 0xCF, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0x78,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3,
  0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x1F, 0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x80, 0xFC,
  0xF8, 0x1F, 0x9F, 0x83, 0xF1, 0xF0, 0x7E, 0x1F, 0x03, 0xC1, 0xF0, 0x18,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1,
  0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x07, 0xC1, 0xC0, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xC1, 0xFC, 0x1C, 0x03, 0xF0,
  0x60, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF8, 0x01, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x40, 0x07, 0xE3, 0x00, 0x1F, 0x3E, 0x00,
  0xFC, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0xFB,
  0xFF, 0x01, 0xEF, 0xFF, 0x03, 0xDF, 0xFF, 0x07, 0xE0, 0xFE, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x82, 0x00, 0x3F, 0x0E, 0x00, 0x7E, 0x3E, 0x01, 0xF8,
  0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x7C, 0xFF, 0x87, 0xEF,
  0xFE, 0x3E, 0xFF, 0xF9, 0xFC, 0x1F, 0xDF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0x7E, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7C, 0x00, 0xF9, 0xF0, 0x07,
  0xE7, 0x80, 0x1F, 0x1E, 0x00, 0xFC, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x7E, 0x0F, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x7C, 0x03, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xF8, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFB, 0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFB,
  0xE0, 0xFF, 0xBF, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xF1,
  0xFC, 0x7F, 0x3F, 0xC7, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x1F,
  0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x10, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xFE, 0xFE, 0x1F, 0xFE, 0x03, 0xF7, 0x00, 0xFC, 0x40, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x7E, 0x0F,
  0x80, 0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x1E,
  0x3C, 0xF0, 0xFE, 0xF7, 0xC7, 0xFF, 0xDE, 0x3E, 0x3E, 0x78, 0xF0, 0x79,
  0xE3, 0xC1, 0xEF, 0x9F, 0x07, 0xBE, 0x78, 0x1E, 0xF9, 0xE0, 0xFB, 0xC7,
  0x83, 0xCF, 0x1E, 0x0F, 0x3C, 0x78, 0x3C, 0xF1, 0xE1, 0xF3, 0xC7, 0x87,
  0xCF, 0x1F, 0xFF, 0x3C, 0x7F, 0x78, 0xF0, 0xFD, 0xE3, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8,
  0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0xFC, 0x00,
  0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xF8, 0x1F, 0x8F,
  0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3E, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xDF, 0x80,
  0x7C, 0xF8, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0,
  0x1F, 0x3F, 0x00, 0x40, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0xC1, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x80, 0xFC, 0x3F, 0x0F, 0xE0,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC,
  0x1F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07,
  0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x3F, 0x00, 0x7C,
  0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87,
  0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x0F, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x7E, 0x03, 0xE1,
  0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x41, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xFF,
  0xBF, 0x07, 0xFE, 0xFC, 0x3F, 0xF3, 0xF0, 0xFF, 0xCF, 0xC0, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x3E, 0x1F, 0x01,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xBE, 0x07, 0xFC, 0xF8,
  0x07, 0xC3, 0xC0, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0,
  0xFC, 0x3F, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xC1, 0xF0, 0x0F, 0xE0, 0x7C, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F,
  0x00, 0x3E, 0x1F, 0xC0, 0x0F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF7, 0xE0,
  0x03, 0xF8, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F,
  0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3D, 0xE3, 0xFC,
  0x0F, 0x79, 0xEF, 0x07, 0xDE, 0xF3, 0xC1, 0xF7, 0xBD, 0xF0, 0x7D, 0xFE,
  0x7C, 0x1F, 0x3F, 0x9F, 0x07, 0x8F, 0xC7, 0x81, 0xE3, 0xF1, 0xE0, 0xF8,
  0xF8, 0xF8, 0x3E, 0x1E, 0x3E, 0x0F, 0x87, 0x0F, 0x83, 0xE1, 0xC3, 0xE0,
  0xF0, 0x60, 0xF0, 0x3C, 0x18, 0x3C, 0x1F, 0x04, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0x07, 0xF0, 0x1F, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x3E,
  0x0F, 0xF0, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x1F, 0x78, 0x3C,
  0x1F, 0x78, 0x3C, 0x1F, 0x78, 0x7C, 0x1F, 0x7C, 0x7C, 0x1E, 0x7C, 0x7C,
  0x1E, 0x3C, 0x7C, 0x3E, 0x3C, 0x78, 0x3E, 0x3C, 0x78, 0x3E, 0x3E, 0x78,
  0x3E, 0x3E, 0xF8, 0x3C, 0x1E, 0xF8, 0x3C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF8,
  0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x78, 0x0F, 0xF0,
  0x78, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xC1, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0x7E, 0x00,
  0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0,
  0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F,
  0xCF, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x7E, 0x01,
  0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF1,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0x7E, 0x0F,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x80, 0x0F, 0x83, 0x00, 0x1F, 0x1E, 0x00, 0x7C, 0xFC, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3E, 0x03, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xF8, 0xF8, 0x07,
  0xC3, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7E, 0x07, 0xC0,
  0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x07, 0x07,
  0xE0, 0x04, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0C, 0x00, 0x7E,
  0x3C, 0x00, 0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C,
  0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0xC7, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C,
  0x3F, 0x0F, 0x0F, 0x0F, 0xC7, 0xC3, 0xC3, 0xF1, 0xE0, 0xF1, 0xFC, 0x78,
  0x7C, 0x7F, 0x1E, 0x1F, 0x1F, 0xCF, 0x87, 0xCF, 0xF3, 0xC1, 0xF3, 0xBC,
  0xF0, 0x7C, 0xEF, 0x3C, 0x1E, 0x7B, 0xCF, 0x07, 0x9C, 0xF7, 0xC1, 0xE7,
  0x3D, 0xE0, 0x7B, 0xCF, 0x78, 0x1E, 0xE3, 0xDE, 0x0F, 0xB8, 0xFF, 0x83,
  0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xF0,
  0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E,
  0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x1F,
  0x03, 0xE0, 0x1F, 0x87, 0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0x80, 0x0F,
  0x9F, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x3E, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF1, 0xF0,
  0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x1E, 0x70, 0x00, 0x74, 0x40, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x18,
  0xF3, 0xE3, 0xE7, 0xC7, 0xC7, 0x8F, 0x08, 0x03, 0xF0, 0xF8, 0x3F, 0xCF,
  0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xE3, 0xF8, 0x7F, 0x3F, 0x01, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x9F, 0x03,
  0xF8, 0xFC, 0x37, 0xC7, 0xFF, 0xBE, 0x1F, 0xF9, 0xFC, 0x7F, 0x8F, 0xE1,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0xF9, 0xFF, 0x07, 0xEF, 0xFE,
  0x1F, 0x7F, 0xF8, 0x7D, 0x87, 0xE1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00,
  0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF1,
  0xFC, 0x1F, 0xC7, 0xDF, 0xFE, 0x1F, 0x7F, 0xF0, 0xFC, 0xFF, 0x83, 0xF1,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xF0, 0x7E, 0xFC, 0x07, 0x9F, 0x00, 0x47, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x11, 0xF0, 0x07, 0x3E,
  0x01, 0xFF, 0xC0, 0x7E, 0xFE, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0xF3, 0xE0,
  0xFF, 0xF7, 0xC1, 0xFF, 0xEF, 0x87, 0xF0, 0x7F, 0x1F, 0x80, 0x7C, 0x3F,
  0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03,
  0xF0, 0xF8, 0x0F, 0xE1, 0xF8, 0x7F, 0xC3, 0xFF, 0xDF, 0x03, 0xFF, 0xBE,
  0x03, 0xFE, 0x7C, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xE0, 0xFC, 0x3F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01,
  0xF7, 0xE0, 0x1F, 0x7C, 0x03, 0xF7, 0xC3, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xE0, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x87, 0xC0, 0x1E, 0x7C,
  0x03, 0xF3, 0xF0, 0x7C, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x40, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x10, 0x3E, 0x00, 0x03, 0x03, 0xE0, 0x00, 0xF8, 0x7E, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x7C, 0x0F, 0xF9, 0xF0, 0xFF, 0xF7, 0xC3, 0xFF, 0xDF,
  0x1F, 0xC1, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x81, 0xFC, 0x7F, 0x0F, 0xF0,
  0xFF, 0xEF, 0x83, 0xFF, 0xBE, 0x07, 0xFC, 0xF8, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x0C, 0x03, 0xF0, 0x78, 0x1F, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x03,
  0xE7, 0xFC, 0x1F, 0x7F, 0xE1, 0xFE, 0x1F, 0x8F, 0xA0, 0x7C, 0x7E, 0x03,
  0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x08, 0x0F, 0x83, 0x81, 0xF0, 0xF8, 0x3E,
  0x3E, 0x0F, 0xCF, 0xC1, 0xF3, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x20, 0x3E, 0x07, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0,
  0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x3E, 0x7F, 0xC0, 0x7D,
  0xFF, 0xC1, 0xF6, 0x1F, 0x83, 0xE8, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0xFC,
  0x03, 0xEF, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x04, 0x1F, 0x3F, 0x0E,
  0x7E, 0x3E, 0x3E, 0xF8, 0x7E, 0xF9, 0xF0, 0x7F, 0xE3, 0xE0, 0xFF, 0x87,
  0xC0, 0xFE, 0x1F, 0x80, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x20, 0xF8, 0x38, 0x7C, 0x3E, 0x3E, 0x3E, 0x3F, 0x3E, 0x1F,
  0x3E, 0x0F, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0x3C,
  0x3E, 0x1E, 0x7E, 0x7E, 0x1E, 0xFE, 0xFF, 0x1F, 0x1E, 0x9F, 0x1E, 0x1F,
  0x0F, 0x3E, 0x1F, 0x0F, 0x3E, 0x1E, 0x1F, 0x3C, 0x1E, 0x1F, 0x3C, 0x3E,
  0x1E, 0x3C, 0x3E, 0x1E, 0x3C, 0x3C, 0x1E, 0x7C, 0x3C, 0x1E, 0x78, 0x3C,
  0x3E, 0x78, 0x3C, 0x3E, 0x78, 0x7C, 0x3C, 0x78, 0x7C, 0x3C, 0x78, 0x78,
  0x3C, 0xF8, 0x78, 0x3C, 0xF0, 0x78, 0x7C, 0xF0, 0x78, 0x7C, 0xF0, 0xF8,
  0x78, 0x0F, 0x87, 0xC0, 0x7C, 0xFF, 0x83, 0xEF, 0xFC, 0x3F, 0xC3, 0xF1,
  0xF4, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x1F, 0x1F, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F,
  0x9F, 0x00, 0x7C, 0x7C, 0x07, 0xC3, 0xF0, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x0F, 0x9F, 0xF0, 0x3F,
  0x7F, 0xF0, 0x7D, 0xFF, 0xE0, 0xFB, 0x0F, 0xC1, 0xFC, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x7D, 0xFF, 0xE0, 0xFB, 0xFF, 0x83,
  0xF3, 0xFE, 0x07, 0xC3, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x3F, 0xE7, 0xC7, 0xFF,
  0xBE, 0x3F, 0xFD, 0xF3, 0xF8, 0x3F, 0xBF, 0x00, 0xF9, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x01, 0xFC, 0xFC,
  0x3F, 0xE7, 0xFF, 0xBE, 0x1F, 0xFD, 0xF0, 0x7F, 0xCF, 0x81, 0xF8, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x07, 0xDF, 0xF0, 0x7D,
  0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF1, 0xF8,
  0x3E, 0x1F, 0x00, 0xC3, 0xE0, 0x08, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE2, 0x00, 0x3E, 0x70, 0x07, 0xCF, 0xC0, 0xFC,
  0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x81,
  0x80, 0xF8, 0x3C, 0x0F, 0x87, 0xE1, 0xF9, 0xFC, 0x1F, 0x3F, 0x81, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF9,
  0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x9F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xF0, 0x1F,
  0x9F, 0x81, 0xFC, 0x7C, 0x0F, 0xC3, 0xF1, 0xBE, 0x1F, 0xF9, 0xF0, 0x7F,
  0x8F, 0x81, 0xF8, 0xFC, 0x00, 0xFF, 0x80, 0x67, 0xFC, 0x1F, 0xBF, 0xE0,
  0xFD, 0xFF, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xE3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07,
  0xE3, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E,
  0x1F, 0x81, 0xF3, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x1E, 0x0C, 0x78, 0x3C, 0x78, 0xF0, 0x78, 0xF1, 0xE1, 0xE1,
  0xE3, 0xC3, 0xC3, 0xC7, 0x87, 0x87, 0xDF, 0x0F, 0x0F, 0xBC, 0x1E, 0x1F,
  0x78, 0x7C, 0x3C, 0xF0, 0xF8, 0x79, 0xE1, 0xE0, 0xF3, 0xC3, 0xC1, 0xEF,
  0x87, 0x83, 0xDE, 0x0F, 0x0F, 0x3C, 0x3E, 0x1E, 0x78, 0x7C, 0x3C, 0xF1,
  0xF8, 0xF1, 0xFE, 0xF3, 0xC3, 0xFD, 0xFF, 0x03, 0xF1, 0xFC, 0x03, 0xC1,
  0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x03, 0xFC, 0x3F, 0x83, 0xFF, 0x3F, 0xC7,
  0xF7, 0xB9, 0xF7, 0xE3, 0xD8, 0xF8, 0xE1, 0xE8, 0x7C, 0x40, 0xFC, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xC1, 0xF8,
  0x21, 0xE1, 0xFC, 0x38, 0xF0, 0xDE, 0x3E, 0x7C, 0xCF, 0x7E, 0x3F, 0xE7,
  0xFE, 0x0F, 0xE1, 0xFE, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x3E, 0x1F,
  0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x01,
  0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F,
  0x07, 0xC0, 0x7E, 0x0F, 0x81, 0xFC, 0x1F, 0x8F, 0xF0, 0x3F, 0xFB, 0xE0,
  0x7F, 0xE7, 0xC0, 0x7F, 0x8F, 0x80, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x08, 0x03, 0xF0, 0x3C, 0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x3E, 0x1F,
  0xFC, 0x78, 0x7F, 0xFE, 0xF0, 0xF8, 0x7F, 0xE1, 0xE0, 0x3F, 0x87, 0x80,
  0x7E, 0x0F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0x00, 0x3F, 0x07, 0x00, 0xFC, 0x1E,
  0x03, 0xF0, 0x1E, 0x0F, 0xC0, 0x3C, 0x3F, 0xC0, 0x78, 0xFF, 0xFC, 0xF1,
  0xE7, 0xFF, 0xE7, 0xC3, 0xFF, 0x8F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x18, 0x1F, 0xE0, 0x3C,
  0x7F, 0xC0, 0xF1, 0xFF, 0xC1, 0xE3, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x1E,
  0x0F, 0xFE, 0x3C, 0x0F, 0xF8, 0xF0, 0x1F, 0xE0, 0x60, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 29, 25, 7, -29 },
  { 41, 15, 13, 25, 7, -30 },
  { 66, 26, 29, 25, 0, -29 },
  { 161, 23, 37, 25, 1, -33 },
  { 268, 28, 29, 25, -1, -29 },
  { 370, 24, 29, 25, 0, -29 },
  { 457, 7, 13, 25, 11, -30 },
  { 469, 17, 37, 25, 7, -31 },
  { 548, 17, 37, 25, 1, -31 },
  { 627, 22, 21, 25, 2, -23 },
  { 685, 20, 20, 25, 3, -23 },
  { 735, 11, 13, 25, 5, -7 },
  { 753, 13, 4, 25, 6, -15 },
  { 760, 8, 7, 25, 7, -7 },
  { 767, 24, 37, 25, 0, -31 },
  { 878, 22, 29, 25, 2, -29 },
  { 958, 20, 29, 25, 2, -29 },
  { 1031, 22, 29, 25, 1, -29 },
  { 1111, 22, 29, 25, 1, -29 },
  { 1191, 23, 29, 25, 0, -29 },
  { 1275, 23, 29, 25, 1, -29 },
  { 1359, 21, 29, 25, 2, -29 },
  { 1436, 22, 29, 25, 3, -29 },
  { 1516, 23, 29, 25, 1, -29 },
  { 1600, 21, 29, 25, 3, -29 },
  { 1677, 10, 22, 25, 7, -22 },
  { 1705, 12, 28, 25, 5, -22 },
  { 1747, 20, 24, 25, 3, -25 },
  { 1807, 21, 13, 25, 2, -19 },
  { 1842, 20, 24, 25, 2, -25 },
  { 1902, 18, 29, 25, 5, -29 },
  { 1968, 22, 34, 25, 2, -29 },
  { 2062, 23, 29, 25, -1, -29 },
  { 2146, 21, 29, 25, 2, -29 },
  { 2223, 22, 29, 25, 2, -29 },
  { 2303, 23, 29, 25, 1, -29 },
  { 2387, 22, 29, 25, 2, -29 },
  { 2467, 23, 29, 25, 2, -29 },
  { 2551, 22, 29, 25, 2, -29 },
  { 2631, 24, 29, 25, 1, -29 },
  { 2718, 23, 29, 25, 1, -29 },
  { 2802, 22, 29, 25, 2, -29 },
  { 2882, 26, 29, 25, 1, -29 },
  { 2977, 19, 29, 25, 2, -29 },
  { 3046, 26, 29, 25, 0, -29 },
  { 3141, 24, 29, 25, 1, -29 },
  { 3228, 22, 29, 25, 2, -29 },
  { 3308, 22, 29, 25, 2, -29 },
  { 3388, 22, 37, 25, 2, -29 },
  { 3490, 22, 29, 25, 2, -29 },
  { 3570, 23, 29, 25, 1, -29 },
  { 3654, 24, 29, 25, 3, -29 },
  { 3741, 23, 29, 25, 2, -29 },
  { 3825, 23, 29, 25, 4, -29 },
  { 3909, 26, 29, 25, 1, -29 },
  { 4004, 28, 29, 25, -1, -29 },
  { 4106, 24, 29, 25, 3, -29 },
  { 4193, 25, 29, 25, 0, -29 },
  { 4284, 19, 37, 25, 5, -31 },
  { 4372, 11, 37, 25, 7, -31 },
  { 4423, 19, 37, 25, 1, -31 },
  { 4511, 22, 18, 25, 2, -29 },
  { 4561, 20, 4, 25, 0, 3 },
  { 4571, 7, 9, 25, 8, -33 },
  { 4579, 21, 21, 25, 2, -21 },
  { 4635, 22, 30, 25, 1, -30 },
  { 4718, 19, 21, 25, 3, -21 },
  { 4768, 23, 30, 25, 2, -30 },
  { 4855, 20, 21, 25, 2, -21 },
  { 4908, 28, 38, 25, -1, -30 },
  { 5041, 22, 29, 25, 1, -21 },
  { 5121, 21, 30, 25, 1, -30 },
  { 5200, 19, 30, 25, 3, -30 },
  { 5272, 20, 38, 25, 1, -30 },
  { 5367, 23, 30, 25, 1, -30 },
  { 5454, 17, 30, 25, 4, -30 },
  { 5518, 24, 21, 25, 0, -21 },
  { 5581, 21, 21, 25, 1, -21 },
  { 5637, 21, 21, 25, 2, -21 },
  { 5693, 23, 29, 25, 0, -21 },
  { 5777, 21, 29, 25, 2, -21 },
  { 5854, 20, 21, 25, 4, -21 },
  { 5907, 20, 21, 25, 2, -21 },
  { 5960, 20, 29, 25, 3, -29 },
  { 6033, 21, 21, 25, 2, -21 },
  { 6089, 21, 21, 25, 2, -21 },
  { 6145, 23, 21, 25, 1, -21 },
  { 6206, 25, 21, 25, 0, -21 },
  { 6272, 23, 29, 25, 0, -21 },
  { 6356, 23, 21, 25, 1, -21 },
  { 6417, 20, 37, 25, 4, -31 },
  { 6510, 11, 37, 25, 7, -31 },
  { 6561, 20, 37, 25, 1, -31 },
  { 6654, 23, 10, 25, 1, -17 },
};

const GFXfont IBMPlexMono_SemiBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC41PT7B_H_
