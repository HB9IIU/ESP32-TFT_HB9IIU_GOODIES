#ifndef _IBMPLEXMONO_SEMIBOLDITALIC19PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x73, 0x18, 0xC4, 0x00, 0x1D, 0xEE, 0x00, 0x66, 0xCD,
  0x9B, 0x3E, 0xF9, 0x80, 0x06, 0x60, 0x66, 0x06, 0xC0, 0xCC, 0x3C, 0xF7,
  0xDF, 0x19, 0x8F, 0x9E, 0xF3, 0xC3, 0x30, 0x36, 0x06, 0x60, 0x66, 0x00,
  0x01, 0x80, 0x60, 0x3E, 0x0F, 0xF3, 0xB6, 0x64, 0x0C, 0x81, 0xF0, 0x1F,
  0x80, 0xF8, 0x1B, 0xA2, 0x66, 0x5D, 0xFF, 0x0F, 0xC0, 0x60, 0x0C, 0x00,
  0x0E, 0x1C, 0x7C, 0x63, 0x33, 0x0C, 0xD8, 0x33, 0xC0, 0xF8, 0x01, 0xCE,
  0x00, 0x7C, 0x0F, 0x30, 0x6C, 0xC3, 0x33, 0x08, 0xF8, 0xE1, 0xC0, 0x07,
  0x81, 0xF8, 0x73, 0x0C, 0x61, 0xCC, 0x1B, 0x9F, 0xC3, 0x70, 0xE6, 0x1C,
  0xE7, 0x9D, 0xFD, 0xE7, 0x9C, 0x6D, 0xBF, 0x80, 0x07, 0x0C, 0x18, 0x38,
  0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x70, 0x30,
  0x18, 0x38, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60,
  0xC3, 0x0E, 0x38, 0xE0, 0x0E, 0x03, 0x08, 0xC7, 0xFF, 0xFF, 0x87, 0x83,
  0xE1, 0xD8, 0xE3, 0x11, 0x00, 0x06, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xE0, 0xC0, 0x70, 0x18, 0x06, 0x00, 0x39, 0xDC, 0xC6, 0x60, 0xFF, 0xF0,
  0x7F, 0xE0, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x00, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0xE0, 0xFB, 0x3E, 0xDF, 0x37,
  0xC1, 0xF0, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x0F, 0x0F, 0x8F, 0xCE, 0xE6,
  0x67, 0x31, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x1F, 0xFF, 0xF8, 0x0F, 0x83,
  0xF8, 0xE3, 0x88, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x3F, 0xEF, 0xFC, 0x0F, 0x83, 0xF8, 0xE3, 0x88, 0x70, 0x0C, 0x1F,
  0x03, 0xE0, 0x0E, 0x01, 0xC8, 0x3B, 0x87, 0x3F, 0xC3, 0xE0, 0x01, 0xC0,
  0x78, 0x1F, 0x07, 0xE0, 0xDC, 0x33, 0x0C, 0x63, 0x0C, 0xFF, 0xFF, 0xFC,
  0x0E, 0x01, 0x80, 0x30, 0x3F, 0xCF, 0xF3, 0x01, 0x80, 0x6F, 0x1F, 0xE6,
  0x38, 0x06, 0x01, 0xD0, 0x6C, 0x3B, 0xFC, 0x7E, 0x00, 0x07, 0x83, 0x81,
  0xC0, 0xC0, 0x7F, 0x1F, 0xEE, 0x3B, 0x87, 0xC1, 0xF0, 0x6E, 0x39, 0xFC,
  0x3E, 0x00, 0xFF, 0xFF, 0xEC, 0x3B, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x70,
  0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x00, 0x1F, 0x8F, 0xF7, 0x1D, 0x83,
  0x71, 0x8F, 0xC7, 0xF3, 0x8E, 0xC1, 0xB0, 0x6E, 0x3B, 0xFC, 0x7E, 0x00,
  0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0xE0, 0xF8, 0x7E, 0x1D, 0xFE, 0x3F, 0x81,
  0xC0, 0xE0, 0x70, 0xF8, 0x00, 0x3B, 0xCE, 0x00, 0x00, 0x0E, 0xF7, 0x00,
  0x1C, 0xF1, 0xC0, 0x00, 0x00, 0x0E, 0x39, 0xC6, 0x18, 0xC0, 0x00, 0x81,
  0xC3, 0xC7, 0x8F, 0x06, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x00, 0x80, 0x7F,
  0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x20, 0x38, 0x0F, 0x01, 0xE0,
  0x78, 0x0C, 0x1E, 0x3C, 0x78, 0x70, 0x20, 0x00, 0x3E, 0x3F, 0xB8, 0xE8,
  0x70, 0x30, 0xF8, 0xF0, 0x60, 0x00, 0x00, 0x1C, 0x0E, 0x07, 0x00, 0x0F,
  0x0F, 0xE7, 0x0D, 0x83, 0x66, 0xF3, 0xFD, 0xCF, 0x62, 0xD9, 0xB7, 0xED,
  0xDB, 0x00, 0xE0, 0x1F, 0x83, 0xE0, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0x60,
  0xEC, 0x19, 0x87, 0x38, 0xE7, 0x1F, 0xE7, 0xFC, 0xC1, 0xB8, 0x3E, 0x06,
  0x3F, 0x8F, 0xF7, 0x1D, 0xC7, 0x61, 0x9F, 0xC7, 0xF1, 0x86, 0xE1, 0xB8,
  0x6E, 0x3B, 0xFC, 0xFE, 0x00, 0x0F, 0x8F, 0xF3, 0x1D, 0xC3, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x3F, 0x0F,
  0xE7, 0x1D, 0xC3, 0x70, 0xD8, 0x76, 0x1D, 0x87, 0xE1, 0xF8, 0x6C, 0x3B,
  0xFC, 0xFC, 0x00, 0x3F, 0xCF, 0xF3, 0x01, 0xC0, 0x70, 0x1F, 0xE7, 0xF9,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0xC0,
  0x38, 0x07, 0x00, 0xFF, 0x1F, 0xE3, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x00, 0x0F, 0x0F, 0xE7, 0x1D, 0xC3, 0x60, 0x38, 0x0E, 0x7F, 0x9E,
  0xC1, 0xB8, 0x6E, 0x39, 0xFE, 0x3B, 0x80, 0x18, 0x73, 0x86, 0x38, 0x63,
  0x0E, 0x30, 0xE3, 0xFE, 0x3F, 0xC7, 0x0C, 0x70, 0xC6, 0x1C, 0x61, 0xC6,
  0x1C, 0xE1, 0x80, 0x3F, 0xCF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0x83, 0xFC, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x30, 0xCE, 0x73, 0xF8, 0x7C,
  0x00, 0x30, 0xF3, 0x1C, 0x73, 0x87, 0x70, 0x66, 0x06, 0xE0, 0x7E, 0x07,
  0x60, 0xE7, 0x0E, 0x70, 0xC3, 0x0C, 0x38, 0xC1, 0x80, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1F, 0xFF, 0xF8,
  0x38, 0x73, 0x8F, 0x3C, 0xE3, 0xDE, 0x3D, 0x66, 0xF6, 0x66, 0x66, 0x6E,
  0x64, 0xC6, 0x4C, 0x60, 0xCE, 0x0C, 0xC0, 0xC0, 0x1C, 0x73, 0xC6, 0x3C,
  0x63, 0xC6, 0x36, 0x63, 0x6E, 0x36, 0xC7, 0x6C, 0x66, 0xC6, 0x3C, 0x63,
  0xC6, 0x3C, 0xE3, 0x80, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0xE0, 0xF8, 0x3E,
  0x1F, 0x07, 0xC1, 0xF0, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x3F, 0x8F, 0xF3,
  0x0D, 0xC3, 0x70, 0xD8, 0x77, 0xF9, 0xFC, 0x60, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x00, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC1, 0xF0, 0x6E, 0x39, 0xFC, 0x3E, 0x07, 0x20, 0xCC, 0x1E, 0x07, 0x00,
  0x3F, 0x8F, 0xF3, 0x1D, 0xC3, 0x70, 0xD8, 0x77, 0xF9, 0xFC, 0xE6, 0x39,
  0x8E, 0x73, 0x0C, 0xC3, 0x80, 0x0F, 0x83, 0xFC, 0xE1, 0x98, 0x03, 0x80,
  0x7C, 0x07, 0xE0, 0x1E, 0x00, 0xC8, 0x19, 0x87, 0x7F, 0xC3, 0xF0, 0xFF,
  0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x00, 0x70, 0xEE, 0x19, 0xC3, 0x30, 0x66, 0x1C, 0xC3,
  0xB8, 0x67, 0x0C, 0xE1, 0x98, 0x73, 0x8E, 0x7F, 0x83, 0xE0, 0xC0, 0xF0,
  0x7E, 0x1B, 0x8E, 0xE3, 0x39, 0xCE, 0x71, 0x98, 0x6E, 0x1B, 0x07, 0xC1,
  0xE0, 0x78, 0x00, 0x30, 0x33, 0x03, 0x70, 0x36, 0x73, 0x67, 0x66, 0x76,
  0x6F, 0x66, 0xB6, 0x6B, 0xC7, 0xBC, 0x73, 0xC7, 0x3C, 0xF3, 0x80, 0x1C,
  0x38, 0x63, 0x83, 0x98, 0x1D, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0D, 0x80, 0xEE, 0x0E, 0x30, 0x61, 0xCF, 0x0E, 0x00, 0xC0, 0xFC, 0x3B,
  0x8E, 0x31, 0x87, 0x70, 0xFC, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0x8F, 0xC6, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xFC, 0xFC, 0x00, 0xC3, 0x06, 0x18, 0x61, 0x86,
  0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x61, 0x86, 0x1C, 0x1F, 0x8F, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0xFC, 0xFC, 0x00, 0x0F, 0x03, 0xC1, 0xB0, 0xEE, 0x31, 0x98, 0x6E,
  0x1F, 0x03, 0xFF, 0xFF, 0xC0, 0xD9, 0xB0, 0x3D, 0xDF, 0xE6, 0x3B, 0x86,
  0xE1, 0xB0, 0xEC, 0x3B, 0x9C, 0xFB, 0x9C, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x77, 0x1B, 0xE7, 0x19, 0x87, 0x61, 0xF8, 0x6E, 0x1B, 0x8E, 0xDF,
  0x37, 0x80, 0x1F, 0x1F, 0xDC, 0x6C, 0x0E, 0x07, 0x03, 0x87, 0xC7, 0x7F,
  0x1E, 0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x63, 0xDC, 0xFF, 0x98, 0x67,
  0x0C, 0xE1, 0x98, 0x73, 0x0E, 0x73, 0xCF, 0xB0, 0xE6, 0x00, 0x1F, 0x1F,
  0xDC, 0x6C, 0x7F, 0xFF, 0xE3, 0x85, 0xC7, 0x7F, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x60, 0x03, 0x01, 0xFF, 0x8F, 0xF8, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x23, 0x03, 0x98, 0x0E, 0xC0,
  0x3E, 0x00, 0xE0, 0x00, 0x1E, 0xE7, 0xFC, 0xE3, 0x38, 0x67, 0x0C, 0xC1,
  0x98, 0x73, 0x9E, 0x7F, 0x87, 0xB0, 0x06, 0x21, 0xCF, 0xF0, 0x7C, 0x00,
  0x30, 0x18, 0x0C, 0x0E, 0x07, 0x73, 0xFD, 0xC6, 0xC3, 0x61, 0xF0, 0xF8,
  0xF8, 0x7C, 0x36, 0x18, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x03, 0xE3, 0xF0,
  0x38, 0x1C, 0x0C, 0x06, 0x43, 0x33, 0xB1, 0xF0, 0x70, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0xC4, 0x63, 0x98, 0x76, 0x0F, 0x81, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x77, 0x1B, 0xE7, 0x19, 0x86, 0x63, 0x3B, 0x8F, 0xCB, 0x3B,
  0xCF, 0xB1, 0xC0, 0xFC, 0xF8, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30,
  0x72, 0x77, 0x6E, 0x7C, 0x78, 0x7E, 0xED, 0xFD, 0xDD, 0xB3, 0x36, 0x66,
  0xCC, 0xF3, 0x36, 0x66, 0xCC, 0xD9, 0x98, 0x77, 0x3F, 0xDC, 0x6C, 0x36,
  0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0x61, 0x80, 0x1F, 0x1F, 0xDC, 0x7C, 0x3E,
  0x1E, 0x0F, 0x07, 0xC7, 0x7F, 0x1E, 0x00, 0x3B, 0x86, 0xF8, 0xE3, 0x18,
  0x77, 0x0E, 0xE1, 0x9C, 0x33, 0x8E, 0x6F, 0x8D, 0xE1, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x00, 0x3D, 0xDF, 0xF6, 0x1B, 0x86, 0xE1, 0xB0, 0x6C, 0x3B,
  0x9E, 0xFB, 0x1C, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0xFB, 0xFF, 0xCE,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x00, 0x1F, 0x1F, 0xDC,
  0x4E, 0x07, 0xE1, 0xF8, 0x0E, 0x87, 0xFF, 0x3F, 0x00, 0x0C, 0x03, 0x01,
  0xC1, 0xFF, 0xFF, 0x86, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x63, 0x78, 0xF8,
  0x1C, 0x00, 0x71, 0xD8, 0x66, 0x19, 0x86, 0xE1, 0xB8, 0xEE, 0x3B, 0x9E,
  0xFB, 0x1C, 0xC0, 0xF1, 0xF9, 0xCC, 0x6E, 0x37, 0x1B, 0x1D, 0x8E, 0xCE,
  0x7E, 0x3C, 0x00, 0x36, 0x6C, 0xCD, 0x99, 0xB3, 0x36, 0x66, 0xCC, 0xD3,
  0x16, 0xA6, 0xF4, 0x8C, 0xE0, 0x1C, 0xE7, 0xBD, 0xDD, 0xA3, 0x30, 0x60,
  0x1C, 0x33, 0x96, 0x77, 0xF7, 0xCC, 0x60, 0x38, 0xE6, 0x18, 0xC3, 0x18,
  0x67, 0x0C, 0xE3, 0x9C, 0x73, 0x9C, 0x7D, 0x87, 0x30, 0x0E, 0x21, 0xCF,
  0xF0, 0xFC, 0x00, 0x3C, 0xDF, 0xF4, 0x38, 0x1C, 0x0E, 0x07, 0x47, 0x1B,
  0xE6, 0xFF, 0xB3, 0xC0, 0x0F, 0x8F, 0xC6, 0x03, 0x00, 0xC0, 0x60, 0x31,
  0xF0, 0xF8, 0x0E, 0x02, 0x03, 0x03, 0x03, 0x01, 0x80, 0xFC, 0x3C, 0x00,
  0x18, 0xC6, 0x31, 0x98, 0xC6, 0x31, 0x8C, 0xC6, 0x31, 0x8C, 0xE0, 0x3E,
  0x1F, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x1F, 0x0F, 0x8C, 0x04, 0x03,
  0x01, 0x80, 0x60, 0x61, 0xF0, 0xF8, 0x00, 0x38, 0xDE, 0x3C, 0xDB, 0x3E,
  0x87, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 7, 6, 11, 3, -14 },
  { 16, 12, 13, 11, 0, -13 },
  { 36, 11, 17, 11, 0, -15 },
  { 60, 14, 13, 11, -1, -13 },
  { 83, 11, 13, 11, 0, -13 },
  { 101, 3, 6, 11, 5, -14 },
  { 104, 8, 17, 11, 3, -14 },
  { 121, 7, 17, 11, 1, -14 },
  { 136, 10, 10, 11, 1, -10 },
  { 149, 10, 10, 11, 1, -11 },
  { 162, 5, 6, 11, 2, -3 },
  { 166, 6, 2, 11, 3, -7 },
  { 168, 4, 3, 11, 3, -3 },
  { 170, 11, 17, 11, 0, -14 },
  { 194, 10, 13, 11, 1, -13 },
  { 211, 9, 13, 11, 1, -13 },
  { 226, 11, 13, 11, 0, -13 },
  { 244, 11, 13, 11, 0, -13 },
  { 262, 11, 13, 11, 0, -13 },
  { 280, 10, 13, 11, 1, -13 },
  { 297, 10, 13, 11, 1, -13 },
  { 314, 10, 13, 11, 2, -13 },
  { 331, 10, 13, 11, 1, -13 },
  { 348, 10, 13, 11, 1, -13 },
  { 365, 5, 10, 11, 3, -10 },
  { 372, 6, 13, 11, 2, -10 },
  { 382, 9, 11, 11, 2, -11 },
  { 395, 10, 6, 11, 1, -9 },
  { 403, 9, 11, 11, 1, -11 },
  { 416, 9, 13, 11, 2, -13 },
  { 431, 10, 15, 11, 1, -13 },
  { 450, 11, 13, 11, -1, -13 },
  { 468, 10, 13, 11, 1, -13 },
  { 485, 10, 13, 11, 1, -13 },
  { 502, 10, 13, 11, 1, -13 },
  { 519, 10, 13, 11, 1, -13 },
  { 536, 11, 13, 11, 1, -13 },
  { 554, 10, 13, 11, 1, -13 },
  { 571, 12, 13, 11, 0, -13 },
  { 591, 10, 13, 11, 1, -13 },
  { 608, 10, 13, 11, 1, -13 },
  { 625, 12, 13, 11, 1, -13 },
  { 645, 9, 13, 11, 1, -13 },
  { 660, 12, 13, 11, 0, -13 },
  { 680, 12, 13, 11, 0, -13 },
  { 700, 10, 13, 11, 1, -13 },
  { 717, 10, 13, 11, 1, -13 },
  { 734, 10, 17, 11, 1, -13 },
  { 756, 10, 13, 11, 1, -13 },
  { 773, 11, 13, 11, 0, -13 },
  { 791, 10, 13, 11, 2, -13 },
  { 808, 11, 13, 11, 1, -13 },
  { 826, 10, 13, 11, 2, -13 },
  { 843, 12, 13, 11, 0, -13 },
  { 863, 13, 13, 11, -1, -13 },
  { 885, 11, 13, 11, 2, -13 },
  { 903, 12, 13, 11, 0, -13 },
  { 923, 9, 17, 11, 2, -14 },
  { 943, 6, 17, 11, 3, -14 },
  { 956, 9, 17, 11, 0, -14 },
  { 976, 10, 8, 11, 1, -13 },
  { 986, 9, 2, 11, 0, 2 },
  { 989, 3, 4, 11, 4, -15 },
  { 991, 10, 10, 11, 1, -10 },
  { 1004, 10, 14, 11, 1, -14 },
  { 1022, 9, 10, 11, 1, -10 },
  { 1034, 11, 14, 11, 1, -14 },
  { 1054, 9, 10, 11, 1, -10 },
  { 1066, 13, 18, 11, -1, -14 },
  { 1096, 11, 14, 11, 0, -10 },
  { 1116, 9, 14, 11, 1, -14 },
  { 1132, 9, 15, 11, 1, -15 },
  { 1149, 10, 19, 11, 0, -15 },
  { 1173, 10, 14, 11, 1, -14 },
  { 1191, 8, 14, 11, 2, -14 },
  { 1205, 11, 10, 11, 0, -10 },
  { 1219, 9, 10, 11, 1, -10 },
  { 1231, 9, 10, 11, 1, -10 },
  { 1243, 11, 14, 11, 0, -10 },
  { 1263, 10, 14, 11, 1, -10 },
  { 1281, 9, 10, 11, 2, -10 },
  { 1293, 9, 10, 11, 1, -10 },
  { 1305, 10, 13, 11, 1, -13 },
  { 1322, 10, 10, 11, 1, -10 },
  { 1335, 9, 10, 11, 1, -10 },
  { 1347, 11, 10, 11, 0, -10 },
  { 1361, 11, 10, 11, 0, -10 },
  { 1375, 11, 14, 11, 0, -10 },
  { 1395, 10, 10, 11, 1, -10 },
  { 1408, 9, 17, 11, 2, -14 },
  { 1428, 5, 17, 11, 3, -14 },
  { 1439, 9, 17, 11, 1, -14 },
  { 1459, 10, 5, 11, 1, -8 },
};

const GFXfont IBMPlexMono_SemiBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC19PT7B_H_
