#ifndef _IBMPLEXMONO_SEMIBOLDITALIC55PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE7, 0x9F, 0xE0, 0xFF, 0x1F, 0x0F,
  0x01, 0xFC, 0x3E, 0x0C, 0x07, 0xF0, 0x7C, 0x10, 0x0F, 0xE0, 0xF8, 0x00,
  0x1F, 0xC1, 0xE0, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x7F, 0x0F, 0x80, 0x00,
  0xFF, 0x1F, 0x00, 0x00, 0xFF, 0xBE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7B, 0xFF, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x07,
  0xC3, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0xE0, 0x40, 0x3C,
  0x1F, 0xC1, 0x80, 0x78, 0x3F, 0x87, 0xC0, 0xF0, 0xFF, 0x1F, 0xC3, 0xE3,
  0xFC, 0x7F, 0xE7, 0xDF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x0F, 0x80,
  0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x7C, 0x00, 0x03, 0xFF,
  0xF1, 0xF8, 0x00, 0x03, 0xFF, 0xC7, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0x8F, 0xFF,
  0xC0, 0x00, 0x3E, 0x3F, 0xFF, 0x80, 0x00, 0xF8, 0x7E, 0x1F, 0x80, 0x03,
  0xF1, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x7C, 0x00, 0x7E, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x3F, 0x00, 0x7E, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0xF7,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x87, 0xF0, 0x0F, 0xE0, 0x73, 0xF8,
  0x07, 0xF8, 0x7F, 0xFC, 0x03, 0xFC, 0x7E, 0x7F, 0x01, 0x7E, 0x3F, 0x3F,
  0x81, 0xBF, 0xBF, 0x1F, 0xE1, 0xCF, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x01, 0xF8, 0x06,
  0x3E, 0x07, 0xE0, 0xF8, 0xFF, 0x3F, 0x9F, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x0F, 0x87, 0xFD,
  0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x87, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD, 0xFE, 0x1F, 0x07, 0xF7, 0xF0, 0xFE,
  0x1F, 0xDF, 0xC3, 0xF8, 0xFF, 0x7F, 0x0F, 0xE3, 0xFD, 0xFC, 0x3F, 0x0F,
  0xF7, 0xF0, 0x78, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0x7E,
  0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x07,
  0xF9, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xF0,
  0x1F, 0xC0, 0x0C, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x1E, 0x00, 0x1F, 0xC0, 0x10,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFC,
  0x00, 0xFF, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0x00, 0x07, 0xF0, 0x08, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x20, 0x00, 0x3F,
  0xC1, 0xC0, 0x00, 0xFF, 0x1F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE3,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x01, 0xF8, 0xFF, 0xE0, 0x03, 0xE7, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xE0,
  0x1F, 0xBF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0x82, 0x78, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x7F, 0x81, 0xC0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0x9F, 0xFC, 0x03, 0xFD, 0xFF, 0xF8,
  0x1F, 0xDF, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xE0, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F,
  0x80, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFE,
  0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7E,
  0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x0F, 0xFE, 0x7F, 0xFF,
  0xEF, 0xE7, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0x9F, 0xC1, 0xFF, 0xF3, 0xF8,
  0x0F, 0xFE, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x20, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x90, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xFC, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0x9F, 0x00, 0x3F, 0xC3, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x3E,
  0x3F, 0x1F, 0x83, 0xFC, 0xFC, 0x7C, 0x1F, 0xFB, 0xF3, 0xF0, 0x7F, 0xFF,
  0xCF, 0xC3, 0xFF, 0xFE, 0x3F, 0x0F, 0xE3, 0xF8, 0xF8, 0x7E, 0x07, 0xE7,
  0xE1, 0xF8, 0x1F, 0x9F, 0x8F, 0xC0, 0x7E, 0x7E, 0x3F, 0x01, 0xF9, 0xF8,
  0xFC, 0x07, 0xC7, 0xE3, 0xF0, 0x1F, 0x1F, 0x0F, 0xC0, 0x7C, 0x7C, 0x3E,
  0x03, 0xF3, 0xF0, 0xF8, 0x0F, 0xCF, 0xC3, 0xE0, 0x3F, 0x3F, 0x0F, 0x81,
  0xF8, 0xFC, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0xEF, 0x8F, 0xC3, 0xFF, 0xFE,
  0x3F, 0x0F, 0xFD, 0xF8, 0xFC, 0x1F, 0xF7, 0xE1, 0xF0, 0x3F, 0x9F, 0x07,
  0xC0, 0x30, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F,
  0xC0, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x70, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0x00, 0xFE, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0x01, 0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x87, 0xF0, 0x07, 0xFC, 0x1F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0x83, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFD, 0xFE, 0x07, 0xFF,
  0xCF, 0xF0, 0x3F, 0xFE, 0x7F, 0x81, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0x9F,
  0xC0, 0xFF, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x83,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0x3F, 0x01, 0xFF,
  0xFB, 0xF8, 0x0F, 0xFF, 0x9F, 0xC0, 0x1F, 0xF8, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x7F, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x1F, 0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x81,
  0xFB, 0xE1, 0xF7, 0xE0, 0x7E, 0xF8, 0xFD, 0xF8, 0x1F, 0xBE, 0x3E, 0x7E,
  0x07, 0xEF, 0xDF, 0xBF, 0x03, 0xF3, 0xF7, 0xCF, 0xC0, 0xFC, 0x7F, 0xF3,
  0xF0, 0x3F, 0x1F, 0xF8, 0xFC, 0x0F, 0xC7, 0xFE, 0x3F, 0x03, 0xF1, 0xFF,
  0x1F, 0xC0, 0xFC, 0x7F, 0xC7, 0xE0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x0F, 0xE0, 0x7E,
  0x0F, 0x83, 0xF8, 0x1F, 0x81, 0xC0, 0xFC, 0x0F, 0xE0, 0x70, 0x3F, 0x03,
  0xF0, 0x18, 0x0F, 0xC0, 0xFC, 0x06, 0x03, 0xF0, 0x3F, 0x01, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x3F, 0x03,
  0xFF, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x7F, 0x03,
  0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x80, 0x7E, 0x07,
  0xFF, 0x80, 0x7E, 0x07, 0xFF, 0x80, 0x7E, 0x07, 0xEF, 0xC0, 0xFE, 0x07,
  0xEF, 0xC0, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0x0F,
  0xE7, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x0F, 0xC7, 0xE1, 0xFC, 0x0F,
  0xC7, 0xE1, 0xF8, 0x0F, 0xC7, 0xE1, 0xF8, 0x0F, 0xC3, 0xE1, 0xF8, 0x1F,
  0xC3, 0xF1, 0xF8, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x83, 0xF3, 0xF8, 0x1F,
  0x83, 0xF3, 0xF0, 0x1F, 0x81, 0xF3, 0xF0, 0x1F, 0x81, 0xFB, 0xF0, 0x3F,
  0x81, 0xFB, 0xF0, 0x3F, 0x01, 0xFB, 0xF0, 0x3F, 0x01, 0xFF, 0xF0, 0x3F,
  0x01, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xE0, 0x7F,
  0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x7E,
  0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC,
  0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F,
  0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x81,
  0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01,
  0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF,
  0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xBF,
  0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x10, 0x00, 0x1F, 0xC0, 0x60, 0x00, 0x3F, 0x83, 0xC0, 0x00,
  0xFE, 0x1F, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x78, 0x07, 0xF0, 0x00,
  0x20, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x08, 0x00, 0x07, 0xF8, 0x18, 0x00, 0x07,
  0xF0, 0x3E, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7C, 0x0F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x7F, 0x83, 0xF0, 0x3F, 0x0F, 0xF0, 0x7E, 0x07, 0xE1,
  0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0xC1, 0xF0, 0x3F, 0x0F, 0xF8, 0x7E, 0x07,
  0xE1, 0xEF, 0x0F, 0xC0, 0xFC, 0x7D, 0xE1, 0xF8, 0x1F, 0x8F, 0xBC, 0x3E,
  0x03, 0xF1, 0xE7, 0x8F, 0xC0, 0x7E, 0x7C, 0xF1, 0xF8, 0x0F, 0xCF, 0x9F,
  0x3F, 0x01, 0xF9, 0xE3, 0xE7, 0xC0, 0x3E, 0x7C, 0x7C, 0xF8, 0x0F, 0xCF,
  0x8F, 0xBF, 0x01, 0xF9, 0xE1, 0xF7, 0xE0, 0x3F, 0x7C, 0x3E, 0xF8, 0x07,
  0xEF, 0x87, 0xDF, 0x00, 0xFD, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xF1, 0xC0, 0x00,
  0x0E, 0x01, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x0C, 0x0F,
  0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC,
  0x10, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xC0, 0xFF, 0xF9, 0xFE,
  0x0F, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0x7F, 0x07, 0xFC, 0x1F, 0xF8, 0x7F,
  0x80, 0x7F, 0xC3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF8, 0xFF,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xFE,
  0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0x83, 0xBF, 0xF3, 0xFF, 0xF9, 0xFF, 0x8F,
  0xFF, 0xCF, 0xFC, 0x3F, 0xFC, 0x3F, 0xC0, 0xFF, 0xC0, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xF0, 0xFF, 0xC0, 0x3F, 0x8F, 0xFF, 0x01, 0xFC, 0xFF, 0xFC,
  0x0F, 0xEF, 0xFF, 0xE0, 0x7E, 0xF0, 0xFF, 0x87, 0xF6, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xE1, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F,
  0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x8F, 0xFE, 0x0F, 0xF8, 0x7F, 0x7F, 0xFF, 0x83, 0xFB, 0xFF, 0xFC, 0x1F,
  0xCF, 0xFF, 0x80, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0x3C, 0x3F, 0xC0, 0x04, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x18, 0x7F, 0x00, 0x0F, 0x1F, 0xC0, 0x07, 0xF7, 0xF0,
  0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xFC, 0x7F, 0x00, 0xFF, 0xFC, 0xFE, 0x03,
  0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFB, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF,
  0x81, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x06, 0xFC, 0x07, 0xFC, 0x3F, 0xF8,
  0x07, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x1F, 0xC0,
  0x0F, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x3F,
  0xE7, 0xF0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x02, 0x07, 0xE0, 0x00, 0x60, 0xFE, 0x00, 0x1F, 0x1F, 0xC0,
  0x07, 0xF3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x01,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFF,
  0x3F, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0x7F, 0x07,
  0xFF, 0xFD, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x06, 0xFE, 0x0F, 0xF8,
  0x7B, 0xF8, 0x1F, 0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0x7F, 0x00, 0xFF, 0xF9,
  0xFC, 0x01, 0xFF, 0x87, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x20, 0x01, 0xFC, 0x01, 0xC0, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xF8, 0x0F, 0xE3, 0xFF, 0xC0, 0xFE,
  0x7F, 0xFE, 0x0F, 0xEF, 0xFF, 0xE0, 0xFE, 0xE1, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF1, 0xFF, 0x00, 0x7F, 0x1F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xC0, 0x1F, 0xC0, 0xF8, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x80, 0x3F, 0x80, 0x1C, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0xFE, 0x3F,
  0xFC, 0x03, 0xF9, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF, 0xF0, 0x3F, 0xB8, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xF0,
  0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0x8F, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x21, 0xFC, 0x3F, 0x81,
  0xE7, 0xF0, 0x7F, 0x0F, 0xDF, 0xC1, 0xFC, 0x7E, 0x7F, 0x07, 0xF3, 0xF3,
  0xF8, 0x0F, 0xFF, 0x8F, 0xE0, 0x3F, 0xFC, 0x3F, 0x80, 0x7F, 0xE0, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x10, 0x07, 0xF0,
  0x18, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0xCF, 0xE1, 0xFE, 0x0F, 0xDF, 0xF3,
  0xFF, 0x0F, 0xDF, 0xF3, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x0F, 0xA3, 0xF6,
  0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x1F, 0xC1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0x3F, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x03, 0xF0,
  0x3E, 0x3F, 0x03, 0xF0, 0x3E, 0x3F, 0x03, 0xF0, 0x7E, 0x3F, 0x03, 0xE0,
  0x7E, 0x3F, 0x07, 0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0x7E, 0x3E, 0x07, 0xE0,
  0x7C, 0x7E, 0x07, 0xE0, 0x7C, 0x7E, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xC0,
  0xFC, 0x7E, 0x0F, 0xC0, 0xFC, 0x7E, 0x0F, 0xC0, 0xFC, 0x7C, 0x0F, 0xC0,
  0xF8, 0xFC, 0x0F, 0xC0, 0xF8, 0xFC, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0x81,
  0xF8, 0xFC, 0x0F, 0x81, 0xF8, 0xFC, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x1F, 0xF8, 0x0F, 0xE3, 0xFF, 0xC0, 0xFE, 0x7F, 0xFE, 0x0F,
  0xEF, 0xFF, 0xE0, 0xFE, 0xE1, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x1F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x87,
  0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x03, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0xFF, 0xC0, 0x0F, 0xE3, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF,
  0xC0, 0x3F, 0xBF, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x81, 0xFD, 0x80, 0xFF,
  0x03, 0xFE, 0x00, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0x7F, 0x7F,
  0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xF8, 0x03, 0xF8, 0xFF,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFF, 0x1F, 0xC0, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F,
  0xFF, 0xBF, 0x87, 0xFC, 0x1F, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0xFF, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0xE1, 0xFC, 0x01, 0xFF, 0x0F, 0xE0, 0x1B, 0xF8, 0x7F,
  0xC3, 0xFF, 0x81, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xCF, 0xE0, 0x3F, 0xFC,
  0x7F, 0x00, 0xFF, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x07,
  0xF7, 0xFF, 0xE1, 0xFE, 0x7F, 0xFE, 0x3F, 0xE7, 0xFF, 0xE7, 0xFE, 0x7F,
  0xFC, 0xFF, 0xE8, 0x1F, 0xDF, 0xFE, 0x01, 0xFD, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x03, 0x80,
  0xFE, 0x00, 0x10, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x80, 0x01, 0xFC, 0x1C, 0x00, 0x1F, 0xC3, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x18, 0x07, 0xF0, 0x0F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x07,
  0xFC, 0x1F, 0xC3, 0xFC, 0x07, 0xF3, 0xFC, 0x01, 0xF9, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x8F, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x07,
  0xF8, 0x77, 0xF0, 0x7F, 0xFF, 0x7F, 0x07, 0xFF, 0xE7, 0xF0, 0x3F, 0xFC,
  0x7F, 0x01, 0xFF, 0x87, 0xE0, 0x07, 0xE0, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC7, 0xFF, 0x80, 0x3E, 0x7F, 0xF8, 0x1F, 0xE7, 0xFF, 0x80, 0xFE, 0x7F,
  0xF8, 0x0F, 0xF7, 0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0xC1, 0xFF, 0x01, 0xFC, 0x3F, 0xE0, 0x1F, 0xCF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x03,
  0xF1, 0xF0, 0x7E, 0x07, 0xC3, 0xF0, 0xFC, 0x0F, 0x87, 0xE1, 0xF8, 0x3F,
  0x07, 0xC3, 0xF0, 0x7E, 0x0F, 0x87, 0xC0, 0xFC, 0x1F, 0x8F, 0x81, 0xF8,
  0x3F, 0x3F, 0x03, 0xE0, 0x7E, 0x7E, 0x07, 0xC0, 0xFC, 0xFC, 0x1F, 0x81,
  0xF9, 0xF8, 0x3F, 0x03, 0xF3, 0xE0, 0x7E, 0x07, 0xC7, 0xC0, 0xFC, 0x0F,
  0x9F, 0x81, 0xF0, 0x1F, 0x3F, 0x03, 0xE0, 0x7E, 0x7E, 0x07, 0xC0, 0xFC,
  0xFC, 0x1F, 0x81, 0xF9, 0xF0, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x07, 0xCF,
  0xC0, 0xF8, 0x1F, 0x9F, 0x83, 0xF0, 0x3E, 0x3F, 0x07, 0xE0, 0xFC, 0x7E,
  0x1F, 0xC1, 0xF0, 0xFC, 0x77, 0x87, 0xE1, 0xFF, 0xEF, 0x9F, 0x83, 0xFF,
  0x9F, 0xFE, 0x03, 0xFE, 0x3F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xF8,
  0xFF, 0xBF, 0x78, 0xFC, 0xFF, 0x1F, 0xB8, 0x7E, 0x3F, 0x0F, 0xD8, 0x3F,
  0x0E, 0x07, 0xFC, 0x1F, 0x86, 0x03, 0xFC, 0x0F, 0xC0, 0x01, 0xFE, 0x06,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0x81, 0xFE,
  0x00, 0x0F, 0xC0, 0xFF, 0x01, 0x87, 0xE0, 0xFF, 0x81, 0xE3, 0xF0, 0x6F,
  0xC3, 0xF1, 0xF8, 0x77, 0xE3, 0xFC, 0xFE, 0x7B, 0xF7, 0xFC, 0x7F, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7F, 0x01, 0xBF, 0x81, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xF7,
  0xF0, 0x1F, 0xFF, 0x9F, 0xC0, 0x3F, 0xFC, 0x7F, 0x00, 0x7F, 0xE1, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x10, 0x00, 0x7F, 0x00, 0xE0,
  0x03, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC3,
  0xF0, 0x3F, 0xFF, 0xC7, 0xE0, 0xFF, 0xFF, 0xEF, 0xC1, 0xFC, 0x1F, 0xFF,
  0x83, 0xF0, 0x0F, 0xFE, 0x07, 0xC0, 0x0F, 0xF8, 0x0F, 0x80, 0x1F, 0xE0,
  0x1F, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0xFF, 0x01, 0xC0, 0x07,
  0xFC, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0x1F, 0x01, 0xFE,
  0x00, 0x3E, 0x07, 0xF8, 0x00, 0x7C, 0x1F, 0xFF, 0x80, 0xFC, 0x7F, 0xFF,
  0xF9, 0xF8, 0xFC, 0xFF, 0xFF, 0xE1, 0xF8, 0x7F, 0xFF, 0xC3, 0xF0, 0x3F,
  0xFF, 0x07, 0xE0, 0x0F, 0xFC, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x07, 0xFC, 0x00, 0x7C,
  0x1F, 0xFC, 0x01, 0xF8, 0x7F, 0xFC, 0x03, 0xE1, 0xFF, 0xFC, 0x0F, 0xC3,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC3, 0xF8, 0x7E, 0x1F, 0x03, 0xF8, 0xFC, 0x3E,
  0x03, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0xC1, 0xF0, 0x07, 0xFF, 0x03, 0xE0,
  0x07, 0xFC, 0x09, 0xC0, 0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 14, 39, 33, 10, -38 },
  { 70, 21, 17, 33, 9, -41 },
  { 115, 35, 38, 33, 0, -38 },
  { 282, 31, 52, 33, 1, -45 },
  { 484, 39, 40, 33, -2, -39 },
  { 679, 33, 40, 33, 0, -39 },
  { 844, 9, 17, 33, 15, -41 },
  { 864, 23, 50, 33, 10, -42 },
  { 1008, 22, 50, 33, 2, -42 },
  { 1146, 30, 28, 33, 2, -30 },
  { 1251, 27, 27, 33, 3, -30 },
  { 1343, 15, 17, 33, 6, -9 },
  { 1375, 18, 6, 33, 8, -20 },
  { 1389, 11, 10, 33, 9, -9 },
  { 1403, 33, 50, 33, 0, -42 },
  { 1610, 30, 40, 33, 2, -39 },
  { 1760, 27, 38, 33, 3, -38 },
  { 1889, 30, 39, 33, 1, -39 },
  { 2036, 30, 40, 33, 1, -39 },
  { 2186, 31, 38, 33, 0, -38 },
  { 2334, 31, 39, 33, 1, -38 },
  { 2486, 29, 39, 33, 2, -38 },
  { 2628, 29, 38, 33, 5, -38 },
  { 2766, 30, 40, 33, 2, -39 },
  { 2916, 28, 39, 33, 4, -39 },
  { 3053, 14, 30, 33, 9, -29 },
  { 3106, 17, 37, 33, 6, -29 },
  { 3185, 26, 32, 33, 5, -33 },
  { 3289, 29, 17, 33, 2, -25 },
  { 3351, 26, 32, 33, 3, -33 },
  { 3455, 25, 40, 33, 6, -39 },
  { 3580, 30, 45, 33, 2, -39 },
  { 3749, 32, 38, 33, -2, -38 },
  { 3901, 29, 38, 33, 2, -38 },
  { 4039, 30, 40, 33, 3, -39 },
  { 4189, 30, 38, 33, 2, -38 },
  { 4332, 31, 38, 33, 2, -38 },
  { 4480, 32, 38, 33, 2, -38 },
  { 4632, 29, 40, 33, 3, -39 },
  { 4777, 32, 38, 33, 1, -38 },
  { 4929, 31, 38, 33, 2, -38 },
  { 5077, 30, 39, 33, 2, -38 },
  { 5224, 34, 38, 33, 2, -38 },
  { 5386, 25, 38, 33, 3, -38 },
  { 5505, 34, 38, 33, 0, -38 },
  { 5667, 32, 38, 33, 1, -38 },
  { 5819, 30, 40, 33, 2, -39 },
  { 5969, 31, 38, 33, 2, -38 },
  { 6117, 30, 50, 33, 2, -39 },
  { 6305, 31, 38, 33, 2, -38 },
  { 6453, 32, 40, 33, 1, -39 },
  { 6613, 32, 38, 33, 4, -38 },
  { 6765, 31, 39, 33, 3, -38 },
  { 6917, 31, 38, 33, 5, -38 },
  { 7065, 35, 38, 33, 1, -38 },
  { 7232, 38, 38, 33, -2, -38 },
  { 7413, 32, 38, 33, 5, -38 },
  { 7565, 34, 38, 33, 0, -38 },
  { 7727, 25, 50, 33, 7, -42 },
  { 7884, 16, 50, 33, 9, -42 },
  { 7984, 26, 50, 33, 1, -42 },
  { 8147, 30, 24, 33, 2, -38 },
  { 8237, 27, 5, 33, 0, 5 },
  { 8254, 10, 12, 33, 11, -44 },
  { 8269, 29, 30, 33, 2, -29 },
  { 8378, 29, 42, 33, 2, -41 },
  { 8531, 26, 30, 33, 3, -29 },
  { 8629, 31, 42, 33, 2, -41 },
  { 8792, 27, 30, 33, 3, -29 },
  { 8894, 37, 53, 33, -1, -41 },
  { 9140, 30, 41, 33, 1, -29 },
  { 9294, 28, 41, 33, 2, -41 },
  { 9438, 26, 42, 33, 4, -41 },
  { 9575, 28, 53, 33, 1, -41 },
  { 9761, 30, 42, 33, 2, -41 },
  { 9919, 24, 42, 33, 5, -41 },
  { 10045, 32, 29, 33, 0, -29 },
  { 10161, 28, 29, 33, 2, -29 },
  { 10263, 27, 30, 33, 3, -29 },
  { 10365, 31, 40, 33, 0, -29 },
  { 10520, 29, 40, 33, 2, -29 },
  { 10665, 28, 28, 33, 5, -28 },
  { 10763, 28, 30, 33, 2, -29 },
  { 10868, 26, 39, 33, 4, -38 },
  { 10995, 28, 29, 33, 3, -28 },
  { 11097, 28, 30, 33, 2, -29 },
  { 11202, 31, 30, 33, 1, -29 },
  { 11319, 33, 30, 33, 0, -29 },
  { 11443, 30, 40, 33, 1, -28 },
  { 11593, 31, 30, 33, 1, -29 },
  { 11710, 26, 50, 33, 6, -42 },
  { 11873, 14, 50, 33, 10, -42 },
  { 11961, 26, 50, 33, 2, -42 },
  { 12124, 31, 13, 33, 1, -23 },
};

const GFXfont IBMPlexMono_SemiBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC55PT7B_H_
