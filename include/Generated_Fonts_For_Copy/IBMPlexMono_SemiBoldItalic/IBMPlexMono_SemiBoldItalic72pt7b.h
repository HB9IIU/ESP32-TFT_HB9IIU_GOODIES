#ifndef _IBMPLEXMONO_SEMIBOLDITALIC72PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x7F, 0xC0,
  0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F,
  0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8,
  0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE7, 0xEF, 0xFE, 0x01, 0xFF,
  0xC3, 0xF0, 0xFE, 0x00, 0xFF, 0x81, 0xF8, 0x3E, 0x00, 0xFF, 0xC0, 0xFC,
  0x0E, 0x00, 0x7F, 0xC0, 0xFC, 0x02, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xFC,
  0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0xE0,
  0x00, 0x00, 0xFF, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0xE0, 0x10, 0x03, 0xF0, 0x3F, 0xF0, 0x1C, 0x01, 0xF8, 0x1F,
  0xF0, 0x1F, 0x00, 0xFC, 0x1F, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xFC, 0x1F,
  0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0xFF, 0x3F, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0xC3,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x3F, 0x80, 0x00,
  0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x40, 0xFF,
  0x80, 0x1F, 0xF0, 0x0C, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xE7, 0xFE, 0x00,
  0x7F, 0xC0, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xEF, 0xF8, 0x01, 0xFF,
  0x87, 0xF9, 0xFF, 0x00, 0x6F, 0xF9, 0xFE, 0x3F, 0xF0, 0x1C, 0xFF, 0x3F,
  0xC7, 0xFF, 0x07, 0x9F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F,
  0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x40, 0x03, 0xFC, 0x00, 0x21, 0xE0,
  0x0F, 0xF0, 0x07, 0x8F, 0xF0, 0x3F, 0xC0, 0xFE, 0x3F, 0xF8, 0xFF, 0x1F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xF0,
  0x7F, 0xE3, 0xFF, 0xDF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x00, 0x7F, 0xDF, 0xF8, 0x1F, 0x80, 0xFF, 0xBF, 0xF0, 0x7F, 0x83, 0xFF,
  0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFE, 0x0F, 0xFD, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xEF, 0xFC, 0x1F, 0xE0, 0xFF,
  0xDF, 0xF8, 0x1F, 0x81, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7E, 0x01,
  0xFF, 0x80, 0x03, 0xC0, 0x1F, 0xF0, 0x00, 0x18, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x10,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x02, 0x00,
  0x00, 0x1F, 0xF8, 0x06, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0x00, 0x00, 0x3F,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xFE, 0x00, 0x03, 0xF8,
  0xFF, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0xFF,
  0xE0, 0x07, 0xF3, 0xFF, 0xFF, 0xE0, 0x07, 0xF7, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x60, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0x00, 0x00,
  0x3F, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x3F,
  0x80, 0x01, 0xFF, 0x8F, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xFE, 0x00, 0xFF,
  0x9F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0xFF,
  0x87, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xE3,
  0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xF8, 0x00,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xF3,
  0xFF, 0xE0, 0x3F, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xFE,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0x7F, 0xE0, 0x3F,
  0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xE1, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x9F, 0xF0, 0x00,
  0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xE3, 0xF8, 0x00, 0x1F, 0xF8, 0x78, 0x00,
  0x0F, 0xFC, 0x04, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xC3,
  0xFC, 0x01, 0xF8, 0x3F, 0x87, 0xF8, 0x0F, 0xFC, 0x7F, 0x1F, 0xE0, 0x3F,
  0xF9, 0xFE, 0x3F, 0xC0, 0xFF, 0xFB, 0xFC, 0x7F, 0x83, 0xFF, 0xF7, 0xF0,
  0xFE, 0x07, 0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xC1, 0xFC, 0x01, 0xFE,
  0x7F, 0x87, 0xF8, 0x03, 0xF8, 0xFF, 0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE3, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x7F,
  0x8F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x7F, 0x87,
  0xF8, 0x03, 0xF8, 0xFF, 0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x7F, 0x80, 0xFF, 0x8F, 0xE0,
  0xFF, 0x03, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xFC, 0x3F, 0x81, 0xFF, 0xFB,
  0xF8, 0x7F, 0x03, 0xFF, 0xF7, 0xF0, 0xFE, 0x07, 0xFF, 0xCF, 0xE1, 0xFC,
  0x07, 0xFF, 0xBF, 0xC3, 0xF8, 0x0F, 0xFE, 0x7F, 0x07, 0xF0, 0x0F, 0xF8,
  0xFE, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x40, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x01,
  0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xFE,
  0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x40, 0x1F, 0xE3, 0xFE, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x03,
  0xDF, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xFB, 0xFE, 0x01,
  0xFF, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8,
  0xFF, 0x00, 0x1F, 0xFF, 0xC3, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xE3, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xDF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC1, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x0F,
  0xEF, 0xF0, 0x0F, 0xF3, 0xF8, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xC7, 0xF3,
  0xFC, 0x03, 0xFC, 0xFE, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7, 0xF3, 0xF9, 0xFE,
  0x00, 0xFF, 0x3F, 0xFF, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0xFC, 0x7F, 0x80,
  0x7F, 0x87, 0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xFE, 0x3F, 0xE0, 0x1F,
  0xE1, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7E, 0x03,
  0xFC, 0x01, 0xFE, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x70, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x18, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x04, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x80,
  0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF7, 0xF8, 0x07,
  0xF8, 0x07, 0xFD, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x8F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x8F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x87, 0xFC,
  0x03, 0xFC, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x0F,
  0xE1, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x3F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0x07, 0xF3, 0xFC, 0x03,
  0xFE, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0x01,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x04, 0x00, 0x00, 0x7F, 0xC0, 0x1C, 0x00,
  0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x3C, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x03, 0xFE, 0x01, 0xFC,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x03,
  0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x3F, 0x81,
  0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xEF, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x7C,
  0x1F, 0xE0, 0x3F, 0xC3, 0xF3, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0x9F, 0x07,
  0xF0, 0x0F, 0xF0, 0xFC, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xC7, 0xC3, 0xFC,
  0x03, 0xF8, 0x7E, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3, 0xF3, 0xF0, 0xFE, 0x01,
  0xFE, 0x3F, 0x1F, 0x8F, 0xF0, 0x0F, 0xF1, 0xF8, 0xFC, 0x7F, 0x80, 0x7F,
  0x8F, 0xC7, 0xE3, 0xF8, 0x03, 0xFC, 0xFC, 0x3F, 0x1F, 0xC0, 0x1F, 0xE7,
  0xE1, 0xF8, 0xFE, 0x00, 0xFF, 0x3F, 0x0F, 0xCF, 0xF0, 0x07, 0xFB, 0xF0,
  0x7E, 0x7F, 0x80, 0x3F, 0x9F, 0x83, 0xF3, 0xF8, 0x01, 0xFC, 0xFC, 0x1F,
  0x9F, 0xC0, 0x0F, 0xEF, 0xC0, 0xFE, 0xFE, 0x00, 0xFF, 0x7E, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE7, 0xFE,
  0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x20, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x78, 0x0F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0x80, 0x20, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0x1F, 0xF0,
  0x1F, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x7F, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFE, 0x0F, 0xBF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFE,
  0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0xFE,
  0x00, 0xFF, 0x9F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xFF, 0xF0, 0x1F, 0xFB,
  0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0x03, 0xFF, 0x81, 0xFF, 0x78, 0x07, 0xFE,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xFF, 0xFF, 0x01, 0xFF,
  0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x07, 0xF4, 0x7F, 0xE0, 0x00, 0xF8, 0x0F,
  0xF8, 0x00, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x18,
  0x0F, 0xF8, 0x00, 0x03, 0xC1, 0xFF, 0x00, 0x00, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xC3, 0xFE, 0x00, 0x3F,
  0xFF, 0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x77, 0xFC, 0x01, 0xFF, 0xC0,
  0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x3F,
  0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x01, 0xFF, 0x00, 0x00,
  0x78, 0x3F, 0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0x00,
  0x7F, 0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFF,
  0xFB, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xBF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xBF, 0xE0, 0x0F, 0xFF, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x3F, 0xE0,
  0x07, 0xFF, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x04, 0x00, 0x01,
  0xFF, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0xFC, 0x07, 0xFC,
  0xFF, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0xFE, 0x07, 0xFD, 0xE0, 0xFF, 0xF0,
  0xFF, 0xFC, 0x03, 0xFF, 0x0F, 0xFB, 0x80, 0x3F, 0xF0, 0xFF, 0xF0, 0x01,
  0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0x00, 0x07, 0xFC, 0x00,
  0xE0, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x03,
  0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xFF,
  0xE7, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0xFF, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0x00,
  0xFF, 0xBF, 0xFF, 0xFE, 0x01, 0xFF, 0x78, 0x3F, 0xFC, 0x07, 0xFD, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFB, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x01, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x03, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x20, 0xFF, 0xC3, 0xFE, 0x00, 0xE1, 0xFF, 0x07, 0xFE, 0x03, 0xE3, 0xFE,
  0x07, 0xFC, 0x0F, 0xE7, 0xFC, 0x0F, 0xF8, 0x3F, 0xEF, 0xF8, 0x0F, 0xF8,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xF8, 0xFF,
  0x80, 0x3F, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x04, 0x00, 0x7F, 0xC0, 0x1C, 0x01, 0xFF, 0x00, 0x7E,
  0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x01,
  0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0x8F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xE7, 0xFF, 0x1F, 0xFF, 0x07, 0xFB, 0xFF, 0xC7,
  0xFF, 0xC1, 0xFE, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xD8, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xC3, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x87, 0xF0, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0xF0, 0x07, 0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xC0, 0x7F, 0xCF, 0xFF, 0xFE, 0x07, 0xFC,
  0xFF, 0xFF, 0xE0, 0x7F, 0xDE, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xB8, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x80,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFF, 0x8F,
  0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0xFF, 0x9F, 0xFF, 0xFC,
  0x01, 0xFF, 0xBF, 0xFF, 0xFE, 0x01, 0xFF, 0x7C, 0x0F, 0xFE, 0x01, 0xFF,
  0x78, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xF7,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFF,
  0x80, 0x1F, 0xF1, 0xFF, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xF0,
  0x07, 0xFF, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0xFF,
  0xCF, 0xF8, 0x0F, 0xFF, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00,
  0xFF, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0xEF, 0xF8, 0x1F, 0xFC, 0x0F, 0xBF, 0xE0, 0x7F, 0xFF,
  0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0x9F, 0xF0,
  0x07, 0xFF, 0xFC, 0x7F, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0x00, 0x1F, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xF7, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF,
  0xFE, 0x1F, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xFE, 0x00, 0x7F, 0xDF,
  0xFF, 0xC0, 0x07, 0xFD, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F,
  0x80, 0x7F, 0xC0, 0x00, 0x70, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x40, 0x00,
  0x0F, 0xF8, 0x0C, 0x00, 0x00, 0xFF, 0x81, 0xF0, 0x00, 0x0F, 0xF8, 0x3F,
  0x80, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x20, 0x00, 0xFF, 0x80, 0x06, 0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x03, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0xF0,
  0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0xDF, 0xF0, 0x7F, 0xF0, 0x0E, 0xFF, 0x81, 0xFF, 0xC1, 0xEF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xFF, 0x1F,
  0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC3, 0xFF, 0xFC, 0x00, 0x3E, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xFF,
  0x00, 0xFF, 0xC7, 0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0xFF, 0x80, 0x1F, 0xFB,
  0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xFF, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC,
  0x0F, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0xF0, 0x01, 0xFE, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE3, 0xFC, 0x07,
  0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x7F, 0x01,
  0xFE, 0x03, 0xF9, 0xFE, 0x03, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xE0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x01,
  0xFD, 0xFE, 0x03, 0xF8, 0x07, 0xFB, 0xF8, 0x07, 0xF0, 0x0F, 0xF7, 0xF0,
  0x0F, 0xE0, 0x1F, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x80,
  0x7F, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFC, 0x03, 0xFD, 0xFC,
  0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0,
  0x3F, 0x8F, 0xE0, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0x81, 0xFC, 0x3F,
  0x83, 0xFF, 0x03, 0xF8, 0x7F, 0x8F, 0x7E, 0x0F, 0xE0, 0xFF, 0xFE, 0xFE,
  0x3F, 0xC1, 0xFF, 0xF9, 0xFF, 0xFF, 0x03, 0xFF, 0xF3, 0xFF, 0xFC, 0x07,
  0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFB,
  0xFC, 0xF0, 0xFF, 0x1F, 0xFC, 0x7F, 0xBC, 0x1F, 0xE3, 0xFF, 0x07, 0xF7,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0xE0, 0x3F, 0x83, 0xE0, 0x1F, 0xF8, 0x07,
  0xF0, 0x70, 0x03, 0xFF, 0x00, 0xFE, 0x04, 0x00, 0x7F, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x1F, 0xF8, 0x01, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x70, 0x7F, 0x80, 0xFF,
  0xE0, 0x3F, 0x0F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0x7F, 0x83,
  0xFE, 0x3F, 0xC1, 0xE7, 0xF1, 0xFF, 0xE7, 0xFC, 0x7C, 0xFE, 0x7F, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x01, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFC,
  0x03, 0xBF, 0xE0, 0x0F, 0xFE, 0x0F, 0xBF, 0xE0, 0x0F, 0xFF, 0xFF, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x7F, 0xC0, 0x03,
  0xFF, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0xE0,
  0x7F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x3F,
  0x80, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x08, 0x00, 0x07, 0xFF,
  0x00, 0x70, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xF8,
  0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0x1F, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC7, 0xF8, 0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xFF,
  0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x1F, 0xFF, 0xFE, 0x01,
  0xFC, 0x1F, 0xE3, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0x3F,
  0x80, 0xFF, 0x87, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x7F, 0x00, 0x7F,
  0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xC0,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0E, 0x00,
  0x01, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 19, 51, 43, 13, -50 },
  { 123, 27, 22, 43, 12, -53 },
  { 198, 45, 50, 43, 0, -50 },
  { 480, 41, 66, 43, 1, -58 },
  { 819, 50, 52, 43, -2, -51 },
  { 1144, 43, 52, 43, 0, -51 },
  { 1424, 11, 22, 43, 20, -53 },
  { 1455, 30, 65, 43, 13, -55 },
  { 1699, 30, 65, 43, 2, -55 },
  { 1943, 38, 36, 43, 3, -40 },
  { 2114, 35, 35, 43, 5, -39 },
  { 2268, 20, 23, 43, 8, -12 },
  { 2326, 24, 8, 43, 10, -26 },
  { 2350, 14, 13, 43, 12, -12 },
  { 2373, 42, 65, 43, 1, -55 },
  { 2715, 39, 52, 43, 3, -51 },
  { 2969, 36, 50, 43, 3, -50 },
  { 3194, 40, 51, 43, 1, -51 },
  { 3449, 40, 52, 43, 1, -51 },
  { 3709, 40, 50, 43, 1, -50 },
  { 3959, 40, 51, 43, 2, -50 },
  { 4214, 37, 51, 43, 3, -50 },
  { 4450, 38, 50, 43, 6, -50 },
  { 4688, 40, 52, 43, 2, -51 },
  { 4948, 37, 51, 43, 5, -51 },
  { 5184, 19, 39, 43, 12, -38 },
  { 5277, 23, 49, 43, 8, -38 },
  { 5418, 35, 42, 43, 6, -43 },
  { 5602, 38, 22, 43, 3, -33 },
  { 5707, 36, 42, 43, 3, -43 },
  { 5896, 33, 52, 43, 8, -51 },
  { 6111, 39, 59, 43, 3, -51 },
  { 6399, 41, 50, 43, -2, -50 },
  { 6656, 38, 50, 43, 3, -50 },
  { 6894, 39, 52, 43, 4, -51 },
  { 7148, 40, 50, 43, 2, -50 },
  { 7398, 40, 50, 43, 3, -50 },
  { 7648, 41, 50, 43, 3, -50 },
  { 7905, 38, 52, 43, 4, -51 },
  { 8152, 42, 50, 43, 2, -50 },
  { 8415, 40, 50, 43, 3, -50 },
  { 8665, 38, 51, 43, 3, -50 },
  { 8908, 46, 50, 43, 2, -50 },
  { 9196, 33, 50, 43, 4, -50 },
  { 9403, 45, 50, 43, 0, -50 },
  { 9685, 42, 50, 43, 2, -50 },
  { 9948, 39, 52, 43, 3, -51 },
  { 10202, 40, 50, 43, 3, -50 },
  { 10452, 39, 66, 43, 3, -51 },
  { 10774, 40, 50, 43, 3, -50 },
  { 11024, 42, 52, 43, 1, -51 },
  { 11297, 41, 50, 43, 6, -50 },
  { 11554, 40, 51, 43, 4, -50 },
  { 11809, 40, 50, 43, 7, -50 },
  { 12059, 45, 50, 43, 2, -50 },
  { 12341, 49, 50, 43, -2, -50 },
  { 12648, 42, 50, 43, 6, -50 },
  { 12911, 44, 50, 43, 0, -50 },
  { 13186, 33, 65, 43, 9, -55 },
  { 13455, 20, 65, 43, 12, -55 },
  { 13618, 33, 65, 43, 2, -55 },
  { 13887, 38, 31, 43, 3, -50 },
  { 14035, 36, 7, 43, -1, 6 },
  { 14067, 13, 16, 43, 14, -57 },
  { 14093, 37, 39, 43, 3, -38 },
  { 14274, 38, 54, 43, 2, -53 },
  { 14531, 35, 39, 43, 4, -38 },
  { 14702, 41, 54, 43, 3, -53 },
  { 14979, 35, 39, 43, 4, -38 },
  { 15150, 49, 68, 43, -2, -53 },
  { 15567, 40, 53, 43, 1, -38 },
  { 15832, 36, 53, 43, 3, -53 },
  { 16071, 34, 55, 43, 5, -54 },
  { 16305, 37, 69, 43, 1, -54 },
  { 16625, 39, 54, 43, 3, -53 },
  { 16889, 31, 54, 43, 7, -53 },
  { 17099, 42, 38, 43, 0, -38 },
  { 17299, 36, 38, 43, 3, -38 },
  { 17470, 36, 39, 43, 4, -38 },
  { 17646, 40, 52, 43, 0, -38 },
  { 17906, 38, 52, 43, 3, -38 },
  { 18153, 36, 37, 43, 7, -37 },
  { 18320, 36, 39, 43, 3, -38 },
  { 18496, 35, 51, 43, 5, -50 },
  { 18720, 37, 38, 43, 4, -37 },
  { 18896, 37, 39, 43, 3, -38 },
  { 19077, 39, 39, 43, 2, -38 },
  { 19268, 43, 39, 43, 0, -38 },
  { 19478, 40, 52, 43, 1, -37 },
  { 19738, 39, 39, 43, 2, -38 },
  { 19929, 35, 65, 43, 7, -55 },
  { 20214, 19, 65, 43, 13, -55 },
  { 20369, 35, 65, 43, 2, -55 },
  { 20654, 40, 17, 43, 2, -31 },
};

const GFXfont IBMPlexMono_SemiBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic72pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC72PT7B_H_
