#ifndef _IBMPLEXMONO_SEMIBOLDITALIC46PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC3, 0xE7,
  0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F,
  0x3F, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x03, 0xFF, 0x0F,
  0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0xFF, 0x3D, 0xF8, 0x3F, 0x0E, 0x1C, 0x0F, 0xC7, 0x82, 0x07,
  0xE1, 0xE0, 0x01, 0xF8, 0x78, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0x87, 0x80,
  0x03, 0xF1, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0x9F, 0xC0, 0x01, 0xE3, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0x07, 0xC1, 0x01, 0xC3, 0xF0, 0xE0, 0xF0,
  0xFC, 0x7C, 0x3C, 0x7F, 0x3F, 0xCF, 0x7F, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xC0, 0x7F, 0xF0, 0x07, 0xC0, 0x7F, 0xF8, 0x07, 0xC0, 0x3E, 0x3E, 0x03,
  0xC0, 0x3E, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x83, 0xE0, 0x0F, 0x03, 0xC1,
  0xE0, 0x07, 0x81, 0xE1, 0xF0, 0x07, 0xC1, 0xF1, 0xF0, 0x03, 0xE0, 0xF8,
  0xF0, 0x00, 0xF0, 0x78, 0xF8, 0x00, 0x78, 0x7C, 0xF8, 0x00, 0x3F, 0xFC,
  0x78, 0x00, 0x0F, 0xFC, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x8F, 0xFE, 0x00, 0x07, 0x8F, 0xFF, 0x00, 0x07, 0xCF, 0x87, 0x80, 0x07,
  0xC7, 0x83, 0xE0, 0x03, 0xC3, 0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0xF8, 0x03,
  0xE1, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x3C, 0x01, 0xF0, 0x78, 0x1E, 0x01,
  0xF0, 0x3C, 0x1F, 0x00, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0x80,
  0xF8, 0x03, 0xFF, 0x80, 0x78, 0x00, 0xFF, 0x80, 0x40, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xF7, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xF7,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x9F, 0x80, 0xFC, 0x3F, 0xF0, 0x1F, 0x8F, 0xFE, 0x03, 0xF1, 0xF7,
  0xE0, 0xFF, 0x7C, 0xFE, 0x33, 0xFF, 0x1F, 0xFE, 0x7F, 0xE1, 0xFF, 0x87,
  0xF8, 0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x07, 0x80, 0x3E, 0x7D, 0xFB, 0xF7,
  0xCF, 0x9F, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x30, 0x3E, 0x03, 0x7E, 0x3E,
  0x1F, 0x7F, 0xBE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x1E, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC,
  0x3C, 0x3F, 0xFE, 0x3E, 0x3F, 0xFE, 0x1F, 0x1F, 0xFF, 0x1F, 0x8F, 0xDF,
  0x87, 0x87, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x3F,
  0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x03, 0xF8, 0x7E, 0x01, 0xE0, 0xFC,
  0x01, 0x81, 0xF8, 0x02, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x07, 0x80, 0x1F, 0x80,
  0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0x00,
  0xFE, 0x07, 0x00, 0x3F, 0x01, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x08, 0x00, 0x3F,
  0x0E, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0xCF, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xE3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x9F, 0xF8, 0x03, 0xCF, 0xFF, 0x01, 0xF7, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x08, 0x00, 0x7F, 0x0F, 0x00, 0x1F, 0x87, 0xE0,
  0x0F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F,
  0xF0, 0x3F, 0x7F, 0xF8, 0x3F, 0x7F, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F, 0xC1,
  0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0xF8, 0x00,
  0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80,
  0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0x80,
  0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0xFE,
  0xFC, 0x3F, 0xFC, 0xFC, 0x1F, 0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF8, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0x18, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x03, 0xC7, 0xCF, 0x83, 0xFB, 0xE7,
  0xC3, 0xFD, 0xF3, 0xC3, 0xFE, 0xF3, 0xE3, 0xF1, 0xF9, 0xF1, 0xF0, 0x7C,
  0xF8, 0xF8, 0x3E, 0x7C, 0xF8, 0x1F, 0x3C, 0x7C, 0x0F, 0xBE, 0x3E, 0x07,
  0x9F, 0x1F, 0x03, 0xCF, 0x8F, 0x83, 0xE7, 0xC7, 0xC1, 0xF3, 0xE3, 0xC0,
  0xF9, 0xF1, 0xE0, 0xFC, 0xF0, 0xF8, 0x7C, 0x78, 0x7E, 0xDE, 0x3C, 0x3F,
  0xEF, 0x1E, 0x0F, 0xEF, 0x8F, 0x83, 0xE7, 0xC7, 0xC0, 0x40, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E,
  0x00, 0xFC, 0x7C, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x1F, 0x3F,
  0x00, 0x1C, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x40, 0xFC, 0x00, 0x78, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFE, 0x3F,
  0x01, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x83,
  0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0,
  0x0E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xFF, 0x3F,
  0x07, 0xFF, 0x3F, 0x83, 0xFF, 0x9F, 0xC1, 0xFF, 0xCF, 0xE0, 0xFF, 0xE7,
  0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C,
  0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x3F,
  0xC1, 0xFF, 0xF7, 0xC0, 0xFF, 0xFB, 0xE0, 0x3F, 0xF9, 0xF0, 0x0F, 0xF8,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x08, 0x01, 0xF8, 0xF8, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81,
  0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x07,
  0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xCF, 0xC0,
  0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFE, 0x0F, 0xBC, 0x7F, 0xE0, 0x7D, 0xF3, 0xDF, 0x03, 0xEF, 0xBE, 0xF8,
  0x1F, 0x7F, 0xE7, 0xC0, 0xF9, 0xFF, 0x3E, 0x0F, 0x8F, 0xF3, 0xF0, 0x7C,
  0x7F, 0x1F, 0x03, 0xE3, 0xF8, 0xF8, 0x1F, 0x1F, 0x87, 0xC0, 0xF8, 0x7C,
  0x3E, 0x07, 0xC3, 0xC3, 0xF0, 0x7E, 0x1E, 0x1F, 0x83, 0xE0, 0xE0, 0xF8,
  0x1F, 0x03, 0x07, 0xC0, 0xF8, 0x10, 0x3E, 0x07, 0xC1, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xE0, 0xFF, 0x00, 0xFC, 0x1F,
  0xE0, 0x1F, 0x03, 0xFE, 0x03, 0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0xF8, 0x0F,
  0x83, 0xFF, 0x01, 0xF0, 0x7F, 0xE0, 0x7E, 0x0F, 0xFE, 0x0F, 0x81, 0xF7,
  0xC1, 0xF0, 0x3E, 0xF8, 0x3E, 0x07, 0xDF, 0x07, 0xC1, 0xFB, 0xE0, 0xF8,
  0x3E, 0x3E, 0x3F, 0x07, 0xC7, 0xC7, 0xC0, 0xF8, 0xF8, 0xF8, 0x1F, 0x1F,
  0x1F, 0x03, 0xE3, 0xE3, 0xE0, 0xFC, 0x3C, 0x7C, 0x1F, 0x07, 0xDF, 0x83,
  0xE0, 0xFB, 0xE0, 0x7C, 0x1F, 0x7C, 0x0F, 0x83, 0xEF, 0x81, 0xF0, 0x3F,
  0xF0, 0x7E, 0x07, 0xFE, 0x0F, 0x80, 0xFF, 0xC1, 0xF0, 0x1F, 0xF0, 0x3E,
  0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xC0, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0xFF,
  0x07, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03,
  0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x7F, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E,
  0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0x83, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07,
  0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0xFF, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7E, 0x02, 0x00, 0x1F, 0x83, 0x80, 0x07, 0xE3, 0xE0,
  0x03, 0xF3, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E,
  0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8,
  0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0xF8,
  0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0x00, 0xF0, 0x3F, 0x00,
  0x18, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x04, 0x00, 0x0F, 0xC3,
  0x80, 0x07, 0xE1, 0xF0, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC7, 0xC1, 0xF8, 0x7C, 0x3E, 0x0F, 0xC3, 0xE1, 0xF0,
  0xFE, 0x1F, 0x0F, 0x87, 0xF0, 0xF8, 0x7C, 0x3F, 0x87, 0x83, 0xE3, 0xFC,
  0x7C, 0x1F, 0x1F, 0xE3, 0xE0, 0xF8, 0xEF, 0x1F, 0x07, 0xCF, 0x78, 0xF0,
  0x3C, 0x7B, 0xCF, 0x83, 0xE3, 0x9E, 0x7C, 0x1F, 0x3C, 0xF3, 0xE0, 0xF9,
  0xE7, 0x9F, 0x07, 0xCE, 0x3C, 0xF0, 0x3E, 0xF1, 0xEF, 0x81, 0xF7, 0x8F,
  0x7C, 0x0F, 0xB8, 0x7B, 0xE0, 0x7F, 0xC3, 0xDE, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F,
  0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0xFE,
  0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xBF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF0, 0x01, 0xF9, 0xF0, 0x01, 0xF9,
  0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0x7C, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x38, 0x00, 0x1E, 0x08, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x18, 0x7C, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E, 0x1F, 0x0F, 0x0C, 0x00, 0xFC,
  0x3F, 0x03, 0xFE, 0x3E, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0xFE, 0x1F, 0xC1,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0x7E, 0x1D,
  0xFE, 0x7F, 0xF9, 0xFE, 0x3F, 0xF9, 0xFE, 0x3F, 0xE0, 0xFE, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x01,
  0xF8, 0xFF, 0x80, 0xFC, 0xFF, 0xE0, 0x7E, 0xFF, 0xF8, 0x3E, 0xE1, 0xFC,
  0x3F, 0x60, 0x7E, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xCF, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7E, 0xFF, 0xF0, 0x7E, 0x3F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xFF, 0xFE, 0x1F, 0xC1, 0xF8, 0xFE, 0x03, 0xF3, 0xF0, 0x06, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x63, 0xF0, 0x03, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0xFC, 0x7F, 0x07,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xFC, 0xFC, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xEF, 0xC1, 0xFC, 0x1F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0xDF, 0x81, 0xFF, 0xF7, 0xE0, 0x3F, 0xF9, 0xF0, 0x0F,
  0xFC, 0x7C, 0x00, 0xFC, 0x20, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0xFE, 0x03, 0xF3, 0xF0,
  0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x0F, 0xEF, 0xC1, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x43, 0xF0, 0x01, 0xCF, 0xC0, 0x0F, 0x9F, 0x80,
  0x7E, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x20,
  0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0xFF, 0xCF,
  0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB, 0xF0, 0xFE, 0x0F, 0xF8, 0xFE, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F,
  0x00, 0xFE, 0x1F, 0xC0, 0xDF, 0x07, 0xF0, 0xFF, 0x83, 0xFF, 0xEF, 0xC0,
  0xFF, 0xE7, 0xE0, 0x3F, 0xE3, 0xF0, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0x00, 0x7F,
  0x03, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0x80, 0xFC, 0x7F, 0xC1, 0xF9, 0xFF, 0xC3, 0xF7, 0xFF, 0x87, 0xFC, 0x3F,
  0x8F, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xE0,
  0x07, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xC0, 0x3F, 0x07, 0xC0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x20, 0x3F, 0x00,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x03, 0xF1, 0xFF, 0x01, 0xF9, 0xFF,
  0xC0, 0xFD, 0xFF, 0xF0, 0x7F, 0xC3, 0xF8, 0x3E, 0xC0, 0xFC, 0x1F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xFC, 0x7F, 0x80, 0x7E,
  0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x87, 0xC0, 0xC7,
  0xC3, 0xF0, 0xF7, 0xE1, 0xF8, 0xFF, 0xF0, 0x7E, 0xF9, 0xF8, 0x3F, 0xF8,
  0xFC, 0x0F, 0xF8, 0x7E, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0xC0, 0xFC, 0x1E, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF9,
  0xF8, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0x0F, 0x9E, 0x07, 0x83, 0xE7, 0xE3, 0xF8, 0x7D, 0xFE, 0xFF,
  0x8F, 0xBF, 0xDF, 0xF1, 0xF8, 0xFE, 0x3E, 0x3E, 0x1F, 0x87, 0xC7, 0xC3,
  0xF0, 0xF9, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F, 0x83, 0xC7, 0xC1, 0xF0, 0xF8,
  0xF8, 0x3C, 0x1F, 0x1F, 0x0F, 0x83, 0xE3, 0xC1, 0xF0, 0x7C, 0xF8, 0x3E,
  0x0F, 0x9F, 0x07, 0xC1, 0xE3, 0xE0, 0xF8, 0x7C, 0x7C, 0x1E, 0x0F, 0x8F,
  0x87, 0xC1, 0xF1, 0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x07, 0xCF, 0x83, 0xE0,
  0xF1, 0xF0, 0x7C, 0x3E, 0x3E, 0x0F, 0x07, 0xC7, 0xC3, 0xE0, 0xF8, 0x1F,
  0x83, 0xE0, 0x3F, 0x1F, 0xF0, 0x7E, 0x7F, 0xF0, 0xFD, 0xFF, 0xE1, 0xFF,
  0x0F, 0xE3, 0xFC, 0x0F, 0xCF, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xF9,
  0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x01,
  0xF8, 0xFF, 0x80, 0x7E, 0x7F, 0xF0, 0x1F, 0xBF, 0xFE, 0x07, 0xDC, 0x3F,
  0x83, 0xF6, 0x07, 0xE0, 0xFF, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x01,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xF7, 0xFF, 0x81, 0xF8,
  0xFF, 0xC0, 0x7E, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x03,
  0xFF, 0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xBF, 0x1F, 0xC1, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x0D, 0xF8, 0x7F,
  0xFD, 0xF8, 0x3F, 0xF9, 0xF0, 0x3F, 0xF1, 0xF0, 0x0F, 0xC3, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0x07, 0xEF,
  0xFC, 0x1F, 0xB0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x07, 0x07, 0xE0,
  0x04, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x40, 0x07, 0xE1,
  0xC0, 0x0F, 0xCF, 0xE0, 0x7F, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0C, 0x0F,
  0xC0, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xDF,
  0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0x8F, 0xE1, 0xBF,
  0x1F, 0xFE, 0x7C, 0x1F, 0xFD, 0xF8, 0x1F, 0xF3, 0xF0, 0x1F, 0x80, 0x00,
  0x7F, 0xE0, 0x0C, 0xFF, 0xC0, 0xFB, 0xFF, 0x03, 0xF7, 0xFE, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x01,
  0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xF3, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x0F, 0x83, 0x0F, 0x07, 0xC7, 0xC7, 0x83, 0xE3, 0xE7, 0xC1, 0xE1,
  0xF3, 0xE0, 0xF0, 0xF9, 0xF0, 0x78, 0x3C, 0xF8, 0x7C, 0x1E, 0x78, 0x3E,
  0x0F, 0x3C, 0x1F, 0x07, 0xBE, 0x0F, 0x83, 0xDF, 0x07, 0x81, 0xEF, 0x83,
  0xC1, 0xF7, 0xC3, 0xE0, 0xFB, 0xC1, 0xF0, 0x7D, 0xE0, 0xF8, 0x3F, 0xF0,
  0x7C, 0x1E, 0xF8, 0x3E, 0x0F, 0x7C, 0x1E, 0x0F, 0xBE, 0x1F, 0x07, 0x9F,
  0x0F, 0x87, 0xCF, 0x8F, 0xC3, 0xC7, 0xFC, 0xF3, 0xC3, 0xFE, 0x7F, 0xC0,
  0xFE, 0x3F, 0xC0, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x1F,
  0xE1, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0xE7, 0xFE, 0x3F, 0xDF, 0x73,
  0xF3, 0xF1, 0xF6, 0x1F, 0x1E, 0x1F, 0xC1, 0xF1, 0x81, 0xFC, 0x1F, 0x00,
  0x1F, 0xC1, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x38, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x30, 0xF8, 0x6F,
  0x07, 0x8F, 0x86, 0xF1, 0xFC, 0xF8, 0xEF, 0xBF, 0x8F, 0xFC, 0xFF, 0xF0,
  0x7F, 0xC7, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0x1E, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFF, 0x07, 0xF0,
  0xDF, 0x83, 0xFF, 0xEF, 0xC0, 0xFF, 0xE7, 0xC0, 0x3F, 0xE3, 0xE0, 0x07,
  0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x03, 0x00, 0x7E, 0x03, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x0F, 0x81, 0xFF, 0xC7, 0xC1, 0xFF, 0xF3, 0xE1, 0xFF, 0xFF, 0xF1, 0xF8,
  0x7F, 0xF8, 0xF8, 0x0F, 0xF8, 0x7C, 0x03, 0xF8, 0x3C, 0x03, 0xF8, 0x1E,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x30, 0x07, 0xF0, 0x7C,
  0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x0F, 0x07, 0xF0, 0x07, 0xC7, 0xFE, 0x03,
  0xE7, 0xFF, 0xF8, 0xF3, 0xE7, 0xFF, 0xF1, 0xF0, 0xFF, 0xF9, 0xF0, 0x0F,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xE0,
  0x07, 0x01, 0xFE, 0x01, 0xF0, 0xFF, 0xC0, 0x78, 0x7F, 0xF0, 0x1E, 0x3E,
  0x3E, 0x0F, 0x8F, 0x0F, 0xC3, 0xC7, 0xC1, 0xF1, 0xF1, 0xE0, 0x3F, 0xF8,
  0x78, 0x0F, 0xFC, 0x3E, 0x01, 0xFE, 0x03, 0x80, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 12, 33, 28, 8, -32 },
  { 51, 17, 14, 28, 8, -34 },
  { 81, 29, 32, 28, 0, -32 },
  { 197, 26, 44, 28, 1, -38 },
  { 340, 33, 34, 28, -2, -33 },
  { 481, 27, 34, 28, 0, -33 },
  { 596, 7, 14, 28, 13, -34 },
  { 609, 19, 41, 28, 8, -35 },
  { 707, 19, 41, 28, 1, -35 },
  { 805, 24, 23, 28, 2, -25 },
  { 874, 22, 22, 28, 3, -25 },
  { 935, 13, 14, 28, 5, -7 },
  { 958, 15, 5, 28, 7, -17 },
  { 968, 9, 8, 28, 8, -7 },
  { 977, 27, 41, 28, 0, -35 },
  { 1116, 25, 34, 28, 2, -33 },
  { 1223, 23, 32, 28, 2, -32 },
  { 1315, 25, 33, 28, 1, -33 },
  { 1419, 25, 34, 28, 1, -33 },
  { 1526, 26, 32, 28, 0, -32 },
  { 1630, 26, 33, 28, 1, -32 },
  { 1738, 24, 33, 28, 2, -32 },
  { 1837, 24, 32, 28, 4, -32 },
  { 1933, 26, 34, 28, 1, -33 },
  { 2044, 24, 33, 28, 3, -33 },
  { 2143, 12, 24, 28, 8, -23 },
  { 2179, 15, 30, 28, 5, -23 },
  { 2236, 22, 27, 28, 4, -28 },
  { 2311, 24, 14, 28, 2, -21 },
  { 2353, 23, 27, 28, 2, -28 },
  { 2431, 21, 34, 28, 5, -33 },
  { 2521, 25, 38, 28, 2, -33 },
  { 2640, 26, 32, 28, -1, -32 },
  { 2744, 24, 32, 28, 2, -32 },
  { 2840, 24, 34, 28, 3, -33 },
  { 2942, 25, 32, 28, 2, -32 },
  { 3042, 25, 32, 28, 2, -32 },
  { 3142, 26, 32, 28, 2, -32 },
  { 3246, 25, 34, 28, 2, -33 },
  { 3353, 27, 32, 28, 1, -32 },
  { 3461, 25, 32, 28, 2, -32 },
  { 3561, 24, 33, 28, 2, -32 },
  { 3660, 29, 32, 28, 1, -32 },
  { 3776, 21, 32, 28, 3, -32 },
  { 3860, 29, 32, 28, 0, -32 },
  { 3976, 27, 32, 28, 1, -32 },
  { 4084, 25, 34, 28, 2, -33 },
  { 4191, 25, 32, 28, 2, -32 },
  { 4291, 25, 42, 28, 2, -33 },
  { 4423, 25, 32, 28, 2, -32 },
  { 4523, 26, 34, 28, 1, -33 },
  { 4634, 26, 32, 28, 4, -32 },
  { 4738, 25, 33, 28, 3, -32 },
  { 4842, 26, 32, 28, 4, -32 },
  { 4946, 29, 32, 28, 1, -32 },
  { 5062, 31, 32, 28, -1, -32 },
  { 5186, 27, 32, 28, 4, -32 },
  { 5294, 28, 32, 28, 0, -32 },
  { 5406, 21, 41, 28, 6, -35 },
  { 5514, 13, 41, 28, 8, -35 },
  { 5581, 21, 41, 28, 1, -35 },
  { 5689, 24, 20, 28, 2, -32 },
  { 5749, 22, 4, 28, 0, 4 },
  { 5760, 8, 10, 28, 9, -36 },
  { 5770, 24, 25, 28, 2, -24 },
  { 5845, 25, 35, 28, 1, -34 },
  { 5955, 22, 25, 28, 3, -24 },
  { 6024, 26, 35, 28, 2, -34 },
  { 6138, 22, 25, 28, 3, -24 },
  { 6207, 31, 44, 28, -1, -34 },
  { 6378, 25, 34, 28, 1, -24 },
  { 6485, 23, 34, 28, 2, -34 },
  { 6583, 22, 36, 28, 3, -35 },
  { 6682, 23, 45, 28, 1, -35 },
  { 6812, 25, 35, 28, 2, -34 },
  { 6922, 20, 35, 28, 4, -34 },
  { 7010, 27, 24, 28, 0, -24 },
  { 7091, 23, 24, 28, 2, -24 },
  { 7160, 23, 25, 28, 2, -24 },
  { 7232, 26, 33, 28, 0, -24 },
  { 7340, 24, 33, 28, 2, -24 },
  { 7439, 22, 24, 28, 5, -24 },
  { 7505, 23, 25, 28, 2, -24 },
  { 7577, 22, 33, 28, 3, -32 },
  { 7668, 23, 25, 28, 3, -24 },
  { 7740, 23, 25, 28, 2, -24 },
  { 7812, 25, 25, 28, 1, -24 },
  { 7891, 28, 25, 28, 0, -24 },
  { 7979, 25, 34, 28, 1, -24 },
  { 8086, 25, 25, 28, 1, -24 },
  { 8165, 22, 41, 28, 5, -35 },
  { 8278, 12, 41, 28, 8, -35 },
  { 8340, 23, 41, 28, 1, -35 },
  { 8458, 26, 11, 28, 1, -19 },
};

const GFXfont IBMPlexMono_SemiBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC46PT7B_H_
