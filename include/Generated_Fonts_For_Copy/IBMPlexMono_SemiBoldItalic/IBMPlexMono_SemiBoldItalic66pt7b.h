#ifndef _IBMPLEXMONO_SEMIBOLDITALIC66PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81,
  0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0xFD, 0xFF,
  0x80, 0xFF, 0xC3, 0xE1, 0xFC, 0x03, 0xFE, 0x0F, 0x83, 0xE0, 0x0F, 0xF0,
  0x3E, 0x03, 0x00, 0x7F, 0xC0, 0xF8, 0x08, 0x01, 0xFE, 0x07, 0xE0, 0x00,
  0x07, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x00, 0x7F, 0xC1,
  0xF0, 0x00, 0x01, 0xFF, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0x00,
  0x0F, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x7F, 0xE0, 0x00, 0x03, 0xF0,
  0xFF, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x00, 0x3E, 0x07, 0xFC, 0x00,
  0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x40, 0x0F, 0x81,
  0xFE, 0x01, 0x80, 0x7E, 0x07, 0xF8, 0x1E, 0x01, 0xF8, 0x3F, 0xE0, 0xFE,
  0x07, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0x0F, 0xFC, 0x3F, 0xFE, 0x7C, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC,
  0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1,
  0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC7, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xE3, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xF8, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x00, 0x7F,
  0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x87, 0xFC,
  0x01, 0xFF, 0x03, 0xCF, 0xF8, 0x01, 0xFE, 0x07, 0xEF, 0xF0, 0x07, 0xFC,
  0x1F, 0xDF, 0xE0, 0x0F, 0xFC, 0x7F, 0x3F, 0xE0, 0x3F, 0xF8, 0xFE, 0x7F,
  0xE1, 0xE7, 0xFB, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x20, 0x01,
  0xFC, 0x00, 0x43, 0x80, 0x3F, 0x80, 0x38, 0xFE, 0x0F, 0xF0, 0x3F, 0x1F,
  0xF1, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x0F, 0xE0, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0x9F, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0xF8, 0x1F, 0xF7,
  0xFC, 0x3F, 0xC1, 0xFE, 0xFF, 0xC3, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xC3,
  0xFE, 0xFF, 0x83, 0xFC, 0x3F, 0xEF, 0xF8, 0x7F, 0xC3, 0xFE, 0xFF, 0x83,
  0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xC7, 0xF8, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xC1, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x07,
  0xC0, 0x3F, 0xE0, 0x01, 0xC0, 0x1F, 0xF0, 0x00, 0x60, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0x80,
  0x0C, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xC0,
  0x1E, 0x00, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x04, 0x00, 0x00, 0xFF, 0x80,
  0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xFF, 0x80, 0x01, 0xFC, 0x7F,
  0xFF, 0x00, 0x0F, 0xCF, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0xF0, 0x07,
  0xF7, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x80, 0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x01, 0xFF, 0x01, 0xF0, 0x00, 0x1F,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x03, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0x3F, 0xFF, 0x80, 0x7F, 0xDF, 0xFF,
  0xF8, 0x3F, 0xEF, 0xFF, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xC3, 0xFD, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x00, 0xFF,
  0x87, 0xF0, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x01,
  0xFF, 0x04, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFE,
  0x7F, 0xC0, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFC, 0x3F, 0xE0, 0x03, 0xF8,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xC7, 0xC0, 0x01, 0xFF, 0x06, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF8, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x3E, 0x0F, 0xC7, 0xF0,
  0x1F, 0xF1, 0xF8, 0xFE, 0x07, 0xFF, 0x3F, 0x3F, 0x81, 0xFF, 0xEF, 0xE7,
  0xF0, 0x7F, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xFF, 0x9F, 0xC3, 0xFE, 0x1F,
  0xF7, 0xF0, 0x7F, 0x81, 0xFC, 0xFE, 0x0F, 0xE0, 0x3F, 0x9F, 0xC3, 0xF8,
  0x03, 0xF3, 0xF8, 0x7F, 0x00, 0xFE, 0x7F, 0x0F, 0xE0, 0x1F, 0xCF, 0xE3,
  0xFC, 0x03, 0xFB, 0xF8, 0x7F, 0x00, 0x7E, 0x7F, 0x0F, 0xE0, 0x0F, 0xCF,
  0xE1, 0xFC, 0x01, 0xF9, 0xFC, 0x3F, 0x80, 0x7F, 0x3F, 0x87, 0xF0, 0x0F,
  0xE7, 0xF0, 0xFE, 0x01, 0xFC, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0x83, 0xF8,
  0x1F, 0xE3, 0xF0, 0x7F, 0x03, 0xFC, 0x7E, 0x0F, 0xF1, 0xFF, 0x8F, 0xC0,
  0xFF, 0xFF, 0xF1, 0xF8, 0x1F, 0xFE, 0xFE, 0x3F, 0x03, 0xFF, 0x9F, 0x87,
  0xE0, 0x3F, 0xF3, 0xF0, 0xFE, 0x03, 0xFC, 0x7E, 0x1F, 0xC0, 0x1C, 0x10,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3E, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xF3, 0xFE, 0x03, 0xFF,
  0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0xF3, 0xFF, 0x01,
  0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xF9, 0xFF,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x03, 0xF8,
  0xFF, 0x80, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x03, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xF7, 0xF8,
  0x0F, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0x1F, 0xC0, 0x0F, 0xFF, 0xC7,
  0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x60,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xF0,
  0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0x9F, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0x7E, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x87,
  0xEF, 0xE0, 0x1F, 0xDF, 0xC7, 0xF7, 0xF0, 0x0F, 0xEF, 0xE3, 0xF3, 0xF8,
  0x0F, 0xF3, 0xF3, 0xF9, 0xFC, 0x07, 0xF9, 0xFB, 0xF9, 0xFE, 0x03, 0xF8,
  0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0x81,
  0xFE, 0x03, 0xFC, 0x0F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x30, 0x0F, 0xF0, 0x1F, 0xE0, 0x18, 0x07,
  0xF8, 0x0F, 0xF0, 0x08, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x00, 0xFE, 0x01, 0xFF,
  0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0xFC, 0x01, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xE0,
  0x3F, 0xCF, 0xE0, 0x3F, 0x80, 0xFF, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x7F,
  0x07, 0xF8, 0x0F, 0xE1, 0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x7F, 0x00,
  0xFE, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE,
  0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0xFF, 0x01, 0xFC, 0x0F, 0xE3, 0xFC, 0x07,
  0xF0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0xFE, 0x03, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F,
  0x80, 0x7F, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xFF,
  0x80, 0x7F, 0x00, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xF0,
  0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xF0, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x20, 0x00, 0x0F, 0xF0,
  0x07, 0x00, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x01,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x00, 0x1C, 0x00, 0xFF,
  0x80, 0x00, 0x20, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x01, 0x00, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0x00,
  0x7F, 0xC0, 0x78, 0x00, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xE7,
  0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0x07, 0xF0, 0x1F,
  0xC1, 0xF7, 0xC3, 0xF8, 0x07, 0xF0, 0xFD, 0xF0, 0xFE, 0x01, 0xFC, 0x3E,
  0x7C, 0x3F, 0x80, 0x7F, 0x0F, 0x9F, 0x0F, 0xE0, 0x1F, 0xC7, 0xE7, 0xC3,
  0xF0, 0x0F, 0xF1, 0xF1, 0xF1, 0xFC, 0x03, 0xF8, 0x7C, 0x7C, 0x7F, 0x00,
  0xFE, 0x3F, 0x1F, 0x1F, 0xC0, 0x3F, 0x8F, 0x8F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xE3, 0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0xFC, 0xFE, 0x00, 0xFE, 0x7C, 0x3F,
  0x3F, 0x80, 0x3F, 0x9F, 0x0F, 0xCF, 0xE0, 0x0F, 0xEF, 0xC3, 0xF3, 0xF0,
  0x03, 0xFB, 0xE0, 0xFD, 0xFC, 0x01, 0xFC, 0xF8, 0x3F, 0x7F, 0x00, 0x7F,
  0x7E, 0x0F, 0xDF, 0xC0, 0x1F, 0xDF, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x08, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x07, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF8, 0x02, 0x00, 0xE0, 0x3F, 0x0F, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3C,
  0x03, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFF, 0xC7, 0xFC, 0x0F, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xFE, 0x7F, 0x81,
  0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFE,
  0x1F, 0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0xFF,
  0xF0, 0xFF, 0xC0, 0x77, 0xF8, 0x1F, 0xF8, 0x3D, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xF8, 0xFF, 0xFF, 0x9F, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0xE0, 0x07, 0xFC, 0x7F,
  0xFE, 0x00, 0xFF, 0x9F, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF, 0xFE, 0x03, 0xFC,
  0xFF, 0xFF, 0xC0, 0x7F, 0xBC, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x83,
  0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xF0, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFB, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xF0, 0x3F, 0xE7, 0xFF, 0xFC,
  0x07, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xC0, 0xFF, 0x80, 0x02, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x7F, 0xC0, 0x00, 0x30, 0xFF,
  0x80, 0x00, 0xF9, 0xFF, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xF8,
  0x00, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFF,
  0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xF0, 0x0E, 0xFF, 0x00, 0xFF, 0xC1, 0xF7, 0xF8, 0x07, 0xFF, 0xFF,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF3, 0xFC, 0x00, 0xFF, 0xFF, 0x9F, 0xE0, 0x03,
  0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80,
  0x1F, 0xFE, 0x7F, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x60, 0xFF, 0x80, 0x00, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x7F, 0xC0, 0x0F, 0xFF, 0xE3, 0xFC, 0x00,
  0xFF, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1D, 0xFE, 0x01, 0xFF, 0x83, 0xEF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xFF, 0x3F,
  0xE0, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0x00, 0x00,
  0xFF, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0xF0, 0x03, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0x1F, 0xFF,
  0xC0, 0x7F, 0xCF, 0xFF, 0xF8, 0x1F, 0xF7, 0xFF, 0xFE, 0x07, 0xF9, 0xC1,
  0xFF, 0x81, 0xFE, 0xE0, 0x3F, 0xE0, 0x7F, 0xB0, 0x07, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x80, 0x07, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x0F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x10, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x03,
  0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xC7, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xFF,
  0x80, 0x7F, 0x9F, 0xFF, 0xF8, 0x07, 0xFB, 0xC1, 0xFF, 0xC0, 0x7F, 0xB8,
  0x07, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xE7, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFE, 0x3F,
  0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0x83, 0xFC, 0x1F, 0xE0, 0x3E, 0x3F,
  0xC1, 0xFF, 0x07, 0xF3, 0xFC, 0x0F, 0xF0, 0xFF, 0x7F, 0xC0, 0xFF, 0x1F,
  0xE7, 0xFC, 0x0F, 0xFB, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0x87, 0xF8, 0x07,
  0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x60, 0x0F, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0x7F, 0x03, 0xFC,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xE3, 0xFC, 0x1F, 0xF0, 0x1F, 0xCF, 0xFC, 0x7F,
  0xF0, 0x3F, 0xBF, 0xF9, 0xFF, 0xE0, 0x7F, 0x7F, 0xF3, 0xFF, 0xC0, 0xFD,
  0xFF, 0xEF, 0xFF, 0xC3, 0xFB, 0x1F, 0xDC, 0x7F, 0x87, 0xFC, 0x3F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xC3,
  0xFF, 0xE0, 0x0F, 0xF1, 0xFF, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0x81, 0xFF,
  0x7F, 0xFF, 0xE0, 0x7F, 0x9C, 0x1F, 0xF8, 0x1F, 0xEE, 0x03, 0xFE, 0x07,
  0xFB, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC,
  0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xC7, 0xFF,
  0xE0, 0x03, 0xFE, 0x7F, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xFE, 0x00, 0xFF,
  0x3F, 0xFF, 0xF0, 0x07, 0xFB, 0xC1, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFC, 0x03, 0xFD,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xFF, 0xFC, 0x01, 0xFF, 0x1F, 0xFF, 0xC0,
  0x0F, 0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x87, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F,
  0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xBF, 0xC0,
  0xFF, 0xC1, 0xF7, 0xF8, 0x1F, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0x3F,
  0xC0, 0x3F, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xFC,
  0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0x3F, 0xFE, 0x00,
  0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0x78, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7C, 0x0F,
  0xF8, 0x00, 0x38, 0x0F, 0xF0, 0x00, 0x10, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x03, 0xFC, 0x0C,
  0x00, 0x03, 0xFC, 0x1E, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x20, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x3C, 0x00,
  0x7F, 0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8,
  0x7F, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x0D, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFC, 0x1E, 0xFF, 0x83, 0xFF, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0x3F,
  0xC0, 0x7F, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0x0F,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x3F, 0xFF,
  0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF,
  0xE0, 0x0F, 0xF7, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x07,
  0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8,
  0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F,
  0xFC, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x3F, 0x01, 0xFC, 0x1F, 0x03, 0xF8, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x1F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F,
  0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE0, 0x3F, 0x8F,
  0xC0, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC0,
  0x7F, 0x3F, 0x80, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xE0, 0x1F, 0x8F, 0xE0, 0x3F,
  0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0xFF, 0x83,
  0xF8, 0x7F, 0x8E, 0xFC, 0x1F, 0x81, 0xFF, 0xF7, 0xF1, 0xF8, 0x0F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x7F, 0xFE, 0x07,
  0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFC, 0xFC, 0xF8, 0xFF, 0x3F, 0xF8, 0xFE,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0xE0, 0x7F, 0x0F, 0xC0, 0xFF, 0xC0, 0x7F,
  0x07, 0x00, 0xFF, 0xC0, 0x7F, 0x06, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0xFF, 0x80, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x03,
  0xFF, 0x00, 0x60, 0xFE, 0x03, 0x7F, 0x01, 0xE0, 0xFE, 0x07, 0x7F, 0x03,
  0xF0, 0xFE, 0x07, 0x7F, 0x0F, 0xF8, 0xFE, 0x0F, 0x7F, 0x1F, 0xF8, 0xFF,
  0x1E, 0x7F, 0x7F, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x6F, 0xF0, 0x1F, 0xF0, 0x0E, 0xFF, 0x01,
  0xFF, 0xC3, 0xDF, 0xF0, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x9F,
  0xE0, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xE0, 0x01, 0xFF,
  0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x08, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x1E, 0x00,
  0x1F, 0xF0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xFE,
  0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xE0,
  0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0xFE, 0x01,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x06, 0x00, 0x07, 0xFE, 0x01,
  0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0xF8, 0x03, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0x83,
  0xFF, 0xE0, 0x01, 0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF, 0xF9,
  0xF8, 0x7F, 0x7F, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x03,
  0xFF, 0xC0, 0x03, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0x0F, 0xFF, 0xF0, 0x07,
  0xE1, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F,
  0xC1, 0xFC, 0x3F, 0x01, 0xFE, 0x3F, 0xC7, 0xF0, 0x1F, 0xFF, 0xF8, 0x7E,
  0x00, 0xFF, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xFC,
  0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x1C, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 17, 47, 40, 12, -46 },
  { 101, 25, 21, 40, 11, -49 },
  { 167, 42, 46, 40, 0, -46 },
  { 409, 38, 62, 40, 1, -54 },
  { 704, 46, 48, 40, -2, -47 },
  { 980, 39, 48, 40, 0, -47 },
  { 1214, 11, 21, 40, 18, -49 },
  { 1243, 27, 59, 40, 12, -50 },
  { 1443, 27, 59, 40, 2, -50 },
  { 1643, 35, 33, 40, 3, -36 },
  { 1788, 33, 32, 40, 4, -36 },
  { 1920, 19, 21, 40, 7, -11 },
  { 1970, 22, 8, 40, 9, -24 },
  { 1992, 13, 12, 40, 11, -11 },
  { 2012, 38, 59, 40, 1, -50 },
  { 2293, 36, 48, 40, 3, -47 },
  { 2509, 33, 46, 40, 3, -46 },
  { 2699, 37, 47, 40, 1, -47 },
  { 2917, 37, 48, 40, 1, -47 },
  { 3139, 36, 46, 40, 1, -46 },
  { 3346, 37, 47, 40, 2, -46 },
  { 3564, 34, 47, 40, 3, -46 },
  { 3764, 35, 46, 40, 5, -46 },
  { 3966, 36, 48, 40, 2, -47 },
  { 4182, 33, 47, 40, 5, -47 },
  { 4376, 17, 36, 40, 11, -35 },
  { 4453, 21, 45, 40, 7, -35 },
  { 4572, 33, 39, 40, 5, -40 },
  { 4733, 35, 20, 40, 3, -30 },
  { 4821, 32, 39, 40, 3, -40 },
  { 4977, 30, 48, 40, 7, -47 },
  { 5157, 35, 54, 40, 3, -47 },
  { 5394, 38, 46, 40, -2, -46 },
  { 5613, 35, 46, 40, 3, -46 },
  { 5815, 35, 48, 40, 4, -47 },
  { 6025, 36, 46, 40, 2, -46 },
  { 6232, 36, 46, 40, 3, -46 },
  { 6439, 37, 46, 40, 3, -46 },
  { 6652, 35, 48, 40, 3, -47 },
  { 6862, 38, 46, 40, 2, -46 },
  { 7081, 37, 46, 40, 2, -46 },
  { 7294, 35, 47, 40, 3, -46 },
  { 7500, 42, 46, 40, 2, -46 },
  { 7742, 30, 46, 40, 4, -46 },
  { 7915, 41, 46, 40, 0, -46 },
  { 8151, 38, 46, 40, 2, -46 },
  { 8370, 36, 48, 40, 3, -47 },
  { 8586, 36, 46, 40, 3, -46 },
  { 8793, 36, 60, 40, 3, -47 },
  { 9063, 36, 46, 40, 3, -46 },
  { 9270, 38, 48, 40, 1, -47 },
  { 9498, 38, 46, 40, 5, -46 },
  { 9717, 36, 47, 40, 4, -46 },
  { 9929, 37, 46, 40, 6, -46 },
  { 10142, 42, 46, 40, 1, -46 },
  { 10384, 45, 46, 40, -2, -46 },
  { 10643, 39, 46, 40, 5, -46 },
  { 10868, 40, 46, 40, 0, -46 },
  { 11098, 30, 59, 40, 9, -50 },
  { 11320, 19, 59, 40, 11, -50 },
  { 11461, 30, 59, 40, 2, -50 },
  { 11683, 35, 29, 40, 3, -46 },
  { 11810, 33, 6, 40, -1, 6 },
  { 11835, 12, 15, 40, 13, -53 },
  { 11858, 34, 36, 40, 3, -35 },
  { 12011, 35, 50, 40, 2, -49 },
  { 12230, 31, 36, 40, 4, -35 },
  { 12370, 37, 50, 40, 3, -49 },
  { 12602, 32, 36, 40, 4, -35 },
  { 12746, 45, 63, 40, -2, -49 },
  { 13101, 37, 49, 40, 1, -35 },
  { 13328, 34, 49, 40, 2, -49 },
  { 13537, 31, 50, 40, 5, -49 },
  { 13731, 33, 63, 40, 1, -49 },
  { 13991, 36, 50, 40, 2, -49 },
  { 14216, 29, 50, 40, 6, -49 },
  { 14398, 39, 35, 40, 0, -35 },
  { 14569, 34, 35, 40, 2, -35 },
  { 14718, 33, 36, 40, 3, -35 },
  { 14867, 37, 48, 40, 0, -35 },
  { 15089, 35, 48, 40, 3, -35 },
  { 15299, 32, 34, 40, 7, -34 },
  { 15435, 32, 36, 40, 3, -35 },
  { 15579, 33, 47, 40, 4, -46 },
  { 15773, 33, 35, 40, 4, -34 },
  { 15918, 33, 36, 40, 3, -35 },
  { 16067, 37, 36, 40, 1, -35 },
  { 16234, 40, 36, 40, 0, -35 },
  { 16414, 36, 48, 40, 1, -34 },
  { 16630, 36, 36, 40, 2, -35 },
  { 16792, 32, 59, 40, 7, -50 },
  { 17028, 17, 59, 40, 12, -50 },
  { 17154, 32, 59, 40, 2, -50 },
  { 17390, 36, 15, 40, 2, -27 },
};

const GFXfont IBMPlexMono_SemiBoldItalic66pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic66pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic66pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC66PT7B_H_
