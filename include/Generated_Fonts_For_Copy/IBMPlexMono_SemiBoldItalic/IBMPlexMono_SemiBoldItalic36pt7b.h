#ifndef _IBMPLEXMONO_SEMIBOLDITALIC36PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0x78, 0x00, 0x3C, 0x79, 0xE3,
  0xDF, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x1E, 0x78, 0xF7,
  0x87, 0xBC, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE3, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x1F, 0xE3, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0x0E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xE0, 0x1F, 0xE3, 0xFC, 0x7F, 0xC7,
  0xF8, 0xFF, 0x0F, 0xF0, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0xF0, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F,
  0xB9, 0xE1, 0xE3, 0x8C, 0x3E, 0x38, 0x83, 0xE3, 0x80, 0x3E, 0x38, 0x01,
  0xFB, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0x7E, 0x00, 0xE3, 0xE0, 0x0E, 0x3E, 0x20, 0xE3,
  0xE7, 0x0E, 0x3E, 0xFC, 0xEF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x07, 0x83, 0xFC, 0x07, 0x83, 0xFF, 0x03, 0x81,
  0xE3, 0x83, 0x81, 0xE1, 0xC3, 0xC0, 0xF0, 0xE3, 0xC0, 0x70, 0x71, 0xC0,
  0x38, 0x39, 0xE0, 0x1C, 0x3D, 0xE0, 0x0F, 0x1D, 0xE0, 0x07, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x78, 0x03, 0xDC, 0x1C, 0x03, 0xCE, 0x0E, 0x01, 0xC7,
  0x0F, 0x01, 0xC7, 0x87, 0x81, 0xE3, 0xC3, 0x81, 0xE0, 0xE3, 0xC0, 0xE0,
  0x7F, 0xC0, 0xE0, 0x1F, 0xC0, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xC7, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1F, 0x0F, 0x00,
  0x78, 0xF0, 0x07, 0xDF, 0x01, 0xFF, 0xE0, 0x1E, 0x78, 0x01, 0xE3, 0xE0,
  0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xE1, 0x3E, 0x0F, 0x8F, 0xF0,
  0x7C, 0xFF, 0x83, 0xE7, 0xBE, 0x27, 0xF9, 0xFF, 0x3F, 0x87, 0xF0, 0xFC,
  0x1F, 0x03, 0x80, 0x3D, 0xF7, 0x9E, 0x79, 0xE7, 0xBE, 0xF3, 0xCF, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xE1, 0xE3, 0xBF, 0x7B,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3E, 0xF8, 0x0F, 0x8F, 0x03, 0xE1, 0xF0, 0x78, 0x1C,
  0x02, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3E,
  0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x7F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x71,
  0xFF, 0x9F, 0x3F, 0xF3, 0xC7, 0xFC, 0x78, 0xFF, 0x80, 0x3E, 0xF0, 0x07,
  0xDE, 0x00, 0xFB, 0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0xC3, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x01, 0xF3, 0xC0,
  0xF8, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F, 0x03, 0x87, 0xC0, 0x41, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0x87, 0xE1, 0xF0, 0x3E, 0x3E, 0x01, 0xF0, 0x40,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x87, 0xE0, 0xE0, 0x3F, 0x04,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x20, 0x07, 0xCF, 0x00, 0xFC, 0xFC, 0x1F,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7B, 0xE0, 0x0F, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x3C,
  0x07, 0xC3, 0xC0, 0x78, 0x7C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x07,
  0x87, 0x80, 0x78, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x7E,
  0x01, 0xEF, 0xF8, 0x1D, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x0F, 0xE1, 0xC0,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x10,
  0x07, 0xC7, 0x80, 0x7C, 0xFC, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x7C, 0x0F, 0x7F, 0xC7, 0xFF, 0xF9, 0xEF, 0xFE, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B,
  0xE0, 0x3E, 0xFC, 0x1F, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0x80, 0x7C, 0xF0, 0x0F, 0xBC, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01,
  0xE1, 0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x7C, 0xFC, 0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7E, 0x0F, 0xBF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xBF, 0xFF,
  0xE7, 0xFE, 0xF0, 0xFF, 0x7C, 0x1F, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x0F, 0xCF, 0xE7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x00,
  0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x78, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00,
  0x10, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80,
  0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0x7C, 0x3F, 0xF8, 0x1F, 0x30, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC1, 0xE1, 0xE0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x7B, 0xC1, 0xCF, 0x78, 0xFD, 0xEF, 0x3F, 0xFD, 0xC7,
  0x8F, 0xF9, 0xE0, 0xEF, 0x3C, 0x1D, 0xE7, 0x87, 0xBC, 0xF0, 0xF7, 0x1C,
  0x1E, 0xE3, 0x83, 0xDC, 0x70, 0xF3, 0x8E, 0x1E, 0x71, 0xFF, 0xCE, 0x3F,
  0xF9, 0xC3, 0xEF, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0,
  0x03, 0xEF, 0x00, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8,
  0xF8, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0xF8,
  0x00, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x03,
  0xE1, 0xE0, 0x7C, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x3E, 0x07, 0xCF, 0x80, 0x79, 0xF0, 0x0E,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF3,
  0xE0, 0x1F, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0x07, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x1F, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x7E, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x1C,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x3F, 0xEF, 0x87, 0xFD,
  0xF0, 0xFF, 0xBE, 0x1F, 0xF7, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0xC3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFB, 0xC1,
  0xFE, 0x78, 0x0F, 0x8F, 0x00, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC3, 0xC0,
  0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78,
  0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x81, 0x80, 0xF8, 0xF8,
  0x0F, 0x07, 0x81, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xF0, 0x3E,
  0x07, 0xE0, 0x78, 0x1F, 0x80, 0xF0, 0x7E, 0x03, 0xE1, 0xF8, 0x07, 0xC7,
  0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xFF, 0xFD, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x0F,
  0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xB8, 0xEE, 0x0F, 0x73, 0xFC, 0x1E, 0xFF,
  0x78, 0x3D, 0xFE, 0xF0, 0x7B, 0xF9, 0xE1, 0xF3, 0xE3, 0xC3, 0xC7, 0xCF,
  0x07, 0x8F, 0x1E, 0x0F, 0x1E, 0x3C, 0x1E, 0x18, 0x78, 0x3C, 0x30, 0xF0,
  0xF8, 0x41, 0xE1, 0xE0, 0x87, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x0F,
  0xC0, 0x78, 0x7E, 0x07, 0xC3, 0xF0, 0x3C, 0x1F, 0xC1, 0xE1, 0xFE, 0x0F,
  0x0F, 0xF0, 0x78, 0x7F, 0x83, 0xC3, 0xFC, 0x3E, 0x1E, 0xF1, 0xE0, 0xF7,
  0x8F, 0x0F, 0x3C, 0x78, 0x79, 0xE3, 0xC3, 0xCF, 0x1E, 0x1E, 0x3D, 0xF0,
  0xF1, 0xEF, 0x07, 0x8F, 0x78, 0x78, 0x7B, 0xC3, 0xC3, 0xDE, 0x1E, 0x0F,
  0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xF8, 0x3C, 0x1F, 0xC3, 0xC0, 0xFE, 0x1E,
  0x03, 0xF0, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB,
  0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0xC3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x7E, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0xDF, 0x80,
  0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07,
  0xDE, 0x00, 0xFB, 0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0xC3, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x7C, 0x10, 0x07, 0xC7,
  0x00, 0x79, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xE0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x83,
  0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x3E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xFF, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC1, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x87, 0x80, 0xF8,
  0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0x1F, 0x83, 0xF1, 0xF0, 0x0E, 0x1E, 0x00, 0x81, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x20, 0x03, 0xC7, 0x00, 0x7C, 0xFC, 0x0F, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF1,
  0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x3E,
  0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03,
  0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xFC,
  0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x9E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F,
  0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3E, 0x78, 0x01, 0xF7, 0xC0, 0x0F,
  0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F,
  0x1F, 0x1E, 0x1C, 0x3E, 0x3C, 0x78, 0xFC, 0x78, 0xF1, 0xF8, 0xE1, 0xE3,
  0xF3, 0xC3, 0xCE, 0xE7, 0x87, 0x9D, 0xCF, 0x0F, 0x3B, 0x9C, 0x1E, 0xE7,
  0x78, 0x3D, 0xCE, 0xF0, 0x73, 0x9D, 0xE1, 0xEE, 0x3B, 0x83, 0xDC, 0x77,
  0x07, 0xB8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0xF8, 0x01, 0xF1, 0xF0,
  0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xC7, 0xC0,
  0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF8, 0x7C, 0x03, 0xC3, 0xE0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x03,
  0xDF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07,
  0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0,
  0x0F, 0xBE, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x87, 0xC0, 0xF0,
  0xF0, 0x1E, 0x3E, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xDC, 0x00, 0x61,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x13, 0xCF, 0x9E,
  0x3C, 0xF1, 0xC6, 0x07, 0xE7, 0xC3, 0xFD, 0xF3, 0xFF, 0xFC, 0xF8, 0x7F,
  0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0xBC,
  0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x83,
  0xF3, 0xE1, 0xFC, 0xFF, 0xDF, 0xDF, 0xE7, 0xE3, 0xE0, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0x03, 0xCF, 0xF0, 0x7B, 0xFF,
  0x0F, 0x63, 0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3C, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x03, 0xE3, 0xF0, 0xFC, 0x7B, 0xFF, 0x1F, 0x7F, 0xC3,
  0xE3, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF3,
  0xE0, 0x73, 0xE0, 0x21, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x27, 0xC0, 0x3D, 0xE0, 0x3C, 0xF8,
  0x3E, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE3, 0xC0, 0xFF, 0x3C, 0x1F, 0xFF, 0xC3,
  0xE0, 0xFC, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x78,
  0xF8, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x1F,
  0x0F, 0x01, 0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xF0, 0xFF, 0xDF, 0x07, 0xF9,
  0xF0, 0x1F, 0x1E, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C,
  0x3E, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x3E, 0xF8, 0x7F,
  0xBF, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x87,
  0x80, 0x79, 0xF0, 0x7C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x30, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x7F, 0x9E, 0x0F, 0xFD,
  0xE1, 0xF8, 0x7E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0,
  0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0x78,
  0x07, 0x87, 0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0x78, 0x3F, 0xEF, 0x83,
  0xFC, 0xF8, 0x0F, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x02, 0x01, 0xE0,
  0x70, 0x3E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x07, 0xCF, 0xE1, 0xF7, 0xFC, 0x7B,
  0x1F, 0x1E, 0x83, 0xCF, 0xC0, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03,
  0xCF, 0x01, 0xF3, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xE7,
  0xC0, 0x79, 0xE0, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF8, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x40, 0x7C, 0x38, 0x3C, 0x3E,
  0x1E, 0x3C, 0x1F, 0x3C, 0x0F, 0xBC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x81, 0xE0, 0xF0, 0x78, 0x3E, 0x3E, 0x07, 0x8F, 0x80, 0xF3,
  0xE0, 0x3E, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x1F, 0x01, 0xF3, 0xFC, 0x1E,
  0x7F, 0xC1, 0xEC, 0x7C, 0x1F, 0x83, 0xE3, 0xF0, 0x3C, 0x3E, 0x03, 0xC3,
  0xE0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x3C, 0xFC, 0x07, 0xDF, 0x00,
  0x7C, 0xF0, 0x07, 0xCF, 0x86, 0x7C, 0x78, 0xF7, 0x87, 0xDE, 0x78, 0x7F,
  0xCF, 0x83, 0xF8, 0xF8, 0x1E, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x08, 0x1F, 0x0E, 0x1F, 0x1F,
  0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80,
  0x1E, 0x70, 0xF0, 0xE7, 0xCF, 0xCF, 0x7E, 0xFE, 0x7C, 0xF4, 0xF3, 0xC3,
  0xC7, 0x9E, 0x1C, 0x3C, 0xF1, 0xE1, 0xE7, 0x0F, 0x0F, 0x38, 0x78, 0x73,
  0xC3, 0xC7, 0x9E, 0x1E, 0x3C, 0xF0, 0xE1, 0xE7, 0x8F, 0x0F, 0x38, 0x78,
  0x79, 0xC3, 0xC3, 0x9E, 0x1E, 0x3C, 0xF0, 0xF1, 0xE7, 0x87, 0x0F, 0x3C,
  0x78, 0x78, 0x1F, 0x1F, 0x07, 0xCF, 0xE1, 0xF7, 0xFC, 0x7B, 0x1F, 0x1E,
  0x83, 0xCF, 0xC0, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01,
  0xF3, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0x79,
  0xE0, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF8, 0x01, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFC, 0x3E, 0x7C, 0x07, 0x9F, 0x01, 0xF7, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E,
  0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x81, 0xF1, 0xF0, 0xF8, 0x7F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0x8F, 0x80, 0xF3, 0xFC, 0x0F, 0x7F, 0xE0,
  0xF6, 0x3F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x7D, 0xFF, 0x87, 0xDF,
  0xF0, 0x7C, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE3, 0xC3,
  0xFC, 0xF1, 0xFF, 0xFC, 0xF8, 0x3F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0x80,
  0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3E,
  0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x83, 0xF3, 0xE1, 0xFC, 0xFF, 0xDF, 0x1F,
  0xE7, 0xC1, 0xF1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF, 0x87, 0xFF, 0xCF,
  0xFF, 0xEF, 0xE1, 0xFF, 0xF0, 0xF6, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE0, 0xE3, 0xE0, 0x21,
  0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0xF2, 0x00, 0x79, 0x80, 0x7D, 0xF0, 0x7E, 0xFF,
  0xFE, 0x3F, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xA1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x40, 0xF8,
  0x78, 0x3C, 0x3E, 0x0F, 0x1E, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x0F, 0x9E,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83,
  0xF3, 0xF1, 0x7C, 0x7F, 0xDF, 0x1F, 0xE7, 0xC1, 0xF1, 0xE0, 0xFF, 0x01,
  0x3F, 0xC3, 0xEF, 0xF0, 0x78, 0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xF1,
  0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xC0, 0xF8, 0xF0,
  0x3E, 0x3C, 0x1F, 0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xF3, 0xF0, 0x3F, 0xF8,
  0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3C, 0x78, 0x63, 0x87, 0x9E, 0x38, 0x78,
  0xE7, 0x87, 0x8F, 0x78, 0x70, 0xF7, 0x87, 0x0F, 0x78, 0xF0, 0xF7, 0x8F,
  0x0F, 0x70, 0xF0, 0xFF, 0x0F, 0x0E, 0xF0, 0xF0, 0xEF, 0x0E, 0x1E, 0xF1,
  0xE1, 0xEF, 0x1E, 0x1C, 0xF1, 0xE3, 0xCF, 0x3E, 0x38, 0xFE, 0xE7, 0x0F,
  0xCF, 0xE0, 0x78, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x1F, 0xCF, 0xE1, 0xFF,
  0x3F, 0x8F, 0x9D, 0x9F, 0x7C, 0x76, 0x3C, 0x41, 0xD0, 0xF0, 0x07, 0xC3,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x30, 0xF8, 0x03, 0xC3, 0xE1, 0x8F, 0x1F, 0x8F, 0x3C, 0xDE,
  0xFC, 0xFF, 0x3F, 0xE1, 0xF8, 0xFE, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3,
  0xF1, 0xFC, 0x1F, 0xF7, 0xC0, 0xFE, 0x78, 0x07, 0xC7, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x81, 0x01, 0xF0, 0x38, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x07, 0xE0, 0xF0, 0xFF, 0x9E, 0x1F, 0xFF, 0xE3, 0xE3,
  0xFE, 0x3C, 0x0F, 0xC3, 0xC0, 0xF8, 0x38, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x80, 0x7C, 0x38, 0x0F, 0x83, 0xC1,
  0xF0, 0x1C, 0x7F, 0x01, 0xC7, 0xFF, 0x1C, 0xF7, 0xFF, 0xCF, 0x1F, 0xF8,
  0xF0, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1F, 0x03, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07,
  0x80, 0x61, 0xFC, 0x0F, 0x3F, 0xE0, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xC7,
  0x07, 0xFC, 0xF0, 0x3F, 0x86, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 25, 22, 6, -25 },
  { 33, 13, 11, 22, 6, -27 },
  { 51, 23, 25, 22, 0, -25 },
  { 123, 20, 33, 22, 1, -29 },
  { 206, 25, 25, 22, -1, -25 },
  { 285, 21, 25, 22, 0, -25 },
  { 351, 6, 11, 22, 10, -27 },
  { 360, 14, 32, 22, 7, -27 },
  { 416, 15, 32, 22, 1, -27 },
  { 476, 19, 18, 22, 2, -20 },
  { 519, 18, 17, 22, 2, -19 },
  { 558, 10, 11, 22, 4, -6 },
  { 572, 12, 4, 22, 5, -13 },
  { 578, 7, 6, 22, 6, -6 },
  { 584, 21, 32, 22, 0, -27 },
  { 668, 19, 25, 22, 2, -25 },
  { 728, 18, 25, 22, 2, -25 },
  { 785, 20, 25, 22, 1, -25 },
  { 848, 20, 25, 22, 1, -25 },
  { 911, 20, 25, 22, 0, -25 },
  { 974, 20, 25, 22, 1, -25 },
  { 1037, 18, 25, 22, 2, -25 },
  { 1094, 19, 25, 22, 3, -25 },
  { 1154, 20, 25, 22, 1, -25 },
  { 1217, 18, 25, 22, 3, -25 },
  { 1274, 9, 19, 22, 6, -19 },
  { 1296, 11, 24, 22, 4, -19 },
  { 1329, 18, 21, 22, 3, -22 },
  { 1377, 19, 11, 22, 2, -16 },
  { 1404, 17, 21, 22, 2, -22 },
  { 1449, 16, 25, 22, 4, -25 },
  { 1499, 19, 29, 22, 2, -25 },
  { 1568, 21, 25, 22, -1, -25 },
  { 1634, 20, 25, 22, 1, -25 },
  { 1697, 19, 25, 22, 2, -25 },
  { 1757, 20, 25, 22, 1, -25 },
  { 1820, 20, 25, 22, 1, -25 },
  { 1883, 21, 25, 22, 1, -25 },
  { 1949, 19, 25, 22, 2, -25 },
  { 2009, 21, 25, 22, 1, -25 },
  { 2075, 20, 25, 22, 1, -25 },
  { 2138, 20, 25, 22, 1, -25 },
  { 2201, 23, 25, 22, 1, -25 },
  { 2273, 17, 25, 22, 2, -25 },
  { 2327, 23, 25, 22, 0, -25 },
  { 2399, 21, 25, 22, 1, -25 },
  { 2465, 19, 25, 22, 2, -25 },
  { 2525, 20, 25, 22, 1, -25 },
  { 2588, 19, 32, 22, 2, -25 },
  { 2664, 20, 25, 22, 1, -25 },
  { 2727, 20, 25, 22, 1, -25 },
  { 2790, 20, 25, 22, 3, -25 },
  { 2853, 20, 25, 22, 2, -25 },
  { 2916, 21, 25, 22, 3, -25 },
  { 2982, 23, 25, 22, 1, -25 },
  { 3054, 24, 25, 22, -1, -25 },
  { 3129, 21, 25, 22, 3, -25 },
  { 3195, 22, 25, 22, 0, -25 },
  { 3264, 16, 32, 22, 5, -27 },
  { 3328, 10, 32, 22, 6, -27 },
  { 3368, 16, 32, 22, 1, -27 },
  { 3432, 19, 16, 22, 2, -25 },
  { 3470, 17, 3, 22, 0, 3 },
  { 3477, 6, 8, 22, 7, -29 },
  { 3483, 18, 19, 22, 2, -19 },
  { 3526, 19, 27, 22, 1, -27 },
  { 3591, 17, 19, 22, 2, -19 },
  { 3632, 20, 27, 22, 2, -27 },
  { 3700, 18, 19, 22, 2, -19 },
  { 3743, 24, 34, 22, -1, -27 },
  { 3845, 20, 26, 22, 1, -19 },
  { 3910, 18, 27, 22, 1, -27 },
  { 3971, 17, 29, 22, 3, -29 },
  { 4033, 18, 36, 22, 1, -29 },
  { 4114, 20, 27, 22, 1, -27 },
  { 4182, 16, 27, 22, 3, -27 },
  { 4236, 21, 19, 22, 0, -19 },
  { 4286, 18, 19, 22, 1, -19 },
  { 4329, 18, 19, 22, 2, -19 },
  { 4372, 20, 26, 22, 0, -19 },
  { 4437, 18, 26, 22, 2, -19 },
  { 4496, 17, 19, 22, 4, -19 },
  { 4537, 17, 19, 22, 2, -19 },
  { 4578, 18, 25, 22, 2, -25 },
  { 4635, 18, 19, 22, 2, -19 },
  { 4678, 18, 19, 22, 2, -19 },
  { 4721, 20, 19, 22, 1, -19 },
  { 4769, 22, 19, 22, 0, -19 },
  { 4822, 20, 26, 22, 0, -19 },
  { 4887, 20, 19, 22, 1, -19 },
  { 4935, 17, 32, 22, 4, -27 },
  { 5003, 9, 32, 22, 7, -27 },
  { 5039, 18, 32, 22, 1, -27 },
  { 5111, 20, 8, 22, 1, -15 },
};

const GFXfont IBMPlexMono_SemiBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC36PT7B_H_
