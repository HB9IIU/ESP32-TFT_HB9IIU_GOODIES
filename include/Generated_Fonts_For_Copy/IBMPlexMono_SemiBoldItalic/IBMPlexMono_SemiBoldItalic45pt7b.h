#ifndef _IBMPLEXMONO_SEMIBOLDITALIC45PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07,
  0xC0, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1E,
  0x00, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC3, 0xFF, 0x1F,
  0xF8, 0x7F, 0xF0, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF8, 0x07, 0xC3,
  0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFF, 0x7B, 0xFC, 0x3F, 0x1E, 0x3C, 0x1F, 0x87, 0x86,
  0x07, 0xE1, 0xE0, 0x01, 0xF8, 0x70, 0x00, 0x7E, 0x1C, 0x00, 0x1F, 0xCF,
  0x00, 0x03, 0xFB, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0x9F, 0xC0, 0x01, 0xC3, 0xF0, 0x00, 0x70,
  0xFC, 0x00, 0x3C, 0x3F, 0x04, 0x0F, 0x0F, 0xC3, 0x83, 0xC3, 0xF1, 0xF0,
  0xF1, 0xF8, 0xFF, 0x3D, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0x01, 0xFF,
  0xC0, 0x1E, 0x03, 0xFF, 0xC0, 0x3C, 0x07, 0xC3, 0xC0, 0x7C, 0x07, 0xC1,
  0xE0, 0xF8, 0x07, 0x81, 0xE0, 0xF0, 0x07, 0x83, 0xE1, 0xE0, 0x0F, 0x83,
  0xC3, 0xE0, 0x0F, 0x83, 0xC3, 0xC0, 0x0F, 0x83, 0xC7, 0x80, 0x07, 0x87,
  0xCF, 0x80, 0x07, 0xFF, 0x9F, 0x00, 0x07, 0xFF, 0x1E, 0x00, 0x03, 0xFE,
  0x20, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7C, 0xFF, 0xE0, 0x00, 0x78, 0xFF, 0xE0, 0x00, 0xF1,
  0xF1, 0xF0, 0x01, 0xF1, 0xE0, 0xF0, 0x01, 0xE3, 0xE0, 0xF0, 0x03, 0xC3,
  0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0xF0, 0x07, 0x83, 0xC1, 0xF0, 0x0F, 0x83,
  0xC1, 0xF0, 0x1F, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xE3, 0xE0, 0x3E, 0x03,
  0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x80, 0x78, 0x00, 0xFF, 0x00, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF8,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0xEF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xE7, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x08, 0xFC,
  0x0F, 0xC1, 0xDF, 0x80, 0xFC, 0x7F, 0xF0, 0x2F, 0x9F, 0x3E, 0x05, 0xF3,
  0xE7, 0xE1, 0xBF, 0xF8, 0xFF, 0xF3, 0xFE, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF,
  0x07, 0xF0, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x30, 0x3E, 0x06, 0x7E, 0x3E, 0x3E, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xCF, 0x80, 0x1F, 0x8F, 0xC0,
  0x3F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1C, 0x03, 0x80,
  0x08, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0x7E, 0x00, 0x3F, 0x7E, 0x3C, 0x3F, 0xFE, 0x3E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x03, 0xF9, 0xF0, 0x0F,
  0xC7, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0x3E, 0x0F,
  0x80, 0x70, 0x3E, 0x00, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0x7F, 0x07, 0x80, 0x1F, 0x80, 0x80, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x03, 0xF8, 0x1E, 0x00, 0xFE, 0x06, 0x00, 0x7F, 0x02, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x10, 0x00,
  0xFE, 0x1C, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0xE0, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0xF1, 0xFF,
  0x80, 0x7B, 0xFF, 0xE0, 0x7D, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x10, 0x00, 0xFC, 0x3C,
  0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x03, 0xFB,
  0xFF, 0x07, 0xEF, 0xFF, 0x1F, 0xBF, 0xFF, 0x3F, 0x7F, 0xFE, 0x7F, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xFC, 0x03, 0xF9, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x7F, 0x87, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0x9F, 0xC0, 0x3F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xBF, 0x81, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFD, 0xF8, 0xFF, 0xF7, 0xE0, 0xFF, 0xCF, 0xC0, 0x7E,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC3, 0xFC,
  0x7F, 0x8F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x08, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF7,
  0xF0, 0xFF, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x18, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0,
  0x7E, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0x1F, 0x00,
  0x0F, 0x3E, 0x07, 0x8F, 0x3E, 0x1F, 0xCF, 0x3C, 0x3F, 0xFF, 0x7C, 0x3F,
  0xFF, 0x7C, 0x7E, 0x3F, 0x7C, 0x7C, 0x1E, 0x7C, 0xF8, 0x1E, 0x78, 0xF8,
  0x1E, 0xF8, 0xF8, 0x3E, 0xF8, 0xF8, 0x3E, 0xF8, 0xF0, 0x3E, 0xF8, 0xF0,
  0x3C, 0xF8, 0xF0, 0x3C, 0xF0, 0xF0, 0x7C, 0xF0, 0xF0, 0xFC, 0xF0, 0xFF,
  0xFC, 0xF0, 0xFF, 0xFC, 0xF0, 0xFF, 0x78, 0xF0, 0x7E, 0x78, 0xF8, 0x10,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0xFE,
  0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0x01, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xFC, 0x7C, 0x03, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x38, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x80,
  0xF8, 0x00, 0xF0, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0xFE,
  0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F,
  0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE,
  0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7C, 0x03, 0xF8, 0xFC, 0x0F, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x18, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xFE, 0x7E, 0x0F, 0xFE,
  0xFE, 0x0F, 0xFE, 0xFE, 0x0F, 0xFE, 0xFC, 0x1F, 0xFC, 0xFC, 0x00, 0x7C,
  0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xFE, 0xF8,
  0x3F, 0xFC, 0xF8, 0x1F, 0xFD, 0xF8, 0x0F, 0xF9, 0xF0, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x08, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x3F, 0x00,
  0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF8,
  0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F,
  0xC3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0x00, 0x3E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xBC, 0xFB,
  0xE0, 0xFB, 0xCF, 0xBE, 0x0F, 0xBF, 0xF7, 0xC0, 0xFB, 0xFE, 0x7C, 0x1F,
  0x3F, 0xE7, 0xC1, 0xF1, 0xFC, 0x7C, 0x1F, 0x1F, 0xC7, 0xC1, 0xF1, 0xF8,
  0x7C, 0x1F, 0x1F, 0x8F, 0x81, 0xF0, 0xF0, 0xF8, 0x3E, 0x0E, 0x0F, 0x83,
  0xE0, 0xE0, 0xF8, 0x3E, 0x0C, 0x0F, 0x83, 0xE0, 0xC1, 0xF8, 0x3E, 0x08,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x07, 0xC1, 0xFE, 0x01,
  0xF0, 0x7F, 0x80, 0x7C, 0x1F, 0xE0, 0x1F, 0x07, 0xF8, 0x0F, 0xC3, 0xFF,
  0x03, 0xE0, 0xFF, 0xC0, 0xF8, 0x3F, 0xF0, 0x3E, 0x0F, 0xFC, 0x0F, 0x83,
  0xEF, 0x03, 0xE0, 0xFB, 0xE1, 0xF8, 0x7E, 0xF8, 0x7C, 0x1F, 0x3E, 0x1F,
  0x07, 0xCF, 0x87, 0xC1, 0xF1, 0xE1, 0xF0, 0x7C, 0x7C, 0x7C, 0x1F, 0x1F,
  0x3F, 0x0F, 0xC7, 0xCF, 0x83, 0xE1, 0xF3, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E,
  0x0F, 0xBE, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFF, 0xC1, 0xF8, 0x3F, 0xF0,
  0x7C, 0x07, 0xFC, 0x1F, 0x01, 0xFF, 0x07, 0xC0, 0x7F, 0xC1, 0xF0, 0x1F,
  0xF0, 0x7C, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFE,
  0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF8,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0xFC, 0x08, 0x00, 0x7E, 0x1C, 0x00, 0x7E, 0x3E,
  0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7E, 0x03,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0,
  0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xF8,
  0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0xF0, 0x3F, 0x00, 0x18, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x10, 0x00, 0x7E, 0x0E, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xE3, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0xF8,
  0x3E, 0x3E, 0x1F, 0x83, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC3,
  0xE3, 0xF8, 0x7C, 0x3E, 0x3F, 0x87, 0x83, 0xE3, 0xB8, 0x78, 0x3C, 0x7B,
  0x8F, 0x87, 0xC7, 0xB8, 0xF8, 0x7C, 0x73, 0x8F, 0x87, 0xCF, 0x38, 0xF0,
  0x7C, 0xF3, 0x9F, 0x07, 0xCE, 0x39, 0xF0, 0x7D, 0xE3, 0x9F, 0x07, 0xDE,
  0x39, 0xE0, 0x7D, 0xC3, 0x9E, 0x07, 0xFC, 0x3B, 0xE0, 0x7B, 0xC3, 0xBE,
  0x0F, 0xB8, 0x3B, 0xC0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xF0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xF9, 0xF0, 0x01,
  0xF1, 0xF0, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F,
  0xC0, 0xFC, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7E,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x38, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x18, 0x78,
  0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x08, 0x01, 0xF8, 0x00, 0x07,
  0xFC, 0xFC, 0x3F, 0xFD, 0xF8, 0xFF, 0xFB, 0xF1, 0xFC, 0x1F, 0xE7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3,
  0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0x87, 0xE1, 0xFF, 0xEF, 0xFF, 0x7F, 0x9F,
  0xFC, 0x7F, 0x1F, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x0F, 0xCF, 0xFC, 0x0F, 0xDF, 0xFC, 0x0F, 0x9F, 0xFE, 0x0F,
  0xB8, 0x7E, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x83, 0xF8, 0x7F, 0xFF, 0xF0, 0x7C, 0xFF, 0xF0, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFC, 0x3F, 0x9F, 0x80, 0x78, 0xFC, 0x03, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x47, 0xE0,
  0x07, 0xBF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0xFF, 0x8F, 0xC1, 0xFF, 0xE7, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F,
  0xC0, 0x7F, 0x83, 0xF0, 0xEF, 0x81, 0xFF, 0xE7, 0xC0, 0x7F, 0xF7, 0xE0,
  0x3F, 0xE3, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xC1, 0xF8, 0xFC, 0x03, 0xE3,
  0xE0, 0x0F, 0xDF, 0x80, 0x3E, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC3,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x43, 0xF0, 0x03, 0x8F, 0xC0, 0x1F, 0xBF,
  0x00, 0xFC, 0x7F, 0x07, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x10, 0x1F, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x8F, 0xC1, 0xFF, 0xE7, 0xC1, 0xFF, 0xFF, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0xDF,
  0x83, 0xFF, 0xEF, 0x80, 0xFF, 0xE7, 0xC0, 0x3F, 0xE7, 0xE0, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0x00, 0x7E, 0x03, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x1F,
  0x81, 0xF8, 0xFF, 0x07, 0xE7, 0xFE, 0x1F, 0xBF, 0xFC, 0x7D, 0xC7, 0xF1,
  0xF4, 0x0F, 0xCF, 0xE0, 0x1F, 0x3F, 0x80, 0x7C, 0xFC, 0x01, 0xF3, 0xF0,
  0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0xF8, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x20, 0x0F, 0xC1, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x7C, 0x07, 0xE3, 0xF0,
  0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xC0, 0x7E, 0x07, 0x81, 0xF8, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x00, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0,
  0x1F, 0x8F, 0xF8, 0x1F, 0x9F, 0xFC, 0x1F, 0xBF, 0xFC, 0x1F, 0x71, 0xFC,
  0x1F, 0x40, 0xFC, 0x3F, 0x80, 0x7C, 0x3F, 0x80, 0x7C, 0x3F, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xE0,
  0x7E, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7E, 0x00,
  0x7C, 0x7E, 0x0E, 0xFC, 0x3E, 0x1F, 0xFC, 0x3F, 0x3E, 0xFC, 0x1F, 0x7E,
  0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x08,
  0x0F, 0x81, 0xE1, 0xF8, 0x3F, 0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x9F,
  0x81, 0xFB, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x0F, 0x83, 0xCF, 0xC7, 0xF1, 0xF7, 0xF3, 0xFC, 0x7D,
  0xFF, 0xFF, 0x1F, 0x8F, 0xE7, 0xC7, 0xC3, 0xF1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x78, 0x3E, 0x1F, 0x3E, 0x0F, 0x07, 0xCF, 0x83, 0xC1, 0xF3, 0xE1, 0xF0,
  0x7C, 0xF8, 0x7C, 0x1E, 0x3C, 0x1F, 0x07, 0x8F, 0x07, 0xC3, 0xE7, 0xC1,
  0xE0, 0xF9, 0xF0, 0x78, 0x3E, 0x7C, 0x3E, 0x0F, 0x9F, 0x0F, 0x83, 0xC7,
  0x83, 0xE0, 0xF1, 0xE0, 0xF8, 0x7C, 0xF8, 0x3C, 0x1F, 0x3E, 0x0F, 0x07,
  0xCF, 0x87, 0xC1, 0xF3, 0xE1, 0xF0, 0x78, 0x00, 0x07, 0xE0, 0x7E, 0x3F,
  0xC1, 0xF9, 0xFF, 0x87, 0xEF, 0xFF, 0x1F, 0x71, 0xFC, 0x7D, 0x03, 0xF3,
  0xF8, 0x07, 0xCF, 0xE0, 0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xE0,
  0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x1F, 0x83, 0xF0,
  0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xF3, 0xFF, 0x01, 0xFB, 0xFF, 0x80, 0xF9,
  0xFF, 0xE0, 0x7D, 0xC3, 0xF0, 0x7F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F,
  0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0xF9, 0xFF,
  0xE0, 0xFC, 0x7F, 0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFE, 0x3F, 0x0F, 0xFF, 0x3E, 0x0F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C,
  0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF8, 0x7E, 0x1D, 0xF0,
  0x7F, 0xF9, 0xF0, 0x3F, 0xFB, 0xF0, 0x3F, 0xF3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x7F, 0xF8, 0x7E, 0xFF, 0xE1, 0xFD, 0xFF, 0xCF, 0xF3, 0xFF, 0x9F, 0xE8,
  0x3F, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFA, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0x7E, 0x00, 0xC1,
  0xF0, 0x02, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE1, 0x00, 0x1F, 0x9E,
  0x00, 0x7C, 0xFE, 0x07, 0xF3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x06, 0x03, 0xF0, 0x3C, 0x0F, 0xC1,
  0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0xFE, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0,
  0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x07, 0xF3, 0xE0, 0x1F, 0xCF, 0xC0, 0xBE,
  0x3F, 0x8E, 0xF8, 0xFF, 0xF7, 0xE1, 0xFF, 0x9F, 0x83, 0xFC, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xC0, 0xFB, 0xFF, 0x03, 0xF7, 0xFE,
  0x07, 0xEF, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0xFC,
  0x1F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x03,
  0xF3, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x0F, 0x07, 0xCF, 0x87, 0x83, 0xC3, 0xC7,
  0xC1, 0xE1, 0xF3, 0xE0, 0xF0, 0xF9, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x3E,
  0x78, 0x3E, 0x1F, 0x3C, 0x1E, 0x0F, 0xBE, 0x0F, 0x07, 0xDF, 0x07, 0x83,
  0xEF, 0x87, 0xC1, 0xF7, 0xC3, 0xE0, 0xF3, 0xC1, 0xF0, 0x79, 0xE0, 0xF8,
  0x3D, 0xF0, 0x78, 0x3E, 0xF8, 0x3C, 0x1E, 0x7C, 0x3E, 0x0F, 0x3E, 0x1F,
  0x0F, 0x9F, 0x1F, 0x87, 0x8F, 0x8F, 0xC7, 0xC7, 0xFD, 0xE3, 0xC3, 0xFE,
  0xFF, 0xC0, 0xFE, 0x3F, 0xC0, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x3F, 0x83, 0xF8, 0x1F, 0xF8, 0xFF, 0x07, 0xFF, 0x3F, 0xF3, 0xF9,
  0xE6, 0x3E, 0x7E, 0x3D, 0x87, 0xC7, 0x07, 0xF0, 0xF8, 0xC0, 0xFC, 0x1F,
  0x00, 0x1F, 0x83, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x18, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x63, 0xE1, 0xBC,
  0x3E, 0x7C, 0x37, 0x8F, 0xCF, 0x8C, 0xF3, 0xF9, 0xFF, 0x9F, 0xFC, 0x1F,
  0xE3, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01,
  0xFC, 0x3F, 0x02, 0xFC, 0x3F, 0x86, 0xF8, 0x3F, 0xFC, 0xF8, 0x1F, 0xFD,
  0xF8, 0x0F, 0xF9, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x30, 0x07, 0xE0, 0x7C, 0x1F,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x07, 0xC3, 0xFF, 0xE3, 0xE1, 0xFF,
  0xFB, 0xE1, 0xF8, 0x7F, 0xF0, 0xF8, 0x0F, 0xF0, 0x78, 0x03, 0xF0, 0x3C,
  0x03, 0xF0, 0x1E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x70,
  0x07, 0xF0, 0x78, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x1F, 0x07, 0xE0, 0x07,
  0x87, 0xFE, 0x03, 0xC7, 0xFF, 0xF1, 0xE3, 0xE7, 0xFF, 0xF1, 0xE0, 0xFF,
  0xF1, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x03, 0xE0, 0x07, 0x03, 0xFC, 0x03, 0xC7, 0xFF, 0x03, 0xE3, 0xFF, 0x81,
  0xE3, 0xE3, 0xE1, 0xF1, 0xE1, 0xF9, 0xF1, 0xF0, 0x7F, 0xF8, 0xF0, 0x1F,
  0xF8, 0xF8, 0x07, 0xF8, 0x18, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 12, 32, 27, 8, -31 },
  { 49, 16, 14, 27, 8, -33 },
  { 77, 28, 31, 27, 0, -31 },
  { 186, 26, 43, 27, 1, -37 },
  { 326, 32, 33, 27, -2, -32 },
  { 458, 27, 33, 27, 0, -32 },
  { 570, 8, 14, 27, 12, -33 },
  { 584, 19, 40, 27, 8, -34 },
  { 679, 19, 40, 27, 1, -34 },
  { 774, 24, 23, 27, 2, -25 },
  { 843, 22, 22, 27, 3, -25 },
  { 904, 12, 14, 27, 5, -7 },
  { 925, 15, 5, 27, 6, -16 },
  { 935, 8, 8, 27, 8, -7 },
  { 943, 27, 40, 27, 0, -34 },
  { 1078, 24, 33, 27, 2, -32 },
  { 1177, 22, 31, 27, 2, -31 },
  { 1263, 25, 32, 27, 1, -32 },
  { 1363, 25, 33, 27, 1, -32 },
  { 1467, 26, 31, 27, 0, -31 },
  { 1568, 25, 32, 27, 1, -31 },
  { 1668, 23, 32, 27, 2, -31 },
  { 1760, 24, 31, 27, 4, -31 },
  { 1853, 25, 33, 27, 1, -32 },
  { 1957, 23, 32, 27, 3, -32 },
  { 2049, 11, 24, 27, 8, -23 },
  { 2082, 14, 30, 27, 5, -23 },
  { 2135, 22, 27, 27, 4, -27 },
  { 2210, 24, 14, 27, 2, -21 },
  { 2252, 22, 27, 27, 2, -27 },
  { 2327, 20, 33, 27, 5, -32 },
  { 2410, 24, 37, 27, 2, -32 },
  { 2521, 26, 31, 27, -1, -31 },
  { 2622, 24, 31, 27, 2, -31 },
  { 2715, 24, 33, 27, 3, -32 },
  { 2814, 24, 31, 27, 2, -31 },
  { 2907, 25, 31, 27, 2, -31 },
  { 3004, 26, 31, 27, 2, -31 },
  { 3105, 24, 33, 27, 2, -32 },
  { 3204, 26, 31, 27, 1, -31 },
  { 3305, 25, 31, 27, 2, -31 },
  { 3402, 24, 32, 27, 2, -31 },
  { 3498, 29, 31, 27, 1, -31 },
  { 3611, 20, 31, 27, 3, -31 },
  { 3689, 28, 31, 27, 0, -31 },
  { 3798, 26, 31, 27, 1, -31 },
  { 3899, 24, 33, 27, 2, -32 },
  { 3998, 25, 31, 27, 2, -31 },
  { 4095, 24, 41, 27, 2, -32 },
  { 4218, 25, 31, 27, 2, -31 },
  { 4315, 26, 33, 27, 1, -32 },
  { 4423, 25, 31, 27, 4, -31 },
  { 4520, 24, 32, 27, 3, -31 },
  { 4616, 25, 31, 27, 4, -31 },
  { 4713, 28, 31, 27, 1, -31 },
  { 4822, 30, 31, 27, -1, -31 },
  { 4939, 26, 31, 27, 4, -31 },
  { 5040, 28, 31, 27, 0, -31 },
  { 5149, 20, 40, 27, 6, -34 },
  { 5249, 12, 40, 27, 8, -34 },
  { 5309, 21, 40, 27, 1, -34 },
  { 5414, 24, 19, 27, 2, -31 },
  { 5471, 22, 4, 27, 0, 4 },
  { 5482, 8, 10, 27, 9, -36 },
  { 5492, 23, 25, 27, 2, -24 },
  { 5564, 24, 34, 27, 1, -33 },
  { 5666, 21, 25, 27, 3, -24 },
  { 5732, 25, 34, 27, 2, -33 },
  { 5839, 22, 25, 27, 3, -24 },
  { 5908, 30, 43, 27, -1, -33 },
  { 6070, 25, 34, 27, 1, -24 },
  { 6177, 22, 33, 27, 2, -33 },
  { 6268, 22, 35, 27, 3, -34 },
  { 6365, 22, 44, 27, 1, -34 },
  { 6486, 24, 34, 27, 2, -33 },
  { 6588, 20, 34, 27, 4, -33 },
  { 6673, 26, 24, 27, 0, -24 },
  { 6751, 22, 24, 27, 2, -24 },
  { 6817, 23, 25, 27, 2, -24 },
  { 6889, 25, 33, 27, 0, -24 },
  { 6993, 24, 33, 27, 2, -24 },
  { 7092, 23, 23, 27, 4, -23 },
  { 7159, 22, 25, 27, 2, -24 },
  { 7228, 22, 32, 27, 3, -31 },
  { 7316, 22, 24, 27, 3, -23 },
  { 7382, 23, 25, 27, 2, -24 },
  { 7454, 25, 25, 27, 1, -24 },
  { 7533, 27, 25, 27, 0, -24 },
  { 7618, 24, 33, 27, 1, -23 },
  { 7717, 25, 25, 27, 1, -24 },
  { 7796, 22, 40, 27, 5, -34 },
  { 7906, 12, 40, 27, 8, -34 },
  { 7966, 22, 40, 27, 1, -34 },
  { 8076, 25, 10, 27, 1, -19 },
};

const GFXfont IBMPlexMono_SemiBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC45PT7B_H_
