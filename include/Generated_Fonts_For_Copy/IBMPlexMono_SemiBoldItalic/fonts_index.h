#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &IBMPlexMono_SemiBoldItalic6pt7b, 6, "IBMPlexMono_SemiBoldItalic6pt7b" },
  { &IBMPlexMono_SemiBoldItalic7pt7b, 7, "IBMPlexMono_SemiBoldItalic7pt7b" },
  { &IBMPlexMono_SemiBoldItalic8pt7b, 8, "IBMPlexMono_SemiBoldItalic8pt7b" },
  { &IBMPlexMono_SemiBoldItalic9pt7b, 9, "IBMPlexMono_SemiBoldItalic9pt7b" },
  { &IBMPlexMono_SemiBoldItalic10pt7b, 10, "IBMPlexMono_SemiBoldItalic10pt7b" },
  { &IBMPlexMono_SemiBoldItalic11pt7b, 11, "IBMPlexMono_SemiBoldItalic11pt7b" },
  { &IBMPlexMono_SemiBoldItalic12pt7b, 12, "IBMPlexMono_SemiBoldItalic12pt7b" },
  { &IBMPlexMono_SemiBoldItalic13pt7b, 13, "IBMPlexMono_SemiBoldItalic13pt7b" },
  { &IBMPlexMono_SemiBoldItalic14pt7b, 14, "IBMPlexMono_SemiBoldItalic14pt7b" },
  { &IBMPlexMono_SemiBoldItalic15pt7b, 15, "IBMPlexMono_SemiBoldItalic15pt7b" },
  { &IBMPlexMono_SemiBoldItalic16pt7b, 16, "IBMPlexMono_SemiBoldItalic16pt7b" },
  { &IBMPlexMono_SemiBoldItalic17pt7b, 17, "IBMPlexMono_SemiBoldItalic17pt7b" },
  { &IBMPlexMono_SemiBoldItalic18pt7b, 18, "IBMPlexMono_SemiBoldItalic18pt7b" },
  { &IBMPlexMono_SemiBoldItalic19pt7b, 19, "IBMPlexMono_SemiBoldItalic19pt7b" },
  { &IBMPlexMono_SemiBoldItalic20pt7b, 20, "IBMPlexMono_SemiBoldItalic20pt7b" },
  { &IBMPlexMono_SemiBoldItalic21pt7b, 21, "IBMPlexMono_SemiBoldItalic21pt7b" },
  { &IBMPlexMono_SemiBoldItalic22pt7b, 22, "IBMPlexMono_SemiBoldItalic22pt7b" },
  { &IBMPlexMono_SemiBoldItalic23pt7b, 23, "IBMPlexMono_SemiBoldItalic23pt7b" },
  { &IBMPlexMono_SemiBoldItalic24pt7b, 24, "IBMPlexMono_SemiBoldItalic24pt7b" },
  { &IBMPlexMono_SemiBoldItalic25pt7b, 25, "IBMPlexMono_SemiBoldItalic25pt7b" },
  { &IBMPlexMono_SemiBoldItalic26pt7b, 26, "IBMPlexMono_SemiBoldItalic26pt7b" },
  { &IBMPlexMono_SemiBoldItalic27pt7b, 27, "IBMPlexMono_SemiBoldItalic27pt7b" },
  { &IBMPlexMono_SemiBoldItalic28pt7b, 28, "IBMPlexMono_SemiBoldItalic28pt7b" },
  { &IBMPlexMono_SemiBoldItalic29pt7b, 29, "IBMPlexMono_SemiBoldItalic29pt7b" },
  { &IBMPlexMono_SemiBoldItalic30pt7b, 30, "IBMPlexMono_SemiBoldItalic30pt7b" },
  { &IBMPlexMono_SemiBoldItalic31pt7b, 31, "IBMPlexMono_SemiBoldItalic31pt7b" },
  { &IBMPlexMono_SemiBoldItalic32pt7b, 32, "IBMPlexMono_SemiBoldItalic32pt7b" },
  { &IBMPlexMono_SemiBoldItalic33pt7b, 33, "IBMPlexMono_SemiBoldItalic33pt7b" },
  { &IBMPlexMono_SemiBoldItalic34pt7b, 34, "IBMPlexMono_SemiBoldItalic34pt7b" },
  { &IBMPlexMono_SemiBoldItalic35pt7b, 35, "IBMPlexMono_SemiBoldItalic35pt7b" },
  { &IBMPlexMono_SemiBoldItalic36pt7b, 36, "IBMPlexMono_SemiBoldItalic36pt7b" },
  { &IBMPlexMono_SemiBoldItalic37pt7b, 37, "IBMPlexMono_SemiBoldItalic37pt7b" },
  { &IBMPlexMono_SemiBoldItalic38pt7b, 38, "IBMPlexMono_SemiBoldItalic38pt7b" },
  { &IBMPlexMono_SemiBoldItalic39pt7b, 39, "IBMPlexMono_SemiBoldItalic39pt7b" },
  { &IBMPlexMono_SemiBoldItalic40pt7b, 40, "IBMPlexMono_SemiBoldItalic40pt7b" },
  { &IBMPlexMono_SemiBoldItalic41pt7b, 41, "IBMPlexMono_SemiBoldItalic41pt7b" },
  { &IBMPlexMono_SemiBoldItalic42pt7b, 42, "IBMPlexMono_SemiBoldItalic42pt7b" },
  { &IBMPlexMono_SemiBoldItalic43pt7b, 43, "IBMPlexMono_SemiBoldItalic43pt7b" },
  { &IBMPlexMono_SemiBoldItalic44pt7b, 44, "IBMPlexMono_SemiBoldItalic44pt7b" },
  { &IBMPlexMono_SemiBoldItalic45pt7b, 45, "IBMPlexMono_SemiBoldItalic45pt7b" },
  { &IBMPlexMono_SemiBoldItalic46pt7b, 46, "IBMPlexMono_SemiBoldItalic46pt7b" },
  { &IBMPlexMono_SemiBoldItalic47pt7b, 47, "IBMPlexMono_SemiBoldItalic47pt7b" },
  { &IBMPlexMono_SemiBoldItalic48pt7b, 48, "IBMPlexMono_SemiBoldItalic48pt7b" },
  { &IBMPlexMono_SemiBoldItalic49pt7b, 49, "IBMPlexMono_SemiBoldItalic49pt7b" },
  { &IBMPlexMono_SemiBoldItalic50pt7b, 50, "IBMPlexMono_SemiBoldItalic50pt7b" },
  { &IBMPlexMono_SemiBoldItalic51pt7b, 51, "IBMPlexMono_SemiBoldItalic51pt7b" },
  { &IBMPlexMono_SemiBoldItalic52pt7b, 52, "IBMPlexMono_SemiBoldItalic52pt7b" },
  { &IBMPlexMono_SemiBoldItalic53pt7b, 53, "IBMPlexMono_SemiBoldItalic53pt7b" },
  { &IBMPlexMono_SemiBoldItalic54pt7b, 54, "IBMPlexMono_SemiBoldItalic54pt7b" },
  { &IBMPlexMono_SemiBoldItalic55pt7b, 55, "IBMPlexMono_SemiBoldItalic55pt7b" },
  { &IBMPlexMono_SemiBoldItalic56pt7b, 56, "IBMPlexMono_SemiBoldItalic56pt7b" },
  { &IBMPlexMono_SemiBoldItalic57pt7b, 57, "IBMPlexMono_SemiBoldItalic57pt7b" },
  { &IBMPlexMono_SemiBoldItalic58pt7b, 58, "IBMPlexMono_SemiBoldItalic58pt7b" },
  { &IBMPlexMono_SemiBoldItalic59pt7b, 59, "IBMPlexMono_SemiBoldItalic59pt7b" },
  { &IBMPlexMono_SemiBoldItalic60pt7b, 60, "IBMPlexMono_SemiBoldItalic60pt7b" },
  { &IBMPlexMono_SemiBoldItalic61pt7b, 61, "IBMPlexMono_SemiBoldItalic61pt7b" },
  { &IBMPlexMono_SemiBoldItalic62pt7b, 62, "IBMPlexMono_SemiBoldItalic62pt7b" },
  { &IBMPlexMono_SemiBoldItalic63pt7b, 63, "IBMPlexMono_SemiBoldItalic63pt7b" },
  { &IBMPlexMono_SemiBoldItalic64pt7b, 64, "IBMPlexMono_SemiBoldItalic64pt7b" },
  { &IBMPlexMono_SemiBoldItalic65pt7b, 65, "IBMPlexMono_SemiBoldItalic65pt7b" },
  { &IBMPlexMono_SemiBoldItalic66pt7b, 66, "IBMPlexMono_SemiBoldItalic66pt7b" },
  { &IBMPlexMono_SemiBoldItalic67pt7b, 67, "IBMPlexMono_SemiBoldItalic67pt7b" },
  { &IBMPlexMono_SemiBoldItalic68pt7b, 68, "IBMPlexMono_SemiBoldItalic68pt7b" },
  { &IBMPlexMono_SemiBoldItalic69pt7b, 69, "IBMPlexMono_SemiBoldItalic69pt7b" },
  { &IBMPlexMono_SemiBoldItalic70pt7b, 70, "IBMPlexMono_SemiBoldItalic70pt7b" },
  { &IBMPlexMono_SemiBoldItalic71pt7b, 71, "IBMPlexMono_SemiBoldItalic71pt7b" },
  { &IBMPlexMono_SemiBoldItalic72pt7b, 72, "IBMPlexMono_SemiBoldItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
