#ifndef _IBMPLEXMONO_SEMIBOLDITALIC67PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F,
  0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFD,
  0xFF, 0xC0, 0x7F, 0xC3, 0xF0, 0xFC, 0x03, 0xFE, 0x0F, 0xC1, 0xE0, 0x0F,
  0xF0, 0x3F, 0x03, 0x00, 0x3F, 0xC0, 0xF8, 0x08, 0x01, 0xFF, 0x03, 0xE0,
  0x00, 0x07, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x00, 0x7F,
  0xC1, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x1F, 0x00,
  0x00, 0x0F, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x7F, 0xF0, 0x00, 0x01,
  0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0x07, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x0F,
  0x80, 0xFF, 0x01, 0x00, 0x3E, 0x07, 0xFC, 0x06, 0x00, 0xF8, 0x1F, 0xF0,
  0x3C, 0x03, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0x83, 0xFE, 0x1F, 0xF0, 0x7E,
  0x3F, 0xF0, 0xFF, 0xF9, 0xFB, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x7F,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xE1, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC4, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x0F, 0xE0, 0x00, 0x03,
  0xF1, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x87, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x30, 0xFF, 0x80, 0x1F, 0xE0, 0x3C, 0xFF, 0x80, 0x1F, 0xE0, 0x7F,
  0x7F, 0x80, 0x3F, 0xF0, 0x7F, 0x7F, 0x80, 0x37, 0xF0, 0xFE, 0x7F, 0xC0,
  0x77, 0xF9, 0xFC, 0x7F, 0xE0, 0xF7, 0xF9, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x3F, 0x80,
  0x38, 0xFC, 0x07, 0xF0, 0x3F, 0x9F, 0xF0, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0x0F, 0xC1, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0xF8, 0x1F,
  0xF7, 0xFC, 0x1F, 0xC1, 0xFF, 0x7F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF,
  0x83, 0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xC1, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F,
  0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x03, 0xC0, 0x1F, 0xE0, 0x00, 0xC0, 0x0F,
  0xF0, 0x00, 0x40, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x0C, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x00,
  0xFF, 0xC0, 0x1E, 0x00, 0x03, 0xFE, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x02,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x20, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x7C,
  0x00, 0x03, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xFE, 0x00, 0x0F, 0xE3, 0xFF, 0xF8,
  0x00, 0x7F, 0x3F, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xFF, 0xC0, 0x3F, 0xBF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x04, 0x00,
  0x00, 0xFF, 0x80, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x07, 0xF0, 0x00, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0xF0, 0x1F,
  0xF3, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0xF1,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFE, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x7F,
  0xF7, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x1F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x00,
  0xFF, 0x8F, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x0F, 0xF8, 0x3F,
  0x80, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x7F, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0x9F, 0xFF, 0xFF,
  0x7F, 0xC3, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF,
  0xE3, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0x1F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0x80, 0x01, 0xFF, 0x0E, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0x87,
  0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x1F, 0xC0, 0xFF, 0xE7, 0xF3, 0xF8, 0x1F,
  0xFF, 0x7F, 0x3F, 0x81, 0xFF, 0xF7, 0xE3, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F,
  0x83, 0xF8, 0x1F, 0xE7, 0xF8, 0x7F, 0x00, 0xFE, 0x7F, 0x07, 0xF0, 0x0F,
  0xE7, 0xF0, 0xFE, 0x00, 0xFE, 0x7F, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0xFE,
  0x00, 0xFC, 0x7F, 0x0F, 0xE0, 0x1F, 0xCF, 0xF0, 0xFE, 0x01, 0xFC, 0xFE,
  0x1F, 0xC0, 0x1F, 0xCF, 0xE1, 0xFC, 0x01, 0xFC, 0xFE, 0x1F, 0xC0, 0x1F,
  0x8F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE1, 0xFC,
  0x07, 0xF8, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFC,
  0x0F, 0xF3, 0xFF, 0x0F, 0xC0, 0xFF, 0xFB, 0xF0, 0xFC, 0x0F, 0xFF, 0x7F,
  0x0F, 0xC0, 0xFF, 0xF7, 0xF0, 0xFC, 0x07, 0xFE, 0x7F, 0x0F, 0xE0, 0x3F,
  0xC7, 0xF0, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0xC3, 0xFC, 0x00,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xF8,
  0x1F, 0xF0, 0x00, 0x10, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x0F, 0xF8,
  0x00, 0x07, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x00,
  0x1F, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x10, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xFC, 0x7F,
  0xC0, 0x7F, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF,
  0x8F, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0x8F, 0xF8, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xEF, 0xE0, 0x3F,
  0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xF9, 0xFE,
  0x00, 0xFF, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0x1F, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1C, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x8F,
  0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x8F, 0xFC, 0x00,
  0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xEF, 0xE0, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x1F, 0xBF, 0xC0, 0x3F,
  0x9F, 0x8F, 0xEF, 0xF0, 0x0F, 0xE7, 0xE3, 0xF3, 0xF8, 0x07, 0xF9, 0xFD,
  0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x7E, 0x3F, 0x80, 0x7F, 0x9F, 0xFF, 0x9F,
  0xE0, 0x1F, 0xC3, 0xFF, 0xC7, 0xF8, 0x07, 0xF0, 0xFF, 0xE1, 0xFE, 0x01,
  0xFC, 0x3F, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3E, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x81, 0xFE, 0x01, 0xFE,
  0x03, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x38,
  0x07, 0xF8, 0x07, 0xF0, 0x04, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0xC0,
  0x03, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xF8,
  0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0xFE, 0x01, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xF8, 0x07, 0xF3,
  0xF8, 0x0F, 0xF0, 0x0F, 0xE7, 0xF8, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F,
  0xC0, 0x7F, 0x8F, 0xE0, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0xFE, 0x01, 0xFE,
  0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x3F, 0x80, 0x7F,
  0x83, 0xF8, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x07, 0xF3,
  0xFC, 0x03, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xF0, 0x1F, 0xCF, 0xF0, 0x1F,
  0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xFC, 0x07,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0xC0,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x00, 0x07,
  0xFC, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x1F, 0xF0, 0x00, 0x04,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x40, 0x00,
  0x03, 0xFE, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xFE, 0x07,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0xFE, 0x03, 0xFC, 0x1F, 0xF8, 0x1F, 0xC0,
  0x7F, 0x83, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0x7C, 0x1F, 0xC0, 0x3F, 0x83, 0xEF, 0x83, 0xF8, 0x07, 0xF0, 0xFD,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0x3E, 0x1F, 0xC0, 0x1F, 0xC3, 0xE7, 0xC3,
  0xF8, 0x03, 0xF8, 0xFC, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0x1F, 0x0F, 0xE0,
  0x1F, 0xE3, 0xE3, 0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x7C, 0x7F, 0x00, 0x7F,
  0x1F, 0x0F, 0x8F, 0xE0, 0x0F, 0xE3, 0xE1, 0xF1, 0xFC, 0x01, 0xFC, 0xFC,
  0x3E, 0x3F, 0x80, 0x3F, 0x9F, 0x07, 0xCF, 0xE0, 0x07, 0xF3, 0xE0, 0xF9,
  0xFC, 0x00, 0xFE, 0xFC, 0x1F, 0x3F, 0x80, 0x1F, 0xDF, 0x03, 0xE7, 0xF0,
  0x07, 0xFB, 0xE0, 0x7C, 0xFC, 0x00, 0xFE, 0xFC, 0x0F, 0xBF, 0x80, 0x1F,
  0xDF, 0x81, 0xF7, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xD1, 0xE0,
  0x00, 0x00, 0xF0, 0x04, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x02, 0x00, 0xF0, 0x3F, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3C, 0x01,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF,
  0xC3, 0xFC, 0x07, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF,
  0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F,
  0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xF0,
  0x7F, 0xE0, 0xF7, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xFE,
  0x00, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0xFE, 0x03, 0xFE, 0x7F,
  0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0x81, 0xFE,
  0xF8, 0x3F, 0xF8, 0x7F, 0xDC, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F,
  0xF1, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFB,
  0xFF, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0xF8, 0x1F, 0xE7, 0xFF, 0xFE, 0x07,
  0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE,
  0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFC, 0x3F, 0xE0,
  0x00, 0xF0, 0x3F, 0xE0, 0x00, 0x40, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x40, 0xFF, 0x80,
  0x00, 0x70, 0xFF, 0x80, 0x00, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0xF3, 0xFE,
  0x00, 0xFF, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF,
  0xFE, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x1E, 0xFF, 0x00, 0x7F,
  0xFF, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xFE, 0x7F,
  0xC0, 0x0F, 0xFF, 0xF1, 0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xF1, 0xFE, 0x03, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xC0,
  0xFF, 0x80, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x7E, 0x1F, 0xF0, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xE3, 0xFE,
  0x00, 0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF,
  0xF7, 0xF8, 0x0F, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x3D, 0xFF, 0x01, 0xFF, 0xFF, 0xEF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xF3, 0xFC, 0x00, 0xFF, 0xFF,
  0x1F, 0xE0, 0x03, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x01, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x0F,
  0xFF, 0xC0, 0x3F, 0xC7, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0xFE, 0x07, 0xFC,
  0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xF0, 0x7F, 0xDE, 0x0F, 0xFC, 0x1F,
  0xEE, 0x01, 0xFF, 0x07, 0xFB, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0xC0, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x30, 0x00, 0xFF, 0x80, 0x78, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFE, 0x3F, 0xF0, 0x01, 0xFE,
  0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x40, 0x07,
  0xFC, 0x00, 0x18, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF0, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xE1, 0xFF,
  0xF8, 0x00, 0xFF, 0x1F, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xFF, 0x80, 0x7F,
  0xCF, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0x83, 0xFF,
  0x00, 0xFF, 0x70, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xF0,
  0x01, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xCF, 0xFC, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x02, 0x07, 0xFC, 0x3F, 0xC0, 0x38, 0x3F, 0xC1, 0xFF, 0x03, 0xE1,
  0xFE, 0x07, 0xF8, 0x3F, 0x8F, 0xF0, 0x3F, 0xE3, 0xFE, 0xFF, 0x81, 0xFF,
  0x3F, 0xE7, 0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xE1, 0xFE,
  0x00, 0xFF, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x20, 0x07, 0xF8, 0x03, 0x80, 0x3F, 0xC0, 0x3E,
  0x03, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x07, 0xFE, 0x07,
  0xF8, 0x7F, 0xE0, 0x3F, 0xC7, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF7,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x0F, 0xE3, 0xFC, 0x0F,
  0xF8, 0x1F, 0xCF, 0xFC, 0x3F, 0xF0, 0x3F, 0x9F, 0xF8, 0xFF, 0xF0, 0x7F,
  0x7F, 0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xF7, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF,
  0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFE, 0x1F,
  0xE0, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x07, 0xF1, 0xFE, 0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x07, 0xF1,
  0xFC, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0xFF,
  0x03, 0xFF, 0x00, 0x3F, 0xC3, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0xFC, 0x07,
  0xFC, 0x7F, 0xFF, 0x81, 0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFC,
  0x1F, 0xF7, 0x83, 0xFF, 0x07, 0xFB, 0x80, 0x7F, 0xC1, 0xFE, 0xC0, 0x1F,
  0xF0, 0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xF0, 0x03, 0xFE,
  0x3F, 0xFF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFE, 0x00, 0xFF, 0x3F, 0xFF, 0xF8,
  0x07, 0xF9, 0xFF, 0xFF, 0xC0, 0x3F, 0xDF, 0x07, 0xFF, 0x03, 0xFE, 0xE0,
  0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xF7,
  0xFF, 0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xC0,
  0x3F, 0xE3, 0xFF, 0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0x87, 0xFC, 0x03,
  0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xF3, 0xFC,
  0x0F, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFE, 0x07, 0xBF, 0xC0, 0xFF, 0xFF, 0xF7,
  0xF8, 0x1F, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF,
  0xC7, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xBF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF,
  0xEF, 0xFF, 0xF8, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFC, 0x01, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0x7C, 0x00, 0x00, 0x7F, 0xB8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3C, 0x07, 0xFC,
  0x00, 0x04, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x04, 0x00, 0x00, 0xFF, 0x03, 0x00, 0x00, 0xFF,
  0x83, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x20, 0x03, 0xFE, 0x00, 0x70, 0x03, 0xFE, 0x00, 0xF8, 0x03, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x03, 0xFC,
  0x3F, 0xF8, 0x07, 0xFC, 0x7F, 0xF0, 0x07, 0xFC, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xE0, 0x07, 0xFF, 0x0F, 0xF8, 0x03, 0x7F, 0xC3, 0xFE, 0x01, 0xDF,
  0xE0, 0xFF, 0xE0, 0xF7, 0xF8, 0x3F, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xFC,
  0xFF, 0x81, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0x8F, 0xF8, 0x07, 0xFF,
  0xC3, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x06, 0x1F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xE0, 0x1F, 0xF1,
  0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xFF, 0x80, 0x3F,
  0xEF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0xC0, 0x1F, 0xE3,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x30, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x0F,
  0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x1F,
  0xC7, 0xF0, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F,
  0xC0, 0x3F, 0x8F, 0xC0, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x07, 0xF1,
  0xFC, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0x3F, 0x87,
  0xE0, 0x7F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0xFF, 0x1E, 0xF8,
  0x3F, 0x83, 0xFF, 0xFB, 0xF1, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xF0, 0x1F,
  0xFF, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFE,
  0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFC,
  0xFE, 0xF8, 0xFF, 0x3F, 0xF8, 0xFE, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0xE0,
  0x7F, 0x0F, 0xC0, 0xFE, 0xC0, 0x7F, 0x07, 0x00, 0xFF, 0xC0, 0x7F, 0x06,
  0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1E, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x60, 0xFE,
  0x03, 0xFF, 0x00, 0xF0, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0x7F,
  0x07, 0xF8, 0xFE, 0x07, 0x7F, 0x1F, 0xFC, 0xFF, 0x1F, 0x7F, 0x3F, 0xF0,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFC, 0x07,
  0xFE, 0x03, 0xBF, 0xC0, 0x3F, 0xF8, 0x3D, 0xFE, 0x00, 0xFF, 0xFF, 0xCF,
  0xF0, 0x07, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xE7, 0xFC, 0x00, 0xFF,
  0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xE1, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x01,
  0x80, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xC1, 0xFC,
  0x07, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0x00, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x60, 0x00,
  0x3F, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x00, 0xFE, 0x0F, 0xFF,
  0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0x87, 0xFF, 0xFF, 0xF8, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFD, 0xFF, 0xFF, 0xFF, 0x1F, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xF8, 0x3F,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0xFF,
  0xF0, 0x00, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0x00, 0x3F,
  0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0x1F, 0xC3, 0xF8, 0xFF,
  0x81, 0xFC, 0x3F, 0x83, 0xFE, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x1F,
  0xC0, 0x7F, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xFF,
  0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0x80,
  0x03, 0xFF, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 18, 48, 40, 12, -47 },
  { 109, 25, 21, 40, 11, -50 },
  { 175, 42, 47, 40, 0, -47 },
  { 422, 38, 63, 40, 1, -55 },
  { 722, 47, 49, 40, -2, -48 },
  { 1010, 40, 49, 40, 0, -48 },
  { 1255, 11, 21, 40, 18, -50 },
  { 1284, 28, 60, 40, 12, -51 },
  { 1494, 27, 60, 40, 2, -51 },
  { 1697, 35, 34, 40, 3, -37 },
  { 1846, 33, 33, 40, 4, -37 },
  { 1983, 18, 21, 40, 8, -11 },
  { 2031, 22, 8, 40, 10, -24 },
  { 2053, 13, 12, 40, 12, -11 },
  { 2073, 39, 60, 40, 1, -51 },
  { 2366, 36, 49, 40, 3, -48 },
  { 2587, 33, 47, 40, 3, -47 },
  { 2781, 37, 48, 40, 1, -48 },
  { 3003, 37, 49, 40, 1, -48 },
  { 3230, 37, 47, 40, 1, -47 },
  { 3448, 37, 48, 40, 2, -47 },
  { 3670, 34, 48, 40, 3, -47 },
  { 3874, 35, 47, 40, 6, -47 },
  { 4080, 37, 49, 40, 2, -48 },
  { 4307, 34, 48, 40, 5, -48 },
  { 4511, 16, 36, 40, 12, -35 },
  { 4583, 20, 45, 40, 8, -35 },
  { 4696, 32, 40, 40, 6, -41 },
  { 4856, 35, 21, 40, 3, -31 },
  { 4948, 33, 40, 40, 3, -41 },
  { 5113, 30, 49, 40, 8, -48 },
  { 5297, 36, 56, 40, 3, -48 },
  { 5549, 39, 47, 40, -2, -47 },
  { 5779, 35, 47, 40, 3, -47 },
  { 5985, 36, 49, 40, 4, -48 },
  { 6206, 37, 47, 40, 2, -47 },
  { 6424, 37, 47, 40, 3, -47 },
  { 6642, 38, 47, 40, 3, -47 },
  { 6866, 36, 49, 40, 3, -48 },
  { 7087, 39, 47, 40, 2, -47 },
  { 7317, 38, 47, 40, 2, -47 },
  { 7541, 35, 48, 40, 3, -47 },
  { 7751, 42, 47, 40, 2, -47 },
  { 7998, 31, 47, 40, 4, -47 },
  { 8181, 42, 47, 40, 0, -47 },
  { 8428, 39, 47, 40, 2, -47 },
  { 8658, 36, 49, 40, 3, -48 },
  { 8879, 37, 47, 40, 3, -47 },
  { 9097, 36, 61, 40, 3, -48 },
  { 9372, 37, 47, 40, 3, -47 },
  { 9590, 39, 49, 40, 1, -48 },
  { 9829, 38, 47, 40, 5, -47 },
  { 10053, 37, 48, 40, 4, -47 },
  { 10275, 38, 47, 40, 6, -47 },
  { 10499, 43, 47, 40, 1, -47 },
  { 10752, 45, 47, 40, -2, -47 },
  { 11017, 39, 47, 40, 5, -47 },
  { 11247, 41, 47, 40, 0, -47 },
  { 11488, 30, 60, 40, 9, -51 },
  { 11713, 19, 60, 40, 11, -51 },
  { 11856, 30, 60, 40, 2, -51 },
  { 12081, 36, 29, 40, 3, -47 },
  { 12212, 34, 7, 40, -1, 5 },
  { 12242, 12, 15, 40, 13, -54 },
  { 12265, 34, 36, 40, 3, -35 },
  { 12418, 35, 51, 40, 2, -50 },
  { 12642, 32, 36, 40, 4, -35 },
  { 12786, 38, 51, 40, 3, -50 },
  { 13029, 33, 36, 40, 4, -35 },
  { 13178, 46, 64, 40, -2, -50 },
  { 13546, 37, 49, 40, 1, -35 },
  { 13773, 34, 50, 40, 2, -50 },
  { 13986, 32, 51, 40, 5, -50 },
  { 14190, 34, 64, 40, 1, -50 },
  { 14462, 37, 51, 40, 2, -50 },
  { 14698, 29, 51, 40, 6, -50 },
  { 14883, 39, 35, 40, 0, -35 },
  { 15054, 34, 35, 40, 2, -35 },
  { 15203, 34, 36, 40, 3, -35 },
  { 15356, 37, 48, 40, 0, -35 },
  { 15578, 35, 48, 40, 3, -35 },
  { 15788, 33, 35, 40, 7, -35 },
  { 15933, 33, 36, 40, 3, -35 },
  { 16082, 32, 48, 40, 5, -47 },
  { 16274, 34, 36, 40, 4, -35 },
  { 16427, 34, 36, 40, 3, -35 },
  { 16580, 38, 36, 40, 1, -35 },
  { 16751, 40, 36, 40, 0, -35 },
  { 16931, 37, 49, 40, 1, -35 },
  { 17158, 37, 36, 40, 2, -35 },
  { 17325, 32, 60, 40, 7, -51 },
  { 17565, 17, 60, 40, 12, -51 },
  { 17693, 33, 60, 40, 2, -51 },
  { 17941, 37, 17, 40, 2, -29 },
};

const GFXfont IBMPlexMono_SemiBoldItalic67pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic67pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic67pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC67PT7B_H_
