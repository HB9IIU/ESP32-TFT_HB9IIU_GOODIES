#ifndef _IBMPLEXMONO_SEMIBOLDITALIC61PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF9, 0xF7, 0xFC, 0x07, 0xFC,
  0x7C, 0x3F, 0x00, 0xFF, 0x0F, 0x83, 0xC0, 0x3F, 0xC1, 0xF0, 0x30, 0x07,
  0xF8, 0x3E, 0x00, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x00, 0x0F, 0xF0, 0xF8,
  0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF1,
  0xFF, 0x00, 0x00, 0x3E, 0x1F, 0xF0, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x00,
  0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0xFF, 0x00,
  0x00, 0xF8, 0x1F, 0xE0, 0x60, 0x1F, 0x03, 0xF8, 0x1E, 0x03, 0xE0, 0xFF,
  0x07, 0xE0, 0x7C, 0x3F, 0xE1, 0xFE, 0x0F, 0x8F, 0xF8, 0x7F, 0xF1, 0xF7,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x00, 0x07, 0xFF, 0xE2, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0xFF,
  0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0xFC,
  0x00, 0x03, 0xF1, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xC0, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE1, 0xF8, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xFF, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x18, 0xFF, 0x00, 0x7F, 0x81, 0xEF, 0xF0, 0x07, 0xF8, 0x3F,
  0xFF, 0x00, 0xFF, 0xC7, 0xF7, 0xF8, 0x0D, 0xFC, 0x7E, 0x7F, 0xC3, 0xDF,
  0xCF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0xCF, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x07, 0xF0, 0x06, 0x3E,
  0x07, 0xF0, 0x3E, 0x7F, 0xC7, 0xF1, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xC3, 0xFF,
  0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xE7, 0xFC,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0xF8, 0x1F, 0xFF,
  0xF0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x0F, 0xF7, 0xF8, 0x7F, 0x87, 0xFB,
  0xFC, 0x3F, 0xC3, 0xFD, 0xFE, 0x1F, 0xC1, 0xFE, 0xFF, 0x07, 0xC0, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xDF,
  0xE0, 0x07, 0xFE, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x87, 0xF8,
  0x07, 0xFC, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01,
  0xF8, 0x0F, 0xF0, 0x03, 0xC0, 0x3F, 0xC0, 0x06, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x07, 0xFC,
  0x01, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xF0,
  0x03, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x1F, 0xF0, 0x06,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x04, 0x00, 0x01, 0xFE,
  0x03, 0x00, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0xFF, 0x00, 0x3F,
  0x3F, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x0F, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x03, 0x00,
  0x00, 0xFF, 0x81, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0x81, 0xFE,
  0x7F, 0xFF, 0x87, 0xFD, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFE,
  0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF8,
  0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFB, 0xFC, 0x1F,
  0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0x8F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x9F, 0xF8, 0x3F, 0xFB, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xEF, 0xC0, 0x03, 0xFC, 0x78, 0x00, 0x7F, 0x82, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x1F, 0x81, 0xFF, 0x3F, 0x3F, 0x83,
  0xFF, 0xBF, 0x3F, 0x07, 0xFF, 0xBF, 0x3F, 0x07, 0xFF, 0xBF, 0x7F, 0x0F,
  0xF0, 0xFF, 0x7F, 0x0F, 0xE0, 0x7F, 0x7E, 0x1F, 0xC0, 0x7E, 0x7E, 0x1F,
  0xC0, 0x7E, 0x7E, 0x1F, 0x80, 0x7E, 0xFE, 0x1F, 0x80, 0x7E, 0xFE, 0x3F,
  0x80, 0x7E, 0xFE, 0x3F, 0x80, 0x7E, 0xFC, 0x3F, 0x00, 0xFC, 0xFC, 0x3F,
  0x00, 0xFC, 0xFC, 0x3F, 0x00, 0xFC, 0xFC, 0x3F, 0x00, 0xFC, 0xFC, 0x3F,
  0x01, 0xFC, 0xFC, 0x3F, 0x03, 0xFC, 0xFC, 0x3F, 0x83, 0xF8, 0xFC, 0x3F,
  0xCF, 0xF8, 0xFC, 0x1F, 0xFD, 0xF8, 0xFC, 0x1F, 0xFD, 0xF8, 0xFC, 0x0F,
  0xF9, 0xF8, 0xFC, 0x0F, 0xF3, 0xF8, 0xFC, 0x03, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x87,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x7E, 0x3F, 0xE0, 0x00, 0x60, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x02, 0x00, 0xFE, 0x00, 0x03,
  0xC0, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F,
  0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x0F,
  0xD1, 0xFE, 0x00, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xF9, 0xFF, 0x01,
  0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0xFE, 0x3F, 0xC0,
  0x7F, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xE7, 0xF0,
  0x07, 0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0xE3, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x1F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x0F,
  0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x0F,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xBF, 0x00, 0xFD,
  0xF8, 0x7E, 0xFC, 0x07, 0xF7, 0xE3, 0xF7, 0xF0, 0x1F, 0xDF, 0x8F, 0xDF,
  0xC0, 0x7F, 0x3F, 0x7E, 0x7F, 0x01, 0xFC, 0xFD, 0xF9, 0xFC, 0x07, 0xE3,
  0xFF, 0xC7, 0xE0, 0x1F, 0x8F, 0xFF, 0x1F, 0x80, 0xFE, 0x3F, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0, 0x3F, 0x87,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0x81, 0xFC, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x1F, 0xC0, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0x80, 0xFE, 0x03, 0xF8, 0x06, 0x03, 0xF8, 0x0F, 0xE0, 0x10,
  0x0F, 0xE0, 0x3F, 0x80, 0x40, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xE0,
  0x7F, 0xF0, 0x01, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0xC0, 0x0F,
  0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xF0,
  0x07, 0xF0, 0x3F, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF,
  0xF8, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0,
  0x7E, 0xFE, 0x03, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x03, 0xF9, 0xF8, 0x0F,
  0xE0, 0x7F, 0x3F, 0x01, 0xF8, 0x0F, 0xE7, 0xF0, 0x7F, 0x01, 0xFC, 0xFE,
  0x0F, 0xE0, 0x3F, 0x9F, 0xC1, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x81, 0xFC,
  0x3F, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x3F, 0x80,
  0xFE, 0x1F, 0xC7, 0xF0, 0x1F, 0xC1, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x1F,
  0xC0, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x7E, 0x03, 0xF8, 0x1F,
  0xDF, 0xC0, 0x7F, 0x01, 0xFB, 0xF8, 0x0F, 0xE0, 0x3F, 0x7F, 0x03, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0x01,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFC, 0x07, 0xF0, 0x07, 0xFF,
  0x81, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xFE, 0x07, 0xF0, 0x03,
  0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE3, 0xFE,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x01, 0x80, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC,
  0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x1F, 0xE0, 0x00, 0x10, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x01,
  0x80, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xF8,
  0x3F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x83,
  0xF0, 0x1F, 0xC3, 0xFF, 0x07, 0xE0, 0x3F, 0x07, 0xFE, 0x1F, 0xC0, 0x7E,
  0x0F, 0xFC, 0x3F, 0x80, 0xFC, 0x3E, 0xF8, 0x7E, 0x03, 0xF8, 0x7D, 0xF0,
  0xFC, 0x07, 0xF0, 0xFB, 0xE1, 0xF8, 0x0F, 0xE3, 0xE7, 0xC7, 0xF0, 0x1F,
  0xC7, 0xCF, 0x8F, 0xC0, 0x3F, 0x8F, 0x9F, 0x1F, 0x80, 0x7F, 0x3E, 0x3E,
  0x3F, 0x00, 0xFC, 0x7C, 0x7C, 0xFE, 0x01, 0xF8, 0xF8, 0xF9, 0xFC, 0x03,
  0xF3, 0xE1, 0xF3, 0xF0, 0x07, 0xE7, 0xC3, 0xE7, 0xE0, 0x0F, 0xCF, 0x87,
  0xCF, 0xC0, 0x3F, 0xBE, 0x0F, 0xBF, 0x80, 0x7F, 0x7C, 0x1F, 0x7E, 0x00,
  0xFE, 0xF8, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x7D, 0xF8, 0x03, 0xFF, 0xC0,
  0xFB, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00,
  0x7C, 0x0C, 0x00, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x01, 0xC0, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x04, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xC7, 0xF8,
  0x3F, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0x9F, 0xE1, 0xFF, 0xFF, 0xBF, 0x87,
  0xFE, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0x80, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x03,
  0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x0F, 0x7F, 0x83, 0xFF, 0xFE, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0x8F, 0xFF, 0x83, 0xFF,
  0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0xF0, 0x07, 0xF8, 0xFF, 0xF8,
  0x07, 0xF1, 0xFF, 0xFC, 0x0F, 0xF3, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFE,
  0x0F, 0xF7, 0x83, 0xFE, 0x0F, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC,
  0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0,
  0x7F, 0x7F, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0xC0,
  0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xE1, 0xFE, 0x00, 0x1C,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x10, 0x7F, 0x80, 0x01, 0xC3, 0xFC, 0x00, 0x1F, 0x9F,
  0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x0F, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xFC, 0xFE,
  0x01, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xDF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x06, 0xFF, 0x03, 0xFF, 0x07,
  0xBF, 0x80, 0x7F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xF7, 0xF8, 0x03, 0xFF,
  0xF9, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0x80, 0x0F, 0xFC, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x03,
  0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFB, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x06, 0x1F, 0xE0, 0x00, 0x78, 0xFF, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x10, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xE3, 0xFC, 0x07, 0xFF,
  0xFC, 0xFE, 0x01, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x1E, 0xFF, 0x01,
  0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0xE7, 0xF8,
  0x01, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x1F, 0xE0, 0x07, 0x80,
  0x0F, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x1F, 0xFC, 0x03, 0xFC, 0x7F, 0xFC, 0x07,
  0xF9, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF, 0xF8, 0x1F, 0xCE, 0x1F, 0xF0, 0x7F,
  0xB0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x18,
  0x00, 0xFF, 0x01, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xFE, 0x01,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF9,
  0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x10, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x20, 0x07, 0xF0, 0x01, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE1,
  0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0xF0, 0x07, 0xF1, 0xFF, 0xFC, 0x03, 0xF9,
  0xFF, 0xFF, 0x01, 0xFD, 0xE1, 0xFF, 0x81, 0xFE, 0xC0, 0x3F, 0xC0, 0xFF,
  0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0x0F, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x01,
  0x07, 0xF0, 0xFF, 0x01, 0xC3, 0xF8, 0x3F, 0xC1, 0xF3, 0xFC, 0x1F, 0xE1,
  0xFD, 0xFE, 0x07, 0xF1, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x7F, 0x81, 0xFF,
  0xFE, 0x3F, 0x80, 0x7F, 0xFE, 0x1F, 0xC0, 0x3F, 0xFE, 0x1F, 0xE0, 0x0F,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x18, 0x07, 0xF0, 0x0F, 0x03, 0xFC, 0x07,
  0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xF8,
  0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x3F, 0x83,
  0xFC, 0x07, 0xE7, 0xFC, 0x7F, 0xE0, 0xFE, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFD, 0x8F, 0xD8, 0xFF, 0x0F, 0xF0, 0xFD, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE0,
  0x7E, 0x1F, 0xC0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x81, 0xFC, 0x3F, 0x03,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x03,
  0xF8, 0x7E, 0x07, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x03, 0xF0, 0xFE, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0xE0,
  0x1F, 0xE3, 0xFF, 0xE0, 0x3F, 0xCF, 0xFF, 0xE0, 0x7F, 0x3F, 0xFF, 0xC0,
  0xFE, 0x70, 0xFF, 0x83, 0xFD, 0x80, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x0F,
  0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0xFF,
  0x00, 0x1F, 0xE3, 0xFF, 0xE0, 0x07, 0xF1, 0xFF, 0xFC, 0x01, 0xFC, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0xE0, 0x3F, 0xDE, 0x0F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0x7F, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF, 0xFC, 0x03,
  0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xF8, 0xFE, 0x03,
  0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xFD, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x6F, 0xF0, 0xFF, 0xC1, 0xEF, 0xE0, 0x7F,
  0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0x9F, 0xE0, 0x3F,
  0xFF, 0x1F, 0xE0, 0x0F, 0xFE, 0x1F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0xFD, 0xFF,
  0xFC, 0x1F, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0x80, 0x7F, 0xBF,
  0xFE, 0x01, 0xFE, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x38, 0x0F, 0xE0,
  0x00, 0x40, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x18, 0x00,
  0x0F, 0xF0, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFE, 0x3F, 0xF0, 0x1F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x08, 0x00, 0xFF, 0x00, 0x70, 0x03, 0xFC, 0x03, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x80, 0xFE, 0x0F, 0xF8, 0x07,
  0xF8, 0xFF, 0xC0, 0x1F, 0xE7, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0xFF, 0x8F, 0xE0, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xF8, 0xFF,
  0x00, 0xDF, 0xC3, 0xFC, 0x07, 0xFF, 0x0F, 0xF8, 0x3B, 0xFC, 0x3F, 0xFF,
  0xCF, 0xF0, 0x7F, 0xFF, 0x3F, 0xC0, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0x83,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xFF, 0xF0, 0x03,
  0xE7, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0x01, 0xFE, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x03, 0xFE, 0x01, 0xFC, 0x3F, 0xF0, 0x07, 0xF3,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x07, 0xF1, 0xF8,
  0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7F, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0xFC, 0xFE, 0x07, 0xE0, 0x3F,
  0x3F, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x80,
  0xFC, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F, 0x03, 0xF0, 0x1F, 0xDF, 0xC0, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E, 0x7E, 0x03,
  0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x03, 0xF1, 0xF8,
  0x1F, 0x81, 0xF8, 0xFE, 0x0F, 0xE0, 0x7E, 0x3F, 0x87, 0xF8, 0x3F, 0x0F,
  0xE3, 0xFE, 0x0F, 0xC3, 0xFF, 0xEF, 0xC7, 0xE0, 0x7F, 0xFB, 0xFF, 0xF0,
  0x1F, 0xFC, 0x7F, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFC, 0xFC, 0xE3, 0xFC, 0xFF, 0xC7,
  0xEE, 0x0F, 0xE3, 0xF8, 0x3F, 0x70, 0x7F, 0x0F, 0x81, 0xFB, 0x03, 0xF8,
  0x30, 0x0F, 0xF8, 0x1F, 0xC1, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x04, 0x1F, 0x80, 0xDF, 0x80, 0xE0, 0xFC, 0x0E, 0xFC,
  0x0F, 0x87, 0xE0, 0x77, 0xE1, 0xFE, 0x3F, 0x87, 0x3F, 0x1F, 0xF9, 0xFC,
  0x79, 0xF9, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0x80,
  0x2F, 0xF0, 0x3F, 0xC0, 0x37, 0xF8, 0x1F, 0xF0, 0x73, 0xF8, 0x0F, 0xFF,
  0xFB, 0xFC, 0x03, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0x7F,
  0xFC, 0x7F, 0x80, 0x1F, 0xF8, 0x3F, 0xC0, 0x03, 0xF0, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x01, 0x00, 0x07, 0xFC, 0x01, 0xC0, 0x07, 0xFC, 0x01,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x1F, 0xC0, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFF,
  0xF3, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x00, 0x7F, 0xFC, 0x3F, 0x80,
  0x1F, 0xFC, 0x1F, 0x80, 0x0F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFC, 0x07, 0xE0,
  0x0F, 0xF8, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x04, 0x00,
  0x0F, 0xF8, 0x0F, 0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0xF8, 0x07, 0xE0,
  0x1F, 0xF0, 0x03, 0xF0, 0x1F, 0xF0, 0x01, 0xF8, 0x1F, 0xF0, 0x00, 0x7E,
  0x1F, 0xFC, 0x00, 0x3F, 0x1F, 0xFF, 0xF0, 0x1F, 0x8F, 0xFF, 0xFF, 0x8F,
  0xCF, 0xE3, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF,
  0xE1, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x7F, 0xF8,
  0x01, 0xF8, 0x3F, 0xFF, 0x00, 0x7E, 0x0F, 0xFF, 0xC0, 0x1F, 0x87, 0xFF,
  0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0x03, 0xF0, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F,
  0x07, 0xF8, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0xFF, 0xC3,
  0xF8, 0x07, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0xFC,
  0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 16, 44, 37, 11, -43 },
  { 89, 23, 19, 37, 10, -45 },
  { 144, 38, 43, 37, 0, -43 },
  { 349, 35, 56, 37, 1, -49 },
  { 594, 43, 44, 37, -2, -43 },
  { 831, 36, 44, 37, 0, -43 },
  { 1029, 10, 19, 37, 17, -45 },
  { 1053, 25, 54, 37, 11, -46 },
  { 1222, 25, 54, 37, 2, -46 },
  { 1391, 32, 31, 37, 3, -33 },
  { 1515, 30, 30, 37, 4, -34 },
  { 1628, 17, 19, 37, 7, -10 },
  { 1669, 20, 8, 37, 9, -23 },
  { 1689, 12, 11, 37, 10, -10 },
  { 1706, 36, 54, 37, 0, -46 },
  { 1949, 33, 44, 37, 3, -43 },
  { 2131, 30, 43, 37, 3, -43 },
  { 2293, 34, 43, 37, 1, -43 },
  { 2476, 34, 44, 37, 1, -43 },
  { 2663, 34, 43, 37, 1, -43 },
  { 2846, 34, 44, 37, 2, -43 },
  { 3033, 31, 44, 37, 3, -43 },
  { 3204, 32, 43, 37, 5, -43 },
  { 3376, 34, 44, 37, 2, -43 },
  { 3563, 32, 43, 37, 4, -43 },
  { 3735, 16, 33, 37, 10, -32 },
  { 3801, 19, 41, 37, 7, -32 },
  { 3899, 30, 36, 37, 5, -37 },
  { 4034, 32, 19, 37, 3, -28 },
  { 4110, 30, 36, 37, 3, -37 },
  { 4245, 27, 44, 37, 7, -43 },
  { 4394, 32, 50, 37, 3, -43 },
  { 4594, 35, 43, 37, -2, -43 },
  { 4783, 33, 43, 37, 2, -43 },
  { 4961, 32, 44, 37, 4, -43 },
  { 5137, 33, 43, 37, 2, -43 },
  { 5315, 34, 43, 37, 2, -43 },
  { 5498, 35, 43, 37, 2, -43 },
  { 5687, 33, 44, 37, 3, -43 },
  { 5869, 35, 43, 37, 2, -43 },
  { 6058, 34, 43, 37, 2, -43 },
  { 6241, 33, 44, 37, 2, -43 },
  { 6423, 38, 43, 37, 2, -43 },
  { 6628, 27, 43, 37, 4, -43 },
  { 6774, 38, 43, 37, 0, -43 },
  { 6979, 35, 43, 37, 2, -43 },
  { 7168, 33, 44, 37, 3, -43 },
  { 7350, 34, 43, 37, 2, -43 },
  { 7533, 33, 55, 37, 3, -43 },
  { 7760, 34, 43, 37, 2, -43 },
  { 7943, 35, 44, 37, 1, -43 },
  { 8136, 35, 43, 37, 5, -43 },
  { 8325, 34, 44, 37, 3, -43 },
  { 8512, 34, 43, 37, 6, -43 },
  { 8695, 39, 43, 37, 1, -43 },
  { 8905, 42, 43, 37, -2, -43 },
  { 9131, 36, 43, 37, 5, -43 },
  { 9325, 37, 43, 37, 0, -43 },
  { 9524, 28, 54, 37, 8, -46 },
  { 9713, 17, 54, 37, 10, -46 },
  { 9828, 28, 54, 37, 1, -46 },
  { 10017, 32, 26, 37, 3, -43 },
  { 10121, 30, 6, 37, 0, 5 },
  { 10144, 11, 14, 37, 12, -49 },
  { 10164, 31, 33, 37, 3, -32 },
  { 10292, 32, 46, 37, 2, -45 },
  { 10476, 29, 33, 37, 4, -32 },
  { 10596, 34, 46, 37, 3, -45 },
  { 10792, 29, 33, 37, 4, -32 },
  { 10912, 42, 58, 37, -2, -45 },
  { 11217, 34, 45, 37, 1, -32 },
  { 11409, 31, 45, 37, 2, -45 },
  { 11584, 29, 46, 37, 4, -45 },
  { 11751, 31, 58, 37, 1, -45 },
  { 11976, 33, 46, 37, 2, -45 },
  { 12166, 26, 46, 37, 6, -45 },
  { 12316, 36, 32, 37, 0, -32 },
  { 12460, 31, 32, 37, 2, -32 },
  { 12584, 31, 33, 37, 3, -32 },
  { 12712, 34, 44, 37, 0, -32 },
  { 12899, 32, 44, 37, 3, -32 },
  { 13075, 30, 31, 37, 6, -31 },
  { 13192, 30, 33, 37, 3, -32 },
  { 13316, 30, 44, 37, 4, -43 },
  { 13481, 30, 32, 37, 4, -31 },
  { 13601, 30, 33, 37, 3, -32 },
  { 13725, 34, 33, 37, 1, -32 },
  { 13866, 37, 33, 37, 0, -32 },
  { 14019, 33, 44, 37, 1, -31 },
  { 14201, 33, 33, 37, 2, -32 },
  { 14338, 30, 54, 37, 6, -46 },
  { 14541, 16, 54, 37, 11, -46 },
  { 14649, 29, 54, 37, 2, -46 },
  { 14845, 34, 16, 37, 2, -26 },
};

const GFXfont IBMPlexMono_SemiBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC61PT7B_H_
