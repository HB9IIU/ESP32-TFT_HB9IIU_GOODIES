#ifndef _IBMPLEXMONO_SEMIBOLDITALIC18PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x18, 0xC4, 0x20, 0x19, 0xCE, 0x00, 0x66, 0xD9,
  0xB6, 0x6C, 0xD9, 0x80, 0x06, 0xC0, 0xD8, 0x33, 0x06, 0xC7, 0xDE, 0xF3,
  0xC6, 0xC7, 0xDE, 0xF3, 0xC6, 0x40, 0xD8, 0x33, 0x06, 0xC0, 0x03, 0x00,
  0x60, 0x3E, 0x0F, 0xE3, 0x2E, 0x64, 0x0D, 0x81, 0xF0, 0x1F, 0x80, 0xF8,
  0x13, 0x22, 0x66, 0xDD, 0xFF, 0x0F, 0xC0, 0x60, 0x08, 0x00, 0x0E, 0x18,
  0xF1, 0x8C, 0xD8, 0x66, 0x83, 0x2C, 0x1F, 0x00, 0x77, 0x80, 0x7C, 0x0F,
  0x20, 0xD1, 0x0C, 0x98, 0xC7, 0xCE, 0x1C, 0x00, 0x07, 0x03, 0xF0, 0x67,
  0x0C, 0x61, 0x9C, 0x3B, 0x1F, 0xC3, 0x60, 0xC6, 0x18, 0xCB, 0xAF, 0xFD,
  0xE7, 0x18, 0x6F, 0x6D, 0x80, 0x07, 0x0C, 0x18, 0x30, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x38, 0x38, 0x30,
  0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x61, 0x86, 0x1C, 0x70, 0x0C,
  0x06, 0x23, 0x3F, 0xF7, 0xF1, 0xE0, 0xF8, 0xCC, 0xC3, 0x00, 0x0C, 0x06,
  0x03, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x3B, 0x9C, 0xC6, 0x60, 0xFF,
  0xE0, 0x6F, 0xE0, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06,
  0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x86, 0xE1, 0xFB, 0x7C, 0xDB, 0x76, 0xC1,
  0xB0, 0xEE, 0x71, 0xF8, 0x3C, 0x00, 0x0F, 0x0F, 0x0D, 0x8E, 0xCE, 0x62,
  0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0xFF, 0xF8, 0x0F, 0x87, 0xF3,
  0x9C, 0x43, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x01, 0xFE,
  0xFF, 0x80, 0x0F, 0x87, 0xF3, 0x0C, 0x83, 0x01, 0xC3, 0xC0, 0xF8, 0x06,
  0x01, 0xD0, 0x6E, 0x39, 0xFE, 0x3E, 0x00, 0x01, 0xC0, 0xF0, 0x78, 0x36,
  0x19, 0x86, 0x63, 0x19, 0x8E, 0xFF, 0xFF, 0xF0, 0x30, 0x0C, 0x03, 0x00,
  0x1F, 0xE3, 0xF8, 0xC0, 0x18, 0x03, 0x70, 0x7F, 0x1C, 0x70, 0x0E, 0x01,
  0xC8, 0x39, 0x8E, 0x7F, 0xC3, 0xE0, 0x07, 0x87, 0x06, 0x06, 0x06, 0xF3,
  0xFB, 0x8F, 0x83, 0xC1, 0xE1, 0xF8, 0xCF, 0xE3, 0xC0, 0x7F, 0xDF, 0xF6,
  0x19, 0x8E, 0x83, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0,
  0x70, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0x61, 0x8F, 0xC7, 0xF3, 0x8E,
  0xC3, 0xB0, 0xEC, 0x3B, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x86,
  0xE1, 0xF8, 0x6E, 0x39, 0xF6, 0x3B, 0x01, 0xC0, 0xE0, 0x70, 0xF0, 0x00,
  0x33, 0xDC, 0x00, 0x01, 0x9E, 0xE0, 0x18, 0xF3, 0x80, 0x00, 0x03, 0x9C,
  0x71, 0x86, 0x30, 0x00, 0x81, 0xC3, 0xE3, 0xC7, 0x83, 0x01, 0xC1, 0x78,
  0x0E, 0x03, 0x80, 0x40, 0x7F, 0xBF, 0xE0, 0x1F, 0xFF, 0xF0, 0x40, 0x38,
  0x0F, 0x03, 0xC0, 0x78, 0x18, 0x3C, 0x7C, 0x78, 0x70, 0x20, 0x00, 0x3E,
  0x7F, 0xE7, 0x43, 0x07, 0x1E, 0x38, 0x30, 0x00, 0x00, 0x70, 0x70, 0x70,
  0x1F, 0x1F, 0xDC, 0x6C, 0x14, 0xEE, 0x7F, 0x67, 0xB3, 0xD9, 0xEF, 0xF7,
  0x58, 0x4C, 0x03, 0xF0, 0xF0, 0x03, 0x80, 0xF0, 0x1F, 0x03, 0x60, 0xCC,
  0x19, 0x87, 0x30, 0xC6, 0x3F, 0xC7, 0xF8, 0xC3, 0xB8, 0x7E, 0x0E, 0x3F,
  0x1F, 0xDC, 0x6C, 0x36, 0x3B, 0xF9, 0xFC, 0xC7, 0xE3, 0xE1, 0xF0, 0xDF,
  0xEF, 0xE0, 0x0F, 0x0F, 0xE7, 0x1D, 0x87, 0x60, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x6E, 0x31, 0xFC, 0x3C, 0x00, 0x3E, 0x3F, 0xDC, 0x6C, 0x36,
  0x1B, 0x0D, 0x87, 0xC3, 0xE1, 0xE1, 0xF1, 0xDF, 0xCF, 0xC0, 0x3F, 0xCF,
  0xF7, 0x01, 0xC0, 0x60, 0x1F, 0xE7, 0xF1, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF7, 0x01, 0xC0, 0x60, 0x1F, 0xE7, 0xF1,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x0F, 0xE7, 0x19,
  0x86, 0xE0, 0x78, 0x0E, 0x7B, 0x3E, 0xC1, 0xB0, 0xCE, 0x31, 0xFC, 0x7B,
  0x00, 0x38, 0x67, 0x1C, 0xC3, 0x98, 0x63, 0x0C, 0x7F, 0x8F, 0xF3, 0x8E,
  0x61, 0xCC, 0x31, 0x86, 0x30, 0xCE, 0x18, 0x3F, 0xCF, 0xE4, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x83, 0xFC, 0xFF, 0x00,
  0x1F, 0x9F, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x63, 0xB1,
  0x9F, 0xC7, 0xC0, 0x30, 0xEE, 0x39, 0xCE, 0x33, 0x86, 0xE0, 0xF8, 0x1F,
  0x07, 0xF0, 0xE6, 0x18, 0xE3, 0x1C, 0x61, 0x8C, 0x38, 0x30, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xFF, 0xFF, 0x38, 0xE7,
  0x1C, 0xE7, 0x9E, 0xB6, 0xF6, 0xDD, 0x9B, 0xB3, 0x26, 0x64, 0xCD, 0x19,
  0x83, 0x60, 0xCC, 0x18, 0x3C, 0x67, 0x8C, 0xF3, 0x9E, 0x63, 0xCC, 0x69,
  0x8D, 0xB3, 0x36, 0x66, 0xCC, 0xF1, 0x9E, 0x31, 0xCE, 0x38, 0x1F, 0x0F,
  0xE7, 0x19, 0x86, 0xE1, 0xF8, 0x7C, 0x1B, 0x06, 0xC1, 0xB0, 0xEE, 0x71,
  0xF8, 0x3C, 0x00, 0x3F, 0x0F, 0xE7, 0x1D, 0xC7, 0x61, 0xD8, 0x67, 0xF9,
  0xF8, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x0F, 0xE7, 0x19,
  0x86, 0xE1, 0xF8, 0x7C, 0x1B, 0x06, 0xC1, 0xB0, 0xEE, 0x71, 0xF8, 0x3C,
  0x07, 0x40, 0xD8, 0x3E, 0x07, 0x00, 0x3F, 0x0F, 0xE7, 0x1D, 0xC7, 0x61,
  0xD8, 0x67, 0xF9, 0xF8, 0xEE, 0x39, 0x8C, 0x63, 0x1C, 0xC3, 0x00, 0x0F,
  0x83, 0xF8, 0xE3, 0x98, 0x03, 0x00, 0x7C, 0x07, 0xE0, 0x1E, 0x01, 0xC8,
  0x39, 0x86, 0x7F, 0xC3, 0xE0, 0x7F, 0xEF, 0xFA, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0xDC, 0x76, 0x1D, 0x86, 0x61, 0x98, 0x6E, 0x1B, 0x8E, 0xC3, 0xB0, 0xCE,
  0x73, 0xFC, 0x7C, 0x00, 0xC1, 0xF0, 0x6C, 0x3B, 0x0C, 0xC3, 0x39, 0x8E,
  0x63, 0xB8, 0x6C, 0x1B, 0x07, 0x81, 0xE0, 0x70, 0x00, 0x30, 0x36, 0x02,
  0x60, 0x66, 0x66, 0x66, 0x66, 0xE6, 0x6A, 0xC6, 0xAC, 0x7A, 0xC7, 0xAC,
  0x72, 0x87, 0x38, 0xF3, 0x80, 0x1C, 0x38, 0xE3, 0x83, 0x38, 0x1D, 0x80,
  0x78, 0x03, 0xC0, 0x1C, 0x01, 0xF0, 0x0D, 0x80, 0xCC, 0x0E, 0x70, 0x61,
  0x8E, 0x0E, 0x00, 0xE0, 0xEC, 0x39, 0xC6, 0x19, 0xC3, 0x30, 0x7C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x3F, 0xE7, 0xFC,
  0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x7F, 0xCF, 0xF8, 0x1F, 0x8F, 0x86, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF1, 0xF8, 0xC6, 0x30, 0xC6,
  0x31, 0x8C, 0x31, 0x8C, 0x63, 0x0C, 0x63, 0x1F, 0x8F, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x61, 0xF1,
  0xF8, 0x0E, 0x0F, 0x06, 0xC6, 0x67, 0x33, 0x0F, 0x06, 0x82, 0xFF, 0xFF,
  0x80, 0x6E, 0x63, 0x3D, 0xBE, 0xF8, 0xF8, 0x6C, 0x36, 0x1B, 0x1D, 0xF7,
  0x73, 0x80, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x73, 0x7D, 0xCF, 0xC3, 0xE1,
  0xE1, 0xF0, 0xDF, 0xED, 0xE0, 0x1E, 0x3F, 0x98, 0xFC, 0x0E, 0x06, 0x0B,
  0x8C, 0xFC, 0x3C, 0x00, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x3D, 0x9F, 0x6E,
  0x3B, 0x0E, 0xC3, 0x30, 0xCC, 0xF3, 0xEC, 0x77, 0x00, 0x1F, 0x1F, 0xD8,
  0x7F, 0xEF, 0xC6, 0x13, 0x8C, 0xFE, 0x3C, 0x00, 0x01, 0xF0, 0x3E, 0x03,
  0x00, 0x70, 0x3F, 0xE3, 0xFE, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x8C, 0x0C, 0xC0, 0xEC, 0x07, 0xC0, 0x38, 0x00, 0x1E, 0xCF,
  0xB7, 0x1D, 0xC7, 0x61, 0xD8, 0x66, 0x39, 0xF6, 0x39, 0x80, 0xE4, 0x33,
  0xFC, 0x7C, 0x00, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x73, 0x7D, 0xCE, 0xC7,
  0xE3, 0xF1, 0xB0, 0xD8, 0x6C, 0x70, 0x0E, 0x07, 0x03, 0x00, 0x07, 0xC7,
  0xE0, 0x60, 0x30, 0x18, 0x0D, 0x8F, 0xE7, 0xC1, 0xC0, 0x01, 0x81, 0xC0,
  0x60, 0x01, 0xF8, 0xF8, 0x8C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC4, 0x67,
  0x31, 0xD8, 0x7C, 0x1C, 0x00, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x73, 0x7D,
  0xCE, 0xC6, 0xE6, 0x7E, 0x33, 0x79, 0xFC, 0x70, 0xF9, 0xF0, 0xE1, 0x83,
  0x06, 0x0C, 0x38, 0x64, 0xCD, 0xBB, 0xE7, 0x00, 0x6C, 0xCF, 0xFD, 0x99,
  0x33, 0x66, 0x4C, 0x99, 0xB3, 0x36, 0x66, 0xCD, 0x80, 0x67, 0x37, 0xDC,
  0xEC, 0x7E, 0x3F, 0x1B, 0x0D, 0x86, 0xC7, 0x00, 0x1E, 0x3F, 0x98, 0xFC,
  0x3C, 0x3E, 0x1F, 0x0D, 0xFE, 0x3C, 0x00, 0x33, 0x8D, 0xF3, 0x9C, 0xC3,
  0x70, 0xD8, 0x76, 0x19, 0xFE, 0x6F, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x00,
  0x3D, 0xBE, 0xF8, 0xF8, 0x7C, 0x36, 0x1B, 0x1D, 0xF6, 0x77, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0xFB, 0xFB, 0x8E, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x00, 0x1F, 0x3F, 0xD8, 0x8F, 0x07, 0xF0, 0x79, 0x0D, 0xFE, 0x7C,
  0x00, 0x0C, 0x0E, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x70, 0x30, 0x18,
  0x8D, 0xE7, 0xC3, 0xC0, 0x61, 0xB0, 0xD8, 0xFC, 0x7E, 0x36, 0x1B, 0xBD,
  0xF6, 0x77, 0x00, 0xF3, 0x79, 0xDC, 0x6C, 0x36, 0x3B, 0x19, 0xBC, 0xFC,
  0x78, 0x00, 0x66, 0xD9, 0xB6, 0x6D, 0x93, 0x6C, 0xD3, 0x3C, 0xCF, 0xF6,
  0x67, 0x00, 0x1D, 0xC7, 0xBD, 0xB9, 0xA7, 0x30, 0xE1, 0x99, 0x35, 0x77,
  0xBC, 0x67, 0x00, 0x30, 0xCC, 0x33, 0x1D, 0xC7, 0x71, 0x98, 0x67, 0x79,
  0xF6, 0x3B, 0x80, 0xE4, 0x73, 0xFC, 0x7C, 0x00, 0x1E, 0xCF, 0xF2, 0x3D,
  0x0C, 0x0E, 0x06, 0x67, 0x8D, 0xFF, 0xE7, 0x80, 0x0F, 0x8F, 0x86, 0x03,
  0x01, 0x80, 0x60, 0x31, 0xF0, 0xF8, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x01,
  0xF0, 0xF8, 0x18, 0xC4, 0x63, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x31, 0x18,
  0x3E, 0x3E, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x1F, 0x1F, 0x30, 0x30, 0x18,
  0x18, 0x18, 0xF8, 0xF0, 0x38, 0x4F, 0x36, 0xED, 0x9E, 0xC3, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 7, 6, 11, 3, -13 },
  { 16, 11, 13, 11, 0, -13 },
  { 34, 11, 17, 11, 0, -15 },
  { 58, 13, 13, 11, -1, -13 },
  { 80, 11, 13, 11, 0, -13 },
  { 98, 3, 6, 11, 5, -13 },
  { 101, 8, 16, 11, 3, -14 },
  { 117, 7, 16, 11, 1, -14 },
  { 131, 9, 9, 11, 1, -10 },
  { 142, 9, 8, 11, 1, -10 },
  { 151, 5, 6, 11, 2, -3 },
  { 155, 6, 2, 11, 3, -6 },
  { 157, 4, 3, 11, 3, -3 },
  { 159, 11, 16, 11, 0, -14 },
  { 181, 10, 13, 11, 1, -13 },
  { 198, 9, 13, 11, 1, -13 },
  { 213, 10, 13, 11, 0, -13 },
  { 230, 10, 13, 11, 0, -13 },
  { 247, 10, 13, 11, 0, -13 },
  { 264, 11, 13, 11, 0, -13 },
  { 282, 9, 13, 11, 1, -13 },
  { 297, 10, 13, 11, 1, -13 },
  { 314, 10, 13, 11, 1, -13 },
  { 331, 10, 13, 11, 1, -13 },
  { 348, 5, 9, 11, 3, -9 },
  { 354, 6, 12, 11, 2, -9 },
  { 363, 9, 11, 11, 1, -11 },
  { 376, 9, 5, 11, 1, -8 },
  { 382, 9, 11, 11, 1, -11 },
  { 395, 8, 13, 11, 2, -13 },
  { 408, 9, 15, 11, 1, -13 },
  { 425, 11, 13, 11, -1, -13 },
  { 443, 9, 13, 11, 1, -13 },
  { 458, 10, 13, 11, 1, -13 },
  { 475, 9, 13, 11, 1, -13 },
  { 490, 10, 13, 11, 1, -13 },
  { 507, 10, 13, 11, 1, -13 },
  { 524, 10, 13, 11, 1, -13 },
  { 541, 11, 13, 11, 0, -13 },
  { 559, 10, 13, 11, 1, -13 },
  { 576, 9, 13, 11, 1, -13 },
  { 591, 11, 13, 11, 1, -13 },
  { 609, 8, 13, 11, 1, -13 },
  { 622, 11, 13, 11, 0, -13 },
  { 640, 11, 13, 11, 0, -13 },
  { 658, 10, 13, 11, 1, -13 },
  { 675, 10, 13, 11, 1, -13 },
  { 692, 10, 17, 11, 1, -13 },
  { 714, 10, 13, 11, 1, -13 },
  { 731, 11, 13, 11, 0, -13 },
  { 749, 11, 13, 11, 1, -13 },
  { 767, 10, 13, 11, 1, -13 },
  { 784, 10, 13, 11, 2, -13 },
  { 801, 12, 13, 11, 0, -13 },
  { 821, 13, 13, 11, -1, -13 },
  { 843, 11, 13, 11, 1, -13 },
  { 861, 11, 13, 11, 0, -13 },
  { 879, 9, 16, 11, 2, -14 },
  { 897, 5, 16, 11, 3, -14 },
  { 907, 9, 16, 11, 0, -14 },
  { 925, 9, 8, 11, 1, -13 },
  { 934, 9, 2, 11, 0, 1 },
  { 937, 4, 4, 11, 3, -14 },
  { 939, 9, 9, 11, 1, -9 },
  { 950, 9, 13, 11, 1, -13 },
  { 965, 9, 9, 11, 1, -9 },
  { 976, 10, 13, 11, 1, -13 },
  { 993, 9, 9, 11, 1, -9 },
  { 1004, 12, 17, 11, 0, -13 },
  { 1030, 10, 13, 11, 0, -9 },
  { 1047, 9, 13, 11, 1, -13 },
  { 1062, 9, 13, 11, 1, -13 },
  { 1077, 9, 17, 11, 0, -13 },
  { 1097, 9, 13, 11, 1, -13 },
  { 1112, 7, 13, 11, 2, -13 },
  { 1124, 11, 9, 11, 0, -9 },
  { 1137, 9, 9, 11, 1, -9 },
  { 1148, 9, 9, 11, 1, -9 },
  { 1159, 10, 13, 11, 0, -9 },
  { 1176, 9, 13, 11, 1, -9 },
  { 1191, 9, 9, 11, 2, -9 },
  { 1202, 9, 9, 11, 1, -9 },
  { 1213, 9, 13, 11, 1, -13 },
  { 1228, 9, 9, 11, 1, -9 },
  { 1239, 9, 9, 11, 1, -9 },
  { 1250, 10, 9, 11, 0, -9 },
  { 1262, 11, 9, 11, 0, -9 },
  { 1275, 10, 13, 11, 0, -9 },
  { 1292, 10, 9, 11, 0, -9 },
  { 1304, 9, 16, 11, 2, -14 },
  { 1322, 5, 16, 11, 3, -14 },
  { 1332, 8, 16, 11, 1, -14 },
  { 1348, 10, 5, 11, 0, -8 },
};

const GFXfont IBMPlexMono_SemiBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC18PT7B_H_
