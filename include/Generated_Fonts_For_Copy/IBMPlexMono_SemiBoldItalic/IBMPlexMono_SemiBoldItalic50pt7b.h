#ifndef _IBMPLEXMONO_SEMIBOLDITALIC50PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xF8, 0x00,
  0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0x7C,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xCF, 0xC1, 0xF9,
  0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE7,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x80, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xF9, 0xE7, 0xF0, 0x7F, 0x1E, 0x3E,
  0x0F, 0xE1, 0xE1, 0x80, 0xFC, 0x1E, 0x10, 0x0F, 0xC3, 0xE0, 0x00, 0xFC,
  0x3C, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0xFE, 0x3C, 0x00, 0x0F, 0xF3, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x0F, 0xE0,
  0x00, 0xF0, 0xFE, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0xF0, 0xFE, 0x18, 0x1F,
  0x0F, 0xC3, 0xC1, 0xE1, 0xFC, 0x7E, 0x1E, 0x3F, 0xCF, 0xF9, 0xE7, 0xF8,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x1F,
  0x00, 0xFF, 0xF8, 0x03, 0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xE0,
  0x3E, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x3E, 0x07, 0x81, 0xF0, 0x07, 0xC0,
  0xF8, 0x7C, 0x00, 0xF8, 0x1E, 0x0F, 0x80, 0x1E, 0x03, 0xC3, 0xE0, 0x03,
  0xC0, 0xF8, 0xF8, 0x00, 0x78, 0x1F, 0x1F, 0x00, 0x0F, 0x03, 0xC7, 0xC0,
  0x01, 0xF0, 0xF9, 0xF0, 0x00, 0x3F, 0xFE, 0x3E, 0x00, 0x03, 0xFF, 0x88,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0xFF, 0xF8, 0x00,
  0x1F, 0x1F, 0x0F, 0x80, 0x03, 0xE7, 0xC1, 0xF0, 0x00, 0xF8, 0xF8, 0x3E,
  0x00, 0x3E, 0x1E, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0xF8, 0x01, 0xF0, 0xF8,
  0x1F, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x78, 0x03, 0xE0,
  0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC0, 0x1F, 0xFF, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xF0,
  0x08, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x02, 0x3F, 0x80,
  0xFC, 0x1E, 0xFE, 0x03, 0xF8, 0xFF, 0xF8, 0x1F, 0xE3, 0xE7, 0xF0, 0xFF,
  0xDF, 0x9F, 0xFF, 0xBF, 0xFC, 0x7F, 0xFC, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF,
  0x83, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x00,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC,
  0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x08, 0x07,
  0xE0, 0x11, 0xE0, 0xFC, 0x1E, 0x3F, 0x1F, 0x9F, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xF0, 0x07, 0x80, 0x04,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x3F, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8,
  0x78, 0x3F, 0x7F, 0x1F, 0x8F, 0xEF, 0xC3, 0xF1, 0xFF, 0xF8, 0x7E, 0x3F,
  0xFF, 0x1F, 0x87, 0xFF, 0xE1, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xBF, 0x80,
  0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC, 0x03,
  0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x70, 0x3F, 0x80, 0x10, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xC0, 0x07, 0xF0, 0x18,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3C, 0x00,
  0xFE, 0x01, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x80, 0x03, 0xF8, 0x18,
  0x00, 0x3F, 0x83, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x0F,
  0x8F, 0xFE, 0x00, 0xF9, 0xFF, 0xF0, 0x0F, 0xBF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFC, 0x03, 0xFC, 0x01, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x1F, 0xC0, 0xC0, 0x01, 0xFC,
  0x3E, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0xFF, 0x81, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0xFC, 0x01, 0xF8, 0xFF, 0xC0, 0xFE, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0x1F,
  0xDF, 0xFF, 0xE7, 0xFE, 0x0F, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x00, 0x0F,
  0xE3, 0xE0, 0x01, 0xFC, 0x7C, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xDF, 0xF0, 0x7F, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x7F, 0x03, 0xFF, 0x9F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xF1, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFC, 0x1F, 0xEF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0x38,
  0x01, 0xFC, 0x20, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x0F, 0x8F, 0x8F, 0x83, 0xF9, 0xF3,
  0xE0, 0xFF, 0xBE, 0x7C, 0x3F, 0xF7, 0xCF, 0x87, 0xE3, 0xFB, 0xF1, 0xF8,
  0x3E, 0x7E, 0x3E, 0x07, 0xCF, 0x8F, 0xC0, 0xF9, 0xF1, 0xF0, 0x1F, 0x3E,
  0x3E, 0x03, 0xE7, 0xC7, 0xC0, 0x7D, 0xF8, 0xF8, 0x1F, 0x3F, 0x1F, 0x03,
  0xE7, 0xC3, 0xE0, 0x7C, 0xF8, 0x7C, 0x1F, 0x9F, 0x0F, 0x83, 0xF3, 0xE1,
  0xF0, 0xFE, 0x7C, 0x3F, 0x7F, 0x8F, 0x87, 0xFD, 0xF1, 0xF0, 0x7F, 0xBE,
  0x3E, 0x07, 0xE7, 0xC7, 0xC0, 0x20, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xDF,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF8,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F,
  0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x03,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF0, 0x00, 0xF8, 0xFE, 0x00, 0x20, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x60, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0, 0xFF, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x7E,
  0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0,
  0x0F, 0xE0, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xE3, 0xF8, 0x00, 0x81, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0xEF, 0xE0, 0xFF, 0xFB, 0xF8,
  0x3F, 0xFC, 0xFE, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xE3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0x7C, 0x0F, 0xFF, 0x9F, 0x01,
  0xFF, 0xEF, 0xC0, 0x3F, 0xE3, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0x00,
  0x7F, 0x80, 0x7E, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFF, 0x00, 0x1F, 0x83, 0xFC,
  0x00, 0x3F, 0x0F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xDF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xBE, 0x3F, 0xF8, 0x3F, 0x7C,
  0xFB, 0xF0, 0x7E, 0xF9, 0xF7, 0xC0, 0xFD, 0xF7, 0xCF, 0x81, 0xF3, 0xFF,
  0x1F, 0x03, 0xE3, 0xFE, 0x7E, 0x07, 0xC7, 0xF8, 0xFC, 0x1F, 0x8F, 0xF1,
  0xF8, 0x3F, 0x1F, 0xC3, 0xE0, 0x7E, 0x3F, 0x87, 0xC0, 0xFC, 0x3E, 0x1F,
  0x81, 0xF0, 0x7C, 0x3F, 0x03, 0xE0, 0xF0, 0x7E, 0x0F, 0xC1, 0xE0, 0xFC,
  0x1F, 0x81, 0x81, 0xF0, 0x3F, 0x03, 0x03, 0xE0, 0x7E, 0x04, 0x0F, 0xC0,
  0xF8, 0x08, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0x80, 0x7E, 0x0F, 0xFC,
  0x03, 0xF0, 0x7F, 0xE0, 0x1F, 0x83, 0xFF, 0x00, 0xF8, 0x1F, 0xF8, 0x07,
  0xC0, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x83,
  0xF7, 0xC0, 0xFC, 0x1F, 0xBE, 0x07, 0xC0, 0xFD, 0xF8, 0x3E, 0x07, 0xEF,
  0xC3, 0xF0, 0x3E, 0x3E, 0x1F, 0x81, 0xF1, 0xF0, 0xFC, 0x1F, 0x8F, 0x87,
  0xE0, 0xFC, 0x7C, 0x3E, 0x07, 0xE3, 0xF1, 0xF0, 0x3F, 0x0F, 0x9F, 0x81,
  0xF0, 0x7C, 0xFC, 0x0F, 0x83, 0xE7, 0xE0, 0xFC, 0x1F, 0x3F, 0x07, 0xE0,
  0xFD, 0xF0, 0x3F, 0x07, 0xEF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0xFF,
  0xE0, 0x7C, 0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x3F, 0x01, 0xFF, 0x81,
  0xF8, 0x07, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0x7C, 0x01, 0xFF, 0x03, 0xE0,
  0x0F, 0xF8, 0x3F, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0xFC,
  0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x02, 0x00, 0x07,
  0xE0, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xFE, 0x07,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x38, 0x0F, 0xE0,
  0x01, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0x80,
  0x01, 0xFC, 0x1E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xF0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC,
  0x3F, 0x0F, 0xE0, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8,
  0x3F, 0x1F, 0xE1, 0xF8, 0x3F, 0x1F, 0xE1, 0xF0, 0x3E, 0x1F, 0xE1, 0xF0,
  0x3E, 0x3F, 0xE1, 0xF0, 0x3E, 0x3D, 0xE3, 0xF0, 0x3E, 0x3D, 0xE3, 0xE0,
  0x3E, 0x7D, 0xE3, 0xE0, 0x7E, 0x79, 0xE3, 0xE0, 0x7E, 0x79, 0xE3, 0xE0,
  0x7E, 0x79, 0xE7, 0xC0, 0x7E, 0xF1, 0xE7, 0xC0, 0x7C, 0xF1, 0xE7, 0xC0,
  0x7C, 0xF1, 0xE7, 0xC0, 0x7D, 0xE1, 0xEF, 0xC0, 0x7D, 0xE1, 0xEF, 0x80,
  0x7D, 0xE1, 0xEF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xFC,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x7E,
  0x00, 0x03, 0xF1, 0xC0, 0x00, 0x70, 0x10, 0x00, 0x08, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x08, 0x3E, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07,
  0xC3, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x7F, 0xE7, 0xF0, 0x7F, 0xFD, 0xFC,
  0x3F, 0xFF, 0x7E, 0x1F, 0xE0, 0xFF, 0x87, 0xF0, 0x1F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF,
  0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0x80,
  0xFF, 0x87, 0xF0, 0xEF, 0xF9, 0xFF, 0xFB, 0xFE, 0x3F, 0xFC, 0x7F, 0x87,
  0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC7, 0xFE,
  0x07, 0xF3, 0xFF, 0xC1, 0xFD, 0xFF, 0xF0, 0x7E, 0xE1, 0xFE, 0x1F, 0xB0,
  0x3F, 0x87, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF3, 0xF8,
  0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0x7F, 0x0F, 0xDF, 0xFF, 0xC3,
  0xF3, 0xFF, 0xE0, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0x3E, 0x3F, 0x80, 0x38, 0x3F, 0x00,
  0x20, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x10, 0xFE, 0x00, 0x38, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7F, 0x00,
  0xFC, 0x7F, 0x83, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0xFC, 0x01, 0xFF, 0x8F, 0xC0, 0x7F, 0xFC, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8,
  0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7E,
  0x03, 0x7E, 0x07, 0xF8, 0x77, 0xE0, 0x7F, 0xFE, 0xFE, 0x03, 0xFF, 0xCF,
  0xC0, 0x1F, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0x7E, 0x01, 0xFE, 0xFE, 0x0F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x20, 0xFC, 0x00, 0x18, 0xFE, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x08, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xFC, 0x7E,
  0x03, 0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0x7E, 0x07, 0xF8, 0x3F, 0xE0, 0xFE,
  0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x0F,
  0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x83,
  0xF0, 0x0F, 0xF0, 0x3F, 0x81, 0xFF, 0x03, 0xFC, 0x3B, 0xF0, 0x1F, 0xFF,
  0x3F, 0x01, 0xFF, 0xE3, 0xF0, 0x0F, 0xFC, 0x7F, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x10, 0x01, 0xFC, 0x01, 0x80, 0x1F, 0x80, 0x7E, 0x07, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x7F, 0xE0, 0x7E, 0x7F, 0xF8, 0x7F,
  0x7F, 0xFC, 0x3F, 0xF0, 0xFF, 0x1F, 0xB0, 0x3F, 0x8F, 0xF0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0x00,
  0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0x80, 0x7E,
  0x07, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x7E, 0x07, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x60, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7C,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x7F, 0xE0, 0x1F, 0x9F, 0xFE, 0x07, 0xF7, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFC, 0x1F, 0xB0, 0x3F, 0x83, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xF8, 0x07, 0xE7, 0xFC, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE3, 0xF8, 0x10, 0xFC, 0x3F, 0x03,
  0x1F, 0x87, 0xE0, 0xF3, 0xF0, 0xFE, 0x3F, 0xFE, 0x0F, 0xCF, 0xDF, 0xC1,
  0xFF, 0xF3, 0xF0, 0x1F, 0xFC, 0x7E, 0x03, 0xFF, 0x0F, 0xC0, 0x3F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x10, 0x3F, 0x81, 0xE1, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x7E,
  0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x8F, 0x83, 0xE0,
  0x7C, 0xFE, 0x3F, 0x83, 0xEF, 0xF3, 0xFE, 0x3F, 0xFF, 0xBF, 0xF1, 0xFC,
  0x7D, 0x9F, 0x8F, 0xC3, 0xF8, 0x7C, 0x7E, 0x1F, 0x83, 0xE3, 0xE0, 0xFC,
  0x1F, 0x1F, 0x07, 0xC0, 0xF9, 0xF8, 0x3E, 0x0F, 0xCF, 0xC1, 0xF0, 0x7E,
  0x7C, 0x0F, 0x83, 0xE3, 0xE0, 0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0xF8, 0xF8,
  0x3E, 0x07, 0xCF, 0xC1, 0xF0, 0x7E, 0x7E, 0x0F, 0x83, 0xF3, 0xE0, 0x7C,
  0x1F, 0x1F, 0x07, 0xE0, 0xF8, 0xF8, 0x3F, 0x07, 0xC7, 0xC1, 0xF0, 0x3E,
  0x7E, 0x0F, 0x83, 0xF3, 0xF0, 0x7C, 0x1F, 0x9F, 0x03, 0xE0, 0xF8, 0xF8,
  0x3F, 0x07, 0xC7, 0xC1, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x07, 0xE3,
  0xFF, 0x03, 0xF3, 0xFF, 0xC3, 0xFB, 0xFF, 0xE1, 0xFF, 0x87, 0xF8, 0xFD,
  0x81, 0xFC, 0x7F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0xC0,
  0x07, 0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0x9F, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x1F, 0xF8, 0x07, 0xF3, 0xFF, 0xC0, 0x7F, 0x7F, 0xFC, 0x07,
  0xEE, 0x1F, 0xE0, 0x7E, 0xC0, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFC,
  0x03, 0xF8, 0x3F, 0xE0, 0x7F, 0x03, 0xF7, 0xFF, 0xF0, 0x3F, 0x3F, 0xFE,
  0x03, 0xF1, 0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x7F, 0xE3, 0xF0, 0x7F, 0xFC,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xC7, 0xF0, 0x0F, 0xF3, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x1F,
  0x80, 0xDF, 0x87, 0xF8, 0x77, 0xE1, 0xFF, 0xFB, 0xF8, 0x3F, 0xFC, 0xFC,
  0x07, 0xFE, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xBF, 0xFE, 0x3F, 0xDF, 0xFF, 0x3F,
  0xE0, 0x3F, 0xBF, 0xF0, 0x1F, 0xDF, 0xF8, 0x0F, 0xDC, 0x00, 0x07, 0xE8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0x03, 0xF0, 0x7E, 0x00, 0x70, 0x3F, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x82, 0x00, 0x0F,
  0xC1, 0x80, 0x07, 0xE3, 0xE0, 0x07, 0xF3, 0xFC, 0x07, 0xF0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF4, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x08, 0x03, 0xF8, 0x0E, 0x01, 0xFC, 0x0F, 0x80,
  0xFC, 0x1F, 0xE0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0,
  0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x9F,
  0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3,
  0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0xC7, 0xF0, 0x37,
  0xE3, 0xFC, 0x3F, 0xF0, 0xFF, 0xFB, 0xF0, 0x7F, 0xF9, 0xF8, 0x1F, 0xF8,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0x3F, 0xF8, 0x0F, 0x9F,
  0xFC, 0x1F, 0xDF, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01,
  0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFC,
  0x3F, 0x80, 0x7E, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x41, 0xF0, 0x7C,
  0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE3,
  0xE0, 0x7C, 0x3F, 0x3E, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x1F, 0x3E, 0x0F,
  0x81, 0xF3, 0xE0, 0xF8, 0x1F, 0x3E, 0x0F, 0x83, 0xF7, 0xC0, 0xF8, 0x3F,
  0x7C, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x3E, 0x7C, 0x1F, 0x03, 0xE7, 0xC1,
  0xF0, 0x3E, 0x7C, 0x1F, 0x03, 0xEF, 0x81, 0xF0, 0x7C, 0xF8, 0x3F, 0x07,
  0xCF, 0x83, 0xF0, 0x7C, 0xF8, 0x7F, 0x0F, 0x8F, 0xCF, 0xF1, 0xF0, 0xFF,
  0xFF, 0x3F, 0x0F, 0xFC, 0xFF, 0xE0, 0x7F, 0x8F, 0xFC, 0x07, 0xF8, 0xFF,
  0x80, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0xE7, 0xFF, 0x1F, 0xEF, 0x98, 0xFC,
  0xFE, 0x3E, 0xE1, 0xF1, 0xF0, 0xFB, 0x07, 0xC3, 0x03, 0xEC, 0x1F, 0x08,
  0x0F, 0xE0, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0x81, 0xFC, 0x04, 0x3E, 0x0D, 0xF0, 0x38, 0xF8, 0x37, 0xC3, 0xE3,
  0xE1, 0xDF, 0x1F, 0xCF, 0xC6, 0x7D, 0xFE, 0x3F, 0xF9, 0xFF, 0xF0, 0x7F,
  0xC3, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x07,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x1B, 0xF0, 0x3F, 0x87,
  0x7E, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xF3, 0xF0, 0x0F, 0xFC, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x04, 0x00, 0x7E, 0x01, 0xC0, 0x1F, 0xC0, 0x7E,
  0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x3E, 0x07,
  0xFF, 0xF3, 0xE0, 0xFF, 0xFF, 0xBE, 0x0F, 0xC3, 0xFF, 0xE1, 0xF8, 0x0F,
  0xFC, 0x1F, 0x00, 0x3F, 0x81, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x30,
  0x01, 0xFE, 0x0F, 0x80, 0x3F, 0xC0, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0xFE,
  0x00, 0x7C, 0x1F, 0xC0, 0x07, 0xC3, 0xFF, 0xC0, 0x7C, 0x7D, 0xFF, 0xE7,
  0xC7, 0xC7, 0xFF, 0xF8, 0x7C, 0x0F, 0xFF, 0x8F, 0xC0, 0x3F, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x7F, 0xC0, 0x1F,
  0x0F, 0xFE, 0x01, 0xF0, 0xFF, 0xF0, 0x3E, 0x1F, 0xFF, 0x03, 0xE3, 0xF1,
  0xF8, 0x7E, 0x3E, 0x1F, 0xCF, 0xC7, 0xC0, 0xFF, 0xFC, 0x7C, 0x07, 0xFF,
  0x87, 0xC0, 0x7F, 0xF0, 0xF8, 0x03, 0xFE, 0x01, 0x80, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_SemiBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 13, 36, 30, 9, -35 },
  { 60, 19, 16, 30, 8, -37 },
  { 98, 31, 35, 30, 0, -35 },
  { 234, 28, 46, 30, 1, -40 },
  { 395, 35, 37, 30, -2, -36 },
  { 557, 30, 37, 30, 0, -36 },
  { 696, 8, 16, 30, 14, -37 },
  { 712, 21, 45, 30, 9, -38 },
  { 831, 21, 45, 30, 1, -38 },
  { 950, 27, 25, 30, 2, -27 },
  { 1035, 25, 24, 30, 3, -28 },
  { 1110, 13, 15, 30, 6, -8 },
  { 1135, 17, 6, 30, 7, -18 },
  { 1148, 9, 9, 30, 9, -8 },
  { 1159, 30, 45, 30, 0, -38 },
  { 1328, 27, 37, 30, 2, -36 },
  { 1453, 25, 35, 30, 2, -35 },
  { 1563, 28, 36, 30, 1, -36 },
  { 1689, 28, 37, 30, 1, -36 },
  { 1819, 28, 35, 30, 0, -35 },
  { 1942, 28, 36, 30, 1, -35 },
  { 2068, 26, 36, 30, 2, -35 },
  { 2185, 27, 35, 30, 4, -35 },
  { 2304, 28, 37, 30, 1, -36 },
  { 2434, 26, 36, 30, 3, -36 },
  { 2551, 12, 27, 30, 9, -26 },
  { 2592, 15, 33, 30, 6, -26 },
  { 2654, 25, 30, 30, 4, -30 },
  { 2748, 27, 15, 30, 2, -22 },
  { 2799, 25, 30, 30, 2, -30 },
  { 2893, 22, 37, 30, 6, -36 },
  { 2995, 27, 42, 30, 2, -36 },
  { 3137, 28, 35, 30, -1, -35 },
  { 3260, 27, 35, 30, 2, -35 },
  { 3379, 27, 37, 30, 3, -36 },
  { 3504, 27, 35, 30, 2, -35 },
  { 3623, 28, 35, 30, 2, -35 },
  { 3746, 29, 35, 30, 2, -35 },
  { 3873, 26, 37, 30, 3, -36 },
  { 3994, 29, 35, 30, 1, -35 },
  { 4121, 28, 35, 30, 2, -35 },
  { 4244, 27, 36, 30, 2, -35 },
  { 4366, 31, 35, 30, 2, -35 },
  { 4502, 23, 35, 30, 3, -35 },
  { 4603, 31, 35, 30, 0, -35 },
  { 4739, 29, 35, 30, 1, -35 },
  { 4866, 27, 37, 30, 2, -36 },
  { 4991, 28, 35, 30, 2, -35 },
  { 5114, 27, 46, 30, 2, -36 },
  { 5270, 28, 35, 30, 2, -35 },
  { 5393, 29, 37, 30, 1, -36 },
  { 5528, 28, 35, 30, 4, -35 },
  { 5651, 28, 36, 30, 3, -35 },
  { 5777, 28, 35, 30, 5, -35 },
  { 5900, 32, 35, 30, 1, -35 },
  { 6040, 33, 35, 30, -1, -35 },
  { 6185, 29, 35, 30, 4, -35 },
  { 6312, 31, 35, 30, 0, -35 },
  { 6448, 23, 45, 30, 6, -38 },
  { 6578, 14, 45, 30, 8, -38 },
  { 6657, 23, 45, 30, 1, -38 },
  { 6787, 27, 22, 30, 2, -35 },
  { 6862, 24, 5, 30, 0, 4 },
  { 6877, 9, 11, 30, 10, -40 },
  { 6890, 26, 27, 30, 2, -26 },
  { 6978, 26, 38, 30, 2, -37 },
  { 7102, 24, 27, 30, 3, -26 },
  { 7183, 28, 38, 30, 2, -37 },
  { 7316, 24, 27, 30, 3, -26 },
  { 7397, 34, 48, 30, -1, -37 },
  { 7601, 28, 37, 30, 1, -26 },
  { 7731, 25, 37, 30, 2, -37 },
  { 7847, 23, 40, 30, 4, -39 },
  { 7962, 25, 50, 30, 1, -39 },
  { 8119, 27, 38, 30, 2, -37 },
  { 8248, 21, 38, 30, 5, -37 },
  { 8348, 29, 26, 30, 0, -26 },
  { 8443, 25, 26, 30, 2, -26 },
  { 8525, 26, 27, 30, 2, -26 },
  { 8613, 28, 36, 30, 0, -26 },
  { 8739, 26, 36, 30, 2, -26 },
  { 8856, 25, 26, 30, 5, -26 },
  { 8938, 25, 27, 30, 2, -26 },
  { 9023, 25, 36, 30, 3, -35 },
  { 9136, 25, 27, 30, 3, -26 },
  { 9221, 25, 27, 30, 2, -26 },
  { 9306, 28, 27, 30, 1, -26 },
  { 9401, 30, 27, 30, 0, -26 },
  { 9503, 27, 37, 30, 1, -26 },
  { 9628, 28, 27, 30, 1, -26 },
  { 9723, 24, 45, 30, 5, -38 },
  { 9858, 13, 45, 30, 9, -38 },
  { 9932, 25, 45, 30, 1, -38 },
  { 10073, 28, 12, 30, 1, -21 },
};

const GFXfont IBMPlexMono_SemiBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC50PT7B_H_
