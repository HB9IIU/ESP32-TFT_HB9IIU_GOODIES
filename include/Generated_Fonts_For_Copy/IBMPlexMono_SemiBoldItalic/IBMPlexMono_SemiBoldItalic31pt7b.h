#ifndef _IBMPLEXMONO_SEMIBOLDITALIC31PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x1F, 0x1F, 0x8F,
  0xC3, 0xC0, 0x38, 0xF3, 0x8F, 0x78, 0xE7, 0x8E, 0x79, 0xE7, 0x1E, 0x71,
  0xE7, 0x1E, 0xF1, 0xCF, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x3C, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x1F, 0xC7, 0xF3, 0xFC,
  0xFE, 0x3F, 0x8F, 0xE0, 0x38, 0xE0, 0x07, 0x9E, 0x00, 0x71, 0xC0, 0x07,
  0x1C, 0x0F, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x1E, 0x78, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x03, 0xCF, 0x00, 0x38, 0xE0, 0x03, 0x9E, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0xFF,
  0xFC, 0x79, 0x9E, 0x78, 0xC4, 0x3C, 0x60, 0x1E, 0x70, 0x0F, 0x38, 0x07,
  0xDC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xDF,
  0x00, 0xE7, 0x80, 0x63, 0xC8, 0x31, 0xE6, 0x18, 0xF7, 0xDD, 0xF3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x03, 0xE0, 0x3C, 0x1F, 0xC0, 0xE0, 0xFF, 0x07, 0x07, 0x9C, 0x38, 0x1C,
  0x30, 0xE0, 0x71, 0xC7, 0x01, 0x87, 0x3C, 0x07, 0x1C, 0xE0, 0x1F, 0xE7,
  0x00, 0x7F, 0x9C, 0x00, 0x78, 0x80, 0x00, 0x03, 0xE0, 0x03, 0x9F, 0xC0,
  0x1C, 0xFF, 0x80, 0x73, 0x8E, 0x03, 0x9C, 0x38, 0x1C, 0x70, 0xE0, 0x71,
  0xC3, 0x83, 0x87, 0x1C, 0x0E, 0x1F, 0xF0, 0x70, 0x3F, 0x83, 0x80, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0x3C, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0xF3, 0x81,
  0xFF, 0xC0, 0xF7, 0xC0, 0x79, 0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0x78, 0xFC, 0x3E, 0x7F, 0x8B, 0xBD, 0xFE, 0xFE, 0x7F, 0x1F,
  0x07, 0x83, 0x80, 0x3C, 0xE3, 0x9E, 0x79, 0xE7, 0x9C, 0x73, 0xC0, 0x00,
  0xF0, 0x1C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x02,
  0x1E, 0x13, 0xEF, 0x7D, 0xFF, 0xFF, 0x7F, 0xFC, 0x0F, 0xF8, 0x03, 0xF0,
  0x03, 0xFC, 0x03, 0xDE, 0x03, 0xE7, 0x83, 0xE1, 0xE0, 0xE0, 0xE0, 0x20,
  0x40, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1,
  0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x00, 0x7F, 0xEF, 0xFB, 0xFF, 0x00, 0x3D,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE1, 0xE0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0xE3, 0xDE, 0x79, 0xFF, 0x3C,
  0xFF, 0x9C, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x70, 0x1E, 0x3C,
  0x0F, 0x1F, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x3E, 0x78, 0x7C, 0x78,
  0x38, 0x78, 0x10, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF,
  0xC3, 0xE3, 0xE3, 0xC0, 0xF8, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7C, 0x3E, 0x06, 0x07, 0xC1, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x10, 0x0F, 0x0C, 0x07, 0xCF, 0xC3, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3B, 0xC0, 0x1E, 0xF0, 0x0F,
  0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x3C, 0x1E,
  0x0E, 0x07, 0x87, 0x81, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE3, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0xF8, 0x1D, 0xFE, 0x0E, 0xFF, 0x87, 0x83, 0xE4, 0x81,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x20, 0x1F, 0x38, 0x0F, 0x3E,
  0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0xF8, 0x3D, 0xFE, 0x7B, 0xFE, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0xE0, 0x3E, 0xE0, 0x3C, 0xE0, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x1E, 0x1F, 0x07, 0xFE, 0x01, 0xFE, 0x03,
  0xFF, 0xC7, 0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F,
  0x78, 0x0F, 0xBE, 0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x03,
  0xF0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFE, 0x3F,
  0xDE, 0x1F, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFE, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0xFC, 0xFC, 0xFC, 0x78,
  0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1,
  0xE0, 0x70, 0x3C, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x20, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x10, 0x00,
  0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0x7F, 0xE3, 0xFF, 0xDF, 0x1F, 0xF0, 0x3C, 0x40, 0xF0, 0x03, 0xC0, 0x1F,
  0x01, 0xF8, 0x3F, 0xC0, 0xFC, 0x03, 0xC0, 0x0E, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x70,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE0, 0xF1, 0xE0, 0x39,
  0xE0, 0x1C, 0xE1, 0xCE, 0x71, 0xF7, 0x79, 0xFF, 0xB9, 0xE3, 0xDC, 0xF1,
  0xCE, 0x70, 0xE7, 0x38, 0x77, 0x9C, 0x3B, 0xCE, 0x3D, 0xC7, 0x1E, 0xE3,
  0xFE, 0x71, 0xFF, 0x38, 0x7B, 0x8E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F,
  0x3C, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x07,
  0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x79, 0xE0, 0x0F, 0x78, 0x03, 0xFC, 0x00, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3E,
  0x38, 0x1E, 0x3C, 0x1F, 0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xC1,
  0xE1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x1E,
  0x0F, 0x8F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x39, 0xE0, 0x22, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x10, 0xF0, 0x1E, 0x78, 0x1F, 0x1E, 0x1F,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0xC3, 0xC3, 0xE1, 0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xFB, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x1F, 0x1E, 0x1F, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF8, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x1F, 0xFE, 0x1E, 0x1F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x10,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0xFE, 0xF1, 0xFE, 0xF1, 0xFE,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C,
  0x7F, 0xFC, 0x7F, 0xBC, 0x1F, 0x38, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x0F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x00, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x1E, 0x1E, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0x03, 0xE3, 0xC0, 0xF8, 0x78,
  0x1E, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0x9F, 0x01, 0xE7,
  0xC0, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFD, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xF1, 0xE0, 0x3E, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0xFE, 0x3B, 0x9F, 0xC7, 0x77, 0x70, 0xEE, 0xEE, 0x3D, 0xF9, 0xC7,
  0xBF, 0x78, 0xF3, 0xCF, 0x1C, 0x79, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x1E,
  0x30, 0xE3, 0xC2, 0x3C, 0x78, 0x87, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x38,
  0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1E, 0x00, 0x1F, 0x03, 0xC7, 0xE0, 0xF1,
  0xF8, 0x38, 0x7E, 0x0E, 0x1F, 0x83, 0x8F, 0xE1, 0xE3, 0xFC, 0x78, 0xFF,
  0x1E, 0x3D, 0xC7, 0x0E, 0x71, 0xC3, 0x9C, 0x70, 0xE7, 0xBC, 0x79, 0xEF,
  0x1E, 0x3B, 0xC7, 0x8E, 0xE1, 0xC3, 0xB8, 0x70, 0xFE, 0x1C, 0x3F, 0x8F,
  0x07, 0xE3, 0xC1, 0xF8, 0xF0, 0x7C, 0x38, 0x1F, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x70, 0x1E, 0x3C, 0x0F, 0x1F,
  0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x81,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xE1, 0xE1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F,
  0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x70, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0x08, 0x03, 0xC6, 0x01, 0xEF,
  0x80, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x87,
  0xFF, 0xE3, 0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F,
  0x3C, 0x07, 0x9E, 0x07, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xE7,
  0x81, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F,
  0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3E, 0x1F, 0x1F, 0x01, 0x87, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x20, 0x07, 0x8C, 0x03, 0xC7, 0xC1,
  0xF3, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x1E, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x3B, 0xC0, 0x1D, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0xE7, 0x00,
  0x1C, 0xE0, 0x07, 0xBC, 0x00, 0xE7, 0x80, 0x1C, 0xF1, 0xE3, 0x9E, 0x7C,
  0x73, 0x8F, 0x9E, 0x71, 0xF3, 0x8E, 0x7E, 0x71, 0xCF, 0xCE, 0x39, 0xBB,
  0xC7, 0x77, 0x71, 0xEE, 0xEE, 0x3D, 0x9D, 0xC7, 0xF3, 0xB8, 0xFE, 0x7F,
  0x1D, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x87, 0xC0,
  0x3C, 0x7C, 0x01, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0x78,
  0x07, 0x83, 0xC0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x7C, 0x03, 0xE0, 0xF0,
  0x07, 0xFC, 0x03, 0xEF, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x1F, 0x0F,
  0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xE0, 0x78, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xE0, 0x70, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x7B, 0xC0, 0x3C, 0xF0, 0x3C, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x1E,
  0x07, 0x9E, 0x01, 0xCF, 0x00, 0xFF, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x33, 0xC7, 0x1E, 0x38, 0xE1, 0x40, 0x07, 0xCF, 0x1F, 0xEF,
  0x1F, 0xFF, 0x3E, 0x1F, 0x7C, 0x1F, 0x78, 0x0E, 0x78, 0x1E, 0xF8, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0x78, 0xFC, 0x7F, 0xBF,
  0x7F, 0xBF, 0x1E, 0x1F, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x7C, 0x3C, 0xFE, 0x3D, 0xFF,
  0x3F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0xF7, 0xFC, 0xF7, 0xF8,
  0xF3, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0xFF, 0xF1, 0xE1, 0xF7, 0x81, 0x8F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x23, 0xC0, 0x67, 0x81,
  0xEF, 0x87, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x1F, 0x1E, 0x0F, 0xEF, 0x07, 0xFF, 0xC3, 0xE1, 0xF1, 0xF0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F,
  0x8F, 0x83, 0xE1, 0xE1, 0x78, 0x7F, 0xFC, 0x0F, 0xEF, 0x01, 0xE3, 0xC0,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xFC,
  0x3F, 0x7F, 0xFE, 0xFF, 0xF1, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0xCF, 0x83,
  0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x01,
  0xEF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC7, 0x87, 0xF3, 0x87, 0xFF, 0xC7, 0xC3, 0xE7, 0xC0, 0xF3, 0xC0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x07,
  0xC7, 0x85, 0xE3, 0xFE, 0xE0, 0xFE, 0xF0, 0x3E, 0x78, 0x00, 0x3C, 0x20,
  0x3C, 0x18, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x7C, 0x3E, 0xFE, 0x3D, 0xFE, 0x3D, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x83, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x08, 0x1E, 0x18, 0x3C, 0x78, 0x7B, 0xE0, 0xEF, 0x81,
  0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x08, 0x78,
  0x70, 0xF0, 0xF1, 0xE0, 0xF3, 0xC1, 0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xF8, 0x3C, 0xFE, 0x1E, 0xFF, 0x8F,
  0xC7, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF1, 0xE0,
  0x7B, 0xC0, 0x3C, 0xF1, 0x1E, 0x78, 0xCF, 0x3C, 0xFF, 0x0F, 0xF7, 0x87,
  0xF3, 0xC1, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x84, 0x3C, 0x31, 0xE3, 0xCF, 0x3C, 0x7B, 0xC3,
  0xFC, 0x1F, 0xC0, 0x78, 0x00, 0x3D, 0xC3, 0x8F, 0xF9, 0xF3, 0xBE, 0xFC,
  0xF3, 0xA7, 0x38, 0xF1, 0xCE, 0x38, 0x77, 0x8E, 0x3D, 0xE3, 0x8F, 0x70,
  0xE3, 0x9C, 0x78, 0xE7, 0x1E, 0x39, 0xC7, 0x0E, 0xF1, 0xC7, 0xBC, 0x71,
  0xEE, 0x1C, 0x73, 0x8F, 0x1C, 0x1E, 0x7C, 0x3C, 0xFE, 0x3D, 0xFE, 0x3D,
  0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xF7, 0x81, 0xEF,
  0x87, 0x8F, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0x3E, 0x0F, 0x3F, 0x87,
  0xBF, 0xE3, 0xF1, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE7, 0xE1, 0xF3, 0xDF,
  0xF1, 0xEF, 0xF0, 0xF3, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC7, 0x87, 0xF7, 0x87, 0xFF,
  0xC7, 0xC3, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9F, 0x07, 0xC7, 0x85, 0xE3, 0xFF, 0xE0,
  0xFE, 0xF0, 0x3C, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF, 0x1F, 0xFE, 0x7F, 0xFD, 0xF8, 0x7E,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x03,
  0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0C, 0x3C, 0x00, 0x3C, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1E, 0x20, 0x1E, 0x78,
  0x3C, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x04, 0x1E, 0x1C, 0x3C, 0xFC, 0x7B, 0xE0, 0xFF, 0x81, 0xFC, 0x01, 0xF0,
  0x00, 0x7C, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF0, 0xF8, 0xFF, 0x78, 0x7E, 0x78, 0x3C, 0x78, 0x7F, 0x06, 0x7E,
  0x1E, 0xFE, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C,
  0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x7C, 0x3D, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x38, 0xE3, 0x3C, 0x73, 0x9C, 0x39, 0xEE,
  0x3C, 0x77, 0x1C, 0x3B, 0x8E, 0x1D, 0xC7, 0x0F, 0xE3, 0x8F, 0xE1, 0xC7,
  0x71, 0xE3, 0xB8, 0xE1, 0xDC, 0x71, 0xCE, 0x58, 0xE7, 0xEC, 0xE3, 0xE7,
  0xE0, 0xE1, 0xE0, 0x03, 0x87, 0x81, 0xF9, 0xF8, 0x7F, 0x3F, 0x3E, 0xFC,
  0xF3, 0x8F, 0x1E, 0x41, 0xE3, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0x87, 0x84, 0x71, 0xF1, 0xCF, 0x2E, 0xFD, 0xFD, 0xFE,
  0x1F, 0x1F, 0x83, 0xC3, 0xC0, 0x0F, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x70, 0xF0, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0xBC, 0x3C, 0x3E, 0x0F, 0xF7,
  0x81, 0xFD, 0xE0, 0x3C, 0x78, 0x00, 0x1E, 0x08, 0x0F, 0x03, 0x07, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC7, 0x8F, 0xFB, 0xCF,
  0xFF, 0xC7, 0x0F, 0xE3, 0x83, 0xE1, 0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC7, 0x07, 0xC3, 0x87, 0x80, 0xEF, 0xFC, 0x77, 0xFF,
  0xFB, 0xCF, 0xF9, 0xC1, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x07, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0xFF, 0x83, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0x03, 0x9F, 0xC1, 0xDF,
  0xF1, 0xCE, 0x78, 0xEF, 0x1F, 0xE7, 0x07, 0xF3, 0x81, 0xE0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 9, 22, 19, 5, -22 },
  { 26, 12, 10, 19, 5, -23 },
  { 41, 20, 22, 19, 0, -22 },
  { 96, 17, 28, 19, 1, -25 },
  { 156, 22, 22, 19, -1, -22 },
  { 217, 18, 22, 19, 0, -22 },
  { 267, 6, 10, 19, 8, -23 },
  { 275, 12, 28, 19, 6, -24 },
  { 317, 13, 28, 19, 1, -24 },
  { 363, 17, 16, 19, 1, -17 },
  { 397, 15, 15, 19, 2, -17 },
  { 426, 9, 10, 19, 3, -5 },
  { 438, 11, 3, 19, 4, -11 },
  { 443, 6, 6, 19, 5, -6 },
  { 448, 19, 28, 19, 0, -24 },
  { 515, 17, 22, 19, 1, -22 },
  { 562, 16, 22, 19, 1, -22 },
  { 606, 17, 22, 19, 1, -22 },
  { 653, 18, 22, 19, 0, -22 },
  { 703, 18, 22, 19, 0, -22 },
  { 753, 17, 22, 19, 1, -22 },
  { 800, 16, 22, 19, 1, -22 },
  { 844, 16, 22, 19, 3, -22 },
  { 888, 17, 22, 19, 1, -22 },
  { 935, 16, 22, 19, 2, -22 },
  { 979, 8, 17, 19, 5, -17 },
  { 996, 10, 22, 19, 3, -17 },
  { 1024, 15, 18, 19, 3, -18 },
  { 1058, 17, 9, 19, 1, -14 },
  { 1078, 16, 18, 19, 1, -18 },
  { 1114, 14, 22, 19, 3, -22 },
  { 1153, 17, 25, 19, 1, -22 },
  { 1207, 18, 22, 19, -1, -22 },
  { 1257, 17, 22, 19, 1, -22 },
  { 1304, 17, 22, 19, 2, -22 },
  { 1351, 17, 22, 19, 1, -22 },
  { 1398, 18, 22, 19, 1, -22 },
  { 1448, 18, 22, 19, 1, -22 },
  { 1498, 16, 22, 19, 2, -22 },
  { 1542, 18, 22, 19, 1, -22 },
  { 1592, 17, 22, 19, 1, -22 },
  { 1639, 17, 22, 19, 1, -22 },
  { 1686, 19, 22, 19, 1, -22 },
  { 1739, 14, 22, 19, 2, -22 },
  { 1778, 19, 22, 19, 0, -22 },
  { 1831, 18, 22, 19, 1, -22 },
  { 1881, 17, 22, 19, 1, -22 },
  { 1928, 17, 22, 19, 1, -22 },
  { 1975, 17, 28, 19, 1, -22 },
  { 2035, 17, 22, 19, 1, -22 },
  { 2082, 18, 22, 19, 0, -22 },
  { 2132, 18, 22, 19, 2, -22 },
  { 2182, 17, 22, 19, 2, -22 },
  { 2229, 17, 22, 19, 3, -22 },
  { 2276, 19, 22, 19, 1, -22 },
  { 2329, 21, 22, 19, -1, -22 },
  { 2387, 18, 22, 19, 3, -22 },
  { 2437, 19, 22, 19, 0, -22 },
  { 2490, 14, 28, 19, 4, -24 },
  { 2539, 9, 28, 19, 5, -24 },
  { 2571, 14, 28, 19, 1, -24 },
  { 2620, 17, 13, 19, 1, -22 },
  { 2648, 15, 3, 19, 0, 3 },
  { 2654, 6, 7, 19, 6, -25 },
  { 2660, 16, 16, 19, 1, -16 },
  { 2692, 16, 23, 19, 1, -23 },
  { 2738, 15, 16, 19, 2, -16 },
  { 2768, 18, 23, 19, 1, -23 },
  { 2820, 15, 16, 19, 2, -16 },
  { 2850, 21, 29, 19, -1, -23 },
  { 2927, 17, 22, 19, 1, -16 },
  { 2974, 16, 23, 19, 1, -23 },
  { 3020, 15, 24, 19, 2, -24 },
  { 3065, 15, 30, 19, 1, -24 },
  { 3122, 17, 23, 19, 1, -23 },
  { 3171, 13, 23, 19, 3, -23 },
  { 3209, 18, 16, 19, 0, -16 },
  { 3245, 16, 16, 19, 1, -16 },
  { 3277, 15, 16, 19, 2, -16 },
  { 3307, 17, 22, 19, 0, -16 },
  { 3354, 17, 22, 19, 1, -16 },
  { 3401, 15, 16, 19, 3, -16 },
  { 3431, 16, 16, 19, 1, -16 },
  { 3463, 15, 22, 19, 2, -22 },
  { 3505, 16, 16, 19, 2, -16 },
  { 3537, 16, 16, 19, 1, -16 },
  { 3569, 17, 16, 19, 1, -16 },
  { 3603, 19, 16, 19, 0, -16 },
  { 3641, 18, 22, 19, 0, -16 },
  { 3691, 17, 16, 19, 1, -16 },
  { 3725, 15, 28, 19, 3, -24 },
  { 3778, 8, 28, 19, 6, -24 },
  { 3806, 15, 28, 19, 1, -24 },
  { 3859, 17, 7, 19, 1, -13 },
};

const GFXfont IBMPlexMono_SemiBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC31PT7B_H_
