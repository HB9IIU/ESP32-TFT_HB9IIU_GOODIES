#ifndef _IBMPLEXMONO_SEMIBOLDITALIC49PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0x07,
  0xE3, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F,
  0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC0, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x84, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x07, 0x83, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xF9, 0xEF,
  0xE0, 0xFE, 0x1E, 0x3C, 0x0F, 0xC3, 0xC1, 0x80, 0xFC, 0x3C, 0x00, 0x0F,
  0xC3, 0xC0, 0x00, 0xFC, 0x3C, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0xFC, 0x3C,
  0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0xF1, 0xFC,
  0x00, 0x0F, 0x0F, 0xC0, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x0F, 0xC0, 0x01,
  0xE0, 0xFC, 0x10, 0x1E, 0x1F, 0xC3, 0x81, 0xE1, 0xF8, 0x7E, 0x1E, 0x3F,
  0x8F, 0xF9, 0xEF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x3E, 0x1F, 0x01,
  0xF0, 0x07, 0x81, 0xE0, 0x3E, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0x3E, 0x07,
  0x81, 0xE0, 0x07, 0x81, 0xF0, 0x7C, 0x00, 0xF0, 0x3E, 0x1F, 0x00, 0x1E,
  0x07, 0xC3, 0xC0, 0x03, 0xC0, 0xF8, 0xF8, 0x00, 0x78, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0xC7, 0x80, 0x01, 0xFF, 0xF1, 0xF0, 0x00, 0x1F, 0xFC, 0x7C,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE3, 0xFF, 0x80, 0x00,
  0xF8, 0xFF, 0xF8, 0x00, 0x1E, 0x3F, 0x1F, 0x00, 0x07, 0xC7, 0xC1, 0xE0,
  0x01, 0xF1, 0xF0, 0x3C, 0x00, 0x3C, 0x3E, 0x07, 0x80, 0x0F, 0x87, 0xC0,
  0xF0, 0x03, 0xE0, 0xF8, 0x1E, 0x00, 0x7C, 0x1E, 0x07, 0xC0, 0x1F, 0x03,
  0xC0, 0xF8, 0x07, 0xC0, 0x78, 0x1E, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x3E,
  0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x1F, 0xFC, 0x01, 0xF0, 0x01, 0xFF, 0x00,
  0x40, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC,
  0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xE7,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x03, 0x3F, 0x00, 0xFC, 0x3D, 0xFC, 0x07, 0xE1, 0xFF, 0xE0,
  0x7F, 0x9F, 0xBF, 0x03, 0xFD, 0xF9, 0xFC, 0x37, 0xFF, 0x8F, 0xFF, 0x9F,
  0xFC, 0x3F, 0xFC, 0xFF, 0xC1, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x0F, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x02, 0x01, 0xF8, 0x08, 0xF0, 0x7C, 0x0E, 0x7F, 0x9F, 0x1F, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFD, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x00, 0x38, 0x03, 0x80, 0x04,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x0F, 0xE7, 0xFD,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x78, 0x7F, 0x7E, 0x1F, 0x0F, 0xEF, 0xC7, 0xF1,
  0xFB, 0xF8, 0xFC, 0x3F, 0x7F, 0x1F, 0x8F, 0xEF, 0xE1, 0xE1, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0,
  0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xEF, 0xC0,
  0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0xFE, 0x01, 0xF0, 0x7E, 0x00, 0x70, 0x3F, 0x00, 0x10, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x07,
  0xF8, 0x7E, 0x00, 0x7F, 0x17, 0xC0, 0x0F, 0xE0, 0x30, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xF8, 0x07, 0xF8,
  0x1C, 0x00, 0x7F, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0x1F, 0xC3, 0xC0,
  0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x83, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8,
  0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0x00, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0x80, 0x3F, 0xC0, 0x10, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0C, 0x00, 0x3F, 0x83,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0xFF, 0xE0,
  0xFE, 0xFF, 0xF8, 0x7E, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F,
  0xDF, 0xE0, 0x1F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0x00,
  0x0F, 0xE7, 0xC0, 0x03, 0xF1, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F,
  0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x9F, 0xF0,
  0x7F, 0xE7, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x7E, 0x03,
  0xFF, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC1, 0xFC, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8,
  0xFF, 0x83, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFB, 0xFC, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0x38, 0x01, 0xFC,
  0x20, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xF0,
  0x3E, 0x3C, 0xF8, 0x1F, 0xDF, 0x3E, 0x0F, 0xFF, 0xCF, 0x87, 0xFF, 0xF7,
  0xE3, 0xF0, 0xFD, 0xF0, 0xF8, 0x3F, 0x7C, 0x7E, 0x07, 0xDF, 0x1F, 0x01,
  0xE7, 0xC7, 0xC0, 0xF9, 0xF1, 0xF0, 0x3E, 0xFC, 0x7C, 0x0F, 0xBE, 0x3F,
  0x03, 0xEF, 0x8F, 0xC0, 0xFB, 0xE3, 0xE0, 0x7E, 0xF8, 0xF8, 0x1F, 0x3E,
  0x3E, 0x07, 0xCF, 0x87, 0xC3, 0xF3, 0xE1, 0xFB, 0xFC, 0xF8, 0x7F, 0xDF,
  0x3E, 0x0F, 0xE7, 0xCF, 0x83, 0xFB, 0xE1, 0xE0, 0x10, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0xFC, 0x03, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x01, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xE3, 0xF8,
  0x01, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x0C, 0x0F, 0xC0, 0x03, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E,
  0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7,
  0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF8, 0x7E, 0x03, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x1F,
  0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF4, 0x7E, 0x00, 0x20, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF1, 0xFC, 0x1F, 0xFE,
  0x3F, 0x03, 0xFF, 0xC7, 0xE0, 0x7F, 0xF9, 0xFC, 0x0F, 0xFF, 0x3F, 0x80,
  0x07, 0xC7, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x01,
  0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7E, 0x03,
  0xFF, 0xCF, 0xC0, 0x1F, 0xF1, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0x00, 0x3F, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0x80, 0x1F, 0xE0, 0x7E,
  0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x0F, 0xC1, 0xFE,
  0x00, 0x3F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xE7, 0xE0, 0x00, 0xFF, 0x1F,
  0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x7D, 0xF0,
  0x3F, 0x7C, 0xF3, 0xE0, 0x7C, 0xFB, 0xEF, 0xC0, 0xF9, 0xF7, 0x9F, 0x81,
  0xF3, 0xFF, 0x3E, 0x03, 0xE3, 0xFC, 0x7C, 0x0F, 0xC7, 0xF8, 0xF8, 0x1F,
  0x8F, 0xE3, 0xF0, 0x3F, 0x1F, 0xC7, 0xE0, 0x7C, 0x3F, 0x0F, 0xC0, 0xF8,
  0x3E, 0x1F, 0x01, 0xF0, 0x78, 0x3E, 0x07, 0xE0, 0xE0, 0x7C, 0x0F, 0xC1,
  0xC1, 0xF8, 0x1F, 0x83, 0x03, 0xF0, 0x3E, 0x02, 0x07, 0xE0, 0x7C, 0x08,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x01,
  0xF8, 0x1F, 0xE0, 0x0F, 0x80, 0xFF, 0x00, 0x7C, 0x0F, 0xF8, 0x03, 0xE0,
  0x7F, 0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x0F, 0xC0, 0xFF,
  0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xF7, 0xC1,
  0xF8, 0x1F, 0xBE, 0x0F, 0xC0, 0xF9, 0xF0, 0x7E, 0x07, 0xCF, 0x83, 0xE0,
  0x3E, 0x7E, 0x1F, 0x03, 0xF1, 0xF0, 0xF8, 0x1F, 0x8F, 0x8F, 0xC0, 0xFC,
  0x7C, 0x7E, 0x07, 0xC3, 0xE3, 0xF0, 0x3E, 0x1F, 0x9F, 0x01, 0xF0, 0x7C,
  0xF8, 0x1F, 0x83, 0xE7, 0xC0, 0xFC, 0x1F, 0x7E, 0x07, 0xE0, 0xFB, 0xF0,
  0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0xFC,
  0x07, 0xFE, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x01, 0xFF, 0x81, 0xF0, 0x0F,
  0xFC, 0x0F, 0x80, 0x3F, 0xC0, 0x7C, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87,
  0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x3F, 0xC1,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x9F,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x30, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x03, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFE, 0x07, 0xF0,
  0x03, 0xC0, 0xFE, 0x00, 0x18, 0x0F, 0xE0, 0x01, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x81,
  0x00, 0x01, 0xF8, 0x38, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFF, 0x80,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x7E,
  0x1F, 0xC1, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x7F, 0x0F, 0x83, 0xF1,
  0xFE, 0x1F, 0x07, 0xC3, 0xFC, 0x3E, 0x0F, 0x87, 0xF8, 0x7C, 0x1F, 0x1E,
  0xF1, 0xF0, 0x3E, 0x3D, 0xE3, 0xE0, 0x7C, 0x7B, 0xC7, 0xC0, 0xF9, 0xE7,
  0x8F, 0x83, 0xF3, 0xCF, 0x3E, 0x07, 0xE7, 0x9E, 0x7C, 0x0F, 0xDE, 0x3C,
  0xF8, 0x1F, 0x3C, 0x79, 0xF0, 0x3E, 0x78, 0xF3, 0xE0, 0x7D, 0xE1, 0xEF,
  0x80, 0xFB, 0xC3, 0xDF, 0x01, 0xF7, 0x87, 0xBE, 0x03, 0xFE, 0x0F, 0x7C,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07,
  0xFB, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x83,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x1E, 0x18, 0x00, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x04, 0x0E, 0x3F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C,
  0x3F, 0x0F, 0x83, 0xC1, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xC1,
  0xFF, 0xE7, 0xE1, 0xFF, 0xFB, 0xF1, 0xFE, 0x0F, 0xF8, 0xFE, 0x03, 0xFC,
  0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03,
  0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00,
  0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC3, 0xF0,
  0x3F, 0xE1, 0xFC, 0x3B, 0xFE, 0xFF, 0xF9, 0xFF, 0x3F, 0xF8, 0xFF, 0x0F,
  0xF8, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0xFF, 0x81, 0xF8, 0xFF, 0xE0, 0xFC,
  0xFF, 0xF8, 0x7E, 0xE1, 0xFC, 0x3F, 0xE0, 0x7F, 0x1F, 0xE0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xFE, 0x01, 0xFC, 0xFF, 0x83,
  0xFC, 0x7E, 0xFF, 0xFC, 0x3F, 0x3F, 0xFC, 0x1F, 0x9F, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFE, 0x0F, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x0E, 0x1F, 0x80,
  0x20, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x43, 0xF0, 0x00, 0xE7, 0xF0, 0x03, 0xE7,
  0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xE0, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0xF9, 0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0xFF, 0xFD, 0xF8, 0x1F, 0xE0, 0xFF,
  0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x07, 0xE0, 0x3F, 0xC0,
  0x7F, 0x0E, 0xFC, 0x07, 0xFF, 0xEF, 0xC0, 0x3F, 0xFC, 0xFC, 0x01, 0xFF,
  0x8F, 0xC0, 0x07, 0xE1, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7E, 0x01, 0xFE, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x20,
  0xFC, 0x00, 0x38, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0x7F, 0x83, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x02, 0x03, 0xF0, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0xFC, 0x0F, 0xFF, 0xBF, 0x83,
  0xFF, 0xF7, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x83, 0xF0, 0x1B, 0xF0,
  0x7F, 0x87, 0xFC, 0x07, 0xFF, 0xDF, 0x80, 0xFF, 0xF3, 0xF0, 0x0F, 0xFC,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x20, 0x03, 0xF0, 0x0E, 0x00, 0xFE, 0x03, 0xF0, 0x3F,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x7C, 0x01, 0xF8, 0xFF, 0x80, 0xFC, 0xFF, 0xE0, 0xFE, 0xFF, 0xF8, 0x7E,
  0xE1, 0xFC, 0x3F, 0x60, 0x7E, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC7,
  0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x40, 0x1F, 0x81, 0xC0, 0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0x81, 0xF8,
  0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x02,
  0x01, 0xF8, 0x03, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x1F, 0xF8, 0x0F, 0xCF, 0xFE, 0x07, 0xF7, 0xFF, 0xC1, 0xFB,
  0x87, 0xF0, 0x7E, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0xDF,
  0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x01, 0x1F,
  0x87, 0xE0, 0xF7, 0xE1, 0xF8, 0x7F, 0xF8, 0x7E, 0x3E, 0xFC, 0x0F, 0xDF,
  0x3F, 0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0xC3, 0xF0, 0x1F, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x02, 0x07, 0xF0,
  0x38, 0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03,
  0xF3, 0xF0, 0x1F, 0xBF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x7C, 0xFC, 0x3F, 0x83,
  0xEF, 0xF3, 0xFC, 0x1F, 0xFF, 0xBF, 0xF1, 0xF4, 0x7F, 0x1F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7C, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0x7C, 0x1F, 0x03, 0xE3,
  0xE0, 0xF8, 0x3F, 0x1F, 0x07, 0xC1, 0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0x7C, 0x7C, 0x0F, 0x83, 0xE3, 0xE0, 0xFC, 0x1F, 0x1F, 0x07, 0xC0,
  0xF8, 0xF8, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0x7C, 0x7E, 0x0F, 0x83, 0xE3,
  0xE0, 0x7C, 0x1F, 0x1F, 0x07, 0xE0, 0xF8, 0xF8, 0x3E, 0x07, 0xC7, 0xC1,
  0xF0, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE3, 0xFE, 0x03, 0xF3, 0xFF,
  0x83, 0xFB, 0xFF, 0xE1, 0xFB, 0x87, 0xF0, 0xFD, 0x81, 0xF8, 0x7F, 0x80,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x1F,
  0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x3F, 0xE0, 0x1F, 0xCF, 0xFE,
  0x03, 0xF3, 0xFF, 0xE0, 0x7E, 0xE1, 0xFC, 0x0F, 0xF8, 0x1F, 0xC1, 0xFE,
  0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF8, 0x3F, 0xC1, 0xFB, 0xFF, 0xF0, 0x3F,
  0x3F, 0xFC, 0x07, 0xE7, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xE3, 0xF0, 0x7F,
  0xFD, 0xFC, 0x3F, 0xFF, 0x7E, 0x1F, 0xE0, 0xFF, 0x87, 0xF0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80,
  0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE,
  0x1F, 0x80, 0xFF, 0x07, 0xF0, 0xEF, 0xC1, 0xFF, 0xFB, 0xF0, 0x3F, 0xFC,
  0xFC, 0x07, 0xFE, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1,
  0xFF, 0x03, 0xF3, 0xFE, 0x03, 0xF7, 0xFE, 0x03, 0xF7, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x1C, 0x1F, 0x80,
  0x08, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x10, 0x00, 0x7E, 0x38, 0x00, 0xFE, 0x7C, 0x00, 0xFC, 0xFF, 0x03,
  0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0xFE, 0x07, 0xE1,
  0xFC, 0x07, 0xE3, 0xF8, 0x07, 0xEF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x7F,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0xFF, 0x1F, 0x80, 0x7F,
  0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x6F, 0xC1, 0xFF, 0xE7, 0xE0, 0xFF, 0xF3,
  0xF0, 0x3F, 0xF3, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x3F,
  0xF8, 0x0F, 0x9F, 0xF8, 0x1F, 0xCF, 0xFC, 0x07, 0xEF, 0xFE, 0x03, 0xF8,
  0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x3F, 0x80, 0xFC, 0x7F, 0x80, 0x7C, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC3, 0xE0, 0xF8, 0xF8, 0x7C, 0x1F, 0x1F, 0x8F, 0x83, 0xE1, 0xF1, 0xF0,
  0x7C, 0x3E, 0x7C, 0x0F, 0x07, 0xCF, 0x83, 0xE0, 0xF9, 0xF0, 0x7C, 0x1F,
  0x3E, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x7C, 0xF8, 0x3E, 0x0F, 0xBE, 0x07,
  0xC1, 0xF7, 0xC1, 0xF0, 0x3E, 0xF8, 0x3E, 0x07, 0xDF, 0x07, 0xC0, 0xFB,
  0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x07, 0xDF, 0x83, 0xE0, 0xFB, 0xE0, 0xFC,
  0x1E, 0x7C, 0x1F, 0x07, 0xCF, 0x83, 0xE0, 0xF9, 0xF0, 0xFC, 0x1E, 0x3F,
  0x37, 0x87, 0x87, 0xFE, 0xF9, 0xF0, 0x7F, 0x8F, 0xFC, 0x0F, 0xE1, 0xFE,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0xF1, 0xFF, 0x83, 0xFF, 0xC7, 0xFE, 0x1F, 0xCF, 0xB8, 0xF8,
  0xFE, 0x3E, 0xC3, 0xE1, 0xE0, 0xFB, 0x0F, 0xC3, 0x03, 0xF8, 0x3E, 0x10,
  0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0x81, 0xF8, 0x08, 0x3E, 0x0D, 0xE0, 0x70, 0xF8, 0x37, 0x83, 0xE3,
  0xE1, 0xDF, 0x1F, 0xCF, 0xCE, 0x7D, 0xFE, 0x3F, 0xF9, 0xFF, 0xF0, 0x7F,
  0xC7, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0,
  0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x37, 0xE0, 0x3F, 0xFE,
  0xFC, 0x07, 0xFF, 0x9F, 0x80, 0x7F, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x02, 0x00, 0x1F,
  0x80, 0x60, 0x07, 0xF0, 0x1F, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x7C, 0x1F, 0xFF, 0x1F, 0x87, 0xFF, 0xF3, 0xF0,
  0xF8, 0x3F, 0xFC, 0x3E, 0x01, 0xFF, 0x87, 0xC0, 0x1F, 0xE0, 0xF8, 0x07,
  0xF8, 0x1F, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x18, 0x01, 0xFC, 0x0F, 0x00, 0x7F, 0x03, 0xE0, 0x1F,
  0xC0, 0x3E, 0x07, 0xF0, 0x07, 0xC1, 0xFC, 0x00, 0xF8, 0x7F, 0xF8, 0x0F,
  0x1F, 0x7F, 0xF1, 0xE3, 0xE3, 0xFF, 0xFC, 0x7C, 0x1F, 0xFF, 0x1F, 0x80,
  0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x01, 0x80, 0x7F, 0xC0, 0x1F, 0x0F, 0xFE, 0x03, 0xE1, 0xFF,
  0xE0, 0x3E, 0x1F, 0xFF, 0x07, 0xC3, 0xF3, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F,
  0xC7, 0xC0, 0xFF, 0xF8, 0x7C, 0x0F, 0xFF, 0x07, 0xC0, 0x7F, 0xF0, 0xF8,
  0x03, 0xFC, 0x03, 0x80, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_SemiBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 13, 35, 29, 9, -34 },
  { 58, 19, 15, 29, 8, -36 },
  { 94, 31, 34, 29, 0, -34 },
  { 226, 28, 46, 29, 1, -40 },
  { 387, 35, 36, 29, -2, -35 },
  { 545, 29, 36, 29, 0, -35 },
  { 676, 8, 15, 29, 13, -36 },
  { 691, 20, 44, 29, 9, -37 },
  { 801, 21, 44, 29, 1, -37 },
  { 917, 26, 25, 29, 2, -27 },
  { 999, 24, 22, 29, 3, -26 },
  { 1065, 13, 15, 29, 6, -8 },
  { 1090, 16, 5, 29, 7, -18 },
  { 1100, 10, 9, 29, 8, -8 },
  { 1112, 29, 44, 29, 0, -37 },
  { 1272, 27, 36, 29, 2, -35 },
  { 1394, 25, 34, 29, 2, -34 },
  { 1501, 27, 35, 29, 1, -35 },
  { 1620, 27, 36, 29, 1, -35 },
  { 1742, 28, 34, 29, 0, -34 },
  { 1861, 28, 35, 29, 1, -34 },
  { 1984, 25, 35, 29, 2, -34 },
  { 2094, 26, 34, 29, 4, -34 },
  { 2205, 28, 36, 29, 1, -35 },
  { 2331, 26, 35, 29, 3, -35 },
  { 2445, 13, 27, 29, 8, -26 },
  { 2489, 15, 33, 29, 6, -26 },
  { 2551, 24, 29, 29, 4, -29 },
  { 2638, 26, 14, 29, 2, -22 },
  { 2684, 24, 29, 29, 2, -29 },
  { 2771, 22, 36, 29, 6, -35 },
  { 2870, 26, 40, 29, 2, -35 },
  { 3000, 28, 34, 29, -1, -34 },
  { 3119, 26, 34, 29, 2, -34 },
  { 3230, 26, 36, 29, 3, -35 },
  { 3347, 26, 34, 29, 2, -34 },
  { 3458, 27, 34, 29, 2, -34 },
  { 3573, 28, 34, 29, 2, -34 },
  { 3692, 27, 36, 29, 2, -35 },
  { 3814, 29, 34, 29, 1, -34 },
  { 3938, 27, 34, 29, 2, -34 },
  { 4053, 26, 35, 29, 2, -34 },
  { 4167, 30, 34, 29, 2, -34 },
  { 4295, 22, 34, 29, 3, -34 },
  { 4389, 31, 34, 29, 0, -34 },
  { 4521, 29, 34, 29, 1, -34 },
  { 4645, 27, 36, 29, 2, -35 },
  { 4767, 27, 34, 29, 2, -34 },
  { 4882, 27, 45, 29, 2, -35 },
  { 5034, 27, 34, 29, 2, -34 },
  { 5149, 28, 36, 29, 1, -35 },
  { 5275, 28, 34, 29, 4, -34 },
  { 5394, 27, 35, 29, 3, -34 },
  { 5513, 27, 34, 29, 5, -34 },
  { 5628, 31, 34, 29, 1, -34 },
  { 5760, 33, 34, 29, -1, -34 },
  { 5901, 29, 34, 29, 4, -34 },
  { 6025, 30, 34, 29, 0, -34 },
  { 6153, 23, 44, 29, 6, -37 },
  { 6280, 14, 44, 29, 8, -37 },
  { 6357, 23, 44, 29, 1, -37 },
  { 6484, 26, 21, 29, 2, -34 },
  { 6553, 24, 5, 29, 0, 4 },
  { 6568, 9, 11, 29, 9, -39 },
  { 6581, 25, 27, 29, 2, -26 },
  { 6666, 25, 37, 29, 2, -36 },
  { 6782, 23, 27, 29, 3, -26 },
  { 6860, 28, 37, 29, 2, -36 },
  { 6990, 24, 27, 29, 3, -26 },
  { 7071, 33, 46, 29, -1, -36 },
  { 7261, 27, 36, 29, 1, -26 },
  { 7383, 25, 36, 29, 2, -36 },
  { 7496, 23, 38, 29, 4, -37 },
  { 7606, 25, 47, 29, 1, -37 },
  { 7753, 26, 37, 29, 2, -36 },
  { 7874, 21, 37, 29, 5, -36 },
  { 7972, 29, 26, 29, 0, -26 },
  { 8067, 25, 26, 29, 2, -26 },
  { 8149, 25, 27, 29, 2, -26 },
  { 8234, 27, 36, 29, 0, -26 },
  { 8356, 26, 36, 29, 2, -26 },
  { 8473, 24, 25, 29, 5, -25 },
  { 8548, 24, 27, 29, 2, -26 },
  { 8629, 24, 35, 29, 3, -34 },
  { 8734, 25, 26, 29, 3, -25 },
  { 8816, 25, 27, 29, 2, -26 },
  { 8901, 27, 27, 29, 1, -26 },
  { 8993, 30, 27, 29, 0, -26 },
  { 9095, 27, 35, 29, 1, -25 },
  { 9214, 27, 27, 29, 1, -26 },
  { 9306, 24, 44, 29, 5, -37 },
  { 9438, 12, 44, 29, 9, -37 },
  { 9504, 24, 44, 29, 1, -37 },
  { 9636, 28, 12, 29, 1, -21 },
};

const GFXfont IBMPlexMono_SemiBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC49PT7B_H_
