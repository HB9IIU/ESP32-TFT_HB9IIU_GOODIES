#ifndef _IBMPLEXMONO_SEMIBOLDITALIC11PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x36, 0xDB, 0xB0, 0x14, 0x29, 0xB9, 0x42, 0x9B, 0x94,
  0x28, 0x08, 0xF7, 0x54, 0x70, 0x71, 0x67, 0x78, 0x80, 0x72, 0xA9, 0x63,
  0x00, 0xCE, 0x95, 0x4E, 0x18, 0x48, 0x91, 0x4D, 0x12, 0x37, 0xB6, 0xF8,
  0x39, 0x11, 0x88, 0x42, 0x10, 0x43, 0x00, 0x30, 0x86, 0x10, 0x8C, 0x42,
  0x26, 0x00, 0x12, 0x57, 0xCC, 0x69, 0x40, 0x21, 0x3E, 0x46, 0x00, 0x6D,
  0x60, 0xE0, 0xF0, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x80,
  0x3D, 0x94, 0x55, 0x57, 0x14, 0xDE, 0x39, 0xA5, 0x86, 0x18, 0x41, 0x3F,
  0x3D, 0x90, 0x43, 0x18, 0xC6, 0x3F, 0x3D, 0x10, 0x4E, 0x0C, 0x3C, 0xDE,
  0x0C, 0x73, 0xDA, 0x4B, 0xF0, 0x86, 0x3C, 0x84, 0x16, 0x6C, 0x14, 0xFE,
  0x1C, 0xC6, 0x17, 0x6F, 0x14, 0xDE, 0xFE, 0x29, 0x84, 0x30, 0x86, 0x30,
  0x3D, 0x96, 0x4E, 0x4F, 0x1C, 0xDE, 0x7E, 0x63, 0x1F, 0x88, 0xDC, 0x68,
  0x0D, 0x80, 0x32, 0x00, 0x66, 0x4C, 0x09, 0xF1, 0x83, 0x08, 0x7C, 0x0F,
  0xC0, 0x83, 0x06, 0x7E, 0x40, 0x7E, 0x42, 0x66, 0x01, 0x8C, 0x3D, 0x95,
  0xD5, 0x77, 0x9D, 0xD0, 0x78, 0x18, 0xE2, 0x8A, 0x6D, 0xFC, 0xE3, 0x3D,
  0x96, 0x5E, 0x4D, 0x34, 0xFE, 0x39, 0x2C, 0x60, 0x82, 0x09, 0x9C, 0x39,
  0x96, 0x51, 0x45, 0x14, 0xFE, 0x3E, 0xC1, 0x83, 0xE4, 0x08, 0x10, 0x7C,
  0x3E, 0xC1, 0x83, 0xE4, 0x08, 0x10, 0x60, 0x7E, 0x61, 0x0B, 0xC6, 0x7F,
  0x66, 0xC9, 0x93, 0xE4, 0xC9, 0x93, 0x64, 0x3E, 0xB0, 0x40, 0x81, 0x02,
  0x0C, 0x7C, 0x3C, 0x10, 0xC3, 0x0C, 0x2C, 0x9C, 0x26, 0xD9, 0xE2, 0x87,
  0x89, 0x12, 0x66, 0x42, 0x11, 0x8C, 0x42, 0x1F, 0x66, 0xDD, 0xB2, 0xA5,
  0x5C, 0xB1, 0x46, 0x66, 0xE9, 0x52, 0xA5, 0x4A, 0x97, 0x64, 0x3D, 0x94,
  0x51, 0x47, 0x14, 0xDE, 0x3C, 0xC9, 0x9B, 0x27, 0x88, 0x10, 0x60, 0x3D,
  0x94, 0x51, 0x47, 0x14, 0xDE, 0x14, 0x60, 0x3C, 0xC9, 0x9B, 0x27, 0x8B,
  0x12, 0x66, 0x3C, 0xCD, 0x83, 0x80, 0xC1, 0x93, 0x7C, 0xFC, 0xC2, 0x08,
  0x20, 0x86, 0x18, 0xCF, 0x2C, 0xA2, 0x8A, 0x69, 0xBC, 0xCF, 0x3C, 0xB6,
  0xD1, 0x46, 0x18, 0x42, 0x85, 0x5A, 0xA6, 0xDD, 0xBB, 0x66, 0x66, 0x48,
  0xE1, 0xC3, 0x8D, 0x12, 0x66, 0xCF, 0x25, 0x94, 0x70, 0x86, 0x18, 0x7E,
  0x18, 0x20, 0xC3, 0x0C, 0x10, 0x7E, 0x39, 0x08, 0x44, 0x21, 0x08, 0x47,
  0x80, 0x92, 0x24, 0x92, 0x64, 0x38, 0x42, 0x11, 0x88, 0x42, 0x17, 0x80,
  0x18, 0xE2, 0xD1, 0xC4, 0xF8, 0xD0, 0x35, 0x34, 0xF3, 0x49, 0xF0, 0x21,
  0x87, 0xD9, 0x45, 0x14, 0xFE, 0x76, 0xE1, 0x09, 0xF8, 0x06, 0x08, 0xD2,
  0x64, 0xD9, 0x93, 0x3C, 0x7C, 0x7D, 0x29, 0xF8, 0x0E, 0x31, 0xF8, 0x81,
  0x02, 0x0C, 0x58, 0xF0, 0xC0, 0x35, 0x34, 0x53, 0xCD, 0xE8, 0xBC, 0x21,
  0x87, 0xDB, 0x4D, 0x34, 0xF2, 0x31, 0x81, 0xC2, 0x31, 0xAA, 0x60, 0x0C,
  0x30, 0x0E, 0x08, 0x61, 0x84, 0x91, 0x47, 0x00, 0x21, 0x87, 0xD9, 0x4D,
  0xC5, 0x76, 0xE1, 0x08, 0xC6, 0x29, 0x6C, 0x75, 0x7D, 0x65, 0xB6, 0x90,
  0x7D, 0xB4, 0xD3, 0x4F, 0x20, 0x76, 0x63, 0x39, 0xF8, 0x7D, 0x94, 0x51,
  0x4F, 0xEC, 0x20, 0x35, 0x34, 0xF3, 0x4D, 0xE0, 0x82, 0xED, 0xC6, 0x10,
  0x41, 0x00, 0x3D, 0xA7, 0x07, 0x4F, 0xE0, 0x21, 0x3E, 0xC4, 0x29, 0x6C,
  0xCC, 0x67, 0x39, 0xF8, 0x6F, 0x96, 0x5B, 0x59, 0xC0, 0x55, 0x55, 0x65,
  0xB7, 0x60, 0x7D, 0xAC, 0x40, 0x8B, 0x5B, 0x00, 0x65, 0x14, 0xD3, 0x49,
  0xE8, 0xBC, 0x75, 0x31, 0x8D, 0x47, 0xF0, 0x39, 0x08, 0x2E, 0x10, 0x88,
  0x43, 0x80, 0x2D, 0x24, 0x96, 0x90, 0x38, 0x21, 0x0C, 0x1C, 0x82, 0x04,
  0x13, 0x80, 0x65, 0x59, 0x80,
};

const GFXglyph IBMPlexMono_SemiBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 10, 7, 0, -9 },
  { 21, 7, 8, 7, 0, -8 },
  { 28, 7, 8, 7, 0, -8 },
  { 35, 2, 3, 7, 3, -8 },
  { 36, 5, 10, 7, 2, -8 },
  { 43, 5, 10, 7, 0, -8 },
  { 50, 6, 6, 7, 0, -6 },
  { 55, 5, 5, 7, 1, -6 },
  { 59, 3, 4, 7, 1, -2 },
  { 61, 3, 1, 7, 2, -4 },
  { 62, 2, 2, 7, 2, -2 },
  { 63, 7, 10, 7, 0, -8 },
  { 72, 6, 8, 7, 0, -8 },
  { 78, 6, 8, 7, 0, -8 },
  { 84, 6, 8, 7, 0, -8 },
  { 90, 6, 8, 7, 0, -8 },
  { 96, 6, 8, 7, 0, -8 },
  { 102, 6, 8, 7, 0, -8 },
  { 108, 6, 8, 7, 0, -8 },
  { 114, 6, 8, 7, 1, -8 },
  { 120, 6, 8, 7, 0, -8 },
  { 126, 5, 8, 7, 1, -8 },
  { 131, 3, 6, 7, 2, -6 },
  { 134, 4, 8, 7, 1, -6 },
  { 138, 5, 6, 7, 1, -6 },
  { 142, 6, 3, 7, 0, -5 },
  { 145, 5, 6, 7, 1, -6 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 6, 9, 7, 0, -8 },
  { 161, 6, 8, 7, 0, -8 },
  { 167, 6, 8, 7, 0, -8 },
  { 173, 6, 8, 7, 1, -8 },
  { 179, 6, 8, 7, 0, -8 },
  { 185, 7, 8, 7, 0, -8 },
  { 192, 7, 8, 7, 0, -8 },
  { 199, 5, 8, 7, 1, -8 },
  { 204, 7, 8, 7, 0, -8 },
  { 211, 7, 8, 7, 0, -8 },
  { 218, 6, 8, 7, 0, -8 },
  { 224, 7, 8, 7, 0, -8 },
  { 231, 5, 8, 7, 1, -8 },
  { 236, 7, 8, 7, 0, -8 },
  { 243, 7, 8, 7, 0, -8 },
  { 250, 6, 8, 7, 0, -8 },
  { 256, 7, 8, 7, 0, -8 },
  { 263, 6, 10, 7, 0, -8 },
  { 271, 7, 8, 7, 0, -8 },
  { 278, 7, 8, 7, 0, -8 },
  { 285, 6, 8, 7, 1, -8 },
  { 291, 6, 8, 7, 1, -8 },
  { 297, 6, 8, 7, 1, -8 },
  { 303, 7, 8, 7, 0, -8 },
  { 310, 7, 8, 7, 0, -8 },
  { 317, 6, 8, 7, 1, -8 },
  { 323, 7, 8, 7, 0, -8 },
  { 330, 5, 10, 7, 1, -8 },
  { 337, 3, 10, 7, 2, -8 },
  { 341, 5, 10, 7, 0, -8 },
  { 348, 6, 5, 7, 0, -8 },
  { 352, 5, 1, 7, 0, 1 },
  { 353, 2, 2, 7, 2, -9 },
  { 354, 6, 6, 7, 0, -6 },
  { 359, 6, 8, 7, 0, -8 },
  { 365, 5, 6, 7, 1, -6 },
  { 369, 7, 8, 7, 0, -8 },
  { 376, 5, 6, 7, 1, -6 },
  { 380, 7, 10, 7, 0, -8 },
  { 389, 6, 8, 7, 0, -6 },
  { 395, 6, 8, 7, 0, -8 },
  { 401, 5, 9, 7, 1, -9 },
  { 407, 6, 11, 7, 0, -9 },
  { 416, 6, 8, 7, 0, -8 },
  { 422, 5, 8, 7, 1, -8 },
  { 427, 6, 6, 7, 0, -6 },
  { 432, 6, 6, 7, 0, -6 },
  { 437, 5, 6, 7, 1, -6 },
  { 441, 6, 8, 7, 0, -6 },
  { 447, 6, 8, 7, 0, -6 },
  { 453, 6, 6, 7, 1, -6 },
  { 458, 6, 6, 7, 0, -6 },
  { 463, 5, 8, 7, 1, -8 },
  { 468, 5, 6, 7, 1, -6 },
  { 472, 6, 6, 7, 0, -6 },
  { 477, 6, 6, 7, 0, -6 },
  { 482, 7, 6, 7, 0, -6 },
  { 488, 6, 8, 7, 0, -6 },
  { 494, 6, 6, 7, 0, -6 },
  { 499, 5, 10, 7, 1, -8 },
  { 506, 3, 10, 7, 2, -8 },
  { 510, 6, 10, 7, 0, -8 },
  { 518, 6, 3, 7, 0, -5 },
};

const GFXfont IBMPlexMono_SemiBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC11PT7B_H_
