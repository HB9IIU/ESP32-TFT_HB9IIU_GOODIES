#ifndef _IBMPLEXMONO_SEMIBOLDITALIC40PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3E, 0x00, 0x3C, 0x3E, 0x78, 0x79, 0xF0, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x0F, 0x9E, 0x1F, 0x3C, 0x3C, 0xF8, 0x79, 0xF0, 0xF3, 0xE3,
  0xE7, 0x87, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F,
  0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC,
  0x3F, 0xE3, 0xFE, 0x3F, 0xF0, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x8F, 0x00, 0x07, 0x87, 0x80, 0x7F, 0xC3, 0xFC, 0x7F, 0xE3, 0xFE, 0x3F,
  0xE1, 0xFF, 0x00, 0xF0, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x38, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xCE, 0xFE, 0x3F, 0x1C, 0x70,
  0x7C, 0x78, 0x40, 0xF8, 0xF0, 0x01, 0xF1, 0xC0, 0x03, 0xE3, 0x80, 0x07,
  0xE7, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xBF, 0x80, 0x07, 0x3F, 0x00, 0x1E,
  0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x70, 0xF8, 0x60, 0xE1, 0xF1, 0xE1, 0xC7,
  0xC7, 0xF3, 0x9F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x3F, 0xC0, 0x1E, 0x07, 0xFE,
  0x03, 0xC0, 0xF0, 0xF0, 0x78, 0x0F, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0xF0,
  0x1E, 0x0F, 0x1E, 0x01, 0xE0, 0xF1, 0xE0, 0x1E, 0x0E, 0x3C, 0x01, 0xE1,
  0xE7, 0x80, 0x1E, 0x3E, 0x78, 0x00, 0xFF, 0xCF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xF7, 0xFE, 0x00, 0x1E, 0x78, 0xF0, 0x03, 0xCF, 0x0F, 0x00, 0x78, 0xF0,
  0x70, 0x07, 0x8E, 0x0F, 0x00, 0xF0, 0xE0, 0xF0, 0x1E, 0x0E, 0x0F, 0x01,
  0xE0, 0xE0, 0xE0, 0x3C, 0x0F, 0x1E, 0x07, 0x80, 0xFF, 0xC0, 0x78, 0x07,
  0xF8, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01,
  0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x80, 0x1E,
  0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x1F, 0x08, 0xF8, 0x1F, 0x0E, 0xF8, 0x1F, 0x9F, 0xFC,
  0x1F, 0xBE, 0x7C, 0x37, 0xFE, 0x7F, 0xE7, 0xFC, 0x7F, 0xE7, 0xF8, 0x3F,
  0xC3, 0xF8, 0x0F, 0x81, 0xE0, 0x3C, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x7B,
  0xEF, 0xBE, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x30, 0x3C, 0x09, 0xF1, 0xE3, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x03, 0xC0, 0x30, 0x08, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xE0, 0x3E, 0x7E, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F,
  0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3F, 0xF8, 0xF1, 0xFF, 0xCF, 0x8F, 0xFE, 0x7C, 0x7F, 0xE3,
  0xE3, 0xFF, 0x1E, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x0F, 0xC3,
  0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFD, 0xF0, 0x1F, 0x9F, 0x03, 0xF1, 0xF0, 0x7E, 0x1F, 0x03, 0xC1,
  0xF0, 0x18, 0x3F, 0x01, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8,
  0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0xC1, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0x3C, 0x03, 0xF0, 0x60, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x20, 0x03,
  0xF0, 0xC0, 0x0F, 0xCF, 0x80, 0x7E, 0x3F, 0x03, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF1, 0xF8, 0x07,
  0x9F, 0xF0, 0x1E, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x10, 0x01, 0xF8, 0xE0, 0x07, 0xC7, 0xC0, 0x3F, 0x3F, 0x83, 0xF8, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x3F, 0x03, 0xE7, 0xFC, 0x7F, 0xFF, 0xE7, 0xDF, 0xFE, 0xFF, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x07, 0xE7, 0xE0, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xC0, 0x1F, 0xBC, 0x00, 0xF9,
  0xE0, 0x0F, 0xCF, 0x00, 0xFC, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC,
  0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x3C,
  0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x3F, 0x1F, 0x81, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x3F, 0x07, 0xE7, 0xE0, 0x3F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xBE, 0x3F, 0xF7, 0xE0, 0xFC, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x0F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0xFF, 0x3F, 0xCF,
  0xE3, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0xFC,
  0x1F, 0xBE, 0x03, 0xE7, 0x00, 0xFC, 0x40, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE7,
  0x80, 0x0F, 0x3C, 0x1E, 0x7B, 0xE3, 0xFB, 0xDE, 0x1F, 0xFE, 0xF1, 0xF1,
  0xF7, 0x8F, 0x0F, 0xFC, 0xF0, 0x7B, 0xE7, 0x83, 0xDE, 0x3C, 0x1E, 0xF1,
  0xE0, 0xF7, 0x9F, 0x07, 0xBC, 0xF8, 0x7D, 0xE7, 0xC3, 0xCF, 0x1E, 0x3E,
  0x78, 0xFF, 0xF3, 0xC7, 0xF7, 0x9E, 0x1F, 0x3C, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E,
  0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F,
  0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xF8, 0x3F, 0x8F, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x01, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x0F, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7E, 0x07, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x9F, 0x01, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x07, 0xCF,
  0xC0, 0x1E, 0x3E, 0x00, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x60, 0xFC,
  0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x7E, 0x1F, 0xC3, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x81, 0xF8, 0x3E,
  0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E,
  0x1F, 0x03, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC,
  0x3F, 0x8F, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0x83,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x1F,
  0xFB, 0xF0, 0xFF, 0xDF, 0x87, 0xFE, 0xF8, 0x3F, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x79, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xF0, 0x1F,
  0x8F, 0xC1, 0xFC, 0x7F, 0xFB, 0xC1, 0xFF, 0x9E, 0x07, 0xFD, 0xF0, 0x0F,
  0x8F, 0x80, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07,
  0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x87, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0,
  0x1F, 0x83, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8,
  0x1F, 0x80, 0x7C, 0x1F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xDF, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF8,
  0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xF3, 0xFE, 0x1F, 0x7B,
  0xDF, 0x0F, 0xBD, 0xEF, 0x07, 0xDF, 0xE7, 0x83, 0xCF, 0xF3, 0xC1, 0xE3,
  0xF1, 0xE0, 0xF1, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x78, 0x78, 0x3E,
  0x3C, 0x3C, 0x1F, 0x0C, 0x1E, 0x0F, 0x06, 0x1F, 0x07, 0x82, 0x0F, 0x87,
  0xC1, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x1E, 0x1F, 0xC0, 0x7C, 0x3F, 0xC0, 0xF8, 0x7F, 0x81,
  0xF0, 0xFF, 0x03, 0xE1, 0xFE, 0x07, 0x83, 0xFC, 0x0F, 0x0F, 0xFC, 0x3E,
  0x1F, 0xF8, 0x7C, 0x3E, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF3, 0xC3, 0xC1,
  0xE7, 0x87, 0x87, 0xCF, 0x9F, 0x0F, 0x8F, 0x3E, 0x1F, 0x1E, 0x7C, 0x3C,
  0x3C, 0xF8, 0x78, 0x79, 0xE0, 0xF0, 0xFB, 0xC3, 0xE0, 0xF7, 0x87, 0xC1,
  0xFF, 0x0F, 0x83, 0xFE, 0x1E, 0x07, 0xFC, 0x3C, 0x0F, 0xF0, 0x78, 0x0F,
  0xE1, 0xF0, 0x1F, 0xC3, 0xE0, 0x3F, 0x87, 0xC0, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F,
  0x80, 0xFC, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07,
  0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0xC3,
  0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x1F,
  0x81, 0xF8, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00,
  0xFC, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x03, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0x80, 0xFC, 0xFC, 0x03, 0xE7,
  0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3E,
  0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0x81, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x30,
  0x03, 0xE3, 0xE0, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x1F, 0x81, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0xC7,
  0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80,
  0x7E, 0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xE1,
  0xF0, 0x07, 0x07, 0xE0, 0x04, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x86, 0x00, 0x3E,
  0x1E, 0x00, 0xFC, 0x7F, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07,
  0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF1, 0xF8, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0xF8, 0x7C, 0x78,
  0x7C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x3F, 0x0F, 0x0F, 0x1F, 0x87, 0x8F,
  0x8F, 0xC7, 0xC7, 0xCF, 0xE3, 0xC3, 0xE7, 0x71, 0xE1, 0xF3, 0xB8, 0xF0,
  0xF3, 0xDC, 0xF8, 0x79, 0xCE, 0x78, 0x3C, 0xE7, 0x3C, 0x1E, 0xF3, 0x9E,
  0x0F, 0x71, 0xCF, 0x07, 0xB8, 0xEF, 0x07, 0xFC, 0x77, 0x83, 0xFC, 0x3B,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF0,
  0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x7C, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x8F, 0x80, 0x0F, 0x9F,
  0x80, 0x0F, 0x9F, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x9F, 0x00,
  0xF8, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x30,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x10, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x08, 0x03, 0xF1, 0xF0, 0xFF,
  0x9F, 0x1F, 0xFD, 0xF3, 0xF0, 0x7F, 0x3E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xFC,
  0xF8, 0x1F, 0xCF, 0xC3, 0xFC, 0x7F, 0xEF, 0xF3, 0xFC, 0x7F, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x7E, 0x07, 0xC7, 0xF8, 0x3E, 0xFF, 0xE1, 0xF6, 0x1F, 0x8F,
  0xE0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFD, 0xF8,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0xC3, 0xF8,
  0xFF, 0xFF, 0x8F, 0xDF, 0xF8, 0x7C, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xF8, 0x3E, 0x7E, 0x03, 0x8F, 0x80,
  0x43, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x10, 0xF8, 0x03, 0x9F, 0x00, 0xFB, 0xE0, 0x3E, 0x7E, 0x0F,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x0F,
  0xC3, 0xE0, 0xFF, 0xDF, 0x87, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x0F,
  0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0xC3, 0x7C,
  0x1F, 0xF9, 0xF0, 0x3F, 0xC7, 0xC0, 0x7E, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC, 0x3E, 0x1F, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x07, 0xE7, 0xC3, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x87, 0xC0,
  0x1C, 0x7C, 0x03, 0xE3, 0xE0, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0x07, 0xC0, 0x00, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x7C, 0x1F, 0xFB, 0xF0, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0x01,
  0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7E, 0x0F, 0xE0, 0xF8, 0x6F,
  0x83, 0xFF, 0xBE, 0x07, 0xFC, 0xF8, 0x0F, 0xC3, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x20, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x03, 0xE7, 0xF8,
  0x3F, 0x7F, 0xE1, 0xF6, 0x1F, 0x0F, 0xA0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x83, 0x81, 0xF0, 0xF8, 0x7E, 0x3E, 0x0F,
  0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x20, 0x3E, 0x07, 0x03, 0xE0, 0xF8, 0x3C, 0x07, 0xC7, 0xC0, 0x3C, 0x7C,
  0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x3F, 0x00, 0xF9, 0xFE, 0x07, 0xCF, 0xFC, 0x1F, 0x61,
  0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x87, 0xE0, 0x3E, 0xFE, 0x00, 0xFB,
  0xF0, 0x03, 0xE7, 0xC1, 0x1F, 0x1F, 0x06, 0x7C, 0x3E, 0x7D, 0xF0, 0xFB,
  0xE7, 0xC3, 0xFF, 0x1F, 0x07, 0xF8, 0x7C, 0x1F, 0xC3, 0xF0, 0x3E, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x38, 0x7C,
  0x3E, 0x7E, 0x3E, 0x3F, 0x3E, 0x1F, 0x3E, 0x0F, 0xBE, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7C, 0x00, 0x1E, 0x38, 0x3C, 0x3D, 0xF8, 0xFC, 0x7B, 0xFB,
  0xF8, 0xF9, 0xF8, 0xF3, 0xE1, 0xF1, 0xE7, 0xC3, 0xC3, 0xCF, 0x0F, 0x87,
  0x9E, 0x1F, 0x0F, 0x3C, 0x3C, 0x1E, 0x78, 0x78, 0x7D, 0xF0, 0xF0, 0xFB,
  0xC1, 0xE1, 0xE7, 0x83, 0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x1E, 0x0F, 0x3C,
  0x3C, 0x3E, 0x78, 0x78, 0x7D, 0xF0, 0xF0, 0xF3, 0xC1, 0xE1, 0xE7, 0x87,
  0xC3, 0xCF, 0x0F, 0x07, 0x80, 0x0F, 0x8F, 0xC0, 0x7C, 0xFF, 0x07, 0xCF,
  0xFC, 0x3E, 0xC3, 0xE1, 0xF4, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x7C,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF8, 0x7E, 0x3E,
  0x03, 0xE3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x7C, 0x7C, 0x07, 0xC7, 0xE1, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0xC0,
  0xFB, 0xFF, 0x83, 0xEC, 0x3F, 0x0F, 0xE0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8,
  0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x7E, 0x3F, 0x01, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFE, 0x1F, 0xBF,
  0xF0, 0x7C, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0xF8, 0x7F, 0xEF, 0xC7, 0xFF, 0xFC, 0x7F, 0x0F,
  0xE3, 0xE0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x7E, 0xFC,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x1F, 0xC7, 0xE1,
  0xBE, 0x1F, 0xFD, 0xF0, 0x7F, 0xCF, 0x81, 0xF8, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0xFC, 0x7E,
  0xFF, 0xCF, 0xE0, 0x7D, 0xFE, 0x07, 0xD8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xC1, 0xF1, 0xF0, 0x0C,
  0x7C, 0x01, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF1,
  0x00, 0x3E, 0x70, 0x07, 0xDF, 0x83, 0xF3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0xC0, 0xF8, 0x3C, 0x3E, 0x1F, 0x87, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF9,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x01, 0xF8, 0xFC, 0x17, 0xC3, 0xE1, 0xBE, 0x1F, 0xF9, 0xF0, 0x7F,
  0x9F, 0x01, 0xF8, 0xF8, 0x00, 0xFF, 0x80, 0x4F, 0xF8, 0x3E, 0xFF, 0x83,
  0xE0, 0xF8, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE1, 0xF8, 0x3E, 0x3F, 0x03,
  0xEF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x1E,
  0x18, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0xCF, 0x0F, 0x0F, 0x3C, 0x3C, 0x3C,
  0xF0, 0xF0, 0xF7, 0x83, 0xC3, 0xDE, 0x1E, 0x0F, 0x78, 0x78, 0x3D, 0xE1,
  0xE0, 0xF7, 0x87, 0x83, 0xFE, 0x1E, 0x1E, 0xF0, 0x78, 0x7B, 0xC3, 0xE1,
  0xEF, 0x0F, 0x07, 0x3C, 0x3C, 0x3C, 0xF1, 0xF0, 0xF3, 0xFD, 0xC7, 0x8F,
  0xF7, 0xFC, 0x1F, 0x8F, 0xE0, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x07,
  0xF8, 0xFE, 0x0F, 0xF9, 0xFF, 0x3F, 0x3D, 0x9F, 0x7E, 0x3D, 0x0F, 0x18,
  0x3F, 0x0F, 0x10, 0x3E, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x7C, 0x08, 0xF0, 0xFC, 0x1C, 0xF0, 0xBC, 0x7C, 0xF9,
  0xBC, 0xFE, 0xFF, 0x9F, 0xF8, 0x7F, 0x1F, 0xE0, 0x3E, 0x0F, 0x80, 0x07,
  0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0x07, 0xF0,
  0x3F, 0x1B, 0xE0, 0x7F, 0xE7, 0xC0, 0x7F, 0x9F, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x10, 0x07, 0xC0, 0x78,
  0x3F, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x7C, 0x3F, 0xF9, 0xF1, 0xFF, 0xF7, 0xC7, 0x87, 0xFE, 0x1E, 0x07,
  0xF8, 0xF0, 0x1F, 0x83, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x08, 0x03, 0xF0, 0x60, 0x1F,
  0x83, 0xC0, 0xFC, 0x0F, 0x07, 0xE0, 0x3C, 0x3F, 0xC0, 0x79, 0xFF, 0xF1,
  0xC7, 0xBF, 0xFF, 0x3E, 0x3F, 0xF8, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07,
  0xC0, 0x18, 0x3F, 0x80, 0xF1, 0xFF, 0x03, 0xCF, 0xFE, 0x1F, 0x3C, 0xF8,
  0x79, 0xE1, 0xF3, 0xE7, 0x83, 0xFF, 0x1C, 0x0F, 0xF8, 0xF0, 0x1F, 0xE1,
  0xC0, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 11, 28, 24, 7, -28 },
  { 40, 15, 12, 24, 7, -30 },
  { 63, 25, 28, 24, 0, -28 },
  { 151, 23, 36, 24, 1, -32 },
  { 255, 28, 28, 24, -1, -28 },
  { 353, 24, 28, 24, 0, -28 },
  { 437, 6, 12, 24, 11, -30 },
  { 446, 17, 36, 24, 7, -30 },
  { 523, 17, 36, 24, 1, -30 },
  { 600, 21, 20, 24, 2, -22 },
  { 653, 19, 19, 24, 3, -21 },
  { 699, 11, 12, 24, 5, -6 },
  { 716, 13, 4, 24, 6, -14 },
  { 723, 8, 7, 24, 7, -7 },
  { 730, 24, 36, 24, 0, -30 },
  { 838, 21, 28, 24, 2, -28 },
  { 912, 20, 28, 24, 2, -28 },
  { 982, 22, 28, 24, 1, -28 },
  { 1059, 22, 28, 24, 1, -28 },
  { 1136, 23, 28, 24, 0, -28 },
  { 1217, 22, 28, 24, 1, -28 },
  { 1294, 20, 28, 24, 2, -28 },
  { 1364, 21, 28, 24, 3, -28 },
  { 1438, 22, 28, 24, 1, -28 },
  { 1515, 20, 28, 24, 3, -28 },
  { 1585, 10, 21, 24, 7, -21 },
  { 1612, 12, 27, 24, 5, -21 },
  { 1653, 20, 24, 24, 3, -24 },
  { 1713, 21, 12, 24, 2, -19 },
  { 1745, 19, 24, 24, 2, -24 },
  { 1802, 18, 28, 24, 5, -28 },
  { 1865, 21, 32, 24, 2, -28 },
  { 1949, 23, 28, 24, -1, -28 },
  { 2030, 21, 28, 24, 2, -28 },
  { 2104, 22, 28, 24, 2, -28 },
  { 2181, 22, 28, 24, 1, -28 },
  { 2258, 22, 28, 24, 2, -28 },
  { 2335, 22, 28, 24, 2, -28 },
  { 2412, 21, 28, 24, 2, -28 },
  { 2486, 23, 28, 24, 1, -28 },
  { 2567, 23, 28, 24, 1, -28 },
  { 2648, 21, 28, 24, 2, -28 },
  { 2722, 25, 28, 24, 1, -28 },
  { 2810, 19, 28, 24, 2, -28 },
  { 2877, 25, 28, 24, 0, -28 },
  { 2965, 23, 28, 24, 1, -28 },
  { 3046, 21, 28, 24, 2, -28 },
  { 3120, 22, 28, 24, 2, -28 },
  { 3197, 21, 36, 24, 2, -28 },
  { 3292, 22, 28, 24, 2, -28 },
  { 3369, 23, 28, 24, 1, -28 },
  { 3450, 23, 28, 24, 3, -28 },
  { 3531, 22, 28, 24, 2, -28 },
  { 3608, 22, 28, 24, 4, -28 },
  { 3685, 25, 28, 24, 1, -28 },
  { 3773, 27, 28, 24, -1, -28 },
  { 3868, 24, 28, 24, 3, -28 },
  { 3952, 24, 28, 24, 0, -28 },
  { 4036, 19, 36, 24, 5, -30 },
  { 4122, 11, 36, 24, 7, -30 },
  { 4172, 18, 36, 24, 1, -30 },
  { 4253, 21, 17, 24, 2, -28 },
  { 4298, 19, 4, 24, 0, 3 },
  { 4308, 7, 9, 24, 8, -32 },
  { 4316, 20, 21, 24, 2, -21 },
  { 4369, 21, 30, 24, 1, -30 },
  { 4448, 19, 21, 24, 2, -21 },
  { 4498, 22, 30, 24, 2, -30 },
  { 4581, 20, 21, 24, 2, -21 },
  { 4634, 27, 38, 24, -1, -30 },
  { 4763, 22, 29, 24, 1, -21 },
  { 4843, 21, 30, 24, 1, -30 },
  { 4922, 19, 30, 24, 3, -30 },
  { 4994, 20, 38, 24, 1, -30 },
  { 5089, 22, 30, 24, 1, -30 },
  { 5172, 17, 30, 24, 4, -30 },
  { 5236, 23, 21, 24, 0, -21 },
  { 5297, 21, 21, 24, 1, -21 },
  { 5353, 20, 21, 24, 2, -21 },
  { 5406, 22, 29, 24, 0, -21 },
  { 5486, 21, 29, 24, 2, -21 },
  { 5563, 20, 21, 24, 4, -21 },
  { 5616, 19, 21, 24, 2, -21 },
  { 5666, 19, 28, 24, 3, -28 },
  { 5733, 21, 21, 24, 2, -21 },
  { 5789, 20, 21, 24, 2, -21 },
  { 5842, 22, 21, 24, 1, -21 },
  { 5900, 24, 21, 24, 0, -21 },
  { 5963, 23, 29, 24, 0, -21 },
  { 6047, 22, 21, 24, 1, -21 },
  { 6105, 20, 36, 24, 4, -30 },
  { 6195, 11, 36, 24, 7, -30 },
  { 6245, 20, 36, 24, 1, -30 },
  { 6335, 22, 10, 24, 1, -17 },
};

const GFXfont IBMPlexMono_SemiBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC40PT7B_H_
