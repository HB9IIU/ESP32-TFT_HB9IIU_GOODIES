#ifndef _IBMPLEXMONO_SEMIBOLDITALIC28PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x0E, 0x18, 0x30, 0x40, 0x80,
  0x00, 0x00, 0x3C, 0xF9, 0xF3, 0xE7, 0x80, 0x71, 0xDC, 0x77, 0x1D, 0xCF,
  0xF3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x71, 0xC0,
  0x1C, 0x60, 0x07, 0x38, 0x03, 0x8E, 0x0F, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC,
  0x7E, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x38, 0xE0, 0xFE, 0x7F,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE0, 0x73, 0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03,
  0x9C, 0x01, 0xC7, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x1F, 0x80,
  0xFF, 0xC3, 0xFF, 0xCF, 0x37, 0x9C, 0x62, 0x38, 0xC0, 0x73, 0x80, 0xF7,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xDE, 0x03, 0x9E,
  0x06, 0x39, 0x8C, 0x77, 0x9B, 0xEF, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x70, 0xFE, 0x0E, 0x1F, 0xE1,
  0xC1, 0xC6, 0x18, 0x18, 0x63, 0x81, 0x86, 0x70, 0x18, 0xE7, 0x01, 0xFE,
  0xE0, 0x1F, 0xCC, 0x00, 0xF1, 0x00, 0x00, 0x1E, 0x00, 0x7B, 0xF8, 0x07,
  0x7F, 0x80, 0xE7, 0x38, 0x0C, 0xE1, 0x81, 0xCE, 0x38, 0x38, 0xE3, 0x83,
  0x07, 0xF0, 0x70, 0x7F, 0x0E, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x80, 0xF3, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x3C,
  0x07, 0xBC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0E, 0x78, 0x07, 0x1C, 0x07, 0x8F,
  0x03, 0xC3, 0x89, 0xE1, 0xE7, 0xF1, 0x77, 0x3F, 0xBF, 0x1F, 0x8F, 0x87,
  0x87, 0x80, 0x77, 0x7F, 0xFE, 0xEE, 0xE0, 0x01, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x07, 0x3C, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0x73, 0x81, 0xE7, 0x87, 0x87, 0x06, 0x0C, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFE, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0x1E,
  0x3C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xBC, 0x07,
  0x71, 0x8F, 0xE7, 0xBF, 0xCE, 0x7F, 0x9C, 0xFF, 0x01, 0xFE, 0x03, 0xBC,
  0x0F, 0x38, 0x1E, 0x78, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3E, 0xF0, 0xF3, 0xC7, 0x8E, 0x0C,
  0x38, 0x10, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x1C, 0x0F, 0x0C, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x1F, 0x0C, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xFC,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x20, 0x1E, 0x30, 0x3E, 0xF8, 0x7C,
  0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xDE, 0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x3C,
  0x1E, 0x3C, 0x1C, 0x3C, 0x38, 0x3C, 0x70, 0x38, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x0F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0xF8, 0x3B, 0xF8, 0x6F, 0xF9, 0xE0, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x07,
  0x88, 0x0F, 0x30, 0x1E, 0xF0, 0x79, 0xFF, 0xF1, 0xFF, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0xF8, 0x7B, 0xF8, 0xFF, 0xF9, 0xF0, 0xF7, 0xC0, 0xFF, 0x01,
  0xFE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0x78, 0x78, 0xFF, 0xF0, 0xFF, 0xC0,
  0x7E, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0x80, 0xE7, 0x03, 0xCE,
  0x07, 0x38, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF3,
  0xC0, 0xE7, 0x01, 0xCE, 0x07, 0x9E, 0x1E, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF,
  0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xBC, 0x0F, 0x78, 0x1E, 0xF8, 0x7D,
  0xFF, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F,
  0x0F, 0x70, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xF7,
  0xFF, 0xDF, 0xFE, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x3F, 0x00, 0x1C, 0x7D, 0xFB, 0xF3, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE7, 0xCF, 0x9F, 0x3C, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xC3, 0xC1, 0xE0, 0xE0,
  0xF0, 0x70, 0x38, 0x38, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x20, 0x3F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFC, 0x10, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x07, 0x80, 0x18, 0x00, 0x80, 0x00, 0x0F, 0xC1,
  0xFF, 0x1F, 0xFC, 0xF1, 0xFF, 0x07, 0x90, 0x3C, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0xFE, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF8, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xDE, 0x3B, 0xB8, 0xFF, 0x73, 0xFE,
  0xE7, 0x1D, 0xDC, 0x3F, 0x38, 0x6E, 0x71, 0xDC, 0xE3, 0xB9, 0xFF, 0x73,
  0xEE, 0xE3, 0xDD, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xFE, 0x07, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xDC, 0x01, 0xDE, 0x03, 0xDE, 0x03, 0x9E, 0x07, 0x9E, 0x07, 0x0E, 0x0F,
  0x0E, 0x0F, 0x0E, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x3C, 0x0F, 0x38,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF8, 0xE0, 0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3F, 0xF8,
  0x7F, 0xC0, 0xFF, 0xE3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x38,
  0x1E, 0x70, 0x7D, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xF1, 0xE7, 0x81, 0xEF, 0x03, 0x9C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x0E, 0x78, 0x3C, 0xF0, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE1, 0xF3, 0xC1, 0xE7, 0x81, 0xCF, 0x03,
  0x9E, 0x07, 0x38, 0x1E, 0x70, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF,
  0x03, 0x9C, 0x0F, 0x38, 0x1E, 0x70, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF8, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0xF8, 0x3F, 0xF0, 0xF0, 0xF3, 0xC1, 0xE7, 0x81, 0xDE, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF1, 0xFD, 0xC3, 0xF7, 0x8F, 0xEF, 0x01, 0xDE, 0x03, 0xBC,
  0x0F, 0x38, 0x1E, 0x78, 0x78, 0xFF, 0xF0, 0xFE, 0xE0, 0xF9, 0xC0, 0x1E,
  0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38,
  0x1E, 0x38, 0x1E, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x3C, 0x70,
  0x3C, 0x70, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xF0,
  0x78, 0xE0, 0x78, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x18, 0x1E, 0x78,
  0x38, 0xF0, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0x1E, 0x07, 0x8F,
  0x07, 0x87, 0x07, 0x83, 0x87, 0x83, 0xC7, 0xC1, 0xE7, 0xC0, 0xF3, 0xC0,
  0x7B, 0xC0, 0x3B, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xCE,
  0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x0F, 0x1E, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x07,
  0xC7, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x9F, 0x87, 0xEE, 0xE3,
  0xBB, 0xF0, 0xEF, 0xDC, 0x39, 0xF7, 0x0E, 0x79, 0xC3, 0x9C, 0x70, 0xE7,
  0x3C, 0x79, 0x8F, 0x1C, 0x23, 0x87, 0x10, 0xE1, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x70, 0x1F, 0x07, 0x1F, 0x07, 0x1F,
  0x0F, 0x3F, 0x0E, 0x3F, 0x0E, 0x3B, 0x0E, 0x3B, 0x8E, 0x3B, 0x8E, 0x3B,
  0x9E, 0x7B, 0x9C, 0x73, 0x9C, 0x71, 0xDC, 0x71, 0xDC, 0x71, 0xDC, 0x71,
  0xFC, 0xF1, 0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0x03,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF0, 0xF3, 0xC1, 0xE7, 0x01, 0xDE, 0x03,
  0xBC, 0x07, 0x78, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xBC, 0x0F, 0x78, 0x1E, 0x78, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0x7E,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C, 0x1E, 0x1C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF0,
  0xF3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x0F, 0x78, 0x1E, 0x78,
  0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x78, 0x00, 0x79, 0x80, 0x77,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1C, 0x1E, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x79, 0xE0, 0x78, 0xE0, 0x78, 0xF0,
  0x70, 0xF0, 0x70, 0x70, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0x20, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x60, 0x3C, 0x78, 0x3C, 0x7F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x1E, 0x70,
  0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCF, 0x03, 0x9C, 0x0F, 0x38, 0x1E,
  0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xE7, 0x81, 0xCE, 0x07, 0x9C, 0x0F, 0x38,
  0x1E, 0x70, 0x38, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x78, 0xF0, 0xF0, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x3C, 0x0E,
  0x78, 0x1C, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x78, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x73,
  0x8E, 0x39, 0xCF, 0x1C, 0xE7, 0x8E, 0x73, 0xCE, 0x3B, 0xE7, 0x1D, 0xB3,
  0x9C, 0xD9, 0xCE, 0xEC, 0xC7, 0x66, 0xE3, 0xB3, 0x71, 0xD9, 0xB8, 0xF8,
  0xDC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x00, 0x0F, 0x01, 0xE1, 0xE0,
  0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x38, 0xF0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0xF0, 0xE0, 0x1E, 0x1E,
  0x07, 0x83, 0xC1, 0xE0, 0x3C, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0xBC, 0x07,
  0x9E, 0x07, 0x8F, 0x07, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0x73, 0xC0, 0x39,
  0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0x1F, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x8F, 0xF0, 0xFF, 0x00,
  0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x70, 0x30, 0x38, 0x38,
  0x38, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E,
  0x07, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x20, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0xF7, 0x81, 0xC7, 0x07, 0x8F, 0x1E, 0x0E, 0x38, 0x1C, 0xF0,
  0x3F, 0xC0, 0x39, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x37,
  0x9E, 0x73, 0x88, 0x0F, 0x9E, 0x3F, 0xB8, 0xFF, 0x73, 0xE1, 0xE7, 0x83,
  0xCE, 0x07, 0xBC, 0x0F, 0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE3,
  0xFB, 0xE7, 0xF7, 0xC7, 0x87, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x7C, 0x3D, 0xFC, 0x77,
  0xF8, 0xF8, 0xF3, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x38, 0x1E,
  0x70, 0x3D, 0xF0, 0xF3, 0xFF, 0xE7, 0xBF, 0x8E, 0x3C, 0x00, 0x07, 0xC0,
  0xFF, 0x8F, 0xFE, 0xF0, 0xFF, 0x02, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x37, 0x03, 0xFC, 0x3D, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x0F,
  0x9E, 0x1F, 0xDE, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1C, 0x70, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0xF8, 0x7F, 0xF8, 0x7F,
  0x78, 0x3E, 0x78, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0xF0, 0x7F, 0x03, 0xF8,
  0x7F, 0xFF, 0x9F, 0xE0, 0xE0, 0x07, 0x01, 0xBC, 0x3F, 0xFF, 0xE7, 0xFE,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x02, 0x1C, 0x00, 0xE3, 0x80, 0x3E, 0x70, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xCF, 0x0F, 0xEF, 0x1F,
  0xFF, 0x3E, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x3C, 0x7C, 0x5C, 0x3F, 0xFC, 0x3F, 0xBC, 0x0F, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x30, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x3C, 0x3D, 0xF8, 0xFF, 0xF3, 0xA3, 0xCF, 0x07, 0x78, 0x1D, 0xE0, 0xF7,
  0x83, 0xDE, 0x0F, 0x70, 0x39, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0x07, 0xF8, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x41, 0xC7, 0x1E, 0x78, 0xF7, 0x87, 0xF8, 0x3F, 0x80, 0xF0, 0x00, 0x00,
  0x38, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x63, 0xC3,
  0x8F, 0x0F, 0x3C, 0x1E, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x7C, 0x3D, 0xFC, 0x7F, 0xF8, 0xE8, 0xF1, 0xE0, 0xE7, 0x83, 0xCF,
  0x0F, 0x1E, 0xF8, 0x3F, 0xC0, 0x73, 0xC4, 0xE7, 0xBF, 0xC7, 0xF7, 0x8F,
  0xCF, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x43, 0x8E, 0x39, 0xF7, 0xBC, 0x7F, 0x83, 0xF0, 0x3C, 0x00, 0x39,
  0xCF, 0x3B, 0xDF, 0x3F, 0xDF, 0x39, 0xE7, 0x79, 0xE7, 0x71, 0xC7, 0x71,
  0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x71, 0x8E, 0xE3, 0x8E, 0xE3, 0x8E, 0xE3,
  0x8E, 0xE3, 0x8E, 0x3C, 0xF0, 0xF7, 0xE3, 0xFF, 0xCE, 0x8F, 0x3C, 0x1D,
  0xE0, 0x77, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xC0, 0xE7, 0x03, 0xBC, 0x1E,
  0xF0, 0x7B, 0xC1, 0xE0, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0xCF, 0x0F, 0x78,
  0x1D, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F,
  0xFC, 0x3F, 0xE0, 0x3E, 0x00, 0x1E, 0x7C, 0x1E, 0xFE, 0x1D, 0xFE, 0x1F,
  0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38, 0x1E, 0x38,
  0x1E, 0x7C, 0x3C, 0x7F, 0xFC, 0x7B, 0xF8, 0x71, 0xE0, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x9E, 0x3F,
  0xBC, 0xFF, 0xFB, 0xE1, 0xE7, 0x81, 0xCE, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0xF3, 0xC2, 0xE3, 0xFF, 0xC7, 0xF7, 0x87, 0xCF, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFE,
  0x3F, 0xFB, 0xEF, 0xEF, 0x87, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x07, 0xF0, 0x7F, 0xF1, 0xFF, 0xCF, 0x06, 0x3C, 0x00, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x01, 0xF8, 0x00, 0xE7, 0x07, 0xBF, 0xFE, 0x7F, 0xF0, 0x7F,
  0x00, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0xC3, 0x8F, 0x3D, 0xF1, 0xFF, 0x07, 0xE0, 0x3E, 0x00, 0x78, 0x3D,
  0xE0, 0xF7, 0x03, 0x9C, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xB8, 0x1E,
  0xE0, 0xF3, 0x83, 0xCF, 0x1F, 0x3F, 0xFC, 0xFE, 0xF1, 0xF3, 0x80, 0x7E,
  0x1B, 0xF8, 0xFF, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0xC3, 0xCF,
  0x0F, 0x38, 0x78, 0xE3, 0xE3, 0x9F, 0x0F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00,
  0x71, 0xCC, 0xE3, 0x9D, 0xC7, 0x3B, 0x8C, 0x76, 0x38, 0xFC, 0x71, 0xF8,
  0xE3, 0xF1, 0xC7, 0xE3, 0x8D, 0xCE, 0x3B, 0x9C, 0x77, 0xF9, 0xCF, 0xBF,
  0x0E, 0x3C, 0x00, 0x07, 0x8E, 0x07, 0xCF, 0x8F, 0xFF, 0xEF, 0xBE, 0x73,
  0x1E, 0x39, 0x0F, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE3, 0xC2, 0x71, 0xE3,
  0x39, 0xF7, 0xDF, 0xBF, 0x8F, 0xCF, 0x83, 0xC7, 0x80, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38,
  0x1E, 0x38, 0x3C, 0x38, 0x3C, 0x3C, 0x7C, 0x3F, 0xFC, 0x3F, 0xBC, 0x0F,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x30, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F,
  0x80, 0x0F, 0x8E, 0x7F, 0xDC, 0xFF, 0xFB, 0xC7, 0xF7, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x18, 0x78, 0x3B, 0xFC, 0x77, 0xFF, 0xEE,
  0x7F, 0xDC, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x01, 0xE1, 0xFE, 0x0F,
  0x80, 0x7F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x0E, 0x1C, 0x38,
  0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x78,
  0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE0, 0x0F, 0xE0, 0x7F, 0x83, 0xFC,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0xF0, 0x0F, 0x83, 0xFC, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x00,
  0x1E, 0x06, 0x7E, 0x1D, 0xFE, 0x3B, 0x9C, 0xEE, 0x3F, 0xDC, 0x3F, 0x30,
  0x3C, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 20, 17, 5, -20 },
  { 19, 10, 9, 17, 5, -21 },
  { 31, 18, 20, 17, 0, -20 },
  { 76, 15, 26, 17, 1, -23 },
  { 125, 20, 20, 17, -1, -20 },
  { 175, 17, 20, 17, 0, -20 },
  { 218, 4, 9, 17, 8, -21 },
  { 223, 12, 25, 17, 5, -21 },
  { 261, 11, 25, 17, 1, -21 },
  { 296, 15, 14, 17, 1, -15 },
  { 323, 14, 13, 17, 2, -15 },
  { 346, 8, 9, 17, 3, -5 },
  { 355, 9, 3, 17, 4, -10 },
  { 359, 5, 5, 17, 5, -5 },
  { 363, 17, 25, 17, 0, -21 },
  { 417, 15, 20, 17, 1, -20 },
  { 455, 14, 20, 17, 1, -20 },
  { 490, 16, 20, 17, 0, -20 },
  { 530, 16, 20, 17, 0, -20 },
  { 570, 16, 20, 17, 0, -20 },
  { 610, 15, 20, 17, 1, -20 },
  { 648, 15, 20, 17, 1, -20 },
  { 686, 15, 20, 17, 2, -20 },
  { 724, 15, 20, 17, 1, -20 },
  { 762, 14, 20, 17, 2, -20 },
  { 797, 7, 15, 17, 5, -15 },
  { 811, 9, 19, 17, 3, -15 },
  { 833, 14, 17, 17, 2, -17 },
  { 863, 15, 9, 17, 1, -13 },
  { 880, 14, 17, 17, 1, -17 },
  { 910, 13, 20, 17, 3, -20 },
  { 943, 15, 23, 17, 1, -20 },
  { 987, 16, 20, 17, -1, -20 },
  { 1027, 15, 20, 17, 1, -20 },
  { 1065, 15, 20, 17, 2, -20 },
  { 1103, 15, 20, 17, 1, -20 },
  { 1141, 16, 20, 17, 1, -20 },
  { 1181, 16, 20, 17, 1, -20 },
  { 1221, 15, 20, 17, 1, -20 },
  { 1259, 16, 20, 17, 1, -20 },
  { 1299, 16, 20, 17, 1, -20 },
  { 1339, 15, 20, 17, 1, -20 },
  { 1377, 17, 20, 17, 1, -20 },
  { 1420, 12, 20, 17, 2, -20 },
  { 1450, 18, 20, 17, 0, -20 },
  { 1495, 16, 20, 17, 1, -20 },
  { 1535, 15, 20, 17, 1, -20 },
  { 1573, 16, 20, 17, 1, -20 },
  { 1613, 15, 26, 17, 1, -20 },
  { 1662, 16, 20, 17, 1, -20 },
  { 1702, 17, 20, 17, 0, -20 },
  { 1745, 16, 20, 17, 2, -20 },
  { 1785, 15, 20, 17, 2, -20 },
  { 1823, 15, 20, 17, 3, -20 },
  { 1861, 17, 20, 17, 1, -20 },
  { 1904, 19, 20, 17, -1, -20 },
  { 1952, 17, 20, 17, 2, -20 },
  { 1995, 17, 20, 17, 0, -20 },
  { 2038, 12, 25, 17, 4, -21 },
  { 2076, 8, 25, 17, 5, -21 },
  { 2101, 13, 25, 17, 1, -21 },
  { 2142, 15, 12, 17, 1, -20 },
  { 2165, 14, 3, 17, 0, 2 },
  { 2171, 5, 6, 17, 5, -22 },
  { 2175, 15, 14, 17, 1, -14 },
  { 2202, 15, 21, 17, 1, -21 },
  { 2242, 13, 14, 17, 2, -14 },
  { 2265, 16, 21, 17, 1, -21 },
  { 2307, 13, 14, 17, 2, -14 },
  { 2330, 19, 27, 17, -1, -21 },
  { 2395, 16, 20, 17, 0, -14 },
  { 2435, 14, 21, 17, 1, -21 },
  { 2472, 13, 21, 17, 2, -21 },
  { 2507, 14, 27, 17, 1, -21 },
  { 2555, 15, 21, 17, 1, -21 },
  { 2595, 12, 21, 17, 3, -21 },
  { 2627, 16, 14, 17, 0, -14 },
  { 2655, 14, 14, 17, 1, -14 },
  { 2680, 14, 14, 17, 1, -14 },
  { 2705, 16, 20, 17, 0, -14 },
  { 2745, 15, 20, 17, 1, -14 },
  { 2783, 14, 14, 17, 3, -14 },
  { 2808, 14, 14, 17, 1, -14 },
  { 2833, 13, 20, 17, 2, -20 },
  { 2866, 14, 14, 17, 2, -14 },
  { 2891, 14, 14, 17, 1, -14 },
  { 2916, 15, 14, 17, 1, -14 },
  { 2943, 17, 14, 17, 0, -14 },
  { 2973, 16, 20, 17, 0, -14 },
  { 3013, 15, 14, 17, 1, -14 },
  { 3040, 13, 25, 17, 3, -21 },
  { 3081, 7, 25, 17, 5, -21 },
  { 3103, 13, 25, 17, 1, -21 },
  { 3144, 15, 7, 17, 1, -12 },
};

const GFXfont IBMPlexMono_SemiBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC28PT7B_H_
