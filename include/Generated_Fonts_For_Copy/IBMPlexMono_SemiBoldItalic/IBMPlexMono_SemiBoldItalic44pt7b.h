#ifndef _IBMPLEXMONO_SEMIBOLDITALIC44PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x1F, 0x00, 0x1F, 0x0F, 0x9F, 0x07,
  0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8,
  0x3E, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7,
  0xE1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0,
  0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xC7, 0xC0, 0x00, 0x78,
  0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xF3, 0xDF, 0x83, 0xF1,
  0xE3, 0x83, 0xF0, 0xE0, 0x81, 0xF8, 0x70, 0x00, 0xFC, 0x78, 0x00, 0x7E,
  0x3C, 0x00, 0x3F, 0x9E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x77, 0xF8, 0x00, 0x38, 0xFC, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F,
  0x04, 0x0F, 0x0F, 0x86, 0x07, 0x8F, 0xC7, 0xC3, 0x87, 0xE7, 0xF9, 0xCF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x01, 0xFF, 0x00,
  0x78, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x7C, 0x3C, 0x0F,
  0x00, 0xF0, 0x78, 0x3E, 0x01, 0xE0, 0xF0, 0x78, 0x03, 0xC1, 0xE1, 0xE0,
  0x0F, 0x83, 0xC7, 0xC0, 0x1E, 0x07, 0x9F, 0x00, 0x3C, 0x1F, 0x3C, 0x00,
  0x3C, 0x7C, 0xF0, 0x00, 0x7F, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xF7, 0xFF, 0x80, 0x07, 0xCF, 0x0F, 0x00, 0x0F,
  0x3E, 0x1E, 0x00, 0x3C, 0x78, 0x3C, 0x00, 0xF8, 0xF0, 0x78, 0x01, 0xE1,
  0xE0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0x1F, 0x07, 0x83, 0xC0, 0x3C, 0x0F,
  0x0F, 0x80, 0xF0, 0x1E, 0x1E, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0x80, 0x3F,
  0xF0, 0x1E, 0x00, 0x7F, 0xC0, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x3C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xBF, 0x80, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0x3E, 0x04, 0xFC, 0x0F, 0xC3, 0xFF, 0x03, 0xF1, 0xF7, 0xC0, 0xBE,
  0x79, 0xF8, 0x6F, 0xBE, 0x7F, 0xF3, 0xFF, 0x0F, 0xFC, 0x7F, 0x81, 0xFE,
  0x0F, 0xE0, 0x3E, 0x01, 0xE0, 0x3E, 0x7C, 0xF9, 0xF7, 0xEF, 0x9F, 0x3E,
  0x7C, 0xFB, 0xF7, 0xCF, 0x9F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0C, 0x0F, 0x83, 0xBF, 0x1E,
  0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xDF, 0x80, 0x3F, 0x1F, 0x80, 0xFC, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xC0, 0x38, 0x01, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x7E, 0x3E,
  0xFC, 0x7E, 0x7E, 0xFC, 0x7C, 0x7E, 0xFC, 0x3C, 0x7E, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x7E, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0xCF,
  0xC0, 0xFE, 0x3F, 0x07, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x1C, 0x0F, 0x80,
  0x20, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xC0, 0x7F, 0x1F,
  0x80, 0x3F, 0x07, 0x00, 0x3F, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0x07, 0x80, 0x7F, 0x03, 0x00, 0x3F, 0x02,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x10, 0x00, 0xFC, 0x38,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x81,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0x80,
  0x3F, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE1,
  0xF8, 0x00, 0xF3, 0xFF, 0x00, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x10, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3E, 0x00, 0xFE, 0x3F, 0xC0, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE3,
  0xE0, 0x3F, 0x3F, 0xE0, 0xFD, 0xFF, 0xC7, 0xEF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x7F, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xE7, 0xF0, 0x7F, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0x00,
  0x1F, 0xBE, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF0, 0x07,
  0xE3, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x00, 0x7E,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF3, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x9F,
  0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x80,
  0x7F, 0x7F, 0x83, 0xFE, 0x7F, 0xFE, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xF7,
  0xE0, 0xFF, 0xDF, 0x80, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0x83, 0xF8, 0x7F, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x01, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04,
  0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0xFF, 0xFC, 0x07, 0xF7, 0x80, 0x3F, 0x18,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1F,
  0x3E, 0x0F, 0x9F, 0x3C, 0x1F, 0xDE, 0x7C, 0x3F, 0xDE, 0x7C, 0x7F, 0xFE,
  0x7C, 0x7C, 0x3E, 0x78, 0xF8, 0x3E, 0x78, 0xF8, 0x3E, 0xF8, 0xF0, 0x3C,
  0xF8, 0xF0, 0x3C, 0xF9, 0xF0, 0x3C, 0xF9, 0xF0, 0x3C, 0xF1, 0xF0, 0x7C,
  0xF1, 0xF0, 0x7C, 0xF1, 0xF0, 0xF8, 0xF0, 0xFF, 0xF8, 0xF0, 0xFF, 0x78,
  0xF0, 0xFF, 0x78, 0xF0, 0x7E, 0xF8, 0xF0, 0x10, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03,
  0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE1, 0xF8, 0x1F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xF8, 0x07,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F,
  0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x61, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x38, 0x7C, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE1, 0xFC, 0x3F, 0x83, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3E, 0x07, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF0,
  0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF8,
  0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xFC, 0x3F, 0x03, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x3F,
  0x80, 0x3F, 0x3F, 0x00, 0x30, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xFE, 0xFE,
  0x0F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC,
  0x00, 0x7C, 0xFC, 0x00, 0x78, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFD, 0xF0, 0x1F, 0xF9, 0xF0, 0x0F, 0xF1, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x02, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x7F, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x07,
  0xC0, 0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0x8F, 0xE0, 0x00,
  0xF9, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xEF, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7C,
  0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0,
  0xFB, 0xCF, 0x7C, 0x0F, 0x3C, 0xF7, 0xC1, 0xF3, 0xDE, 0x7C, 0x1F, 0x3F,
  0xE7, 0xC1, 0xF3, 0xFC, 0xF8, 0x1F, 0x1F, 0xCF, 0x81, 0xF1, 0xF8, 0xF8,
  0x1F, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1E, 0x0F, 0x83, 0xE0,
  0xE1, 0xF0, 0x3E, 0x0C, 0x1F, 0x03, 0xE0, 0xC1, 0xF0, 0x3E, 0x08, 0x1F,
  0x07, 0xC0, 0x81, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xC1, 0xFE, 0x03, 0xE0,
  0x7F, 0x80, 0xF8, 0x1F, 0xE0, 0x3E, 0x0F, 0xF8, 0x0F, 0x83, 0xFE, 0x03,
  0xE0, 0xFF, 0xC0, 0xF8, 0x3F, 0xF0, 0x7C, 0x0F, 0xFC, 0x1F, 0x03, 0xFF,
  0x07, 0xC1, 0xF3, 0xC1, 0xF0, 0x7C, 0xF0, 0x7C, 0x1F, 0x3E, 0x1F, 0x07,
  0xCF, 0x8F, 0x81, 0xF3, 0xE3, 0xE0, 0x7C, 0x78, 0xF8, 0x1F, 0x1E, 0x3E,
  0x0F, 0x87, 0xCF, 0x83, 0xE1, 0xF3, 0xE0, 0xF8, 0x7D, 0xF0, 0x3E, 0x0F,
  0x7C, 0x0F, 0x83, 0xDF, 0x03, 0xE0, 0xFF, 0xC1, 0xF0, 0x3F, 0xF0, 0x7C,
  0x0F, 0xFC, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0x7F, 0x81, 0xF0, 0x1F, 0xE0,
  0x7C, 0x07, 0xF8, 0x3E, 0x01, 0xFE, 0x0F, 0x80, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x3E, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x08, 0x00, 0x7C, 0x1C, 0x00, 0x7E,
  0x3C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0,
  0x7F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0x1F, 0x00, 0x7E, 0x1F, 0x00,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x0F,
  0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0x81, 0xF8, 0x3F,
  0x00, 0x78, 0x1F, 0x80, 0x08, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x20, 0x00, 0xFC, 0x30, 0x00, 0xFC, 0x3E, 0x00,
  0x7E, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x87,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3E, 0x3F, 0x87, 0x83, 0xE3, 0xF8, 0xF8, 0x3E, 0x3F, 0x8F, 0x83,
  0xC7, 0xF8, 0xF8, 0x3C, 0x7F, 0x8F, 0x07, 0xC7, 0x78, 0xF0, 0x7C, 0xF7,
  0x9F, 0x07, 0xCF, 0x79, 0xF0, 0x7C, 0xE7, 0x9F, 0x07, 0xCE, 0x79, 0xE0,
  0x7D, 0xE7, 0x9E, 0x07, 0xDC, 0x7B, 0xE0, 0x79, 0xC7, 0xBE, 0x07, 0xBC,
  0x7B, 0xC0, 0x7B, 0x87, 0xBC, 0x0F, 0xB8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xCF, 0xC0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x1F, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00,
  0x7C, 0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3F,
  0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF0, 0x00, 0x78, 0x40, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x10, 0xF3, 0xE7, 0xE7, 0xCF, 0x8F, 0x8F, 0x1E, 0x10, 0x01, 0xF8, 0x7E,
  0x0F, 0xFC, 0xF8, 0x3F, 0xF9, 0xF0, 0xFF, 0xFF, 0xE1, 0xFC, 0x3F, 0xC7,
  0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF9, 0xF8,
  0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3E, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F,
  0xE3, 0xF0, 0x3F, 0xC7, 0xF0, 0xDF, 0xE7, 0xFF, 0xBF, 0xCF, 0xFE, 0x7F,
  0x8F, 0xF8, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0xF8, 0x0F, 0x9F, 0xFC, 0x0F, 0xBF, 0xFC,
  0x1F, 0xB0, 0xFE, 0x1F, 0xE0, 0x7E, 0x1F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x83, 0xF8,
  0x7D, 0xFF, 0xF0, 0x7C, 0xFF, 0xE0, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF8,
  0x3F, 0x1F, 0x80, 0xFD, 0xF8, 0x03, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x10, 0xF8, 0x01, 0xE7, 0xE0, 0x0F, 0xBF,
  0x01, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x7E,
  0x1F, 0x80, 0xFF, 0xCF, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB, 0xE0, 0x7F,
  0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3,
  0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFF, 0x07, 0xF0, 0xFF,
  0x81, 0xFF, 0xEF, 0xC0, 0xFF, 0xE7, 0xE0, 0x3F, 0xE3, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFC, 0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x7C,
  0x03, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0x7F, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x10, 0xF8, 0x00, 0xE7, 0xE0,
  0x0F, 0xBF, 0x00, 0xFC, 0xFC, 0x0F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x03, 0xFF,
  0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xBF, 0x1F, 0xE0, 0xFE, 0x1F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x3F, 0x0E, 0xF8, 0x3F, 0xFD, 0xF8, 0x1F, 0xFD, 0xF8, 0x1F, 0xF9,
  0xF8, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x30, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x7C, 0x07, 0xE7, 0xFC, 0x1F, 0xBF, 0xF8, 0x7C, 0xFF, 0xE1, 0xF6, 0x1F,
  0xCF, 0xF0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0x80, 0x3F, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0xFC, 0xF8,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x60, 0x1F, 0x07, 0x81, 0xF8,
  0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x10, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x1F, 0x9F, 0xF0, 0x1F, 0x3F, 0xF8,
  0x1F, 0x7F, 0xFC, 0x1F, 0x61, 0xFC, 0x3F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0x7E, 0xFF, 0x00, 0x7E, 0xFC, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7E, 0x0C, 0xFC, 0x7E, 0x1E, 0xFC, 0x3E, 0x3F,
  0xFC, 0x3F, 0x7C, 0xFC, 0x1F, 0xF8, 0xF8, 0x1F, 0xF0, 0xF8, 0x0F, 0xE0,
  0x00, 0x07, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x0C,
  0x1F, 0x83, 0xC3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1, 0xF3, 0xF0,
  0x3E, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0x1E, 0x0F, 0x07, 0xCF, 0xCF, 0xE1, 0xF7, 0xF3, 0xFC, 0x7F, 0xFD,
  0xFF, 0x1F, 0x9F, 0x47, 0xC7, 0xC3, 0xE1, 0xF3, 0xE0, 0xF8, 0x7C, 0xF8,
  0x3C, 0x1E, 0x3E, 0x1F, 0x07, 0x8F, 0x87, 0xC3, 0xE3, 0xC1, 0xF0, 0xF8,
  0xF0, 0x7C, 0x3E, 0x7C, 0x1E, 0x0F, 0x9F, 0x07, 0x83, 0xC7, 0xC3, 0xE0,
  0xF1, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x1F, 0x1E, 0x0F, 0x87, 0xC7, 0x83,
  0xC1, 0xF3, 0xE0, 0xF0, 0x78, 0xF8, 0x7C, 0x1E, 0x3E, 0x1F, 0x0F, 0x8F,
  0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x7F, 0xC1, 0xFB, 0xFF, 0x87,
  0xCF, 0xFE, 0x1F, 0x61, 0xFC, 0xFF, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E,
  0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C,
  0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xC1, 0xF8, 0xFC, 0x03, 0xE3,
  0xF0, 0x0F, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3E, 0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x1F,
  0xC3, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xE1, 0xF0, 0x03, 0xE3, 0xFE, 0x01, 0xF3, 0xFF, 0x80, 0xFB,
  0xFF, 0xC0, 0xFD, 0x87, 0xF0, 0x7F, 0x81, 0xF8, 0x3F, 0x80, 0x7C, 0x1F,
  0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3,
  0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F,
  0x07, 0xF8, 0x3F, 0x83, 0xEF, 0xFF, 0x81, 0xF3, 0xFF, 0x81, 0xF9, 0xFF,
  0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xFC, 0xFC, 0x3F,
  0xFD, 0xF8, 0xFF, 0xFB, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x03,
  0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x37, 0xC7,
  0xF0, 0xFF, 0x87, 0xFF, 0xBF, 0x0F, 0xFE, 0x7E, 0x0F, 0xF8, 0xF8, 0x07,
  0xE1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x7F, 0xF0, 0x7D, 0xFF, 0xC7, 0xF7, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF,
  0x03, 0xE7, 0xF8, 0x0F, 0xB0, 0x00, 0x7E, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xC0, 0xF0, 0x7E, 0x01, 0x81, 0xF0, 0x04,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x40, 0x07, 0xC3, 0x80, 0x3F, 0x1F, 0x81, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0x81,
  0xF8, 0x1E, 0x0F, 0xC1, 0xF8, 0x7E, 0x3F, 0x03, 0xE3, 0xF0, 0x1F, 0x3F,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x00,
  0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F,
  0x8F, 0xC1, 0xFE, 0x3F, 0x0D, 0xF8, 0xFF, 0xF7, 0xE1, 0xFF, 0x9F, 0x03,
  0xFC, 0x7C, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x1B, 0xFF, 0x03, 0xEF, 0xFC,
  0x1F, 0xBF, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x7F, 0x03, 0xE7, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x0F, 0x06,
  0x1E, 0x0F, 0x1F, 0x3E, 0x1F, 0x1F, 0x3E, 0x1F, 0x1F, 0x3C, 0x1F, 0x0F,
  0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x7C, 0x1E, 0x0F, 0x7C, 0x3E, 0x0F,
  0x7C, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x3C, 0x1F, 0x78, 0x3C, 0x1F,
  0xF8, 0x3C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3C,
  0xF8, 0xFC, 0x3C, 0xF9, 0xBC, 0x78, 0xFF, 0xBC, 0xF8, 0xFF, 0x3F, 0xF0,
  0x7F, 0x1F, 0xE0, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0xFF, 0x0F,
  0xE0, 0x7F, 0xE7, 0xFC, 0x3F, 0xF9, 0xFF, 0x3F, 0x9E, 0xE7, 0xCF, 0xC7,
  0xB0, 0xF1, 0xC1, 0xE8, 0x3C, 0x60, 0x7E, 0x0F, 0x00, 0x1F, 0x82, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x20, 0xFC, 0x00, 0xF8, 0x7F,
  0x02, 0x3E, 0x1F, 0xC3, 0xCF, 0x8F, 0xF1, 0xFB, 0xE3, 0x7D, 0xFC, 0xFF,
  0xCF, 0xFE, 0x1F, 0xE3, 0xFF, 0x07, 0xF0, 0x7F, 0x00, 0xF8, 0x0F, 0x00,
  0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x0F, 0xF8, 0x3F, 0xFD, 0xF8,
  0x1F, 0xF9, 0xF0, 0x0F, 0xF1, 0xF0, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x30, 0x07, 0xE0, 0x78, 0x1F, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF,
  0x1F, 0x07, 0xFF, 0x1E, 0x01, 0xFE, 0x1E, 0x01, 0xFC, 0x1E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x18, 0x07, 0xF0, 0x7C, 0x0F, 0xE0, 0x3C,
  0x1F, 0xC0, 0x3C, 0x3F, 0xE0, 0x3E, 0x7F, 0xFF, 0x1E, 0x7F, 0xFF, 0xFC,
  0x78, 0xFF, 0xFC, 0xF8, 0x3F, 0xF8, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x0E, 0x07, 0xF8, 0x07, 0xC7, 0xFE, 0x03, 0xC3, 0xFF, 0x83, 0xE3, 0xE7,
  0xE1, 0xE3, 0xE1, 0xF1, 0xF1, 0xE0, 0x7F, 0xF0, 0xF0, 0x3F, 0xF0, 0xF8,
  0x0F, 0xF0, 0x18, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 31, 26, 8, -31 },
  { 44, 17, 14, 26, 7, -33 },
  { 74, 28, 31, 26, 0, -31 },
  { 183, 25, 39, 26, 1, -35 },
  { 305, 31, 32, 26, -2, -31 },
  { 429, 26, 32, 26, 0, -31 },
  { 533, 7, 14, 26, 12, -33 },
  { 546, 18, 39, 26, 8, -33 },
  { 634, 18, 39, 26, 1, -33 },
  { 722, 23, 22, 26, 2, -24 },
  { 786, 21, 21, 26, 3, -24 },
  { 842, 12, 14, 26, 5, -7 },
  { 863, 15, 5, 26, 6, -16 },
  { 873, 8, 8, 26, 8, -8 },
  { 881, 26, 39, 26, 0, -33 },
  { 1008, 24, 32, 26, 2, -31 },
  { 1104, 22, 31, 26, 2, -31 },
  { 1190, 24, 31, 26, 1, -31 },
  { 1283, 24, 32, 26, 1, -31 },
  { 1379, 25, 31, 26, 0, -31 },
  { 1476, 25, 32, 26, 1, -31 },
  { 1576, 22, 32, 26, 2, -31 },
  { 1664, 23, 31, 26, 4, -31 },
  { 1754, 25, 32, 26, 1, -31 },
  { 1854, 23, 31, 26, 3, -31 },
  { 1944, 11, 24, 26, 8, -24 },
  { 1977, 14, 31, 26, 5, -24 },
  { 2032, 21, 26, 26, 4, -26 },
  { 2101, 23, 13, 26, 2, -20 },
  { 2139, 22, 26, 26, 2, -26 },
  { 2211, 20, 31, 26, 5, -31 },
  { 2289, 24, 36, 26, 2, -31 },
  { 2397, 25, 31, 26, -1, -31 },
  { 2494, 23, 31, 26, 2, -31 },
  { 2584, 23, 32, 26, 3, -31 },
  { 2676, 25, 31, 26, 1, -31 },
  { 2773, 24, 31, 26, 2, -31 },
  { 2866, 25, 31, 26, 2, -31 },
  { 2963, 24, 32, 26, 2, -31 },
  { 3059, 26, 31, 26, 1, -31 },
  { 3160, 24, 31, 26, 2, -31 },
  { 3253, 23, 32, 26, 2, -31 },
  { 3345, 28, 31, 26, 1, -31 },
  { 3454, 20, 31, 26, 3, -31 },
  { 3532, 28, 31, 26, 0, -31 },
  { 3641, 26, 31, 26, 1, -31 },
  { 3742, 24, 32, 26, 2, -31 },
  { 3838, 24, 31, 26, 2, -31 },
  { 3931, 24, 40, 26, 2, -31 },
  { 4051, 24, 31, 26, 2, -31 },
  { 4144, 25, 32, 26, 1, -31 },
  { 4244, 25, 31, 26, 4, -31 },
  { 4341, 25, 32, 26, 2, -31 },
  { 4441, 25, 31, 26, 4, -31 },
  { 4538, 28, 31, 26, 1, -31 },
  { 4647, 30, 31, 26, -1, -31 },
  { 4764, 25, 31, 26, 4, -31 },
  { 4861, 27, 31, 26, 0, -31 },
  { 4966, 20, 39, 26, 6, -33 },
  { 5064, 13, 39, 26, 7, -33 },
  { 5128, 20, 39, 26, 1, -33 },
  { 5226, 23, 19, 26, 2, -31 },
  { 5281, 21, 4, 26, 0, 4 },
  { 5292, 7, 10, 26, 9, -35 },
  { 5301, 23, 24, 26, 2, -23 },
  { 5370, 24, 34, 26, 1, -33 },
  { 5472, 21, 24, 26, 3, -23 },
  { 5535, 25, 34, 26, 2, -33 },
  { 5642, 21, 24, 26, 3, -23 },
  { 5705, 30, 42, 26, -1, -33 },
  { 5863, 24, 32, 26, 1, -23 },
  { 5959, 22, 33, 26, 2, -33 },
  { 6050, 21, 35, 26, 3, -34 },
  { 6142, 22, 43, 26, 1, -34 },
  { 6261, 24, 34, 26, 2, -33 },
  { 6363, 19, 34, 26, 4, -33 },
  { 6444, 26, 23, 26, 0, -23 },
  { 6519, 22, 23, 26, 2, -23 },
  { 6583, 22, 24, 26, 2, -23 },
  { 6649, 25, 32, 26, 0, -23 },
  { 6749, 23, 32, 26, 2, -23 },
  { 6841, 22, 23, 26, 4, -23 },
  { 6905, 22, 24, 26, 2, -23 },
  { 6971, 21, 32, 26, 3, -31 },
  { 7055, 22, 24, 26, 3, -23 },
  { 7121, 22, 23, 26, 2, -23 },
  { 7185, 24, 23, 26, 1, -23 },
  { 7254, 26, 24, 26, 0, -23 },
  { 7332, 24, 32, 26, 1, -23 },
  { 7428, 24, 23, 26, 1, -23 },
  { 7497, 21, 39, 26, 5, -33 },
  { 7600, 11, 39, 26, 8, -33 },
  { 7654, 22, 39, 26, 1, -33 },
  { 7762, 25, 10, 26, 1, -19 },
};

const GFXfont IBMPlexMono_SemiBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC44PT7B_H_
