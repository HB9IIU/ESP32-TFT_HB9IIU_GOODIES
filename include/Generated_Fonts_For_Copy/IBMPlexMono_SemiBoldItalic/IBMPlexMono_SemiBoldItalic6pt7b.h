#ifndef _IBMPLEXMONO_SEMIBOLDITALIC6PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x6F, 0xAC, 0x27, 0x42, 0xE4, 0xDE, 0xEE, 0x66, 0xCF,
  0x80, 0x72, 0x49, 0x80, 0x48, 0x95, 0x00, 0xEA, 0x80, 0x5D, 0x00, 0xC0,
  0xC0, 0x80, 0x12, 0x44, 0x88, 0x69, 0xEE, 0x75, 0x70, 0x65, 0x70, 0x6C,
  0xF0, 0x2E, 0xB0, 0xFA, 0x6E, 0x77, 0xF0, 0xF2, 0x44, 0x67, 0xAE, 0x6B,
  0x6C, 0xC8, 0xCA, 0x2D, 0x50, 0x7C, 0x8C, 0xE0, 0xDA, 0x7F, 0xE6, 0x6F,
  0xD0, 0x77, 0xF0, 0x78, 0x86, 0x76, 0xF0, 0x78, 0xEE, 0x78, 0xE8, 0x69,
  0xAE, 0x5A, 0xEA, 0x74, 0x4E, 0x64, 0xF0, 0x7C, 0xAA, 0x4A, 0x70, 0x7E,
  0xEA, 0x56, 0xEA, 0x69, 0xAE, 0x6B, 0xC8, 0x69, 0xAE, 0x60, 0x6B, 0xEA,
  0x74, 0x2E, 0xF4, 0x44, 0xDA, 0xAE, 0xBB, 0x40, 0x9D, 0xEA, 0x76, 0x6A,
  0xD6, 0x44, 0x72, 0x4E, 0x72, 0x49, 0x80, 0xAA, 0x90, 0x64, 0xA5, 0x80,
  0x74, 0xE0, 0xC0, 0x77, 0x80, 0x4E, 0xF0, 0x71, 0x80, 0x36, 0xAE, 0x7D,
  0x80, 0x37, 0x44, 0xC0, 0x77, 0xF0, 0x4E, 0xD0, 0x47, 0x26, 0x21, 0x95,
  0x80, 0x4E, 0xF0, 0xAB, 0xFE, 0xE0, 0x76, 0x80, 0x77, 0x80, 0x77, 0xC0,
  0x77, 0x90, 0xF2, 0x00, 0x6F, 0x80, 0x5D, 0x30, 0xB7, 0x80, 0xF5, 0x80,
  0xFF, 0x80, 0xF4, 0xA0, 0xB7, 0xF0, 0xEB, 0x80, 0x71, 0x49, 0x80, 0x6A,
  0xA0, 0x45, 0x35, 0x80, 0x74,
};

const GFXglyph IBMPlexMono_SemiBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 4, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 2, -4 },
  { 13, 3, 6, 4, 1, -5 },
  { 16, 3, 6, 4, 0, -5 },
  { 19, 3, 3, 4, 0, -3 },
  { 21, 3, 3, 4, 0, -3 },
  { 23, 1, 2, 4, 1, -1 },
  { 24, 2, 1, 4, 1, -2 },
  { 25, 1, 1, 4, 1, -1 },
  { 26, 4, 6, 4, 0, -5 },
  { 29, 4, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 4, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 4, 4, 4, 0, -4 },
  { 45, 4, 4, 4, 0, -4 },
  { 47, 4, 4, 4, 0, -4 },
  { 49, 2, 3, 4, 1, -3 },
  { 50, 2, 4, 4, 1, -3 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 3, 2, 4, 0, -3 },
  { 54, 3, 4, 4, 0, -4 },
  { 56, 2, 4, 4, 1, -4 },
  { 57, 3, 5, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 4, 4, 4, 0, -4 },
  { 85, 4, 4, 4, 0, -4 },
  { 87, 4, 4, 4, 0, -4 },
  { 89, 4, 4, 4, 0, -4 },
  { 91, 4, 5, 4, 0, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 3, 4, 4, 1, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 4, 4, 4, 0, -4 },
  { 108, 4, 4, 4, 0, -4 },
  { 110, 4, 4, 4, 0, -4 },
  { 112, 3, 6, 4, 1, -5 },
  { 115, 2, 6, 4, 1, -5 },
  { 117, 3, 6, 4, 0, -5 },
  { 120, 3, 2, 4, 0, -4 },
  { 121, 3, 1, 4, 0, 0 },
  { 122, 1, 2, 4, 1, -5 },
  { 123, 3, 3, 4, 0, -3 },
  { 125, 3, 4, 4, 0, -4 },
  { 127, 3, 3, 4, 0, -3 },
  { 129, 4, 4, 4, 0, -4 },
  { 131, 3, 3, 4, 0, -3 },
  { 133, 4, 5, 4, 0, -4 },
  { 136, 3, 4, 4, 0, -3 },
  { 138, 3, 4, 4, 0, -4 },
  { 140, 3, 5, 4, 0, -5 },
  { 142, 3, 6, 4, 0, -5 },
  { 145, 3, 4, 4, 0, -4 },
  { 147, 2, 4, 4, 1, -4 },
  { 148, 4, 3, 4, 0, -3 },
  { 150, 3, 3, 4, 0, -3 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 3, 4, 4, 0, -3 },
  { 156, 3, 4, 4, 0, -3 },
  { 158, 3, 3, 4, 1, -3 },
  { 160, 3, 3, 4, 0, -3 },
  { 162, 3, 4, 4, 0, -4 },
  { 164, 3, 3, 4, 0, -3 },
  { 166, 3, 3, 4, 0, -3 },
  { 168, 3, 3, 4, 0, -3 },
  { 170, 4, 3, 4, 0, -3 },
  { 172, 3, 4, 4, 0, -3 },
  { 174, 3, 3, 4, 0, -3 },
  { 176, 3, 6, 4, 1, -5 },
  { 179, 2, 6, 4, 1, -5 },
  { 181, 3, 6, 4, 0, -5 },
  { 184, 3, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_SemiBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC6PT7B_H_
