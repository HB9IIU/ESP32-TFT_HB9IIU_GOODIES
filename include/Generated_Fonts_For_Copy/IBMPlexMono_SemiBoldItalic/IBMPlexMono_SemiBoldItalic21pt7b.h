#ifndef _IBMPLEXMONO_SEMIBOLDITALIC21PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x73, 0x18, 0xC4, 0x20, 0x01, 0xCF, 0x73, 0x80, 0x67,
  0xCF, 0x9E, 0x7C, 0xF9, 0xB3, 0x00, 0x03, 0x30, 0x19, 0x81, 0x98, 0x0C,
  0xC3, 0xE7, 0x9E, 0x7D, 0x33, 0x01, 0x98, 0x19, 0x87, 0xCF, 0xBE, 0x7C,
  0x66, 0x03, 0x30, 0x19, 0x81, 0x98, 0x00, 0x01, 0x80, 0x18, 0x07, 0xC1,
  0xFF, 0x39, 0x33, 0x90, 0x3B, 0x03, 0xB0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x27, 0x06, 0x74, 0x66, 0x76, 0xEF, 0xFC, 0x1F, 0x80, 0xC0, 0x0C, 0x00,
  0x0F, 0x06, 0x3E, 0x18, 0x66, 0x61, 0x8D, 0xC3, 0x1B, 0x06, 0x6C, 0x0F,
  0xC0, 0x0F, 0x38, 0x01, 0xF8, 0x1F, 0x30, 0x76, 0x60, 0xC8, 0xC3, 0x19,
  0x8C, 0x3E, 0x38, 0x38, 0x00, 0x07, 0xC0, 0x7F, 0x03, 0x18, 0x18, 0xC1,
  0xC6, 0x06, 0x30, 0x3B, 0x07, 0xF0, 0x66, 0x07, 0x38, 0x38, 0xC1, 0xC7,
  0x6E, 0x5B, 0xBE, 0xF0, 0xE3, 0x80, 0x6F, 0xFD, 0xB0, 0x07, 0x0E, 0x1C,
  0x38, 0x30, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0xE0, 0x06,
  0x00, 0xC0, 0x18, 0x33, 0x7F, 0xFE, 0x7F, 0x07, 0x81, 0xF8, 0x73, 0x1C,
  0x71, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xFF, 0xFF, 0x83,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x3C, 0xE3, 0x9C, 0x63, 0x80, 0xFF, 0xFC,
  0xEF, 0xFE, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0x0F, 0x83, 0xF8,
  0xE3, 0xB8, 0x37, 0x07, 0xC0, 0xF9, 0xBF, 0x77, 0xEE, 0xFC, 0x1F, 0x83,
  0x70, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0x0F, 0x87, 0xE3, 0xB9, 0xCE, 0x73,
  0x08, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x3F, 0xFF,
  0xFC, 0x07, 0xC1, 0xFE, 0x3C, 0x73, 0x87, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x07, 0xFE, 0xFF, 0xE0,
  0x07, 0xC1, 0xFE, 0x38, 0x71, 0x07, 0x00, 0x70, 0x0E, 0x07, 0xC0, 0xFC,
  0x00, 0xE0, 0x0E, 0x00, 0xE2, 0x0E, 0xE1, 0xE7, 0xFC, 0x1F, 0x00, 0x00,
  0xF0, 0x1E, 0x03, 0xE0, 0x7E, 0x06, 0xE0, 0xCE, 0x1C, 0xE3, 0x8C, 0x70,
  0xC6, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x3F, 0xE7,
  0xFC, 0xC0, 0x18, 0x07, 0x00, 0xCF, 0x1B, 0xF3, 0x8E, 0x00, 0xE0, 0x1C,
  0x03, 0x20, 0xEE, 0x3D, 0xFF, 0x0F, 0x80, 0x03, 0xE0, 0xE0, 0x78, 0x0E,
  0x03, 0x80, 0xEF, 0x1B, 0xF7, 0x8E, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xEE,
  0x1C, 0xFF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0x07, 0x60, 0xEC, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C,
  0x00, 0x0F, 0x87, 0xFC, 0xE3, 0xB8, 0x37, 0x0E, 0x61, 0x87, 0xE1, 0xFC,
  0x71, 0xDC, 0x1B, 0x03, 0xE0, 0xEE, 0x1D, 0xFF, 0x0F, 0x80, 0x0F, 0x87,
  0xF9, 0xE3, 0xB8, 0x76, 0x07, 0xC1, 0xD8, 0x3B, 0x8F, 0x7E, 0xC7, 0xB8,
  0x06, 0x01, 0xC0, 0xF0, 0x3C, 0x1E, 0x00, 0x3B, 0xDE, 0xE0, 0x00, 0x00,
  0xE7, 0xBD, 0xC0, 0x0E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xE1, 0xC7, 0x0C, 0x38, 0x00, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C, 0x38,
  0x0E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x70, 0x04, 0x7F, 0xEF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x20, 0x0E, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x70, 0x1C, 0x3E, 0x3E, 0x3E, 0x0E, 0x02, 0x00, 0x1F, 0x1F, 0xE7,
  0x1F, 0x87, 0x01, 0xC0, 0xE1, 0xF0, 0x60, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x78, 0x1E, 0x03, 0x00, 0x0F, 0x83, 0xF8, 0xE1, 0xB8, 0x36, 0x76, 0xCF,
  0xFB, 0x1E, 0x63, 0xCC, 0xFB, 0x9B, 0x73, 0x67, 0xEC, 0xED, 0x80, 0x38,
  0x03, 0xF8, 0x3F, 0x00, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x76, 0x07, 0x60,
  0x66, 0x0E, 0x60, 0xC7, 0x1C, 0x71, 0xFF, 0x3F, 0xF3, 0x87, 0x70, 0x77,
  0x03, 0xE0, 0x30, 0x3F, 0x87, 0xFC, 0xC3, 0x98, 0x73, 0x0E, 0xE1, 0x9F,
  0xE3, 0xFC, 0x61, 0xCC, 0x19, 0x83, 0x70, 0xEE, 0x1D, 0xFF, 0x3F, 0xC0,
  0x07, 0xC1, 0xFE, 0x38, 0xE3, 0x07, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x8E, 0x0E, 0x71, 0xC7, 0xF8, 0x1F, 0x00, 0x3F,
  0x87, 0xF8, 0xC3, 0x98, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x60, 0xEC,
  0x1F, 0x83, 0x70, 0xEE, 0x39, 0xFF, 0x3F, 0x80, 0x3F, 0xF3, 0xFE, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x7F, 0xC7, 0xFC, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x7F, 0xC7, 0xFC, 0x70, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x77,
  0x00, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xDC, 0x1B, 0x83, 0x70, 0xEF, 0x1C,
  0xFF, 0x8F, 0x70, 0x38, 0x73, 0x06, 0x30, 0x67, 0x0E, 0x70, 0xE7, 0x0E,
  0x7F, 0xE7, 0xFE, 0x60, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCC, 0x1C,
  0xC1, 0x80, 0x3F, 0xF3, 0xFE, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xE3, 0xFC, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x61, 0xCE, 0x39, 0xFE, 0x0F, 0x80, 0x38, 0x79,
  0xC7, 0x8C, 0x78, 0x63, 0x87, 0x38, 0x3B, 0x81, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xB8, 0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE3, 0x07, 0x80, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x3C, 0x39, 0xE3, 0xCF, 0x1E, 0x79,
  0xF3, 0x7F, 0x1B, 0xD8, 0xDE, 0xCE, 0xE6, 0x76, 0x73, 0x13, 0x99, 0x18,
  0xC0, 0xC6, 0x06, 0x70, 0x33, 0x83, 0x80, 0x38, 0x73, 0xC6, 0x3C, 0x67,
  0xC6, 0x7C, 0x66, 0xCE, 0x6E, 0xE6, 0x6E, 0x66, 0xCE, 0x6C, 0xE6, 0xCC,
  0x7C, 0xC7, 0xCC, 0x3C, 0xC3, 0x80, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x77,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x70, 0xEE, 0x38,
  0xFF, 0x0F, 0x80, 0x3F, 0xC7, 0xFC, 0xE3, 0x98, 0x33, 0x06, 0xE1, 0xDC,
  0x3B, 0xFE, 0x7F, 0x8C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00,
  0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x77, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0x70, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0x72, 0x06, 0xE0,
  0xF8, 0x0E, 0x00, 0x3F, 0xC7, 0xFC, 0xE3, 0x98, 0x33, 0x06, 0xE1, 0xDC,
  0x3B, 0xFE, 0x7F, 0x8C, 0xE1, 0x8C, 0x71, 0xCE, 0x39, 0xC3, 0x38, 0x70,
  0x07, 0xC1, 0xFF, 0x1C, 0x73, 0x82, 0x38, 0x03, 0x80, 0x1F, 0x00, 0xFC,
  0x01, 0xE0, 0x0E, 0x00, 0x64, 0x0E, 0x70, 0xEF, 0xFC, 0x1F, 0x00, 0xFF,
  0xFF, 0xFE, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x38, 0x73,
  0x07, 0x70, 0x67, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xE6, 0x0E, 0xE0, 0xCE,
  0x0C, 0xE1, 0xCE, 0x1C, 0xE3, 0x87, 0xF8, 0x3E, 0x00, 0xE0, 0x7E, 0x0E,
  0xE0, 0xEE, 0x1C, 0xE1, 0xC6, 0x18, 0x63, 0x86, 0x38, 0x67, 0x07, 0x70,
  0x76, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x30, 0x1C, 0xC0, 0x63,
  0x01, 0x8C, 0xE6, 0x73, 0xB9, 0xDE, 0xC7, 0x7B, 0x19, 0x6C, 0x6D, 0xB1,
  0xB7, 0xC6, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xC7, 0x8F, 0x1C, 0x00, 0x1C,
  0x1E, 0x1C, 0x38, 0x38, 0xE0, 0x73, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0xE7, 0x03, 0x86, 0x0E,
  0x0E, 0x3C, 0x1C, 0x00, 0xE0, 0x7E, 0x0E, 0x61, 0xC7, 0x1C, 0x73, 0x83,
  0x30, 0x37, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x00, 0x1F, 0xF8, 0xFF, 0xC8, 0x1C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0x8F, 0xCE, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x7F,
  0x3F, 0x00, 0xE1, 0x86, 0x18, 0x70, 0xC3, 0x0C, 0x30, 0xE1, 0x86, 0x18,
  0x61, 0xC3, 0x0C, 0x30, 0xC0, 0x0F, 0xC7, 0xF0, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x1F, 0x8F, 0xE0, 0x07, 0x01, 0xF0, 0x36, 0x0E, 0xC3, 0x9C,
  0x61, 0x9C, 0x37, 0x07, 0x40, 0x40, 0xFF, 0xFF, 0xF0, 0x4E, 0x67, 0x20,
  0x1E, 0xE7, 0xD9, 0xC7, 0x70, 0x6E, 0x1D, 0xC3, 0xB8, 0x77, 0x1E, 0xE3,
  0x9F, 0xB9, 0xE7, 0x00, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE7,
  0x1D, 0xF3, 0xC7, 0x70, 0xEC, 0x1D, 0x83, 0xF0, 0x6E, 0x1D, 0xC3, 0xBF,
  0xE6, 0x78, 0x0F, 0x8F, 0xF7, 0x0D, 0xC4, 0x60, 0x38, 0x0E, 0x03, 0x83,
  0x71, 0x9F, 0xE3, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE1,
  0xEE, 0x3F, 0xE7, 0x1E, 0xE0, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE,
  0x3C, 0xFD, 0x87, 0xB8, 0x0F, 0x8F, 0xF7, 0x0D, 0xC3, 0x61, 0xFF, 0xEF,
  0xE3, 0x82, 0x61, 0xDF, 0xE3, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x13, 0x80,
  0xE7, 0x00, 0xEE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0x71, 0xFF, 0x38,
  0xF7, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xE3, 0xEC, 0x3C,
  0xC0, 0x1C, 0x63, 0x8F, 0xF8, 0x3E, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0xE7, 0x7D, 0xE7, 0x70, 0xDC, 0x36, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1B, 0x06, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x38,
  0x18, 0x0C, 0x0E, 0x07, 0x33, 0xB9, 0xB8, 0xF8, 0x78, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC3, 0x18, 0xF7, 0x06, 0xE0, 0xF8, 0x0F,
  0x00, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE7, 0x1D, 0xF3, 0xC6,
  0x70, 0xCE, 0x39, 0x8E, 0x77, 0x0E, 0xE5, 0xCD, 0xF9, 0xF6, 0x1C, 0xFC,
  0x7E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06,
  0x27, 0x3B, 0xB9, 0xF8, 0x70, 0x36, 0x77, 0xFF, 0x73, 0x36, 0x33, 0x67,
  0x36, 0x63, 0x66, 0x7E, 0x66, 0xC6, 0x6C, 0x66, 0xCE, 0x60, 0x73, 0x9D,
  0xF7, 0x9D, 0xC3, 0x70, 0xD8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x6C, 0x18,
  0x1F, 0x07, 0xF9, 0xC7, 0x30, 0x6E, 0x0F, 0xC1, 0xF8, 0x37, 0x0E, 0xE3,
  0x8F, 0xF0, 0xF8, 0x00, 0x39, 0xC3, 0xBE, 0x3C, 0x73, 0x87, 0x30, 0x73,
  0x07, 0x70, 0x67, 0x0E, 0x70, 0xE7, 0xFC, 0x67, 0x86, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x1E, 0xE7, 0xFD, 0xC7, 0xF0, 0x6E, 0x0D, 0xC3, 0xB8,
  0x77, 0x0E, 0xE3, 0xDF, 0xB1, 0xE6, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0xFD, 0xFF, 0x78, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x00, 0x1F, 0x8F, 0xF7, 0x09, 0xC0, 0x7E, 0x0F, 0xE0,
  0x7C, 0x07, 0x41, 0xBF, 0xE3, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x07,
  0xFE, 0xFF, 0xA7, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x62, 0x1C, 0xE3, 0xB8,
  0x7E, 0x07, 0x00, 0x70, 0xEE, 0x1D, 0xC3, 0x30, 0x66, 0x1C, 0xC3, 0xB8,
  0x77, 0x0E, 0xE7, 0x8F, 0xB1, 0xEE, 0x00, 0xF8, 0xDF, 0x38, 0xC3, 0x18,
  0x73, 0x0C, 0xE1, 0x9C, 0x73, 0x9C, 0x77, 0x8F, 0xE0, 0xF0, 0x00, 0x33,
  0x33, 0x37, 0x63, 0x36, 0x33, 0x67, 0x36, 0x63, 0x66, 0x36, 0x66, 0xEE,
  0x67, 0xEC, 0x73, 0x80, 0x0E, 0x71, 0xF7, 0x9D, 0xAE, 0x4E, 0x70, 0x70,
  0x03, 0x80, 0x1C, 0x19, 0xC4, 0xCF, 0x77, 0xDF, 0x1C, 0xE0, 0x38, 0x73,
  0x87, 0x38, 0x63, 0x86, 0x30, 0xE3, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xC3,
  0xEC, 0x3D, 0xC0, 0x1C, 0x63, 0x8F, 0xF8, 0x3E, 0x00, 0x3E, 0x6F, 0xFD,
  0x8F, 0xB1, 0xC0, 0x70, 0x1C, 0x07, 0x33, 0x86, 0xFC, 0xDF, 0xFB, 0x1E,
  0x00, 0x07, 0xC3, 0xF0, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0xFC,
  0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x1F, 0xC3,
  0xE0, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x33, 0x98, 0xC6, 0x31, 0x9C, 0xC6,
  0x30, 0x1F, 0x07, 0xC2, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x0F,
  0xC3, 0xF1, 0xC0, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0x0F,
  0x80, 0x38, 0x6F, 0x8F, 0xBB, 0x63, 0xEC, 0x38,
};

const GFXglyph IBMPlexMono_SemiBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 7, 7, 13, 4, -16 },
  { 18, 13, 15, 13, 0, -15 },
  { 43, 12, 19, 13, 0, -17 },
  { 72, 15, 15, 13, -1, -15 },
  { 101, 13, 15, 13, 0, -15 },
  { 126, 3, 7, 13, 6, -16 },
  { 129, 8, 19, 13, 4, -16 },
  { 148, 8, 19, 13, 1, -16 },
  { 167, 11, 11, 13, 1, -12 },
  { 183, 11, 10, 13, 1, -11 },
  { 197, 6, 6, 13, 2, -3 },
  { 202, 7, 2, 13, 3, -7 },
  { 204, 4, 4, 13, 4, -4 },
  { 206, 13, 19, 13, 0, -16 },
  { 237, 11, 15, 13, 1, -15 },
  { 258, 10, 15, 13, 1, -15 },
  { 277, 12, 15, 13, 0, -15 },
  { 300, 12, 15, 13, 0, -15 },
  { 323, 12, 15, 13, 0, -15 },
  { 346, 11, 15, 13, 1, -15 },
  { 367, 11, 15, 13, 1, -15 },
  { 388, 11, 15, 13, 2, -15 },
  { 409, 11, 15, 13, 1, -15 },
  { 430, 11, 15, 13, 1, -15 },
  { 451, 5, 12, 13, 4, -12 },
  { 459, 7, 15, 13, 2, -12 },
  { 473, 10, 12, 13, 2, -12 },
  { 488, 11, 7, 13, 1, -10 },
  { 498, 10, 12, 13, 1, -12 },
  { 513, 10, 15, 13, 2, -15 },
  { 532, 11, 17, 13, 1, -15 },
  { 556, 12, 15, 13, -1, -15 },
  { 579, 11, 15, 13, 1, -15 },
  { 600, 12, 15, 13, 1, -15 },
  { 623, 11, 15, 13, 1, -15 },
  { 644, 12, 15, 13, 1, -15 },
  { 667, 12, 15, 13, 1, -15 },
  { 690, 11, 15, 13, 1, -15 },
  { 711, 12, 15, 13, 1, -15 },
  { 734, 12, 15, 13, 1, -15 },
  { 757, 11, 15, 13, 1, -15 },
  { 778, 13, 15, 13, 1, -15 },
  { 803, 10, 15, 13, 1, -15 },
  { 822, 13, 15, 13, 0, -15 },
  { 847, 12, 15, 13, 1, -15 },
  { 870, 11, 15, 13, 1, -15 },
  { 891, 11, 15, 13, 1, -15 },
  { 912, 11, 19, 13, 1, -15 },
  { 939, 11, 15, 13, 1, -15 },
  { 960, 12, 15, 13, 0, -15 },
  { 983, 12, 15, 13, 2, -15 },
  { 1006, 12, 15, 13, 1, -15 },
  { 1029, 12, 15, 13, 2, -15 },
  { 1052, 14, 15, 13, 0, -15 },
  { 1079, 15, 15, 13, -1, -15 },
  { 1108, 12, 15, 13, 2, -15 },
  { 1131, 13, 15, 13, 0, -15 },
  { 1156, 9, 19, 13, 3, -16 },
  { 1178, 6, 19, 13, 3, -16 },
  { 1193, 10, 19, 13, 0, -16 },
  { 1217, 11, 9, 13, 1, -15 },
  { 1230, 10, 2, 13, 0, 2 },
  { 1233, 4, 5, 13, 4, -17 },
  { 1236, 11, 11, 13, 1, -11 },
  { 1252, 11, 16, 13, 1, -16 },
  { 1274, 10, 11, 13, 1, -11 },
  { 1288, 12, 16, 13, 1, -16 },
  { 1312, 10, 11, 13, 1, -11 },
  { 1326, 15, 20, 13, -1, -16 },
  { 1364, 12, 15, 13, 0, -11 },
  { 1387, 10, 16, 13, 1, -16 },
  { 1407, 9, 16, 13, 2, -16 },
  { 1425, 11, 20, 13, 0, -16 },
  { 1453, 11, 16, 13, 1, -16 },
  { 1475, 9, 16, 13, 2, -16 },
  { 1493, 12, 11, 13, 0, -11 },
  { 1510, 10, 11, 13, 1, -11 },
  { 1524, 11, 11, 13, 1, -11 },
  { 1540, 12, 15, 13, 0, -11 },
  { 1563, 11, 15, 13, 1, -11 },
  { 1584, 11, 11, 13, 2, -11 },
  { 1600, 10, 11, 13, 1, -11 },
  { 1614, 11, 15, 13, 1, -15 },
  { 1635, 11, 11, 13, 1, -11 },
  { 1651, 11, 11, 13, 1, -11 },
  { 1667, 12, 11, 13, 0, -11 },
  { 1684, 13, 11, 13, 0, -11 },
  { 1702, 12, 15, 13, 0, -11 },
  { 1725, 11, 11, 13, 1, -11 },
  { 1741, 10, 19, 13, 2, -16 },
  { 1765, 5, 19, 13, 4, -16 },
  { 1777, 10, 19, 13, 1, -16 },
  { 1801, 11, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_SemiBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC21PT7B_H_
