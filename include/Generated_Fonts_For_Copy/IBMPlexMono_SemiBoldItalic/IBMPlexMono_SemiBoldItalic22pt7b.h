#ifndef _IBMPLEXMONO_SEMIBOLDITALIC22PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xC3, 0x0C, 0x20, 0x00, 0x1C, 0xF3, 0xCE,
  0x00, 0x67, 0x67, 0xE6, 0xE6, 0xE6, 0xCE, 0xCE, 0x03, 0xB8, 0x0C, 0xC0,
  0x73, 0x01, 0x98, 0x3E, 0x7C, 0xF9, 0xF0, 0xCC, 0x03, 0x30, 0x1C, 0xC3,
  0xE7, 0xCF, 0x9F, 0x0E, 0x60, 0x33, 0x80, 0xCC, 0x07, 0x70, 0x00, 0x00,
  0xC0, 0x0E, 0x01, 0xF8, 0x3F, 0xF1, 0xDB, 0x1C, 0xD0, 0xE4, 0x07, 0x20,
  0x1F, 0x00, 0x7F, 0x00, 0xFC, 0x06, 0xE0, 0x27, 0x13, 0x39, 0xDB, 0xDF,
  0xFC, 0x1F, 0x80, 0x30, 0x03, 0x80, 0x0F, 0x07, 0x1F, 0x8E, 0x19, 0x8C,
  0x31, 0x98, 0x31, 0xB0, 0x33, 0xF0, 0x1F, 0x00, 0x1E, 0x78, 0x00, 0xF8,
  0x0F, 0x8C, 0x0D, 0x8C, 0x19, 0x8C, 0x31, 0x98, 0x71, 0xF8, 0xE0, 0xF0,
  0x03, 0xC0, 0x7F, 0x03, 0x9C, 0x18, 0xE0, 0xC7, 0x06, 0x30, 0x3B, 0x87,
  0xF0, 0x67, 0x07, 0x38, 0x38, 0xE1, 0xC7, 0x3E, 0x5B, 0xBE, 0xF8, 0xE3,
  0x80, 0x76, 0x66, 0xEE, 0xE0, 0x03, 0x87, 0x07, 0x03, 0x03, 0x81, 0x81,
  0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60,
  0x38, 0x0C, 0x03, 0x80, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0C,
  0x0C, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x06, 0x06, 0x66, 0xFF, 0xF3, 0xFC,
  0x1E, 0x01, 0xF0, 0x3B, 0x87, 0x38, 0x21, 0x00, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x07, 0xFF, 0xFF, 0xC3, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x1E, 0x78,
  0xE1, 0xC7, 0x0C, 0x38, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xFE, 0x38, 0xE7, 0x07,
  0x70, 0x76, 0x07, 0xE6, 0x7E, 0x67, 0xEE, 0x7E, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x7E, 0x1D, 0xC7, 0x38,
  0xC7, 0x08, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x61, 0xFF,
  0xFF, 0xF8, 0x07, 0xC0, 0xFF, 0x8F, 0x1C, 0x70, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x3F,
  0xFB, 0xFF, 0x80, 0x07, 0xE0, 0xFF, 0x8E, 0x1C, 0x20, 0x70, 0x07, 0x00,
  0x38, 0x1F, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x41, 0xCF, 0x0E,
  0x3F, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x37, 0x07, 0x60,
  0xEE, 0x1C, 0xE3, 0x8E, 0x70, 0xE6, 0x0C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1F, 0xF3, 0xFF, 0x30, 0x03, 0x00, 0x30, 0x07, 0x78,
  0x6F, 0xC7, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE4, 0x0E, 0xE1, 0xCF, 0xF8,
  0x3F, 0x00, 0x03, 0xE0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x1F, 0xF7,
  0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1C, 0xFF, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0x83, 0xE0, 0xEC, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x00, 0x0F, 0xC1, 0xFE, 0x38,
  0x77, 0x07, 0x70, 0x73, 0x0E, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE1, 0xCF, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0xF9, 0xC7, 0x70,
  0x7E, 0x0F, 0x81, 0xF8, 0x3F, 0x0E, 0xFF, 0xCF, 0xB0, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x3E, 0x00, 0x3B, 0xDE, 0xF0, 0x00, 0x00, 0x77, 0xBD, 0xC0,
  0x0E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x78, 0xE1, 0xC7, 0x0C,
  0x38, 0x00, 0x00, 0x60, 0x18, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x38, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xC0, 0x10, 0x7F, 0xF7, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x20, 0x07, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x38, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x08,
  0x00, 0x1F, 0x0F, 0xF7, 0x1F, 0x87, 0x01, 0xC0, 0xF1, 0xF8, 0x70, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x1E, 0x03, 0x80, 0x0F, 0xC1, 0xFE, 0x38,
  0x67, 0x03, 0x63, 0xB6, 0x7F, 0xEE, 0x6E, 0xC6, 0xCC, 0x6C, 0xC6, 0xCC,
  0xEC, 0xFE, 0xCF, 0xCC, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x06, 0xE0, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C,
  0x70, 0xFF, 0x8F, 0xFC, 0x70, 0x73, 0x03, 0xB8, 0x1F, 0xC0, 0xE0, 0x3F,
  0xC3, 0xFE, 0x38, 0xE3, 0x87, 0x30, 0xE7, 0x0E, 0x7F, 0xC7, 0xFC, 0x70,
  0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xE1, 0xCF, 0xFC, 0xFF, 0x00, 0x07, 0xC1,
  0xFE, 0x38, 0x73, 0x87, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x8E, 0x0E, 0x71, 0xC7, 0xFC, 0x1F, 0x00, 0x3F, 0x83, 0xFE,
  0x38, 0xE3, 0x07, 0x30, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0xF7, 0x0E,
  0x60, 0xEE, 0x0E, 0xE1, 0xCF, 0xF8, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x7F, 0xE7, 0xFC, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x7F, 0xE7, 0xFC, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0xF7, 0x07,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x3E, 0xE3, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0x71, 0xC7, 0xEC, 0x3D, 0xC0, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x70,
  0x77, 0x06, 0x7F, 0xE7, 0xFE, 0x60, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1,
  0xCE, 0x1C, 0xC1, 0xC0, 0x3F, 0xF3, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x0F,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xCE, 0x1C, 0xE3, 0x87, 0xF8,
  0x3E, 0x00, 0x38, 0x3C, 0xE1, 0xC3, 0x8E, 0x0C, 0x70, 0x73, 0x81, 0xDE,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xCE, 0x0F, 0x38, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x8E, 0x0E, 0x00, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFC,
  0x1C, 0x3C, 0xF0, 0xF3, 0xE7, 0x8F, 0xBE, 0x36, 0xD8, 0xDF, 0xE3, 0x7B,
  0x9D, 0xCC, 0x73, 0x31, 0xC8, 0xC6, 0x23, 0x18, 0x1C, 0x60, 0x73, 0x81,
  0x8E, 0x06, 0x00, 0x3C, 0x33, 0xC3, 0x3C, 0x73, 0xC7, 0x7E, 0x77, 0xE6,
  0x76, 0x66, 0x66, 0x66, 0xE6, 0x7E, 0xE7, 0xEE, 0x3C, 0xC3, 0xCC, 0x3C,
  0xC3, 0xC0, 0x0F, 0x81, 0xFE, 0x38, 0xE7, 0x07, 0x70, 0x77, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7, 0xF8, 0x3F,
  0x00, 0x3F, 0xC3, 0xFE, 0x38, 0x73, 0x87, 0x30, 0x77, 0x07, 0x70, 0xE7,
  0xFE, 0x7F, 0x87, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0x81, 0xFE, 0x38, 0xE7, 0x07, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7, 0xF8, 0x3F, 0x00, 0xE2,
  0x07, 0x70, 0x3C, 0x03, 0x80, 0x3F, 0xC3, 0xFE, 0x38, 0x73, 0x87, 0x30,
  0x77, 0x07, 0x70, 0xE7, 0xFE, 0x7F, 0x87, 0x30, 0x63, 0x8E, 0x38, 0xE1,
  0x8E, 0x1C, 0xE1, 0xC0, 0x07, 0xE0, 0xFF, 0xC7, 0x0C, 0x70, 0x43, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0x80, 0x1C, 0x80, 0xE7,
  0x0E, 0x7F, 0xF0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x33, 0x87, 0x30, 0x77, 0x07, 0x70, 0x77,
  0x06, 0x70, 0x67, 0x0E, 0x60, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xC7,
  0xF8, 0x3F, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0x61, 0xC6, 0x1C,
  0x71, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0x60, 0x7E, 0x07, 0xC0,
  0x3C, 0x00, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0xE7, 0x33, 0x99, 0xDE,
  0x67, 0x79, 0x9D, 0xEE, 0x6D, 0xB1, 0xB6, 0xC6, 0xDB, 0x1A, 0x7C, 0x79,
  0xE1, 0xE7, 0x8F, 0x1E, 0x00, 0x1E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x39,
  0xC0, 0x77, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0D, 0xC0,
  0x3B, 0x80, 0xE7, 0x83, 0x87, 0x07, 0x0E, 0x3C, 0x0E, 0x00, 0xE0, 0x7F,
  0x07, 0x9C, 0x38, 0xE3, 0x87, 0x1C, 0x19, 0xC0, 0xFC, 0x07, 0xE0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFB, 0xFF, 0x80,
  0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0F, 0xE3,
  0xF8, 0xC3, 0x0C, 0x38, 0x61, 0x86, 0x18, 0x70, 0xC3, 0x0C, 0x30, 0xE3,
  0x86, 0x18, 0x61, 0xC7, 0x1F, 0xC7, 0xE2, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x8F, 0xE3, 0xF0, 0x07, 0x80, 0x78, 0x0F, 0xC1, 0xDC, 0x18,
  0xC3, 0x8E, 0x70, 0xE6, 0x06, 0xE0, 0x74, 0x00, 0xFF, 0xFF, 0xF8, 0x2E,
  0x73, 0x30, 0x1E, 0xE7, 0xFD, 0xC3, 0xB0, 0x7E, 0x0F, 0xC1, 0xB8, 0x77,
  0x0E, 0xE3, 0xDF, 0xBD, 0xE7, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE7, 0x9D, 0xFB, 0xC7, 0x70, 0xEE, 0x1D, 0x83, 0xF0, 0x7E, 0x0F,
  0xC3, 0xBF, 0xE7, 0x78, 0x0F, 0x87, 0xF8, 0xE3, 0xB8, 0x47, 0x01, 0xC0,
  0x38, 0x27, 0x06, 0x71, 0xEF, 0xF0, 0xFC, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x71, 0xE6, 0x3F, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0C, 0xE1, 0xCE, 0x3C, 0x7D, 0xC7, 0x9C, 0x0F, 0x87, 0xFC, 0xE3,
  0xB8, 0x76, 0x1F, 0xFF, 0xBF, 0x87, 0x04, 0x70, 0xEF, 0xF8, 0x7C, 0x00,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x11, 0x80, 0xF7, 0x00, 0xEE, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x0F, 0x38, 0xFD, 0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0x8E, 0x1C, 0x71, 0xE1, 0xFF, 0x07, 0x38, 0x01, 0x86, 0x1C, 0x7F,
  0xC0, 0xFC, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x67, 0x9D,
  0xFB, 0xC7, 0x70, 0xEE, 0x1D, 0x83, 0xB0, 0x6E, 0x1D, 0xC3, 0xB8, 0x77,
  0x0E, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0xE2, 0x39, 0xCE, 0xE3, 0xF0, 0x70, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE3, 0x1C, 0xF3, 0x07, 0x60, 0xFC, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x3C, 0x77, 0xE7,
  0x8E, 0x70, 0xE7, 0x0C, 0x73, 0x86, 0xE0, 0xEE, 0x2E, 0x77, 0xE7, 0xEE,
  0x38, 0xFE, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE6, 0x33, 0xDD, 0xC3, 0xE0, 0xF0, 0x37, 0x31, 0xFB,
  0xDC, 0xEE, 0xE6, 0x76, 0x33, 0xB3, 0x99, 0x9C, 0xDC, 0xC6, 0xE6, 0x36,
  0x33, 0xB1, 0x9C, 0x33, 0xCE, 0xFD, 0xE3, 0xB8, 0x77, 0x0E, 0xC1, 0xD8,
  0x37, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x00, 0x0F, 0x87, 0xF9, 0xC3, 0xB8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xCF, 0xF0, 0xFC, 0x00, 0x39,
  0xE3, 0xBF, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x07, 0x70, 0x77, 0x07, 0x70,
  0xE7, 0xFC, 0x67, 0x86, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x73,
  0xFE, 0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0xE3, 0xC7,
  0xDC, 0x79, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0xFC, 0xFF, 0xBC,
  0x78, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x00, 0x0F, 0x87, 0xFD, 0xC1, 0x38, 0x07, 0xE0, 0x7F, 0x01, 0xF0, 0x0E,
  0x61, 0xDF, 0xF0, 0xFC, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x07, 0xFE,
  0xFF, 0xE7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x71, 0x0C, 0x73, 0xBC, 0x3E,
  0x07, 0x80, 0x70, 0x6E, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xC1, 0xB8, 0x77,
  0x0E, 0xE3, 0xCF, 0xB8, 0xE7, 0x00, 0xF8, 0x5F, 0x1C, 0xE3, 0x9C, 0x73,
  0x0E, 0x61, 0xDC, 0x73, 0x8E, 0x77, 0x8F, 0xE0, 0xF0, 0x00, 0x33, 0xB1,
  0x99, 0x9C, 0xCE, 0xC6, 0x76, 0x33, 0xB3, 0x99, 0x9C, 0xCC, 0xC6, 0xEE,
  0x63, 0xD3, 0x1C, 0xE0, 0x0E, 0x71, 0xF7, 0xDD, 0xE6, 0x4F, 0x30, 0x70,
  0x03, 0x80, 0x1C, 0x18, 0xE6, 0xCB, 0x77, 0xDF, 0x1C, 0xF0, 0x38, 0x33,
  0x87, 0x38, 0x73, 0x87, 0x38, 0x73, 0x06, 0x70, 0xE7, 0x0E, 0x71, 0xE3,
  0xEE, 0x1C, 0xE0, 0x1C, 0x61, 0xCF, 0xF8, 0x3E, 0x00, 0x3E, 0x77, 0xFE,
  0x61, 0xE6, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x47, 0x8E, 0xFC, 0x6D, 0xFE,
  0xC7, 0xC0, 0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x06, 0x1F, 0x83, 0xF0, 0x07, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xFC, 0x1F, 0x80, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8C,
  0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x8E, 0x30, 0x1F, 0x07, 0xE0,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x0C, 0x01, 0xF0, 0xFC, 0x70,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x0C, 0x03, 0x0F, 0xC3, 0xE0, 0x38, 0x37,
  0xC6, 0xEE, 0x6C, 0x7C, 0xC3, 0x80,
};

const GFXglyph IBMPlexMono_SemiBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 15, 13, 4, -15 },
  { 13, 8, 7, 13, 4, -16 },
  { 20, 14, 15, 13, 0, -15 },
  { 47, 13, 19, 13, 0, -17 },
  { 78, 16, 15, 13, -1, -15 },
  { 108, 13, 15, 13, 0, -15 },
  { 133, 4, 7, 13, 6, -16 },
  { 137, 9, 20, 13, 4, -17 },
  { 160, 9, 20, 13, 1, -17 },
  { 183, 12, 11, 13, 1, -12 },
  { 200, 11, 10, 13, 1, -12 },
  { 214, 7, 7, 13, 2, -4 },
  { 221, 7, 2, 13, 3, -8 },
  { 223, 4, 4, 13, 4, -4 },
  { 225, 13, 20, 13, 0, -17 },
  { 258, 12, 15, 13, 1, -15 },
  { 281, 11, 15, 13, 1, -15 },
  { 302, 13, 15, 13, 0, -15 },
  { 327, 13, 15, 13, 0, -15 },
  { 352, 12, 15, 13, 0, -15 },
  { 375, 12, 15, 13, 1, -15 },
  { 398, 11, 15, 13, 1, -15 },
  { 419, 11, 15, 13, 2, -15 },
  { 440, 12, 15, 13, 1, -15 },
  { 463, 11, 15, 13, 2, -15 },
  { 484, 5, 12, 13, 4, -12 },
  { 492, 7, 15, 13, 2, -12 },
  { 506, 11, 13, 13, 2, -13 },
  { 524, 12, 7, 13, 1, -10 },
  { 535, 11, 13, 13, 1, -13 },
  { 553, 10, 15, 13, 2, -15 },
  { 572, 12, 17, 13, 1, -15 },
  { 598, 13, 15, 13, -1, -15 },
  { 623, 12, 15, 13, 1, -15 },
  { 646, 12, 15, 13, 1, -15 },
  { 669, 12, 15, 13, 1, -15 },
  { 692, 12, 15, 13, 1, -15 },
  { 715, 12, 15, 13, 1, -15 },
  { 738, 12, 15, 13, 1, -15 },
  { 761, 12, 15, 13, 1, -15 },
  { 784, 12, 15, 13, 1, -15 },
  { 807, 12, 15, 13, 1, -15 },
  { 830, 14, 15, 13, 1, -15 },
  { 857, 10, 15, 13, 1, -15 },
  { 876, 14, 15, 13, 0, -15 },
  { 903, 12, 15, 13, 1, -15 },
  { 926, 12, 15, 13, 1, -15 },
  { 949, 12, 15, 13, 1, -15 },
  { 972, 12, 19, 13, 1, -15 },
  { 1001, 12, 15, 13, 1, -15 },
  { 1024, 13, 15, 13, 0, -15 },
  { 1049, 12, 15, 13, 2, -15 },
  { 1072, 12, 15, 13, 1, -15 },
  { 1095, 12, 15, 13, 2, -15 },
  { 1118, 14, 15, 13, 0, -15 },
  { 1145, 15, 15, 13, -1, -15 },
  { 1174, 13, 15, 13, 2, -15 },
  { 1199, 13, 15, 13, 0, -15 },
  { 1224, 10, 20, 13, 3, -17 },
  { 1249, 6, 20, 13, 4, -17 },
  { 1264, 10, 20, 13, 1, -17 },
  { 1289, 12, 10, 13, 1, -15 },
  { 1304, 11, 2, 13, 0, 2 },
  { 1307, 4, 5, 13, 4, -18 },
  { 1310, 11, 11, 13, 1, -11 },
  { 1326, 11, 16, 13, 1, -16 },
  { 1348, 11, 11, 13, 1, -11 },
  { 1364, 12, 16, 13, 1, -16 },
  { 1388, 11, 11, 13, 1, -11 },
  { 1404, 15, 20, 13, -1, -16 },
  { 1442, 13, 15, 13, 0, -11 },
  { 1467, 11, 16, 13, 1, -16 },
  { 1489, 10, 16, 13, 2, -16 },
  { 1509, 11, 20, 13, 0, -16 },
  { 1537, 12, 16, 13, 1, -16 },
  { 1561, 10, 16, 13, 2, -16 },
  { 1581, 13, 11, 13, 0, -11 },
  { 1599, 11, 11, 13, 1, -11 },
  { 1615, 11, 11, 13, 1, -11 },
  { 1631, 12, 15, 13, 0, -11 },
  { 1654, 12, 15, 13, 1, -11 },
  { 1677, 11, 11, 13, 2, -11 },
  { 1693, 11, 11, 13, 1, -11 },
  { 1709, 11, 15, 13, 1, -15 },
  { 1730, 11, 11, 13, 1, -11 },
  { 1746, 11, 11, 13, 1, -11 },
  { 1762, 13, 11, 13, 0, -11 },
  { 1780, 13, 11, 13, 0, -11 },
  { 1798, 12, 15, 13, 0, -11 },
  { 1821, 12, 11, 13, 1, -11 },
  { 1838, 11, 20, 13, 2, -17 },
  { 1866, 6, 20, 13, 4, -17 },
  { 1881, 10, 20, 13, 1, -17 },
  { 1906, 12, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_SemiBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC22PT7B_H_
