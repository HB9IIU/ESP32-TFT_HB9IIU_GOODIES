#ifndef _IBMPLEXMONO_SEMIBOLDITALIC52PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC,
  0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1,
  0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1,
  0xF0, 0x03, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x3D, 0xFE, 0x07, 0xF1,
  0xF1, 0xF0, 0x3F, 0x87, 0xC3, 0x80, 0xFE, 0x1E, 0x04, 0x03, 0xF0, 0x78,
  0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x3F, 0x87, 0x80, 0x00, 0xFE, 0x3E, 0x00,
  0x03, 0xFE, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xEF, 0xF8, 0x00, 0x07,
  0x8F, 0xF0, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0xF8, 0x7F, 0x00, 0x03, 0xE1,
  0xFC, 0x00, 0x0F, 0x07, 0xF0, 0x60, 0x3C, 0x1F, 0xC3, 0xC0, 0xF0, 0xFE,
  0x1F, 0x83, 0xC7, 0xF8, 0xFF, 0x9F, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x3F,
  0xFC, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x7C,
  0x01, 0xF8, 0x7C, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x3E, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF8, 0xF8, 0x00, 0x1F, 0xFF, 0xC7, 0xC0, 0x00, 0x7F,
  0xFC, 0x7C, 0x00, 0x03, 0xFF, 0xC7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0x8F, 0xFF, 0x00, 0x00, 0xF8, 0xFF, 0xF8, 0x00,
  0x0F, 0x8F, 0xFF, 0xE0, 0x00, 0xFC, 0x7E, 0x1F, 0x00, 0x07, 0xC7, 0xE0,
  0xF8, 0x00, 0x7C, 0x3E, 0x07, 0xC0, 0x07, 0xE1, 0xF0, 0x3E, 0x00, 0x3E,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x7C,
  0x01, 0xF0, 0x1E, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x07,
  0xC0, 0x03, 0xFF, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x8F, 0xE0, 0x3F,
  0x83, 0xDF, 0xC0, 0x3F, 0x07, 0xFF, 0x80, 0xFF, 0x1F, 0x3F, 0x81, 0x7E,
  0x7E, 0x7F, 0x8E, 0x7C, 0xF8, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0xFC,
  0x0E, 0x3F, 0x0F, 0x87, 0xE7, 0xFE, 0xFB, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0E, 0x00, 0x78,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0x1F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0,
  0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7F, 0x0F, 0x87, 0xF7, 0xF1,
  0xFC, 0x7F, 0x7F, 0x1F, 0xC7, 0xF7, 0xF1, 0xFC, 0x7F, 0xFE, 0x1F, 0x87,
  0xFF, 0xE0, 0xF0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87,
  0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x7F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF0, 0x3F,
  0x80, 0x38, 0x0F, 0xC0, 0x06, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0x70, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC0, 0x7C, 0x00, 0xFF, 0x01, 0xC0, 0x07, 0xF8, 0x04, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x10, 0x00, 0x3F, 0x81, 0x80, 0x01, 0xFC, 0x1E, 0x00, 0x1F,
  0xE3, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE3, 0xFF, 0x00, 0x3F, 0x7F, 0xFE, 0x01,
  0xF3, 0xFF, 0xF8, 0x0F, 0xBF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x01, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x1F, 0xC3, 0xE0,
  0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xCF, 0xFC, 0x07, 0xF7, 0xFF, 0xC1, 0xFD,
  0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xC7, 0xEF, 0xFF, 0xF9, 0xFF, 0x81, 0xFF,
  0x3F, 0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00,
  0xFF, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8,
  0x7C, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE3, 0xFE, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0x8F, 0xFF, 0xDF, 0xC3, 0xFF, 0xE7, 0xF0, 0x3F,
  0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x7F,
  0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xC3, 0xFE, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xFC, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x3F, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0xFE, 0x78, 0x01, 0xFC, 0x20, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x1F, 0x81, 0xF1, 0xF1, 0xF0, 0x7F, 0x9F, 0x1F, 0x0F, 0xFD, 0xF3, 0xF0,
  0xFF, 0xDF, 0x3E, 0x1F, 0xFF, 0xF3, 0xE1, 0xF8, 0x7F, 0x7E, 0x3F, 0x03,
  0xE7, 0xE3, 0xF0, 0x3E, 0x7E, 0x3E, 0x03, 0xE7, 0xC7, 0xE0, 0x3E, 0x7C,
  0x7E, 0x03, 0xE7, 0xC7, 0xE0, 0x7E, 0x7C, 0x7E, 0x07, 0xCF, 0xC7, 0xC0,
  0x7C, 0xFC, 0x7C, 0x0F, 0xCF, 0x87, 0xC0, 0xFC, 0xF8, 0x7E, 0x1F, 0xCF,
  0x87, 0xF7, 0xFC, 0xF8, 0x7F, 0xFF, 0x8F, 0x83, 0xFE, 0xF8, 0xF8, 0x3F,
  0xEF, 0x8F, 0x81, 0xFC, 0xF8, 0xFC, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x7F,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x20, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x1E, 0x0F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07,
  0xF1, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xE3, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x87,
  0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0x7F, 0x03, 0xFF, 0xEF, 0xE0, 0x7F,
  0xFD, 0xFC, 0x0F, 0xFF, 0x3F, 0x81, 0xFF, 0xE7, 0xF0, 0x40, 0xFC, 0xFE,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x1F,
  0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x1D, 0xF8, 0x7F, 0xFF, 0xBF, 0x0F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFD, 0xF8,
  0x0F, 0xFF, 0x3F, 0x00, 0xFF, 0xC7, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0,
  0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0,
  0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x3C, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x0F, 0xC3, 0xFC, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x3F, 0xE3, 0xF8, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xEF, 0x8F, 0xFF, 0x01, 0xF7, 0xC7,
  0xDF, 0x81, 0xFB, 0xF7, 0xEF, 0xC0, 0xFC, 0xFB, 0xE7, 0xC0, 0x7E, 0x7F,
  0xE3, 0xE0, 0x3F, 0x3F, 0xF3, 0xF0, 0x1F, 0x9F, 0xF1, 0xF8, 0x0F, 0x87,
  0xF8, 0xFC, 0x0F, 0xC3, 0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x3E, 0x03, 0xF0,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0xFC, 0x1E, 0x0F, 0xC0, 0x7C,
  0x0E, 0x07, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x3F, 0x03, 0x01, 0xF0, 0x1F,
  0x81, 0x81, 0xF8, 0x0F, 0xC0, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x7E, 0x07, 0xFC, 0x01, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x1F, 0xF0, 0x07,
  0xE0, 0x3F, 0xF0, 0x0F, 0xC0, 0xFF, 0xE0, 0x1F, 0x81, 0xFF, 0xC0, 0x3E,
  0x03, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x03, 0xF0,
  0x1F, 0x7E, 0x07, 0xE0, 0x7E, 0xFC, 0x0F, 0xC0, 0xFC, 0xF8, 0x1F, 0x01,
  0xF9, 0xF0, 0x7E, 0x03, 0xF3, 0xF0, 0xFC, 0x07, 0xE7, 0xE1, 0xF8, 0x0F,
  0x8F, 0xC3, 0xF0, 0x3F, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x0F, 0x80, 0xFC,
  0x3F, 0x3F, 0x01, 0xF8, 0x7E, 0x7E, 0x03, 0xF0, 0xFC, 0xFC, 0x07, 0xC0,
  0xF9, 0xF8, 0x1F, 0x81, 0xF3, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0x7E, 0x07,
  0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x01, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x1F,
  0xFC, 0x0F, 0xC0, 0x3F, 0xF8, 0x1F, 0x80, 0x7F, 0xE0, 0x3F, 0x00, 0xFF,
  0xC0, 0x7E, 0x01, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0x01, 0xF0, 0x03, 0xFE,
  0x07, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF3, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0xC7, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x07,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0x80, 0x01, 0xFC,
  0x3C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC3,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x00, 0x7C, 0x07, 0xF0,
  0x00, 0xE0, 0x3F, 0x80, 0x01, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x18, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x7F, 0x87, 0xE0, 0x03, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7F,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x7F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF8,
  0x3F, 0x07, 0xC1, 0xFC, 0x1F, 0x83, 0xE0, 0xFE, 0x0F, 0x83, 0xF0, 0xFF,
  0x07, 0xC1, 0xF8, 0x7F, 0x87, 0xE0, 0xFC, 0x3F, 0xC3, 0xF0, 0x7E, 0x3F,
  0xE1, 0xF0, 0x3F, 0x1E, 0xF0, 0xF8, 0x1F, 0x8F, 0x78, 0xFC, 0x0F, 0x8F,
  0xBC, 0x7E, 0x07, 0xC7, 0x9E, 0x3E, 0x03, 0xE3, 0xCF, 0x1F, 0x01, 0xF3,
  0xE7, 0x8F, 0x81, 0xF9, 0xE3, 0xCF, 0xC0, 0xFC, 0xF1, 0xE7, 0xC0, 0x7E,
  0xF8, 0xF3, 0xE0, 0x3F, 0x78, 0x79, 0xF0, 0x1F, 0xBC, 0x3D, 0xF8, 0x0F,
  0xBE, 0x1E, 0xFC, 0x07, 0xDE, 0x0F, 0x7C, 0x03, 0xEF, 0x07, 0xBE, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x3F, 0x00,
  0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x04, 0x0E, 0x1F, 0x9F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x87,
  0xC1, 0xE0, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0xF1, 0xFC, 0x0F, 0xFF,
  0x3F, 0x83, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0,
  0x1F, 0xF0, 0xFE, 0x07, 0xFE, 0x1F, 0xE1, 0xDF, 0xF3, 0xFF, 0xFB, 0xFE,
  0x3F, 0xFE, 0x7F, 0xC7, 0xFF, 0x87, 0xF8, 0x7F, 0xE0, 0x7F, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0xF0, 0x1F, 0x8F,
  0xFF, 0x03, 0xF3, 0xFF, 0xE0, 0xFE, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x9F, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8,
  0x7F, 0x7F, 0xFE, 0x0F, 0xC7, 0xFF, 0x81, 0xF8, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0x38, 0x3F, 0x80, 0x10, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x04, 0x3F, 0x80,
  0x07, 0x1F, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFF,
  0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x01, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0x9F, 0x80, 0x7F,
  0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00,
  0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x01, 0xBF, 0x01, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0x9F, 0xC0, 0x3F, 0xFC, 0x7E,
  0x00, 0x7F, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x80,
  0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0xE7, 0xE0,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x1F, 0xC0, 0x03, 0x87,
  0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x1F, 0x80, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x07, 0xFF, 0x1F, 0x80, 0x7F, 0xFC, 0xFC, 0x07,
  0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0x7E, 0x00, 0xFF,
  0x03, 0xF8, 0x0D, 0xF8, 0x1F, 0xE0, 0xEF, 0xC0, 0xFF, 0xFE, 0xFE, 0x03,
  0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0x3F, 0x80, 0x3F, 0xF1, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x40, 0x03, 0xF8, 0x03, 0x00, 0x3F, 0xC0, 0x3E, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x0F, 0xE3, 0xFF,
  0x03, 0xF9, 0xFF, 0xE0, 0xFC, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0x1F, 0xDC,
  0x3F, 0xC7, 0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x1F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x0C, 0x03, 0xF8, 0x1E, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xF0,
  0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x01, 0x80, 0x7F, 0x00, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xCF, 0xC0, 0x07, 0xFB, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE3, 0xFF, 0x00, 0xFE, 0x7F, 0xF8,
  0x0F, 0xCF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFC, 0x1F, 0xDC, 0x3F, 0xC1, 0xFF,
  0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x1F, 0xE0, 0x03, 0xF3, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x08, 0x7F, 0x1F, 0xC0, 0xC7,
  0xE0, 0xFC, 0x1F, 0x7E, 0x0F, 0xE7, 0xF7, 0xE0, 0xFE, 0xFE, 0xFE, 0x07,
  0xFF, 0xCF, 0xE0, 0x7F, 0xF8, 0xFE, 0x03, 0xFF, 0x0F, 0xC0, 0x1F, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x02, 0x03, 0xF8, 0x1C, 0x0F, 0xC0, 0xFC,
  0x3F, 0x07, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7E,
  0x7F, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0x81, 0xF0, 0x3E, 0x3F, 0x0F, 0xE0,
  0xF9, 0xFE, 0x7F, 0xC3, 0xEF, 0xF9, 0xFF, 0x1F, 0xBF, 0xEF, 0xFC, 0x7F,
  0x9F, 0xB3, 0xF1, 0xFC, 0x3F, 0x87, 0xC7, 0xE0, 0xFC, 0x1F, 0x1F, 0x83,
  0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF3, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1, 0xF8,
  0x3F, 0x3F, 0x07, 0xE0, 0xF8, 0xF8, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F,
  0x8F, 0x81, 0xF0, 0x3E, 0x7E, 0x0F, 0xC1, 0xF9, 0xF8, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0x1F, 0x1F, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF1, 0xF0,
  0x3E, 0x0F, 0xCF, 0xC1, 0xF8, 0x3F, 0x3F, 0x07, 0xE0, 0xFC, 0xFC, 0x1F,
  0x83, 0xE3, 0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x3E, 0x00, 0x0F, 0xE0,
  0xFC, 0x03, 0xF8, 0xFF, 0xC0, 0xFC, 0x7F, 0xF8, 0x3F, 0x3F, 0xFE, 0x0F,
  0xDF, 0xFF, 0xC7, 0xF7, 0x0F, 0xF1, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x7F,
  0x1F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xC0,
  0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F,
  0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x87, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0x87, 0xFE, 0x00, 0xFC, 0x7F, 0xF8, 0x0F, 0xE7, 0xFF, 0xC0,
  0x7F, 0x7F, 0xFF, 0x03, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xBF, 0xFF, 0x01, 0xF8, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xFC, 0x7E, 0x03, 0xFF, 0xE7, 0xE0, 0x7F,
  0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x1B, 0xF0, 0x7F, 0x87, 0xFF, 0x07, 0xFF, 0xF7, 0xF0,
  0x3F, 0xFE, 0x7F, 0x03, 0xFF, 0xC7, 0xE0, 0x1F, 0xF8, 0x7E, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x0F, 0xDF, 0xFF, 0x0F, 0xF7, 0xFF, 0xC7, 0xFB, 0xFF, 0xF3, 0xFE, 0xFF,
  0xF9, 0xFF, 0x80, 0x7E, 0xFF, 0xE0, 0x3F, 0xB8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0xFE, 0x00,
  0x60, 0x3F, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x18, 0x00, 0x3F, 0x0F, 0x00,
  0x1F, 0xC7, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x04, 0x01, 0xF8, 0x07, 0x01, 0xFC, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xDF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x9F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01,
  0xFE, 0x3F, 0x80, 0xFF, 0x8F, 0xF0, 0xEF, 0xE1, 0xFF, 0xFB, 0xF8, 0x7F,
  0xFC, 0xFC, 0x0F, 0xFE, 0x3F, 0x01, 0xFF, 0x1F, 0xC0, 0x3F, 0x00, 0x00,
  0x7F, 0xF8, 0x01, 0x8F, 0xFE, 0x01, 0xF1, 0xFF, 0xC0, 0xFF, 0x3F, 0xF8,
  0x0F, 0xEF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83,
  0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F,
  0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xE0, 0x3F,
  0x0F, 0xF8, 0x07, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x83, 0xE0, 0x20, 0xF8, 0x1F, 0x1F, 0x87, 0xC0, 0xF8, 0x7C, 0x3E, 0x07,
  0xC3, 0xE1, 0xF0, 0x7E, 0x1F, 0x8F, 0x83, 0xE0, 0xFC, 0xFC, 0x1F, 0x07,
  0xE7, 0xC0, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0xF9, 0xF0, 0x3E, 0x07, 0xCF,
  0x83, 0xF0, 0x7E, 0x7C, 0x1F, 0x83, 0xF7, 0xE0, 0xF8, 0x1F, 0xBF, 0x07,
  0xC0, 0xFD, 0xF0, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x3E, 0x7C, 0x0F, 0x81,
  0xF3, 0xE0, 0xFC, 0x1F, 0xBF, 0x07, 0xE0, 0xF9, 0xF8, 0x3E, 0x07, 0xCF,
  0xC3, 0xF0, 0x7C, 0x7E, 0x1F, 0x83, 0xE3, 0xF1, 0xBC, 0x3E, 0x1F, 0xFD,
  0xF3, 0xF0, 0xFF, 0xEF, 0xFF, 0x03, 0xFE, 0x7F, 0xF0, 0x1F, 0xE1, 0xFF,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xFC, 0xFF,
  0xE3, 0xFD, 0xFB, 0x8F, 0xCF, 0xF1, 0xF6, 0x0F, 0x8F, 0x83, 0xFC, 0x1F,
  0x0E, 0x07, 0xF0, 0x3E, 0x10, 0x0F, 0xE0, 0x7C, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xE0, 0x7F, 0x80, 0x87, 0xC0, 0xFF, 0x03, 0x8F, 0x83,
  0xFE, 0x1F, 0x9F, 0x86, 0xFC, 0x7F, 0x3F, 0x1D, 0xFB, 0xFC, 0x7F, 0xF9,
  0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x1F,
  0xFF, 0xBF, 0x81, 0xFF, 0xF3, 0xF0, 0x0F, 0xFE, 0x3F, 0x00, 0x7F, 0xC3,
  0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x10, 0x00, 0xFE, 0x03, 0x80, 0x1F, 0xC0, 0x7E, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x0F,
  0xFF, 0x0F, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xE0, 0xFF, 0xF8, 0x3E, 0x01, 0xFF, 0x83, 0xF0, 0x07, 0xF8,
  0x1F, 0x00, 0x7F, 0x80, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x10, 0x00, 0xFF, 0x03, 0x80, 0x0F, 0xE0, 0x3E,
  0x01, 0xFE, 0x01, 0xF0, 0x1F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0x3E, 0x1F,
  0xFE, 0x01, 0xF1, 0xFF, 0xFF, 0x8F, 0x8F, 0xDF, 0xFF, 0xFC, 0x7E, 0x3F,
  0xFF, 0xC3, 0xE0, 0x7F, 0xFE, 0x3F, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0xE0, 0x1F, 0xF0, 0x07, 0xC1, 0xFF, 0xC0, 0x3E, 0x1F,
  0xFE, 0x03, 0xE1, 0xFF, 0xF8, 0x1F, 0x1F, 0x8F, 0xE1, 0xF8, 0xF8, 0x3F,
  0x9F, 0x87, 0xC0, 0xFF, 0xFC, 0x7C, 0x07, 0xFF, 0xC3, 0xE0, 0x1F, 0xFC,
  0x1F, 0x00, 0x7F, 0xC1, 0x30, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 14, 37, 31, 9, -36 },
  { 66, 19, 16, 31, 9, -38 },
  { 104, 33, 36, 31, 0, -36 },
  { 253, 30, 48, 31, 1, -42 },
  { 433, 37, 38, 31, -2, -37 },
  { 609, 31, 38, 31, 0, -37 },
  { 757, 9, 16, 31, 14, -38 },
  { 775, 22, 47, 31, 9, -40 },
  { 905, 21, 47, 31, 2, -40 },
  { 1029, 28, 26, 31, 2, -29 },
  { 1120, 26, 25, 31, 3, -28 },
  { 1202, 14, 16, 31, 6, -8 },
  { 1230, 18, 6, 31, 7, -19 },
  { 1244, 10, 9, 31, 9, -8 },
  { 1256, 31, 47, 31, 0, -40 },
  { 1439, 28, 38, 31, 2, -37 },
  { 1572, 26, 36, 31, 2, -36 },
  { 1689, 29, 37, 31, 1, -37 },
  { 1824, 29, 38, 31, 1, -37 },
  { 1962, 29, 36, 31, 0, -36 },
  { 2093, 29, 37, 31, 1, -36 },
  { 2228, 27, 37, 31, 2, -36 },
  { 2353, 28, 36, 31, 4, -36 },
  { 2479, 28, 38, 31, 2, -37 },
  { 2612, 26, 37, 31, 4, -37 },
  { 2733, 13, 28, 31, 9, -27 },
  { 2779, 16, 35, 31, 6, -27 },
  { 2849, 26, 31, 31, 4, -31 },
  { 2950, 28, 16, 31, 2, -24 },
  { 3006, 26, 31, 31, 2, -31 },
  { 3107, 23, 38, 31, 6, -37 },
  { 3217, 28, 43, 31, 2, -37 },
  { 3368, 30, 36, 31, -2, -36 },
  { 3503, 28, 36, 31, 2, -36 },
  { 3629, 28, 38, 31, 3, -37 },
  { 3762, 28, 36, 31, 2, -36 },
  { 3888, 29, 36, 31, 2, -36 },
  { 4019, 30, 36, 31, 2, -36 },
  { 4154, 27, 38, 31, 3, -37 },
  { 4283, 31, 36, 31, 1, -36 },
  { 4423, 29, 36, 31, 2, -36 },
  { 4554, 28, 37, 31, 2, -36 },
  { 4684, 32, 36, 31, 2, -36 },
  { 4828, 24, 36, 31, 3, -36 },
  { 4936, 33, 36, 31, 0, -36 },
  { 5085, 31, 36, 31, 1, -36 },
  { 5225, 28, 38, 31, 2, -37 },
  { 5358, 29, 36, 31, 2, -36 },
  { 5489, 28, 48, 31, 2, -37 },
  { 5657, 29, 36, 31, 2, -36 },
  { 5788, 30, 38, 31, 1, -37 },
  { 5931, 30, 36, 31, 4, -36 },
  { 6066, 29, 37, 31, 3, -36 },
  { 6201, 29, 36, 31, 5, -36 },
  { 6332, 33, 36, 31, 1, -36 },
  { 6481, 35, 36, 31, -1, -36 },
  { 6639, 31, 36, 31, 4, -36 },
  { 6779, 32, 36, 31, 0, -36 },
  { 6923, 24, 47, 31, 7, -40 },
  { 7064, 14, 47, 31, 9, -40 },
  { 7147, 24, 47, 31, 1, -40 },
  { 7288, 28, 22, 31, 2, -36 },
  { 7365, 25, 5, 31, 0, 4 },
  { 7381, 9, 12, 31, 10, -42 },
  { 7395, 27, 28, 31, 2, -27 },
  { 7490, 27, 39, 31, 2, -38 },
  { 7622, 25, 28, 31, 3, -27 },
  { 7710, 30, 39, 31, 2, -38 },
  { 7857, 25, 28, 31, 3, -27 },
  { 7945, 35, 49, 31, -1, -38 },
  { 8160, 29, 38, 31, 1, -27 },
  { 8298, 26, 38, 31, 2, -38 },
  { 8422, 24, 41, 31, 4, -40 },
  { 8545, 26, 51, 31, 1, -40 },
  { 8711, 28, 39, 31, 2, -38 },
  { 8848, 22, 39, 31, 5, -38 },
  { 8956, 30, 27, 31, 0, -27 },
  { 9058, 26, 27, 31, 2, -27 },
  { 9146, 26, 28, 31, 3, -27 },
  { 9237, 29, 37, 31, 0, -27 },
  { 9372, 28, 37, 31, 2, -27 },
  { 9502, 26, 27, 31, 5, -27 },
  { 9590, 26, 28, 31, 2, -27 },
  { 9681, 25, 37, 31, 4, -36 },
  { 9797, 26, 28, 31, 3, -27 },
  { 9888, 27, 28, 31, 2, -27 },
  { 9983, 29, 28, 31, 1, -27 },
  { 10085, 31, 28, 31, 0, -27 },
  { 10194, 28, 38, 31, 1, -27 },
  { 10327, 29, 28, 31, 1, -27 },
  { 10429, 26, 47, 31, 5, -40 },
  { 10582, 14, 47, 31, 9, -40 },
  { 10665, 25, 47, 31, 2, -40 },
  { 10812, 29, 12, 31, 1, -22 },
};

const GFXfont IBMPlexMono_SemiBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC52PT7B_H_
