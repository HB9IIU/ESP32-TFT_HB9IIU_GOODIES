#ifndef _IBMPLEXMONO_SEMIBOLDITALIC15PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x76, 0x66, 0x44, 0x0C, 0xCC, 0xDE, 0xF7, 0x39, 0x00, 0x0D, 0x84,
  0x86, 0xCF, 0x71, 0x21, 0xB3, 0xDC, 0x48, 0x6C, 0x24, 0x00, 0x06, 0x03,
  0x07, 0xC6, 0xB6, 0x43, 0x60, 0xF0, 0x1E, 0x0B, 0x05, 0x92, 0xDF, 0xC1,
  0x80, 0x80, 0x1C, 0x66, 0xD8, 0x9A, 0x12, 0x83, 0xA0, 0x07, 0x07, 0xB1,
  0xA6, 0x24, 0x98, 0xF0, 0x0E, 0x09, 0x84, 0xC6, 0x61, 0xA3, 0xE3, 0x31,
  0x9A, 0xD5, 0xBB, 0x80, 0x6B, 0x6C, 0x1C, 0xC6, 0x10, 0xC3, 0x08, 0x20,
  0x83, 0x0C, 0x10, 0x70, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC1, 0x82, 0x0C,
  0x18, 0x61, 0x8E, 0x00, 0x18, 0x18, 0xDA, 0xFF, 0x38, 0x68, 0xCC, 0x88,
  0x18, 0x30, 0x67, 0xF1, 0x06, 0x0C, 0x00, 0x76, 0xCC, 0xF8, 0xFC, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x18, 0x0C,
  0x0C, 0x00, 0x3C, 0x62, 0xC3, 0xC3, 0xDB, 0xDB, 0xC6, 0xC6, 0xCC, 0x78,
  0x1C, 0xDB, 0x34, 0x60, 0x83, 0x06, 0x0C, 0x19, 0xFC, 0x1E, 0x19, 0x98,
  0x60, 0x60, 0x30, 0x30, 0x60, 0x60, 0x60, 0x7F, 0x80, 0x1F, 0x11, 0x80,
  0xE0, 0x61, 0xC0, 0x18, 0x0C, 0x06, 0xC6, 0x3E, 0x00, 0x07, 0x03, 0x83,
  0xC3, 0x63, 0x33, 0x33, 0x19, 0xFF, 0x06, 0x03, 0x00, 0x3F, 0x98, 0x08,
  0x04, 0x06, 0xE3, 0x98, 0x0C, 0x06, 0x67, 0x7E, 0x00, 0x0E, 0x71, 0xC3,
  0x0D, 0xDC, 0xF1, 0xE3, 0xC6, 0xF0, 0x7F, 0x43, 0xC6, 0x0E, 0x0C, 0x1C,
  0x18, 0x30, 0x30, 0x60, 0x1F, 0x18, 0xC8, 0x66, 0x61, 0xE3, 0x19, 0x8D,
  0x86, 0x63, 0x1E, 0x00, 0x3C, 0x66, 0xC3, 0xC3, 0xC7, 0x7E, 0x06, 0x0C,
  0x18, 0xF0, 0x6F, 0x81, 0xB6, 0x33, 0x70, 0x00, 0x76, 0xCC, 0x03, 0x06,
  0x1C, 0x70, 0xC0, 0xF0, 0x38, 0x0C, 0x04, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x40, 0xE0, 0xE0, 0x70, 0x63, 0xDE, 0x70, 0x80, 0x7B, 0x30, 0xC3, 0x79,
  0x80, 0x18, 0xE3, 0x80, 0x3C, 0x62, 0x43, 0xDF, 0xD3, 0xB2, 0xB2, 0xB6,
  0xBE, 0x80, 0xC0, 0x78, 0x0E, 0x0E, 0x1E, 0x1A, 0x32, 0x33, 0x7F, 0x63,
  0xC3, 0xC3, 0x7E, 0x66, 0x63, 0x66, 0x78, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC,
  0x1E, 0x63, 0x62, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xC6, 0x7C, 0x7C, 0x66,
  0x63, 0x63, 0xC3, 0xC7, 0xC6, 0xC6, 0xCC, 0xF8, 0x7F, 0x60, 0x60, 0x60,
  0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7F, 0x60, 0x60, 0x60, 0x7E, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x63, 0x62, 0xC0, 0xC0, 0xCE, 0xD6, 0xC6,
  0xC6, 0x7E, 0x31, 0x98, 0xCC, 0x64, 0x27, 0xF3, 0x19, 0x8C, 0xC6, 0x63,
  0x63, 0x00, 0x7F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0xFC,
  0x3F, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x8C, 0xCC, 0xF8, 0x31, 0xCC,
  0xE3, 0x70, 0xF8, 0x6C, 0x1F, 0x07, 0x61, 0x98, 0x63, 0x30, 0xC0, 0x30,
  0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0xFC, 0x31, 0x9D, 0xDF, 0xEF,
  0xF6, 0xDB, 0x49, 0x24, 0x86, 0xC3, 0x61, 0x80, 0x39, 0x9C, 0xCE, 0x65,
  0x26, 0x93, 0x79, 0xBC, 0xDE, 0x47, 0x63, 0x00, 0x3C, 0x66, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC6, 0xC6, 0xCC, 0x78, 0x7E, 0x63, 0x63, 0x63, 0x66, 0xFC,
  0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x66, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6,
  0xCC, 0x78, 0x10, 0x1B, 0x0C, 0x7E, 0x63, 0x63, 0x63, 0x66, 0xFC, 0xC8,
  0xCC, 0xCC, 0xC6, 0x1F, 0x18, 0xCC, 0x0E, 0x03, 0xC0, 0x38, 0x0C, 0x06,
  0x43, 0x7E, 0x00, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x00, 0x63, 0x63, 0x63, 0xC3, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC,
  0x78, 0xC3, 0xB1, 0x98, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xF0, 0x78, 0x38,
  0x00, 0x60, 0xD8, 0x26, 0xC9, 0xB6, 0x7D, 0x95, 0x45, 0x51, 0xDC, 0xE7,
  0x39, 0x80, 0x71, 0xCC, 0xE1, 0xB0, 0x78, 0x1C, 0x07, 0x03, 0x60, 0xD8,
  0x67, 0x30, 0xC0, 0xC3, 0xB1, 0x99, 0x87, 0x83, 0xC1, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x00, 0x3F, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0,
  0x60, 0x7F, 0x80, 0x3E, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83,
  0x06, 0x0F, 0x80, 0xC2, 0x18, 0xC6, 0x10, 0x86, 0x31, 0x84, 0x21, 0x80,
  0x3E, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x4F, 0x80,
  0x1C, 0x1C, 0x34, 0x66, 0xC6, 0xC3, 0xFE, 0xC9, 0x80, 0x7E, 0xCF, 0x1E,
  0x3C, 0x79, 0xF3, 0x7B, 0x30, 0x30, 0x30, 0x3F, 0x33, 0x63, 0x63, 0x63,
  0x63, 0x66, 0xDC, 0x3C, 0xCF, 0x06, 0x0C, 0x18, 0xB1, 0xBC, 0x03, 0x03,
  0x03, 0x3B, 0x66, 0xC6, 0xC6, 0xC6, 0xC6, 0xDE, 0xEC, 0x3C, 0xCF, 0x1E,
  0x7F, 0x98, 0xB1, 0xBC, 0x07, 0xC1, 0x80, 0xC0, 0xFE, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x83, 0x60, 0x58, 0x1C, 0x00, 0x1D, 0x99,
  0x98, 0xCC, 0x66, 0x33, 0x19, 0x98, 0x74, 0x06, 0x23, 0x3E, 0x00, 0x60,
  0xC1, 0x83, 0x67, 0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x30, 0x18, 0x30, 0x07,
  0xC3, 0x06, 0x0C, 0x18, 0x36, 0x78, 0xE0, 0x03, 0x07, 0x00, 0x3E, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x4C, 0xCC, 0x6C, 0x38, 0x60, 0x60, 0x60,
  0x7E, 0x66, 0xC6, 0xC6, 0xD8, 0xF8, 0xDB, 0x8C, 0x79, 0x30, 0x61, 0x83,
  0x06, 0x0C, 0x18, 0x66, 0xD8, 0xC0, 0x7B, 0xB6, 0xD2, 0x69, 0x3C, 0x96,
  0xCB, 0x6D, 0xB6, 0x6C, 0xEF, 0x1E, 0x3C, 0x78, 0xF1, 0xC6, 0x3C, 0xCF,
  0x1E, 0x3C, 0x78, 0xF3, 0x3C, 0x3F, 0x33, 0x63, 0x63, 0x63, 0x63, 0x66,
  0x5C, 0xC0, 0xC0, 0xC0, 0x3B, 0x66, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC,
  0x0C, 0x0C, 0x0C, 0x7F, 0xB8, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x3C,
  0xCD, 0x03, 0x81, 0xC0, 0xE3, 0x3C, 0x18, 0x23, 0xF9, 0x83, 0x06, 0x0C,
  0x33, 0x6C, 0x60, 0x63, 0x8F, 0x1E, 0x3C, 0x78, 0xF7, 0x36, 0xE6, 0xCD,
  0x9B, 0x36, 0x78, 0xB3, 0x38, 0x6D, 0x36, 0xD3, 0x69, 0x34, 0x96, 0x4B,
  0xE4, 0xDC, 0x3B, 0xB6, 0xC3, 0x41, 0x81, 0x82, 0xC3, 0xAD, 0xDC, 0x31,
  0x63, 0x63, 0x63, 0x63, 0x63, 0x6E, 0x3E, 0x06, 0x44, 0xF8, 0x3D, 0xB3,
  0x99, 0x81, 0x81, 0xA1, 0x99, 0xC5, 0x9E, 0x1E, 0x60, 0xC1, 0x81, 0x03,
  0x38, 0x18, 0x30, 0xC1, 0x02, 0x0F, 0x80, 0x32, 0x26, 0x66, 0x44, 0xCC,
  0xCC, 0x80, 0x1E, 0x26, 0x06, 0x0C, 0x18, 0x18, 0x07, 0x18, 0x10, 0x18,
  0x08, 0x08, 0xF8, 0x39, 0xA4, 0xB1, 0x80,
};

const GFXglyph IBMPlexMono_SemiBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 10, 9, 3, -10 },
  { 6, 5, 5, 9, 3, -11 },
  { 10, 9, 10, 9, 0, -10 },
  { 22, 9, 14, 9, 0, -12 },
  { 38, 11, 10, 9, -1, -10 },
  { 52, 9, 10, 9, 0, -10 },
  { 64, 3, 5, 9, 4, -11 },
  { 66, 6, 13, 9, 3, -11 },
  { 76, 7, 13, 9, 0, -11 },
  { 88, 8, 8, 9, 1, -8 },
  { 96, 7, 7, 9, 1, -8 },
  { 103, 4, 4, 9, 2, -2 },
  { 105, 5, 1, 9, 2, -5 },
  { 106, 2, 3, 9, 3, -3 },
  { 107, 9, 13, 9, 0, -11 },
  { 122, 8, 10, 9, 1, -10 },
  { 132, 7, 10, 9, 1, -10 },
  { 141, 9, 10, 9, 0, -10 },
  { 153, 9, 10, 9, 0, -10 },
  { 165, 9, 10, 9, 0, -10 },
  { 177, 9, 10, 9, 0, -10 },
  { 189, 7, 10, 9, 1, -10 },
  { 198, 8, 10, 9, 1, -10 },
  { 208, 9, 10, 9, 0, -10 },
  { 220, 8, 10, 9, 1, -10 },
  { 230, 3, 8, 9, 3, -8 },
  { 233, 4, 10, 9, 2, -8 },
  { 238, 8, 9, 9, 1, -9 },
  { 247, 8, 5, 9, 1, -7 },
  { 252, 7, 9, 9, 1, -9 },
  { 260, 6, 10, 9, 2, -10 },
  { 268, 8, 12, 9, 1, -10 },
  { 280, 8, 10, 9, 0, -10 },
  { 290, 8, 10, 9, 1, -10 },
  { 300, 8, 10, 9, 1, -10 },
  { 310, 8, 10, 9, 1, -10 },
  { 320, 8, 10, 9, 1, -10 },
  { 330, 8, 10, 9, 1, -10 },
  { 340, 8, 10, 9, 1, -10 },
  { 350, 9, 10, 9, 0, -10 },
  { 362, 8, 10, 9, 1, -10 },
  { 372, 8, 10, 9, 1, -10 },
  { 382, 10, 10, 9, 0, -10 },
  { 395, 7, 10, 9, 1, -10 },
  { 404, 9, 10, 9, 0, -10 },
  { 416, 9, 10, 9, 0, -10 },
  { 428, 8, 10, 9, 1, -10 },
  { 438, 8, 10, 9, 1, -10 },
  { 448, 8, 13, 9, 1, -10 },
  { 461, 8, 10, 9, 1, -10 },
  { 471, 9, 10, 9, 0, -10 },
  { 483, 9, 10, 9, 1, -10 },
  { 495, 8, 10, 9, 1, -10 },
  { 505, 9, 10, 9, 1, -10 },
  { 517, 10, 10, 9, 0, -10 },
  { 530, 10, 10, 9, 0, -10 },
  { 543, 9, 10, 9, 1, -10 },
  { 555, 9, 10, 9, 0, -10 },
  { 567, 7, 13, 9, 2, -11 },
  { 579, 5, 13, 9, 2, -11 },
  { 588, 7, 13, 9, 0, -11 },
  { 600, 8, 6, 9, 1, -10 },
  { 606, 7, 1, 9, 0, 1 },
  { 607, 3, 3, 9, 3, -12 },
  { 609, 7, 8, 9, 1, -8 },
  { 616, 8, 11, 9, 0, -11 },
  { 627, 7, 8, 9, 1, -8 },
  { 634, 8, 11, 9, 1, -11 },
  { 645, 7, 8, 9, 1, -8 },
  { 652, 10, 14, 9, 0, -11 },
  { 670, 9, 11, 9, 0, -8 },
  { 683, 7, 11, 9, 1, -11 },
  { 693, 7, 11, 9, 1, -11 },
  { 703, 8, 14, 9, 0, -11 },
  { 717, 8, 11, 9, 1, -11 },
  { 728, 7, 11, 9, 1, -11 },
  { 738, 9, 8, 9, 0, -8 },
  { 747, 7, 8, 9, 1, -8 },
  { 754, 7, 8, 9, 1, -8 },
  { 761, 8, 11, 9, 0, -8 },
  { 772, 8, 11, 9, 1, -8 },
  { 783, 8, 8, 9, 1, -8 },
  { 791, 7, 8, 9, 1, -8 },
  { 798, 7, 10, 9, 1, -10 },
  { 807, 7, 8, 9, 1, -8 },
  { 814, 7, 8, 9, 1, -8 },
  { 821, 9, 8, 9, 0, -8 },
  { 830, 9, 8, 9, 0, -8 },
  { 839, 8, 11, 9, 0, -8 },
  { 850, 9, 8, 9, 0, -8 },
  { 859, 7, 13, 9, 2, -11 },
  { 871, 4, 13, 9, 3, -11 },
  { 878, 8, 13, 9, 0, -11 },
  { 891, 9, 3, 9, 0, -6 },
};

const GFXfont IBMPlexMono_SemiBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC15PT7B_H_
