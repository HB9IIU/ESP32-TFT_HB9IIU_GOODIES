#ifndef _IBMPLEXMONO_SEMIBOLDITALIC64PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFE,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x3E, 0xFF, 0xC0, 0x7F, 0xC3,
  0xF1, 0xFC, 0x03, 0xFC, 0x1F, 0x03, 0xC0, 0x3F, 0xE0, 0xF8, 0x0C, 0x01,
  0xFE, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x00, 0x7F, 0x81, 0xF0,
  0x00, 0x03, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x00, 0xFF,
  0x87, 0xC0, 0x00, 0x07, 0xFF, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3E, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0x00,
  0x0F, 0x83, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0xC0, 0x60, 0x0F,
  0x81, 0xFE, 0x07, 0x80, 0x7C, 0x1F, 0xF0, 0x7E, 0x03, 0xE0, 0xFF, 0x07,
  0xFC, 0x3F, 0x0F, 0xF8, 0x7F, 0xF9, 0xF9, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x80, 0x7E,
  0x3F, 0x80, 0x00, 0x7C, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0xC3, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x8F, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x8F, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC7,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xF3, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x43, 0xFC, 0x00,
  0xFF, 0x01, 0xCF, 0xF0, 0x03, 0xFC, 0x0F, 0xBF, 0xE0, 0x0F, 0xF0, 0x7F,
  0x7F, 0x80, 0x7F, 0xE1, 0xF9, 0xFE, 0x03, 0xBF, 0x8F, 0xE7, 0xFE, 0x1E,
  0xFF, 0x7F, 0x1F, 0xFF, 0xFB, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xE0,
  0xFF, 0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x03, 0xF8, 0x00,
  0x8F, 0x00, 0xFE, 0x01, 0xE3, 0xF8, 0x3F, 0x83, 0xF9, 0xFF, 0xCF, 0xE7,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x7F,
  0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0x81, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0x87, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3E, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x7F, 0x80,
  0x0F, 0x80, 0x7F, 0x80, 0x07, 0x00, 0x7F, 0x80, 0x02, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x78,
  0x00, 0x1F, 0xF0, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x03, 0xFE,
  0x00, 0x70, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x00, 0x0F, 0xF8,
  0x0E, 0x00, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0x07, 0xE3, 0xFF, 0xF8,
  0x00, 0xFE, 0x7F, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xF0, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x40, 0x00, 0x0F, 0xF8, 0x0E, 0x00, 0x01, 0xFF,
  0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0x80,
  0x0F, 0xF8, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0xFF,
  0x83, 0xFE, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0xC7, 0xF0, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFC,
  0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0x80, 0x07, 0xF0,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F,
  0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xC0, 0x03, 0xFE,
  0x3C, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x0F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF1, 0xF8, 0x0F, 0xF8, 0xFC, 0xFE,
  0x07, 0xFF, 0x3F, 0x3F, 0x83, 0xFF, 0xDF, 0xCF, 0xE0, 0xFF, 0xFF, 0xF3,
  0xF0, 0x7F, 0x87, 0xF9, 0xFC, 0x1F, 0xC0, 0xFE, 0x7F, 0x0F, 0xE0, 0x1F,
  0x9F, 0xC3, 0xF8, 0x07, 0xE7, 0xF0, 0xFC, 0x03, 0xF9, 0xF8, 0x7F, 0x00,
  0xFE, 0xFE, 0x1F, 0xC0, 0x3F, 0x3F, 0x87, 0xF0, 0x0F, 0xCF, 0xE1, 0xFC,
  0x03, 0xF3, 0xF8, 0x7E, 0x00, 0xFC, 0xFE, 0x1F, 0x80, 0x7F, 0x3F, 0x07,
  0xE0, 0x1F, 0xCF, 0xC1, 0xF8, 0x07, 0xE3, 0xF0, 0x7E, 0x03, 0xF8, 0xFC,
  0x1F, 0x80, 0xFE, 0x3F, 0x07, 0xF0, 0x7F, 0x8F, 0xC1, 0xFE, 0x7F, 0xE3,
  0xF0, 0x7F, 0xFB, 0xF8, 0xFC, 0x0F, 0xFE, 0xFC, 0x3F, 0x03, 0xFF, 0x3F,
  0x0F, 0xC0, 0x7F, 0x8F, 0xC3, 0xF0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x0F, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x00,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x0F, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x1F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0xFC,
  0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF,
  0xF3, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0x8F, 0xF8, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x80,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFB, 0xFC,
  0x07, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x1F, 0xFF, 0x8F,
  0xE0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0x00,
  0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0xC0,
  0x00, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x7F, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFB, 0xF0, 0xFD, 0xFC, 0x03, 0xFB,
  0xF1, 0xF9, 0xFC, 0x07, 0xF3, 0xF1, 0xF9, 0xFC, 0x07, 0xF3, 0xFB, 0xF3,
  0xFC, 0x07, 0xF1, 0xFB, 0xF3, 0xF8, 0x07, 0xF1, 0xFF, 0xE3, 0xF8, 0x07,
  0xF1, 0xFF, 0xE3, 0xF8, 0x07, 0xF1, 0xFF, 0xC3, 0xF8, 0x0F, 0xF1, 0xFF,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFF, 0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x87, 0xF0,
  0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x1F, 0xE0, 0x7C, 0x0F,
  0xF0, 0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x1F,
  0xC0, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x30, 0x0F, 0xE0, 0x3F, 0xC0, 0x20,
  0x1F, 0xE0, 0x3F, 0xC0, 0x20, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0xF0, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xFC, 0x00,
  0x7F, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x7F,
  0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x7F,
  0x01, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x00,
  0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xF3, 0xF0, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x80, 0xFE,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0xFE,
  0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0xFE, 0x0F,
  0xE3, 0xFC, 0x07, 0xF0, 0x3F, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0xFE, 0x03,
  0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xF0, 0x0F, 0xDF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xFF, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F,
  0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x60,
  0x00, 0x3F, 0xC0, 0x38, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x00,
  0xE0, 0x07, 0xF8, 0x00, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0x00, 0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x01, 0xFF, 0x03, 0xF0, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x0F, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xFF, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x83, 0xF8,
  0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0xFF, 0xE0, 0xFE, 0x03, 0xF8,
  0x7D, 0xF0, 0x7E, 0x01, 0xFC, 0x3E, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x7C,
  0x3F, 0x80, 0x7F, 0x1F, 0x3E, 0x1F, 0xC0, 0x7F, 0x0F, 0x9F, 0x0F, 0xC0,
  0x3F, 0x87, 0xCF, 0x87, 0xE0, 0x1F, 0xC7, 0xC7, 0xC7, 0xF0, 0x0F, 0xE3,
  0xE3, 0xE3, 0xF8, 0x07, 0xF1, 0xF1, 0xF1, 0xFC, 0x03, 0xF9, 0xF0, 0xF8,
  0xFC, 0x01, 0xFC, 0xF8, 0x7C, 0xFE, 0x00, 0xFE, 0x7C, 0x3E, 0x7F, 0x00,
  0x7F, 0x7C, 0x1F, 0x3F, 0x80, 0x3F, 0x3E, 0x0F, 0x9F, 0x80, 0x3F, 0x9F,
  0x07, 0xCF, 0xC0, 0x1F, 0xDF, 0x83, 0xEF, 0xE0, 0x0F, 0xEF, 0x81, 0xF7,
  0xF0, 0x07, 0xF7, 0xC0, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0x80,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x00, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0x01, 0xF0, 0x7F, 0x0F, 0xF8, 0x7F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xC0, 0x10,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x7F, 0xFE, 0x3F,
  0xE0, 0x7F, 0xFF, 0x9F, 0xE0, 0x7F, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xF7,
  0xF8, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x03,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x0F, 0xFC, 0x3F,
  0xE0, 0x0F, 0xFE, 0x1F, 0xF0, 0x0F, 0xFE, 0x07, 0xFC, 0x1E, 0xFF, 0xF3,
  0xFF, 0xFF, 0x7F, 0xF9, 0xFF, 0xFF, 0x3F, 0xFC, 0x7F, 0xFF, 0x0F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0x83, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0xF0, 0x07, 0xF8, 0xFF,
  0xFE, 0x01, 0xFE, 0x7F, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0xF0, 0x1F, 0xEF,
  0x07, 0xFE, 0x0F, 0xF7, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xE0, 0xFF,
  0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07,
  0xFB, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xFF, 0xE0,
  0x3F, 0xC7, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFC, 0xFF,
  0x80, 0x07, 0xC3, 0xFE, 0x00, 0x1C, 0x0F, 0xF0, 0x00, 0x40, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x0F,
  0xF0, 0x00, 0x1E, 0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x1F, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0x80, 0x1F, 0xFF, 0xC7,
  0xF8, 0x03, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFE, 0x0F, 0x7F, 0x80, 0x7F, 0xFF,
  0xE7, 0xF8, 0x07, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xCF, 0xF0, 0x01,
  0xFF, 0xF8, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE,
  0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFF, 0x9F, 0xE0, 0x0F, 0xFE, 0x7F,
  0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x60, 0xFF, 0x00,
  0x01, 0xF1, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x7F, 0xC7, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x40, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC3, 0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0xCF, 0xF0, 0x1F,
  0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x1E, 0xFF, 0x01, 0xFF, 0xFF, 0xDF, 0xE0,
  0x1F, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0x1F,
  0xE0, 0x03, 0xFF, 0xC3, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x60, 0x00, 0xFF, 0x80,
  0x1E, 0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0xFF,
  0xE0, 0x0F, 0xF8, 0xFF, 0xF8, 0x07, 0xF8, 0xFF, 0xFE, 0x03, 0xFC, 0xFF,
  0xFF, 0x81, 0xFE, 0x7F, 0xFF, 0xC0, 0xFF, 0x78, 0x7F, 0xE0, 0x7F, 0xB0,
  0x0F, 0xF0, 0x7F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x01, 0x00, 0x0F, 0xF0, 0x0E,
  0x00, 0x7F, 0xC0, 0x7E, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07,
  0xF1, 0xFF, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0xFF,
  0x00, 0x1E, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xC3, 0xFF, 0xF0, 0x07,
  0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC,
  0x03, 0xFD, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xEF, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x83, 0xFC, 0x3F, 0xC0, 0x38, 0x7F, 0x87, 0xFC, 0x0F, 0x0F,
  0xF0, 0x7F, 0x83, 0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0x7F, 0x80, 0xFF, 0x3F,
  0xCF, 0xF0, 0x1F, 0xFF, 0xF1, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F,
  0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x02, 0x00, 0x7F, 0x80, 0x38, 0x07, 0xF8, 0x07, 0xC0, 0x7F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x80,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x8F, 0xE0, 0xFF, 0x81, 0xFC, 0xFF, 0x8F, 0xFE, 0x0F, 0xCF, 0xFC,
  0x7F, 0xF0, 0x7E, 0xFF, 0xF7, 0xFF, 0x87, 0xF4, 0x7F, 0xB1, 0xFC, 0x3F,
  0xC1, 0xFF, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0xC0, 0xFE, 0x3F, 0x80,
  0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x01, 0xFC,
  0x7E, 0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE,
  0x07, 0xF1, 0xFC, 0x07, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x01, 0xFC, 0x7F,
  0x03, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0x01, 0xFC, 0x7F, 0x01,
  0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFE, 0x03, 0xF0,
  0xFC, 0x07, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC,
  0x0F, 0xE3, 0xF8, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0xFE,
  0x07, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0x1F,
  0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0xF0, 0x3F, 0xCF, 0xFF, 0xF8, 0x1F, 0xEF,
  0x0F, 0xFC, 0x0F, 0xF6, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xE3, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF,
  0xC0, 0x1F, 0xEF, 0xFF, 0xFC, 0x01, 0xFE, 0xF0, 0x7F, 0xE0, 0x3F, 0xDC,
  0x03, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0x01, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC, 0x03, 0xFE, 0x7F,
  0xFF, 0x80, 0x3F, 0xC7, 0xFF, 0xF0, 0x03, 0xFC, 0x3F, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0x1F, 0xE0, 0x7F,
  0xFF, 0xCF, 0xF0, 0x7F, 0xFF, 0xE7, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F,
  0xFE, 0x1F, 0xF0, 0x0E, 0xFF, 0x07, 0xFE, 0x0F, 0x7F, 0x83, 0xFF, 0xFF,
  0x3F, 0xC1, 0xFF, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF,
  0x8F, 0xF0, 0x07, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0x81, 0xFF, 0x7F, 0xFF, 0x87, 0xFF,
  0x7F, 0xFF, 0x8F, 0xFF, 0x7F, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0x9F, 0xFE,
  0x00, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0x7F, 0xFE, 0x00, 0xFF, 0x78, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFE, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x30, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x10, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x01, 0xFE, 0x00, 0xF0,
  0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xC3, 0xFF, 0x80, 0x7F, 0x8F, 0xFE, 0x00, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x6F, 0xF0, 0xFF,
  0x80, 0xEF, 0xF0, 0xFF, 0xC1, 0xDF, 0xF0, 0xFF, 0xFF, 0xDF, 0xE0, 0x7F,
  0xFF, 0x9F, 0xE0, 0x7F, 0xFF, 0x1F, 0xE0, 0x3F, 0xFE, 0x1F, 0xE0, 0x1F,
  0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x7F,
  0xFE, 0x00, 0x7C, 0x7F, 0xFE, 0x03, 0xFE, 0x7F, 0xFC, 0x03, 0xFE, 0xFF,
  0xFC, 0x01, 0xFE, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xE1, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0xC0, 0xFE, 0x07, 0xF0, 0x7C,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0x7E, 0x07, 0xF1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xE0, 0x7F,
  0x1F, 0x80, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC0, 0x7F, 0x3F, 0x80, 0xFC,
  0x07, 0xF3, 0xF8, 0x1F, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0x07, 0xF3, 0xF0,
  0x1F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xFE,
  0x7F, 0x01, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0xFE, 0x7E, 0x03, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF0, 0x1F, 0xC7, 0xE0,
  0x7F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0x03, 0xF0,
  0xFF, 0x1F, 0xF0, 0x7F, 0x0F, 0xFF, 0xDF, 0x8F, 0xE0, 0xFF, 0xFD, 0xFF,
  0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xF8, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xBF, 0x9E, 0x3F, 0x8F, 0xFC, 0x7F, 0x38, 0x7F, 0x0F, 0xF0,
  0x7E, 0xE0, 0x7F, 0x0F, 0x80, 0xFD, 0x80, 0xFE, 0x0E, 0x01, 0xFB, 0x01,
  0xFC, 0x10, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x04, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFE,
  0x00, 0x81, 0xFC, 0x0F, 0xFC, 0x07, 0x83, 0xF8, 0x1B, 0xF8, 0x1F, 0x87,
  0xF0, 0x73, 0xF0, 0x7F, 0x8F, 0xE0, 0xE7, 0xE3, 0xFF, 0x1F, 0xE3, 0x8F,
  0xCF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xBF, 0xC0, 0x7F, 0xE0, 0xF7,
  0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF,
  0xC7, 0xF8, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xE0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x03, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x01, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F,
  0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xFF, 0xBF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0x00, 0x7F, 0xFC, 0x0F, 0xC0, 0x07, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x02, 0x00, 0x07, 0xFE, 0x01,
  0xC0, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x1F, 0xF0,
  0x03, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0xFF,
  0xF0, 0x00, 0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0x87, 0xFF, 0xFF, 0xF3, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x87, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF,
  0xF0, 0xFE, 0x01, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x10, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x3F, 0xF0,
  0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0x83, 0xFF, 0xF0, 0x07, 0xF0, 0xFF,
  0xFE, 0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0xFE, 0x07, 0xF1,
  0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x8F, 0xE0, 0x7F, 0xFF,
  0xE1, 0xF8, 0x07, 0xFF, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0x0F, 0xE0, 0x0F,
  0xFF, 0xC1, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0xE0,
  0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 17, 46, 38, 11, -45 },
  { 99, 24, 20, 38, 11, -47 },
  { 159, 40, 45, 38, 0, -45 },
  { 384, 37, 60, 38, 1, -52 },
  { 662, 45, 46, 38, -2, -45 },
  { 921, 38, 46, 38, 0, -45 },
  { 1140, 11, 20, 38, 17, -47 },
  { 1168, 26, 58, 38, 12, -49 },
  { 1357, 26, 58, 38, 2, -49 },
  { 1546, 34, 32, 38, 3, -35 },
  { 1682, 31, 30, 38, 4, -35 },
  { 1799, 18, 19, 38, 7, -10 },
  { 1842, 21, 7, 38, 9, -23 },
  { 1861, 12, 12, 38, 11, -11 },
  { 1879, 37, 58, 38, 1, -49 },
  { 2148, 34, 46, 38, 3, -45 },
  { 2344, 32, 45, 38, 3, -45 },
  { 2524, 36, 45, 38, 1, -45 },
  { 2727, 36, 46, 38, 1, -45 },
  { 2934, 35, 45, 38, 1, -45 },
  { 3131, 36, 46, 38, 2, -45 },
  { 3338, 33, 46, 38, 3, -45 },
  { 3528, 34, 45, 38, 5, -45 },
  { 3720, 35, 46, 38, 2, -45 },
  { 3922, 33, 45, 38, 4, -45 },
  { 4108, 16, 35, 38, 11, -34 },
  { 4178, 20, 43, 38, 7, -34 },
  { 4286, 32, 38, 38, 5, -39 },
  { 4438, 34, 21, 38, 3, -30 },
  { 4528, 31, 38, 38, 3, -39 },
  { 4676, 29, 46, 38, 7, -45 },
  { 4843, 34, 52, 38, 3, -45 },
  { 5064, 37, 45, 38, -2, -45 },
  { 5273, 34, 45, 38, 2, -45 },
  { 5465, 34, 46, 38, 4, -45 },
  { 5661, 35, 45, 38, 2, -45 },
  { 5858, 35, 45, 38, 3, -45 },
  { 6055, 36, 45, 38, 3, -45 },
  { 6258, 34, 46, 38, 3, -45 },
  { 6454, 37, 45, 38, 2, -45 },
  { 6663, 36, 45, 38, 2, -45 },
  { 6866, 35, 46, 38, 2, -45 },
  { 7068, 40, 45, 38, 2, -45 },
  { 7293, 29, 45, 38, 4, -45 },
  { 7457, 40, 45, 38, 0, -45 },
  { 7682, 37, 45, 38, 2, -45 },
  { 7891, 34, 46, 38, 3, -45 },
  { 8087, 35, 45, 38, 3, -45 },
  { 8284, 34, 58, 38, 3, -45 },
  { 8531, 36, 45, 38, 2, -45 },
  { 8734, 37, 46, 38, 1, -45 },
  { 8947, 37, 45, 38, 5, -45 },
  { 9156, 35, 46, 38, 4, -45 },
  { 9358, 36, 45, 38, 6, -45 },
  { 9561, 41, 45, 38, 1, -45 },
  { 9792, 43, 45, 38, -2, -45 },
  { 10034, 38, 45, 38, 5, -45 },
  { 10248, 39, 45, 38, 0, -45 },
  { 10468, 30, 58, 38, 8, -49 },
  { 10686, 18, 58, 38, 11, -49 },
  { 10817, 29, 58, 38, 2, -49 },
  { 11028, 34, 28, 38, 3, -45 },
  { 11147, 32, 7, 38, -1, 5 },
  { 11175, 12, 14, 38, 12, -51 },
  { 11196, 33, 35, 38, 3, -34 },
  { 11341, 34, 48, 38, 2, -47 },
  { 11545, 30, 35, 38, 4, -34 },
  { 11677, 36, 48, 38, 3, -47 },
  { 11893, 31, 35, 38, 4, -34 },
  { 12029, 44, 61, 38, -2, -47 },
  { 12365, 35, 48, 38, 1, -34 },
  { 12575, 33, 47, 38, 2, -47 },
  { 12769, 30, 49, 38, 5, -48 },
  { 12953, 32, 62, 38, 1, -48 },
  { 13201, 35, 48, 38, 2, -47 },
  { 13411, 28, 48, 38, 6, -47 },
  { 13579, 37, 34, 38, 0, -34 },
  { 13737, 33, 34, 38, 2, -34 },
  { 13878, 32, 35, 38, 3, -34 },
  { 14018, 36, 47, 38, 0, -34 },
  { 14230, 33, 47, 38, 3, -34 },
  { 14424, 32, 33, 38, 6, -33 },
  { 14556, 31, 35, 38, 3, -34 },
  { 14692, 31, 46, 38, 4, -45 },
  { 14871, 32, 34, 38, 4, -33 },
  { 15007, 32, 35, 38, 3, -34 },
  { 15147, 36, 34, 38, 1, -33 },
  { 15300, 39, 35, 38, 0, -34 },
  { 15471, 35, 47, 38, 1, -33 },
  { 15677, 35, 35, 38, 2, -34 },
  { 15831, 31, 58, 38, 7, -49 },
  { 16056, 16, 58, 38, 12, -49 },
  { 16172, 31, 58, 38, 2, -49 },
  { 16397, 35, 16, 38, 2, -28 },
};

const GFXfont IBMPlexMono_SemiBoldItalic64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC64PT7B_H_
