#ifndef _IBMPLEXMONO_SEMIBOLDITALIC33PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0x1F, 0x8F,
  0xC7, 0xC3, 0xE0, 0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xEF, 0x1E, 0xF1, 0xCE, 0x3C, 0x00, 0x78, 0xE0, 0x03, 0x8F, 0x00,
  0x1C, 0x70, 0x01, 0xE3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x07, 0x8E,
  0x03, 0xF8, 0xFF, 0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0x80, 0xE3, 0xC0, 0x07,
  0x1C, 0x00, 0x78, 0xE0, 0x3F, 0x8F, 0xF3, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8,
  0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xE0, 0x03, 0xC7,
  0x00, 0x1E, 0x78, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF3, 0x3C, 0xF9,
  0xC6, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF9, 0xC0, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x31, 0xE0,
  0x0C, 0x78, 0x07, 0x1E, 0x21, 0xC7, 0x9C, 0x73, 0xEF, 0x9D, 0xF3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x1E, 0x0F, 0xE0, 0x38, 0x3F, 0xE0, 0xE0, 0xF1, 0xC3,
  0xC1, 0xC3, 0x87, 0x03, 0x87, 0x1C, 0x07, 0x0E, 0x78, 0x0E, 0x1C, 0xE0,
  0x1C, 0x73, 0x80, 0x3F, 0xEF, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xFE, 0x00, 0x7B, 0xFE, 0x00, 0xEF, 0x1C, 0x03, 0x9C, 0x38, 0x0F,
  0x38, 0x70, 0x1C, 0x70, 0xE0, 0x70, 0xE1, 0xC1, 0xE1, 0xC7, 0x03, 0x83,
  0xFE, 0x0E, 0x03, 0xF8, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x38, 0x3C, 0x03,
  0x83, 0xC0, 0x38, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xDF, 0x01,
  0xFF, 0xC0, 0x3D, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x86, 0xF8, 0x7C, 0xFF, 0x8F, 0xDE, 0x7F, 0x9F,
  0xC3, 0xF9, 0xF8, 0x1E, 0x0F, 0x00, 0x3B, 0xDE, 0xF7, 0xBD, 0xDE, 0xF7,
  0x80, 0x00, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x20, 0xF0, 0x9F, 0x39,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x1F, 0x78, 0x0F, 0x8F, 0x07, 0xC3, 0xE0, 0x60, 0x60, 0x10,
  0x10, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x8F, 0x8F, 0x87,
  0xC3, 0xC3, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x00, 0xFF, 0xFF, 0xFB, 0xFF,
  0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x1E, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x38, 0xF7, 0x9F, 0x3D, 0xE7, 0x8F,
  0x78, 0xE7, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x03, 0xC7, 0x81, 0xF1, 0xF0, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x78, 0x1E, 0x78, 0x7E,
  0x78, 0xFC, 0x78, 0x78, 0xF8, 0x30, 0xF0, 0x20, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x3E, 0x07, 0xC7, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0x7C, 0x3E,
  0x0C, 0x07, 0xC2, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x08, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xEF, 0x00, 0x3D, 0xE0,
  0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0x81,
  0xE0, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xFC, 0x0F, 0x7F,
  0x83, 0xFF, 0xF0, 0xF8, 0x7E, 0x18, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x84, 0x03, 0xE7, 0x01, 0xF3, 0xE0, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x7C, 0x1E, 0xFF, 0x9F, 0xFF, 0xCF, 0xC3, 0xF7, 0xC0, 0xFB, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x87,
  0xE3, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0x80, 0xFB, 0x80, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C,
  0x70, 0x0F, 0x1E, 0x07, 0x87, 0xC3, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F,
  0xFF, 0x0F, 0x07, 0xC7, 0x80, 0xFB, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x03,
  0xEF, 0x80, 0xFB, 0xF0, 0x7C, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC3, 0xE7, 0xC0, 0xFB, 0xC0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xEF,
  0x87, 0xF7, 0xFF, 0xF1, 0xFF, 0xF8, 0x3E, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x1E, 0x3F, 0x3F, 0x3F, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0x07, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE1, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x00,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x08, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0xC0, 0x10, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x7E, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF7, 0xC3, 0xEF, 0x03,
  0xE4, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x1F, 0xF0, 0x3F, 0x80,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1F, 0x1E, 0x03, 0xC7, 0x00,
  0x73, 0xC0, 0x1C, 0xE1, 0xE7, 0x38, 0xFD, 0xDE, 0x7F, 0x77, 0x9E, 0x3D,
  0xE7, 0x0E, 0x73, 0xC3, 0x9C, 0xF0, 0xE7, 0x38, 0x3B, 0xCE, 0x1E, 0xF3,
  0x87, 0xBC, 0xFF, 0xCF, 0x3F, 0x73, 0xC7, 0xDC, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF0,
  0x0F, 0x1F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xF7,
  0xC0, 0x3E, 0xF0, 0x07, 0xFE, 0x00, 0x78, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0x78,
  0x1F, 0x1E, 0x07, 0x8F, 0x83, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0x03, 0xC3, 0xC0, 0xF9, 0xF0, 0x1E, 0x7C, 0x0F, 0x9E, 0x03, 0xE7,
  0x80, 0xF1, 0xE0, 0x7C, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x3E, 0x07, 0xCF, 0x01,
  0xF7, 0xC0, 0x21, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x0C, 0x3C, 0x03, 0xCF, 0x81, 0xF1, 0xF0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E,
  0x1E, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF,
  0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0,
  0x79, 0xF0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x10,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x1F, 0xEF, 0x0F,
  0xF7, 0x87, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x3E,
  0x07, 0x9F, 0x8F, 0xC7, 0xFD, 0xE1, 0xFE, 0xF0, 0x7C, 0x78, 0x0F, 0x01,
  0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0x80, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x81, 0xF1,
  0xE0, 0x3C, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x08, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x01, 0xF8, 0x78, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xCF,
  0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xBC, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x3E,
  0x03, 0xC1, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0x7C,
  0x07, 0xC3, 0xC0, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x3B, 0xC3, 0xBF, 0xDC, 0x1C, 0xFC,
  0xE1, 0xE7, 0xEF, 0x0F, 0x3E, 0x78, 0x79, 0xF3, 0xC3, 0xCF, 0x1E, 0x1E,
  0x30, 0xE0, 0xE1, 0x8F, 0x0F, 0x08, 0x78, 0x78, 0x43, 0xC3, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x1E, 0x00, 0x0F, 0x81, 0xE3, 0xF0, 0x3C, 0x7E, 0x07, 0x8F, 0xE0, 0xE1,
  0xFC, 0x3C, 0x3F, 0x87, 0x87, 0x70, 0xF1, 0xEE, 0x1E, 0x3D, 0xE3, 0xC7,
  0xBC, 0x70, 0xF7, 0x8E, 0x1E, 0x73, 0xC3, 0x8E, 0x78, 0xF1, 0xEF, 0x1E,
  0x3D, 0xE3, 0xC7, 0xB8, 0x78, 0x77, 0x0F, 0x0F, 0xE1, 0xC1, 0xFC, 0x78,
  0x3F, 0x8F, 0x07, 0xF1, 0xE0, 0x7C, 0x3C, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x1E, 0x1E, 0x07, 0xCF, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1F,
  0x78, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x1E, 0x78, 0x0F, 0x9E,
  0x03, 0xC7, 0x81, 0xF1, 0xF0, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x83, 0xE1, 0xF0,
  0x3C, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0xF8, 0xF8, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3E, 0x1E, 0x1E, 0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1F, 0x78,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03,
  0xC7, 0x81, 0xF1, 0xF0, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0x84, 0x01, 0xE3, 0xC0, 0x3D, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x83, 0xE1,
  0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x7C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0x83, 0xF1, 0xE0, 0x18, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x84, 0x01, 0xF1, 0xC0, 0x3C, 0x7C, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0x79,
  0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x03, 0xE3, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00,
  0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1E, 0x7C, 0x03, 0xC7, 0x80, 0xF8,
  0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0x8E, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x78, 0x71, 0xE3,
  0xC3, 0x8F, 0x1E, 0x3C, 0x79, 0xF1, 0xE3, 0xCF, 0x8E, 0x1E, 0x6C, 0x70,
  0xE7, 0x67, 0x87, 0x3B, 0x3C, 0x39, 0x9D, 0xC1, 0xDC, 0xEE, 0x1E, 0xE7,
  0x70, 0xF6, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x1F,
  0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0x8F,
  0x00, 0x1E, 0x7C, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xF7, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x78,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0xC1, 0xF0,
  0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xDE, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x78,
  0x3C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x83,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3C,
  0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x78,
  0xF0, 0x3C, 0x3C, 0x1E, 0x07, 0x07, 0x81, 0xE3, 0xC0, 0x79, 0xE0, 0x0F,
  0x78, 0x03, 0xEC, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x33,
  0xE7, 0x8E, 0x3C, 0x71, 0x80, 0x03, 0xE7, 0x87, 0xFB, 0xC7, 0xFD, 0xE7,
  0xC3, 0xF3, 0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x7C, 0x07, 0xBE, 0x07, 0xDF, 0x03, 0xE7, 0x83, 0xE3, 0xE3, 0xF1, 0xFF,
  0x7E, 0x7F, 0x3F, 0x1F, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x7C, 0x1E,
  0xFF, 0x1F, 0xFF, 0xCF, 0x63, 0xE7, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x01,
  0xE7, 0xC3, 0xF7, 0xFF, 0xF3, 0xCF, 0xF1, 0xE3, 0xE0, 0x03, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3E, 0x1F, 0x7C, 0x0C, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x08, 0xF0, 0x0E, 0xF8, 0x1E, 0x7C,
  0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x1F, 0x1E, 0x0F, 0xF7, 0xC3, 0xFF, 0xF0, 0xF8, 0x3E, 0x1E, 0x03, 0xC7,
  0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0xF8, 0x0F, 0x1F,
  0x01, 0xE3, 0xE0, 0x7C, 0x3C, 0x1F, 0x87, 0xC7, 0xF0, 0xFF, 0xBC, 0x0F,
  0xF7, 0x80, 0xF8, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0x3E, 0x1F,
  0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x7E, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xC0,
  0xF0, 0x00, 0xF0, 0x0C, 0xF8, 0x1E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x08, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xE3,
  0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE3, 0xC3, 0xFD, 0xF1, 0xFF, 0xF8, 0xFC,
  0x3E, 0x3C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x3F, 0x1F, 0x1F, 0xC7,
  0xFD, 0xE0, 0xFF, 0x78, 0x1F, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE1, 0x00,
  0xF0, 0x70, 0x7C, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x7C, 0x1E, 0x7F, 0x0F, 0x7F, 0x8F, 0xE3, 0xE7, 0xE0, 0xF3,
  0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0,
  0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x84, 0x0F, 0x8F, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x60, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x7D, 0xE0, 0x3D,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0xF8, 0x1E, 0x7F, 0x07, 0xBF, 0xE3, 0xF8, 0xF8, 0xFC, 0x1E, 0x3E, 0x07,
  0x8F, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0xF0, 0x7D, 0xF0, 0x1E, 0xF8, 0x07,
  0x9E, 0x09, 0xE3, 0xC7, 0x78, 0xF7, 0x9E, 0x3F, 0xCF, 0x87, 0xE3, 0xC0,
  0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x10, 0x78, 0xF3, 0xE7, 0xCF, 0x3E,
  0x3D, 0xF0, 0xFF, 0x81, 0xFC, 0x03, 0xC0, 0x1C, 0xE1, 0xC7, 0xBE, 0x7C,
  0xFF, 0xDF, 0x9F, 0x3C, 0x73, 0xC7, 0x8E, 0x70, 0xE1, 0xCE, 0x1C, 0x7B,
  0xC7, 0x8F, 0x78, 0xF1, 0xEF, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE7,
  0x0E, 0x3D, 0xE3, 0xC7, 0xBC, 0x78, 0xF7, 0x8E, 0x1C, 0xE1, 0xC3, 0x80,
  0x1E, 0x3E, 0x0F, 0x3F, 0x87, 0xBF, 0xC7, 0xF1, 0xF3, 0xF0, 0x79, 0xF0,
  0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E,
  0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3E, 0x1E, 0x78, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F,
  0x1F, 0x03, 0xDF, 0xE1, 0xFF, 0xFC, 0x7B, 0x1F, 0x1F, 0x03, 0xC7, 0xC0,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C,
  0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x87, 0xE7, 0xFF, 0xF1, 0xE7, 0xF8, 0x78,
  0xF8, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE3, 0xC3, 0xFD, 0xF1, 0xFF, 0xF8,
  0xF8, 0x3E, 0x3C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x78,
  0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C, 0x78, 0x3F, 0x1F, 0x1F,
  0xC7, 0xFD, 0xE0, 0xFE, 0x78, 0x1F, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x7F,
  0x8F, 0xBF, 0xCF, 0xBF, 0xEF, 0xC1, 0xFF, 0xE0, 0xF6, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xE3, 0xE0, 0xE1, 0xE0, 0x21, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xC0,
  0x01, 0xE2, 0x01, 0xF3, 0xC1, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xE0,
  0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x06, 0x1F,
  0x1F, 0x1E, 0x3E, 0x1E, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x3C,
  0x0F, 0x9E, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79,
  0xE0, 0x7C, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07,
  0xCF, 0x07, 0xE7, 0xC5, 0xE3, 0xFE, 0xF0, 0xFE, 0x78, 0x3E, 0x3C, 0x00,
  0x7F, 0x03, 0x3F, 0x87, 0x9F, 0xC3, 0xF1, 0xE0, 0xF1, 0xF0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x07, 0x8F, 0x87, 0xC7,
  0x83, 0xC3, 0xC3, 0xE1, 0xE7, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0x80,
  0x00, 0x38, 0x71, 0x8E, 0x3C, 0xE7, 0x8F, 0x3D, 0xE3, 0x8F, 0x70, 0xE1,
  0xDC, 0x38, 0x77, 0x0E, 0x1D, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x70, 0xEE,
  0x1C, 0x3B, 0x87, 0x0E, 0xE3, 0xC7, 0x39, 0xF1, 0xCF, 0xDC, 0xE3, 0xF3,
  0xF0, 0x78, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0xFE, 0x7E, 0x1F, 0xEF, 0xF7,
  0xEE, 0xCF, 0x38, 0xE8, 0xF3, 0x0F, 0x8F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x0E, 0x1F, 0x08, 0xE1, 0xF1,
  0xCF, 0x37, 0x7E, 0xFE, 0x7F, 0x87, 0xE7, 0xF0, 0x38, 0x3C, 0x00, 0x0F,
  0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0,
  0x3E, 0x1E, 0x07, 0xC3, 0xC1, 0xF8, 0x7C, 0x7E, 0x07, 0xFB, 0xC0, 0xFE,
  0x78, 0x0F, 0x8F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x10, 0x0F, 0x03, 0x87,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xC3, 0xC7, 0xFC,
  0xF3, 0xFF, 0xFC, 0xF0, 0xFE, 0x38, 0x1F, 0x0E, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x80, 0xF8, 0x70, 0x7C, 0x1C, 0x3E,
  0x07, 0xBF, 0xF8, 0xEF, 0xFF, 0xFB, 0xCF, 0xFC, 0xF0, 0x7E, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x7F, 0xC0, 0x7E, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70,
  0x70, 0x70, 0xF0, 0xF0, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x01,
  0xFF, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0x01, 0xC7, 0xE0, 0x73, 0xFC, 0x3D,
  0xE7, 0x8E, 0x71, 0xE7, 0xBC, 0x3F, 0xCE, 0x07, 0xE1, 0x80, 0xF0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 23, 20, 6, -23 },
  { 27, 12, 10, 20, 6, -24 },
  { 42, 21, 23, 20, 0, -23 },
  { 103, 18, 29, 20, 1, -26 },
  { 169, 23, 23, 20, -1, -23 },
  { 236, 20, 23, 20, 0, -23 },
  { 294, 5, 10, 20, 9, -24 },
  { 301, 14, 30, 20, 6, -25 },
  { 354, 14, 30, 20, 1, -25 },
  { 407, 18, 17, 20, 1, -18 },
  { 446, 16, 15, 20, 2, -18 },
  { 476, 9, 10, 20, 4, -5 },
  { 488, 11, 3, 20, 5, -11 },
  { 493, 6, 6, 20, 6, -6 },
  { 498, 20, 30, 20, 0, -25 },
  { 573, 18, 23, 20, 1, -23 },
  { 625, 16, 23, 20, 2, -23 },
  { 671, 18, 23, 20, 1, -23 },
  { 723, 18, 23, 20, 1, -23 },
  { 775, 19, 23, 20, 0, -23 },
  { 830, 18, 23, 20, 1, -23 },
  { 882, 17, 23, 20, 1, -23 },
  { 931, 17, 23, 20, 3, -23 },
  { 980, 18, 23, 20, 1, -23 },
  { 1032, 17, 23, 20, 2, -23 },
  { 1081, 8, 18, 20, 6, -18 },
  { 1099, 10, 23, 20, 4, -18 },
  { 1128, 16, 19, 20, 3, -20 },
  { 1166, 18, 10, 20, 1, -15 },
  { 1189, 16, 19, 20, 2, -20 },
  { 1227, 15, 23, 20, 4, -23 },
  { 1271, 18, 27, 20, 1, -23 },
  { 1332, 19, 23, 20, -1, -23 },
  { 1387, 18, 23, 20, 1, -23 },
  { 1439, 18, 23, 20, 2, -23 },
  { 1491, 18, 23, 20, 1, -23 },
  { 1543, 19, 23, 20, 1, -23 },
  { 1598, 19, 23, 20, 1, -23 },
  { 1653, 17, 23, 20, 2, -23 },
  { 1702, 19, 23, 20, 1, -23 },
  { 1757, 19, 23, 20, 1, -23 },
  { 1812, 18, 23, 20, 1, -23 },
  { 1864, 21, 23, 20, 1, -23 },
  { 1925, 15, 23, 20, 2, -23 },
  { 1969, 21, 23, 20, 0, -23 },
  { 2030, 19, 23, 20, 1, -23 },
  { 2085, 18, 23, 20, 1, -23 },
  { 2137, 19, 23, 20, 1, -23 },
  { 2192, 18, 29, 20, 1, -23 },
  { 2258, 19, 23, 20, 1, -23 },
  { 2313, 19, 23, 20, 1, -23 },
  { 2368, 18, 23, 20, 3, -23 },
  { 2420, 18, 23, 20, 2, -23 },
  { 2472, 19, 23, 20, 3, -23 },
  { 2527, 21, 23, 20, 1, -23 },
  { 2588, 22, 23, 20, -1, -23 },
  { 2652, 19, 23, 20, 3, -23 },
  { 2707, 20, 23, 20, 0, -23 },
  { 2765, 15, 30, 20, 4, -25 },
  { 2822, 9, 30, 20, 6, -25 },
  { 2856, 15, 30, 20, 1, -25 },
  { 2913, 18, 14, 20, 1, -23 },
  { 2945, 16, 3, 20, 0, 3 },
  { 2951, 6, 7, 20, 6, -26 },
  { 2957, 17, 17, 20, 1, -17 },
  { 2994, 17, 24, 20, 1, -24 },
  { 3045, 16, 17, 20, 2, -17 },
  { 3079, 19, 24, 20, 1, -24 },
  { 3136, 16, 17, 20, 2, -17 },
  { 3170, 22, 31, 20, -1, -24 },
  { 3256, 18, 24, 20, 1, -17 },
  { 3310, 17, 24, 20, 1, -24 },
  { 3361, 16, 25, 20, 2, -25 },
  { 3411, 16, 32, 20, 1, -25 },
  { 3475, 18, 24, 20, 1, -24 },
  { 3529, 14, 24, 20, 3, -24 },
  { 3571, 19, 17, 20, 0, -17 },
  { 3612, 17, 17, 20, 1, -17 },
  { 3649, 16, 17, 20, 2, -17 },
  { 3683, 18, 24, 20, 0, -17 },
  { 3737, 18, 24, 20, 1, -17 },
  { 3791, 17, 17, 20, 3, -17 },
  { 3828, 17, 17, 20, 1, -17 },
  { 3865, 16, 23, 20, 2, -23 },
  { 3911, 17, 17, 20, 2, -17 },
  { 3948, 17, 17, 20, 1, -17 },
  { 3985, 18, 17, 20, 1, -17 },
  { 4024, 20, 17, 20, 0, -17 },
  { 4067, 19, 24, 20, 0, -17 },
  { 4124, 18, 17, 20, 1, -17 },
  { 4163, 16, 30, 20, 3, -25 },
  { 4223, 8, 30, 20, 6, -25 },
  { 4253, 16, 30, 20, 1, -25 },
  { 4313, 18, 8, 20, 1, -14 },
};

const GFXfont IBMPlexMono_SemiBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC33PT7B_H_
