#ifndef _IBMPLEXMONO_SEMIBOLDITALIC56PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7,
  0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x7D, 0xFE, 0x07, 0xF8, 0x78, 0x7C,
  0x07, 0xF0, 0x78, 0x38, 0x07, 0xF0, 0xF8, 0x10, 0x0F, 0xE0, 0xF8, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x0F, 0xF0, 0xF0, 0x00,
  0x0F, 0xF0, 0xF0, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xEF, 0xFC, 0x00, 0x03, 0xC3, 0xFC,
  0x00, 0x03, 0xC1, 0xFC, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x07, 0xC1, 0xFC,
  0x00, 0x07, 0xC1, 0xFC, 0x08, 0x07, 0xC1, 0xFC, 0x1C, 0x07, 0xC3, 0xFC,
  0x3E, 0x07, 0x83, 0xF8, 0x7F, 0x07, 0x87, 0xF8, 0xFF, 0xCF, 0x9F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x01, 0xF0,
  0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x1F,
  0x80, 0x1F, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x0F, 0x8F, 0xC0, 0x01, 0xF0, 0x3F, 0x1F,
  0x00, 0x03, 0xF0, 0xFC, 0x7E, 0x00, 0x03, 0xFF, 0xF9, 0xF8, 0x00, 0x07,
  0xFF, 0xE3, 0xE0, 0x00, 0x07, 0xFF, 0x88, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xC7, 0xFF, 0xC0, 0x00, 0x3F, 0x1F,
  0xFF, 0xC0, 0x00, 0x7C, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0xF8, 0x1F, 0x00,
  0x07, 0xE3, 0xF0, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0xF8, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x3E, 0x01,
  0xF0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xF0,
  0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x7E, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x23,
  0xF8, 0x03, 0xF8, 0x3D, 0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0x01, 0xFE, 0x1F,
  0xBF, 0x80, 0xFF, 0x9F, 0x9F, 0xE1, 0xCF, 0xCF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF8, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x04, 0x01, 0xF8, 0x02, 0x7C, 0x0F, 0xC0, 0xF3, 0xFC, 0x7E, 0x3F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0x80,
  0x1E, 0x00, 0x08, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x8F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x7F, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x07, 0x83, 0xFD, 0xFE, 0x1F, 0x87,
  0xFB, 0xFC, 0x7F, 0x0F, 0xF7, 0xF0, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F,
  0x9F, 0xC3, 0xF8, 0xFF, 0x3F, 0x83, 0xE1, 0xFE, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xC7,
  0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xBF, 0x80, 0x1F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFF, 0x3F, 0x80,
  0x7F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0xF8, 0x1F, 0xC0, 0x0E, 0x03, 0xF8, 0x00,
  0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0x80, 0x07, 0xF8, 0x02, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0x81, 0xF8, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xFE,
  0x01, 0x80, 0x03, 0xFC, 0x02, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x02, 0x00, 0x01,
  0xFC, 0x0E, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xC3, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xE3, 0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0xC0, 0x1F, 0x3F,
  0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x09, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x81, 0x80, 0x01, 0xFE,
  0x07, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F,
  0xF0, 0x1F, 0xEF, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0x0F, 0xF7, 0xFF, 0xFC,
  0x7F, 0x7F, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x07, 0xFD, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F,
  0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x1F,
  0xE7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0x80,
  0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xE0,
  0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x3F, 0xFF, 0xF7,
  0xF0, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xF3, 0xF8, 0x0F, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xF9,
  0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0x8F, 0x80, 0x0F, 0xF0, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7C, 0x1F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x03,
  0xE3, 0xF1, 0xF8, 0x1F, 0xE7, 0xC3, 0xF0, 0x7F, 0xEF, 0x87, 0xC1, 0xFF,
  0xDF, 0x1F, 0x87, 0xFF, 0xFE, 0x3F, 0x0F, 0xE1, 0xFC, 0x7E, 0x3F, 0x81,
  0xF8, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0xFC, 0x07, 0xC7, 0xE1, 0xF0, 0x0F,
  0x8F, 0xC7, 0xE0, 0x1F, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0xFC, 0x0F, 0xC7,
  0xE1, 0xF8, 0x1F, 0x8F, 0xC3, 0xF0, 0x7F, 0x1F, 0x87, 0xE0, 0xFE, 0x3F,
  0x0F, 0xE7, 0xFC, 0x7E, 0x1F, 0xFD, 0xF0, 0xFC, 0x1F, 0xFB, 0xE1, 0xF8,
  0x3F, 0xE7, 0xC1, 0xF0, 0x3F, 0x9F, 0x83, 0xE0, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xC1, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0xE1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF,
  0x81, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x02, 0x03, 0xFC,
  0x00, 0x1F, 0x07, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0,
  0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80,
  0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x78, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0xCF, 0xF0,
  0x3F, 0xFF, 0x3F, 0xC0, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xE3, 0xF8, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0xC0, 0x07, 0xF0,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F,
  0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xDF, 0x80, 0x7F, 0xFE, 0x7E, 0x00, 0xFF,
  0xF1, 0xF8, 0x01, 0xFF, 0x8F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x06, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x00,
  0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xCF,
  0xE0, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0xBE, 0x1F, 0x7E, 0x03, 0xF7, 0xE3, 0xEF, 0xC0, 0x7E, 0xFC, 0xF9, 0xF8,
  0x0F, 0xCF, 0xBF, 0x3F, 0x03, 0xF9, 0xF7, 0xCF, 0xE0, 0x7E, 0x3F, 0xF9,
  0xF8, 0x0F, 0xC7, 0xFE, 0x3F, 0x01, 0xF8, 0xFF, 0xC7, 0xE0, 0x3F, 0x0F,
  0xF0, 0xFC, 0x07, 0xE1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x87, 0xF0, 0x3F,
  0x87, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x03, 0xF0,
  0x1F, 0x81, 0xE0, 0x7E, 0x03, 0xF0, 0x38, 0x1F, 0xC0, 0xFE, 0x07, 0x03,
  0xF8, 0x1F, 0xC0, 0xC0, 0x7E, 0x03, 0xF0, 0x08, 0x0F, 0xC0, 0x7E, 0x02,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0xFF,
  0x80, 0x1F, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x7F, 0xF0, 0x07, 0xE0, 0x3F,
  0xF8, 0x03, 0xF0, 0x1F, 0xFC, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0xFC, 0x07,
  0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0x01,
  0xFF, 0xF0, 0x1F, 0x80, 0xFD, 0xF8, 0x0F, 0xC0, 0x7E, 0xFC, 0x07, 0xE0,
  0x3F, 0x3F, 0x07, 0xF0, 0x1F, 0x9F, 0x83, 0xF8, 0x1F, 0xCF, 0xC1, 0xF8,
  0x0F, 0xE7, 0xE0, 0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x03, 0xF0, 0xF8, 0x3F,
  0x01, 0xF8, 0x7E, 0x3F, 0x80, 0xFC, 0x3F, 0x1F, 0xC0, 0xFE, 0x1F, 0x8F,
  0xC0, 0x7F, 0x0F, 0xC7, 0xE0, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x81, 0xF9,
  0xF8, 0x0F, 0xC0, 0xFD, 0xFC, 0x07, 0xE0, 0x7E, 0xFE, 0x07, 0xF0, 0x3F,
  0x7E, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFC, 0x03,
  0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF0, 0x3F, 0x80,
  0x7F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x0F, 0xFC, 0x07, 0xE0,
  0x07, 0xFE, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0x83, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F,
  0x87, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF,
  0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F,
  0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x20, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x38,
  0x07, 0xF0, 0x00, 0x10, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x08, 0x00, 0x03, 0xF8, 0x1C, 0x00, 0x07, 0xF8, 0x3E, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xC1,
  0xF8, 0x1F, 0x83, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0xC1, 0xF0, 0x1F, 0x87,
  0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0xC3, 0xF0, 0x3F, 0x8F, 0xFC, 0x3F, 0x03,
  0xF0, 0xFF, 0xC3, 0xF0, 0x3F, 0x0F, 0x7C, 0x7E, 0x03, 0xF1, 0xF7, 0xC7,
  0xE0, 0x3F, 0x1F, 0x7C, 0x7E, 0x03, 0xF1, 0xE7, 0xC7, 0xE0, 0x3F, 0x3E,
  0x7C, 0x7C, 0x03, 0xF3, 0xE7, 0xCF, 0xC0, 0x3F, 0x3C, 0x7C, 0xFC, 0x03,
  0xF7, 0xC7, 0xCF, 0xC0, 0x7E, 0x7C, 0x7C, 0xF8, 0x07, 0xE7, 0x87, 0xDF,
  0x80, 0x7E, 0x78, 0x7D, 0xF8, 0x07, 0xEF, 0x87, 0xDF, 0x80, 0x7E, 0xF0,
  0x7D, 0xF8, 0x07, 0xEF, 0x07, 0xDF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x03,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x0C, 0x0F, 0x8F, 0xE1,
  0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x78, 0x18, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0x1F, 0xC0, 0x7F, 0xFC, 0xFE, 0x07, 0xFF,
  0xE7, 0xF0, 0x7F, 0xFF, 0xBF, 0x87, 0xFC, 0x1F, 0xFC, 0x7F, 0x80, 0x3F,
  0xC3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F,
  0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x01, 0xFF, 0x0F, 0xE0,
  0x1F, 0xF8, 0x7F, 0x81, 0xFF, 0x83, 0xFE, 0x1D, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x7E, 0x1F, 0xFC, 0x07, 0xF1, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0x81, 0xFD,
  0xFF, 0xFE, 0x0F, 0xEE, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC7, 0xFE, 0x01,
  0xFE, 0x3F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x7F, 0x9F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xFE, 0x0F, 0xFC, 0x7F, 0x7F, 0xFF, 0xC3, 0xF9, 0xFF,
  0xFC, 0x1F, 0xCF, 0xFF, 0xC0, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0x3C, 0x1F, 0xC0, 0x06, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x60,
  0xFE, 0x00, 0x1F, 0x1F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x80,
  0x3F, 0x87, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF,
  0xE1, 0xFC, 0x01, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xFB, 0xFC, 0x07, 0xFF,
  0xFB, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC3,
  0xDF, 0xC0, 0x3F, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF, 0xBF, 0x80, 0x1F, 0xFF,
  0x3F, 0x80, 0x0F, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0xE7, 0xF0, 0x7F, 0xFC, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x07,
  0xF0, 0x00, 0x70, 0x7F, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x03, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xE3, 0xF8, 0x0F,
  0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xDF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0xEF, 0xE0,
  0x3F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0x3F, 0x80, 0x7F, 0xFC, 0x7F, 0x00,
  0x7F, 0xF1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x20,
  0x01, 0xFE, 0x00, 0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0xFF, 0x80, 0x7F, 0x3F, 0xFC, 0x0F, 0xE3, 0xFF, 0xE0, 0xFE,
  0x7F, 0xFF, 0x0F, 0xEE, 0x1F, 0xF0, 0xFE, 0xC0, 0xFF, 0x0F, 0xF8, 0x07,
  0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x80, 0x0F, 0xE0, 0x3C, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83,
  0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07,
  0xF3, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x80,
  0x3F, 0x80, 0x3C, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F,
  0x0F, 0xFC, 0x00, 0xFC, 0x7F, 0xFC, 0x03, 0xF9, 0xFF, 0xFC, 0x07, 0xF3,
  0xFF, 0xF8, 0x0F, 0xEE, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x1F, 0xE0,
  0x03, 0xF9, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x30, 0xFE, 0x1F, 0xE0, 0xF9,
  0xFC, 0x1F, 0xC3, 0xFB, 0xF8, 0x3F, 0x8F, 0xC7, 0xF0, 0x3F, 0xBF, 0x0F,
  0xE0, 0x7F, 0xFE, 0x3F, 0x80, 0x7F, 0xF8, 0x7F, 0x00, 0xFF, 0xE0, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x08, 0x07, 0xF0,
  0x1C, 0x0F, 0xF0, 0x3E, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x7C, 0x07, 0xE3, 0xF8, 0x7F, 0x83, 0xF3, 0xFC,
  0x7F, 0xC1, 0xFB, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0x9F,
  0xF1, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x3F, 0x83, 0xF8, 0x3F, 0x1F, 0x81,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0,
  0x7E, 0x07, 0xE1, 0xF0, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0x7E, 0x1F,
  0x83, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x83, 0xF0,
  0xFC, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x7E,
  0x3F, 0x03, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x0F, 0xF8,
  0x07, 0xF3, 0xFF, 0xC0, 0xFE, 0x3F, 0xFE, 0x0F, 0xE7, 0xFF, 0xF0, 0xFE,
  0xE1, 0xFF, 0x0F, 0xEC, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x0F, 0xF0, 0x07,
  0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xC7, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0xE0, 0x0F,
  0xE3, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xC0, 0x7F,
  0x70, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFE, 0xFF, 0xFF, 0x81,
  0xFC, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0xF8, 0x07, 0xF1, 0xFF, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0x87, 0xF0, 0x1F, 0xFF, 0x3F, 0xC0, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFB,
  0xF8, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F,
  0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0,
  0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0x0F, 0x7F, 0x03, 0xFF, 0xF9, 0xFC, 0x0F,
  0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0x3F, 0x80, 0x3F, 0xF0, 0xFE, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFC, 0x07, 0xFB, 0xFF,
  0x80, 0xFE, 0xF0, 0x00, 0x1F, 0xD8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x03, 0xC0, 0xFE, 0x00, 0x18, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x08,
  0x00, 0x1F, 0xC1, 0xC0, 0x01, 0xFC, 0x3E, 0x00, 0x3F, 0xC7, 0xFC, 0x0F,
  0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x01, 0x00, 0x7F, 0x80, 0x70, 0x0F, 0xE0, 0x1F,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0xFF, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xDF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x02, 0xFE, 0x1F, 0xE0, 0x37,
  0xF0, 0x7F, 0x87, 0x7F, 0x83, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0x9F, 0xC0,
  0x7F, 0xF8, 0xFE, 0x01, 0xFF, 0x87, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0xCF, 0xFF, 0x00, 0x7C, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0x01,
  0xFE, 0xFF, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x7F, 0xC0, 0x3F,
  0x9F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x81, 0xF8, 0x0C,
  0x1F, 0x03, 0xF0, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x0F, 0x83, 0xF1,
  0xF8, 0x1F, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x1F, 0x8F,
  0x81, 0xF8, 0x3F, 0x3F, 0x03, 0xF0, 0x7E, 0x7E, 0x07, 0xC0, 0xFC, 0xFC,
  0x0F, 0x81, 0xF9, 0xF8, 0x3F, 0x03, 0xF3, 0xE0, 0x7E, 0x07, 0xE7, 0xC0,
  0xFC, 0x0F, 0xDF, 0x81, 0xF8, 0x1F, 0xBF, 0x03, 0xF0, 0x3F, 0x7E, 0x07,
  0xC0, 0x7C, 0xFC, 0x0F, 0x80, 0xF9, 0xF8, 0x3F, 0x03, 0xF3, 0xE0, 0x7E,
  0x07, 0xEF, 0xC0, 0xFC, 0x0F, 0x9F, 0x81, 0xF8, 0x3F, 0x3F, 0x07, 0xF0,
  0x7C, 0x7E, 0x1B, 0xE1, 0xF8, 0xFE, 0x77, 0xC3, 0xE1, 0xFF, 0xEF, 0x8F,
  0x81, 0xFF, 0x9F, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x03, 0xF8, 0x3F, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF,
  0xE7, 0xFF, 0x87, 0xFD, 0xF9, 0xC7, 0xF3, 0xFC, 0x3E, 0xE0, 0xFC, 0x7E,
  0x0F, 0xB8, 0x3F, 0x0E, 0x03, 0xEC, 0x0F, 0xC3, 0x00, 0xFF, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x0F, 0xF0, 0x00, 0x3F, 0x03,
  0xFC, 0x06, 0x0F, 0xC0, 0xFF, 0x03, 0xC3, 0xF0, 0x7F, 0xC1, 0xF8, 0xFC,
  0x1B, 0xF1, 0xFF, 0x3F, 0x8E, 0x7C, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x81,
  0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x1B, 0xF8, 0x0F, 0xF0,
  0x77, 0xF0, 0x1F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x3F, 0x80, 0x3F, 0xFC,
  0x7F, 0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x20, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xFE, 0x0F, 0xC3, 0xFF, 0xFE, 0x3F, 0x0F,
  0xFF, 0xFD, 0xFC, 0x7F, 0x07, 0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0x87, 0xC0,
  0x07, 0xFC, 0x1F, 0x00, 0x3F, 0xE0, 0x7C, 0x01, 0xFF, 0x01, 0xF0, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x03, 0x00, 0x1F, 0xF0, 0x3C, 0x00, 0xFF, 0x81, 0xF8, 0x07,
  0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0x3F, 0x0F, 0xF8,
  0x00, 0x7C, 0x7F, 0xFF, 0x01, 0xF3, 0xFF, 0xFF, 0xC7, 0xCF, 0xCF, 0xFF,
  0xFF, 0x3F, 0x0F, 0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0xE3, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x70, 0x0F, 0xFC, 0x00, 0xFC, 0x3F,
  0xFC, 0x01, 0xF0, 0xFF, 0xF8, 0x07, 0xE1, 0xFF, 0xF8, 0x0F, 0x87, 0xE3,
  0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8, 0x7C, 0x07,
  0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xC3, 0xE0, 0x0F, 0xFF, 0x07, 0xC0, 0x07,
  0xFC, 0x03, 0x80, 0x07, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 15, 40, 34, 10, -39 },
  { 76, 21, 17, 34, 9, -41 },
  { 121, 35, 39, 34, 0, -39 },
  { 292, 32, 53, 34, 1, -46 },
  { 504, 39, 41, 34, -2, -40 },
  { 704, 33, 41, 34, 0, -40 },
  { 874, 9, 17, 34, 15, -41 },
  { 894, 23, 51, 34, 10, -43 },
  { 1041, 23, 51, 34, 2, -43 },
  { 1188, 29, 28, 34, 3, -31 },
  { 1290, 27, 27, 34, 4, -31 },
  { 1382, 16, 17, 34, 6, -9 },
  { 1416, 18, 6, 34, 8, -20 },
  { 1430, 11, 10, 34, 10, -9 },
  { 1444, 33, 51, 34, 0, -43 },
  { 1655, 31, 41, 34, 2, -40 },
  { 1814, 27, 39, 34, 3, -39 },
  { 1946, 31, 40, 34, 1, -40 },
  { 2101, 31, 41, 34, 1, -40 },
  { 2260, 32, 39, 34, 0, -39 },
  { 2416, 31, 40, 34, 2, -39 },
  { 2571, 29, 40, 34, 2, -39 },
  { 2716, 29, 39, 34, 5, -39 },
  { 2858, 31, 41, 34, 2, -40 },
  { 3017, 29, 40, 34, 4, -40 },
  { 3162, 14, 30, 34, 10, -29 },
  { 3215, 18, 37, 34, 6, -29 },
  { 3299, 27, 33, 34, 5, -34 },
  { 3411, 29, 18, 34, 3, -26 },
  { 3477, 27, 33, 34, 3, -34 },
  { 3589, 26, 41, 34, 6, -40 },
  { 3723, 31, 46, 34, 2, -40 },
  { 3902, 33, 39, 34, -2, -39 },
  { 4063, 30, 39, 34, 2, -39 },
  { 4210, 30, 41, 34, 3, -40 },
  { 4364, 31, 39, 34, 2, -39 },
  { 4516, 31, 39, 34, 2, -39 },
  { 4668, 32, 39, 34, 2, -39 },
  { 4824, 30, 41, 34, 3, -40 },
  { 4978, 33, 39, 34, 1, -39 },
  { 5139, 31, 39, 34, 2, -39 },
  { 5291, 30, 40, 34, 2, -39 },
  { 5441, 35, 39, 34, 2, -39 },
  { 5612, 26, 39, 34, 3, -39 },
  { 5739, 35, 39, 34, 0, -39 },
  { 5910, 33, 39, 34, 1, -39 },
  { 6071, 31, 41, 34, 2, -40 },
  { 6230, 31, 39, 34, 2, -39 },
  { 6382, 31, 51, 34, 2, -40 },
  { 6580, 31, 39, 34, 2, -39 },
  { 6732, 32, 41, 34, 1, -40 },
  { 6896, 32, 39, 34, 4, -39 },
  { 7052, 31, 40, 34, 3, -39 },
  { 7207, 32, 39, 34, 5, -39 },
  { 7363, 36, 39, 34, 1, -39 },
  { 7539, 38, 39, 34, -2, -39 },
  { 7725, 32, 39, 34, 5, -39 },
  { 7881, 34, 39, 34, 0, -39 },
  { 8047, 26, 51, 34, 7, -43 },
  { 8213, 16, 51, 34, 9, -43 },
  { 8315, 26, 51, 34, 1, -43 },
  { 8481, 30, 24, 34, 2, -39 },
  { 8571, 27, 5, 34, 0, 5 },
  { 8588, 10, 12, 34, 11, -44 },
  { 8603, 29, 31, 34, 2, -30 },
  { 8716, 29, 42, 34, 2, -41 },
  { 8869, 27, 31, 34, 3, -30 },
  { 8974, 32, 42, 34, 2, -41 },
  { 9142, 28, 31, 34, 3, -30 },
  { 9251, 38, 53, 34, -2, -41 },
  { 9503, 31, 42, 34, 1, -30 },
  { 9666, 28, 41, 34, 2, -41 },
  { 9810, 27, 44, 34, 4, -43 },
  { 9959, 28, 55, 34, 1, -43 },
  { 10152, 31, 42, 34, 2, -41 },
  { 10315, 24, 42, 34, 5, -41 },
  { 10441, 33, 30, 34, 0, -30 },
  { 10565, 28, 30, 34, 2, -30 },
  { 10670, 28, 31, 34, 3, -30 },
  { 10779, 31, 41, 34, 0, -30 },
  { 10938, 30, 41, 34, 2, -30 },
  { 11092, 27, 29, 34, 6, -29 },
  { 11190, 28, 31, 34, 2, -30 },
  { 11299, 27, 40, 34, 4, -39 },
  { 11434, 29, 30, 34, 3, -29 },
  { 11543, 28, 30, 34, 3, -29 },
  { 11648, 31, 30, 34, 1, -29 },
  { 11765, 34, 31, 34, 0, -30 },
  { 11897, 31, 41, 34, 1, -29 },
  { 12056, 30, 31, 34, 2, -30 },
  { 12173, 27, 51, 34, 6, -43 },
  { 12346, 15, 51, 34, 10, -43 },
  { 12442, 27, 51, 34, 2, -43 },
  { 12615, 31, 13, 34, 2, -23 },
};

const GFXfont IBMPlexMono_SemiBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC56PT7B_H_
