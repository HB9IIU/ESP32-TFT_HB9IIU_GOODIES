#ifndef _IBMPLEXMONO_SEMIBOLDITALIC65PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE,
  0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x81, 0xFE,
  0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFC,
  0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8,
  0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x3E, 0x7F, 0xC0, 0x7F, 0xE1,
  0xF0, 0xFC, 0x03, 0xFE, 0x0F, 0x83, 0xC0, 0x1F, 0xE0, 0xFC, 0x0C, 0x01,
  0xFE, 0x07, 0xE0, 0x40, 0x0F, 0xF0, 0x3E, 0x00, 0x00, 0x7F, 0x81, 0xF0,
  0x00, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0x00, 0xFF,
  0x87, 0xE0, 0x00, 0x07, 0xFF, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF9, 0xFF, 0xC0, 0x00,
  0x0F, 0xC3, 0xFE, 0x00, 0x00, 0x7C, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0x7F,
  0x80, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0xE0, 0x20, 0x0F,
  0xC1, 0xFF, 0x03, 0x00, 0x7E, 0x0F, 0xF8, 0x3C, 0x03, 0xE0, 0x7F, 0x83,
  0xF0, 0x1F, 0x07, 0xFC, 0x3F, 0xE0, 0xF8, 0x7F, 0xE3, 0xFF, 0xC7, 0xCF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE1,
  0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xC7, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x81,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x3F,
  0x00, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x01, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x7F,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFF, 0x80, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x43, 0xFE, 0x00, 0xFF, 0x01, 0xC7, 0xFC,
  0x01, 0xFE, 0x07, 0xEF, 0xF8, 0x03, 0xFE, 0x0F, 0xEF, 0xF0, 0x0D, 0xFC,
  0x3F, 0x9F, 0xF0, 0x1B, 0xFC, 0xFE, 0x3F, 0xF0, 0xF7, 0xF9, 0xFC, 0x7F,
  0xFF, 0xE7, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC7,
  0xF1, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x9F, 0xE7, 0xF9,
  0xFE, 0x7F, 0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x01,
  0xFC, 0x00, 0x8F, 0x00, 0xFF, 0x00, 0xE3, 0xF8, 0x3F, 0x81, 0xFD, 0xFF,
  0xCF, 0xE3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x00, 0x0F, 0xC1, 0xFF, 0x8F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x1F, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0xF8, 0x1F,
  0xF7, 0xFC, 0x3F, 0x83, 0xFE, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xDF, 0xF0,
  0x7F, 0x0F, 0xFB, 0xFE, 0x0F, 0xC1, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0x9F, 0xE0, 0x01,
  0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFE, 0x3F, 0xC0, 0x0F,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0x80, 0x7F, 0x80, 0x07,
  0x80, 0x7F, 0x80, 0x03, 0x00, 0x7F, 0x80, 0x02, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x01, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0x00,
  0x70, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x20, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x04,
  0x00, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x01, 0xFF,
  0x87, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x0F, 0xFF, 0x00, 0x07, 0xE3, 0xFF, 0xFC, 0x00, 0x7E,
  0x7F, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x20, 0x00, 0x0F, 0xF8, 0x0E, 0x00, 0x00, 0xFF, 0x81, 0xF0,
  0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xFC,
  0x7F, 0xF8, 0x07, 0xFC, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0x83, 0xFE,
  0xFF, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF,
  0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0x80,
  0x01, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFC, 0x7F, 0xFF, 0xFB, 0xFE, 0x1F, 0xFF, 0xFD, 0xFF, 0x07, 0xFF,
  0xFD, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0x80, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x7F, 0xC0, 0x1F, 0xF9, 0xFE,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xC7, 0xC0, 0x01, 0xFF, 0x06, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x3E, 0x1F, 0xC7,
  0xF0, 0x1F, 0xF3, 0xF8, 0xFE, 0x07, 0xFE, 0x7F, 0x3F, 0x81, 0xFF, 0xEF,
  0xC7, 0xF0, 0x7F, 0xFD, 0xF8, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0x83, 0xFC,
  0x1F, 0xE7, 0xF0, 0x7F, 0x01, 0xFC, 0xFE, 0x1F, 0xC0, 0x3F, 0x9F, 0xC3,
  0xF8, 0x07, 0xE3, 0xF8, 0x7F, 0x00, 0xFC, 0x7F, 0x1F, 0xC0, 0x1F, 0x9F,
  0xC3, 0xF8, 0x03, 0xF3, 0xF8, 0x7F, 0x00, 0xFE, 0x7F, 0x0F, 0xE0, 0x1F,
  0xCF, 0xE1, 0xFC, 0x03, 0xF1, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x07, 0xE0,
  0x1F, 0xC7, 0xE0, 0xFC, 0x03, 0xF8, 0xFC, 0x1F, 0x80, 0xFF, 0x1F, 0x83,
  0xF8, 0x3F, 0xE3, 0xF0, 0x7F, 0x8F, 0xF8, 0x7E, 0x0F, 0xFF, 0xBF, 0x0F,
  0xC0, 0xFF, 0xF7, 0xE1, 0xF8, 0x1F, 0xFD, 0xFC, 0x3F, 0x01, 0xFF, 0x3F,
  0x87, 0xE0, 0x3F, 0xC7, 0xF0, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x3C, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xC0,
  0x1F, 0xE0, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF8, 0x3F,
  0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3C, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xE3, 0xFE, 0x03,
  0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xF3, 0xFE,
  0x01, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0xF1,
  0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xEF, 0xE0,
  0x3F, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xEF,
  0xF0, 0x07, 0xFF, 0xF9, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xC0, 0x07, 0xFF,
  0x87, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xDF, 0xF0, 0x00, 0x03, 0xFF, 0xCF,
  0xFC, 0x00, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0x0F,
  0xEF, 0xE0, 0x1F, 0xDF, 0xCF, 0xEF, 0xE0, 0x1F, 0xEF, 0xE7, 0xE7, 0xF0,
  0x0F, 0xE3, 0xF7, 0xF3, 0xF8, 0x07, 0xF1, 0xFF, 0xF1, 0xFC, 0x03, 0xF8,
  0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xFC,
  0x7F, 0x00, 0xFF, 0x0F, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xFE, 0x1F, 0xC0,
  0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0x81,
  0xFC, 0x03, 0xFC, 0x0F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x60, 0x1F, 0xC0, 0x3F, 0xC0, 0x20, 0x0F, 0xE0, 0x1F, 0xE0, 0x10, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x00, 0xFE,
  0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0xF0,
  0x03, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0xFC, 0x00, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0xFC, 0x03,
  0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0x03, 0xFB,
  0xF8, 0x07, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xFC,
  0x0F, 0xF3, 0xF8, 0x1F, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x03, 0xF8, 0xFE,
  0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x87,
  0xF0, 0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xF0,
  0x3F, 0x8F, 0xE0, 0x3F, 0x81, 0xFC, 0xFF, 0x03, 0xFC, 0x0F, 0xE7, 0xF8,
  0x1F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF0, 0x0F,
  0xEF, 0xE0, 0x3F, 0x80, 0x7F, 0x7F, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xE0,
  0x07, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0x80, 0x07, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xE0, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xE0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0x00,
  0x00, 0x7F, 0x80, 0x30, 0x00, 0x0F, 0xF8, 0x0F, 0x00, 0x00, 0xFF, 0x83,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE0, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0xFF, 0x80, 0x00,
  0x60, 0x07, 0xF8, 0x00, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x01,
  0x00, 0x00, 0x1F, 0xF0, 0x18, 0x00, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0x07,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xFC,
  0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0x07, 0xF0, 0x1F, 0xC1, 0xFF, 0xC1, 0xFC,
  0x07, 0xF0, 0x7F, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xEF, 0xC3, 0xF8, 0x07, 0xF0, 0xFB,
  0xF0, 0xFC, 0x01, 0xFC, 0x7E, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x3F, 0x1F,
  0xC0, 0x3F, 0x87, 0xCF, 0xC7, 0xF0, 0x0F, 0xE3, 0xF3, 0xF1, 0xFC, 0x03,
  0xF8, 0xF8, 0xFC, 0x7E, 0x00, 0xFE, 0x3E, 0x3F, 0x3F, 0x80, 0x3F, 0x9F,
  0x8F, 0xCF, 0xE0, 0x0F, 0xE7, 0xC3, 0xF3, 0xF8, 0x03, 0xF9, 0xF0, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x3F, 0x7F, 0x00, 0x3F, 0xBE, 0x0F, 0xDF, 0xC0,
  0x0F, 0xCF, 0x83, 0xF7, 0xF0, 0x07, 0xF7, 0xE0, 0xFD, 0xF8, 0x01, 0xFD,
  0xF0, 0x3F, 0x7E, 0x00, 0x7F, 0x7C, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x01, 0xE0, 0x10, 0x00,
  0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF0, 0x02, 0x01, 0xC0, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0x80, 0x80,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0x1F,
  0xE0, 0x7F, 0xFF, 0x8F, 0xF0, 0x7F, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xF7,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xFC, 0x3F,
  0xE0, 0x0F, 0xFE, 0x1F, 0xF0, 0x0E, 0xFF, 0x07, 0xFE, 0x1F, 0x7F, 0xFB,
  0xFF, 0xFF, 0x3F, 0xF9, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xF0, 0xFF, 0xF0, 0x07, 0xF8, 0x7F,
  0xFE, 0x01, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0xF0, 0x1F, 0xEF,
  0xFF, 0xFE, 0x07, 0xFB, 0xC1, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0xF0, 0x7F, 0xBF, 0xFF, 0xF8,
  0x3F, 0xE7, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x1F, 0xF0, 0x01, 0xF8, 0x3F, 0xC0, 0x01, 0xC0, 0xFF, 0x80, 0x02,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x7F,
  0x80, 0x00, 0xF8, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0x83, 0xFC, 0x00, 0xFF,
  0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0xFF, 0x7F, 0x80,
  0x7F, 0xFF, 0xF7, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0xF7, 0xF8, 0x07,
  0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xFC, 0x7F,
  0x80, 0x1F, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x1F, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x07,
  0xFF, 0x7F, 0xC1, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x60,
  0xFF, 0x00, 0x00, 0xF1, 0xFF, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x04, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xE0, 0x3F,
  0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x0E,
  0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0xFD, 0xFE, 0x00, 0xFF,
  0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xF1, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xE0,
  0x01, 0xFF, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0xFF, 0x80,
  0x1E, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x1F, 0x80, 0x07, 0xF8, 0x3F, 0xF8, 0x03, 0xFC, 0x7F, 0xFE, 0x03, 0xFE,
  0x7F, 0xFF, 0x81, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0xE0, 0x7F,
  0xBC, 0x1F, 0xF8, 0x3F, 0xD8, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x01, 0x80, 0x07, 0xF8,
  0x07, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x7F,
  0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x10, 0x01, 0xFE, 0x00, 0x1C, 0x00,
  0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0xC1, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0xCF, 0xFF,
  0xF0, 0x07, 0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xF8, 0x07, 0xFB,
  0xC1, 0xFF, 0x80, 0x7F, 0xB0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x01, 0xFE, 0x3F, 0xF0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x10, 0x3F, 0xC3, 0xFE, 0x03, 0xC3,
  0xFC, 0x1F, 0xE0, 0x7E, 0x3F, 0xC1, 0xFF, 0x0F, 0xF7, 0xFC, 0x0F, 0xF1,
  0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC7, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0x80,
  0x7F, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x10, 0x07, 0xFC, 0x03, 0x80,
  0x7F, 0x80, 0x7E, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0xF8, 0x07, 0xE0, 0x1F, 0xC7, 0xF8, 0x3F, 0xE0, 0x7F,
  0x3F, 0xE1, 0xFF, 0x81, 0xFD, 0xFF, 0xCF, 0xFF, 0x07, 0xE7, 0xFF, 0x7F,
  0xFC, 0x3F, 0xBF, 0xFD, 0xFF, 0xF0, 0xFE, 0x87, 0xFE, 0x3F, 0xC3, 0xFC,
  0x1F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0x3F,
  0x87, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x07, 0xE1,
  0xFC, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x01,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0xE0,
  0x7F, 0x8F, 0xFF, 0xF0, 0x3F, 0xCF, 0xFF, 0xF8, 0x1F, 0xEF, 0x07, 0xFE,
  0x0F, 0xF6, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x3F,
  0xC3, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xF0, 0x01, 0xFE, 0x1F, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xFC, 0x01,
  0xFE, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xFE, 0x01, 0xFE, 0xF0, 0x7F,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xFE,
  0x03, 0xFE, 0x7F, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0xF0, 0x03, 0xFC, 0x1F,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF,
  0xC7, 0xFC, 0x0F, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xFF, 0x7F, 0x81, 0xFF,
  0xFF, 0xDF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0xF7, 0xF8, 0x1F, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFE, 0x7F,
  0x80, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xC3,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xBF, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF, 0xF0,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFA, 0x01, 0xFE,
  0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xB8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x78, 0x0F, 0xF0, 0x00, 0x30, 0x0F, 0xF0, 0x00, 0x20, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x08, 0x00,
  0x03, 0xFC, 0x1C, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x20, 0x01, 0xFE,
  0x00, 0x70, 0x01, 0xFE, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE,
  0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC,
  0x7F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0x80, 0x1F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x1D,
  0xFE, 0x0F, 0xFC, 0x1E, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0x81, 0xFF, 0xFE,
  0x7F, 0xC0, 0x7F, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0x1F, 0xE0, 0x07, 0xFE,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0C, 0x3F,
  0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xC0, 0x7F, 0xEF,
  0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x03, 0xFC,
  0x1F, 0xF8, 0x01, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x60, 0xFE, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0x0F,
  0xC0, 0x7E, 0x07, 0xF1, 0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x03,
  0xF1, 0xFC, 0x0F, 0xE0, 0x3F, 0x1F, 0x80, 0xFE, 0x03, 0xF1, 0xF8, 0x0F,
  0xE0, 0x3F, 0x1F, 0x80, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xC0, 0x3F, 0x3F,
  0x80, 0xFC, 0x03, 0xF3, 0xF8, 0x1F, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0x07,
  0xF3, 0xF0, 0x1F, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0x07, 0xF7, 0xF0, 0x1F,
  0x80, 0x7E, 0x7F, 0x01, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x80, 0xFE, 0x7F,
  0x03, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0x7E, 0x03, 0xF8, 0x1F,
  0xC7, 0xE0, 0x7F, 0x81, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF,
  0x03, 0xF0, 0xFF, 0x1D, 0xF8, 0x7F, 0x07, 0xFF, 0xDF, 0x8F, 0xE0, 0x7F,
  0xF9, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF,
  0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0x3F, 0x3C, 0x7F, 0x9F, 0xFC, 0x7E, 0x70,
  0x7F, 0x1F, 0xE0, 0xFD, 0xC0, 0xFE, 0x1F, 0x81, 0xFB, 0x81, 0xFC, 0x1C,
  0x03, 0xFE, 0x03, 0xF8, 0x30, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0xFF,
  0x80, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x60, 0xFE, 0x03, 0xFE, 0x01, 0xE1,
  0xFC, 0x0E, 0xFC, 0x0F, 0xE3, 0xF8, 0x1D, 0xF8, 0x3F, 0xC7, 0xF0, 0x73,
  0xF0, 0xFF, 0xCF, 0xF1, 0xE7, 0xF7, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xF8,
  0x3F, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF0,
  0x0D, 0xFE, 0x01, 0xFF, 0x83, 0xDF, 0xE0, 0x0F, 0xFF, 0xF9, 0xFE, 0x00,
  0xFF, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0xC3, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x01, 0xFF,
  0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x81, 0xFC, 0x07, 0xFF,
  0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFF, 0xFD, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFE,
  0x0F, 0xC0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x1F,
  0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x02, 0x00, 0x07, 0xFE, 0x01, 0xE0, 0x01, 0xFF, 0x80,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF8, 0x01, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xF0, 0x00, 0x7E, 0x3F,
  0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xFF, 0xF1, 0xF8, 0xFE, 0xFF, 0xFF, 0xFF,
  0x3F, 0xC7, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0xF8, 0xFE, 0x00, 0xFF,
  0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x03, 0xFF,
  0xC0, 0x07, 0xE0, 0x7F, 0xFE, 0x00, 0x7E, 0x0F, 0xFF, 0xF0, 0x0F, 0xE1,
  0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0xC1,
  0xFC, 0x3F, 0x01, 0xFE, 0x3F, 0x87, 0xF0, 0x1F, 0xFF, 0xF0, 0x7E, 0x00,
  0xFF, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xFC, 0x0F,
  0xC0, 0x01, 0xFF, 0x80, 0x1C, 0x00, 0x0F, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 18, 46, 39, 11, -45 },
  { 105, 24, 20, 39, 11, -48 },
  { 165, 41, 45, 39, 0, -45 },
  { 396, 37, 61, 39, 1, -53 },
  { 679, 45, 47, 39, -2, -46 },
  { 944, 39, 47, 39, 0, -46 },
  { 1174, 10, 20, 39, 18, -48 },
  { 1199, 26, 58, 39, 12, -49 },
  { 1388, 27, 58, 39, 2, -49 },
  { 1584, 34, 33, 39, 3, -36 },
  { 1725, 32, 32, 39, 4, -36 },
  { 1853, 18, 21, 39, 7, -11 },
  { 1901, 22, 7, 39, 9, -23 },
  { 1921, 13, 12, 39, 11, -11 },
  { 1941, 38, 58, 39, 1, -49 },
  { 2217, 35, 47, 39, 3, -46 },
  { 2423, 32, 45, 39, 3, -45 },
  { 2603, 36, 46, 39, 1, -46 },
  { 2810, 36, 47, 39, 1, -46 },
  { 3022, 36, 45, 39, 1, -45 },
  { 3225, 36, 46, 39, 2, -45 },
  { 3432, 33, 46, 39, 3, -45 },
  { 3622, 35, 45, 39, 5, -45 },
  { 3819, 36, 47, 39, 2, -46 },
  { 4031, 33, 46, 39, 5, -46 },
  { 4221, 17, 35, 39, 11, -34 },
  { 4296, 21, 44, 39, 7, -34 },
  { 4412, 32, 38, 39, 5, -39 },
  { 4564, 34, 20, 39, 3, -30 },
  { 4649, 32, 38, 39, 3, -39 },
  { 4801, 30, 47, 39, 7, -46 },
  { 4978, 35, 53, 39, 3, -46 },
  { 5210, 37, 45, 39, -2, -45 },
  { 5419, 35, 45, 39, 2, -45 },
  { 5616, 35, 47, 39, 4, -46 },
  { 5822, 36, 45, 39, 2, -45 },
  { 6025, 36, 45, 39, 3, -45 },
  { 6228, 37, 45, 39, 3, -45 },
  { 6437, 35, 47, 39, 3, -46 },
  { 6643, 37, 45, 39, 2, -45 },
  { 6852, 37, 45, 39, 2, -45 },
  { 7061, 35, 46, 39, 2, -45 },
  { 7263, 41, 45, 39, 2, -45 },
  { 7494, 30, 45, 39, 4, -45 },
  { 7663, 41, 45, 39, 0, -45 },
  { 7894, 37, 45, 39, 2, -45 },
  { 8103, 35, 47, 39, 3, -46 },
  { 8309, 35, 45, 39, 3, -45 },
  { 8506, 35, 59, 39, 3, -46 },
  { 8765, 35, 45, 39, 3, -45 },
  { 8962, 37, 47, 39, 1, -46 },
  { 9180, 37, 45, 39, 5, -45 },
  { 9389, 36, 46, 39, 4, -45 },
  { 9596, 36, 45, 39, 6, -45 },
  { 9799, 42, 45, 39, 1, -45 },
  { 10036, 44, 45, 39, -2, -45 },
  { 10284, 38, 45, 39, 5, -45 },
  { 10498, 40, 45, 39, 0, -45 },
  { 10723, 30, 58, 39, 8, -49 },
  { 10941, 18, 58, 39, 11, -49 },
  { 11072, 29, 58, 39, 2, -49 },
  { 11283, 34, 28, 39, 3, -45 },
  { 11402, 33, 6, 39, -1, 6 },
  { 11427, 11, 15, 39, 13, -52 },
  { 11448, 33, 35, 39, 3, -34 },
  { 11593, 34, 49, 39, 2, -48 },
  { 11802, 31, 35, 39, 4, -34 },
  { 11938, 36, 49, 39, 3, -48 },
  { 12159, 31, 35, 39, 4, -34 },
  { 12295, 44, 62, 39, -2, -48 },
  { 12636, 36, 48, 39, 1, -34 },
  { 12852, 33, 48, 39, 2, -48 },
  { 13050, 31, 50, 39, 5, -49 },
  { 13244, 33, 63, 39, 1, -49 },
  { 13504, 36, 49, 39, 2, -48 },
  { 13725, 28, 49, 39, 6, -48 },
  { 13897, 38, 34, 39, 0, -34 },
  { 14059, 33, 34, 39, 2, -34 },
  { 14200, 33, 35, 39, 3, -34 },
  { 14345, 36, 47, 39, 0, -34 },
  { 14557, 34, 47, 39, 3, -34 },
  { 14757, 33, 34, 39, 6, -34 },
  { 14898, 32, 35, 39, 3, -34 },
  { 15038, 32, 46, 39, 4, -45 },
  { 15222, 33, 35, 39, 4, -34 },
  { 15367, 33, 35, 39, 3, -34 },
  { 15512, 36, 35, 39, 1, -34 },
  { 15670, 39, 35, 39, 0, -34 },
  { 15841, 36, 48, 39, 1, -34 },
  { 16057, 35, 35, 39, 2, -34 },
  { 16211, 31, 58, 39, 7, -49 },
  { 16436, 16, 58, 39, 12, -49 },
  { 16552, 31, 58, 39, 2, -49 },
  { 16777, 36, 15, 39, 2, -27 },
};

const GFXfont IBMPlexMono_SemiBoldItalic65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC65PT7B_H_
