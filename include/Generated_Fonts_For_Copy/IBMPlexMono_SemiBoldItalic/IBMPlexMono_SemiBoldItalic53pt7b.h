#ifndef _IBMPLEXMONO_SEMIBOLDITALIC53PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0xF8, 0x00, 0x1F, 0x83, 0xF3, 0xF0,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0x3C, 0xFE, 0x07, 0xF0, 0xF0, 0xF0, 0x3F, 0x83,
  0xC1, 0x80, 0xFE, 0x1F, 0x04, 0x03, 0xF8, 0x7C, 0x00, 0x0F, 0xE1, 0xF0,
  0x00, 0x3F, 0x87, 0x80, 0x00, 0xFE, 0x1E, 0x00, 0x03, 0xFE, 0x78, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xDF, 0xF0, 0x00, 0x1E,
  0x1F, 0xC0, 0x00, 0x78, 0x7F, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x07, 0x83,
  0xF0, 0x40, 0x3E, 0x0F, 0xC1, 0x80, 0xF8, 0x7F, 0x0F, 0x03, 0xC1, 0xFC,
  0x7F, 0x0F, 0x0F, 0xE3, 0xFF, 0x3C, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x3F,
  0xFC, 0x00, 0x7C, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x3E,
  0x01, 0xF8, 0x7C, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xE1, 0xF8, 0x01,
  0xF0, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0xF8, 0x00, 0x7C, 0x0F, 0x8F,
  0xC0, 0x03, 0xE0, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0xC7, 0xC0, 0x00, 0xFF,
  0xFE, 0x7E, 0x00, 0x03, 0xFF, 0xE3, 0xE0, 0x00, 0x1F, 0xFE, 0x20, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0xFF, 0xFC, 0x00,
  0x07, 0xC7, 0xFF, 0xE0, 0x00, 0x7E, 0x7E, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x7C, 0x00, 0x3E, 0x1F, 0x03, 0xE0, 0x03, 0xF1, 0xF0, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x07,
  0xE3, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0xF8, 0x07,
  0xC0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0xF8, 0x02, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x18, 0xFE, 0x01,
  0xF8, 0x1E, 0xFE, 0x01, 0xFC, 0x3F, 0xFE, 0x03, 0xFC, 0x3E, 0x7F, 0x03,
  0x7E, 0x7C, 0x7F, 0x86, 0x7E, 0xFC, 0x7F, 0xFE, 0x7F, 0xF8, 0x3F, 0xFE,
  0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xE0,
  0x07, 0x80, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0xFC, 0x07, 0x3F, 0x0F, 0xC3, 0xF3,
  0xFC, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xF1, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0x8F,
  0xF7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x3C, 0x1F,
  0xDF, 0xC3, 0xF0, 0xFE, 0xFE, 0x3F, 0x8F, 0xF7, 0xF1, 0xFC, 0x7F, 0xFF,
  0x8F, 0xE3, 0xFB, 0xF8, 0x3E, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xC7, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xBF, 0x00, 0x1F, 0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x03, 0xC0, 0xFE, 0x00, 0x30, 0x1F, 0xC0, 0x04,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0x70,
  0x00, 0xFE, 0x00, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x7E, 0x00, 0xFF, 0x01, 0xC0, 0x03,
  0xF8, 0x04, 0x00, 0x1F, 0xC0, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x00,
  0xFE, 0x0E, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x07,
  0xF0, 0x00, 0x7C, 0x7F, 0xF0, 0x03, 0xF3, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF,
  0xC0, 0x3E, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFC,
  0x1F, 0xC0, 0x0F, 0xF0, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x01, 0x00, 0x03, 0xFC, 0x0E, 0x00, 0x0F, 0xE0, 0xF8, 0x00,
  0x7F, 0x87, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x07, 0xF9, 0xFF, 0x80, 0xFE,
  0x7F, 0xFC, 0x3F, 0xDF, 0xFF, 0x87, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF8, 0x3F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF7, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0xC7, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8,
  0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE1, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFB, 0xFF, 0x03, 0xFF, 0x3F, 0xFF, 0xEF, 0xE7, 0xFF, 0xFB, 0xF8,
  0x7F, 0xFF, 0x7F, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xE3, 0xF8, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x3C,
  0x00, 0x7F, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x03, 0xE3,
  0xF1, 0xF0, 0x3F, 0xDF, 0x9F, 0x83, 0xFE, 0xFC, 0xFC, 0x3F, 0xFF, 0xC7,
  0xC3, 0xFF, 0xFE, 0x3E, 0x1F, 0xC3, 0xF3, 0xF0, 0xFC, 0x1F, 0x9F, 0x8F,
  0xC0, 0x7C, 0xFC, 0x7E, 0x07, 0xE7, 0xE3, 0xE0, 0x3E, 0x3E, 0x3F, 0x01,
  0xF1, 0xF1, 0xF8, 0x0F, 0x8F, 0x8F, 0xC0, 0x7C, 0xFC, 0x7E, 0x07, 0xE7,
  0xE3, 0xF0, 0x3F, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0xFC, 0x1F, 0x8F, 0x87,
  0xF7, 0xFC, 0x7C, 0x1F, 0xFB, 0xE3, 0xE0, 0xFF, 0xFF, 0x1F, 0x07, 0xFD,
  0xF8, 0xFC, 0x1F, 0xCF, 0x83, 0xE0, 0x30, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0,
  0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xE3, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x06, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x01, 0xFC, 0x00, 0x1E,
  0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0,
  0x01, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE1,
  0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07,
  0xF3, 0xF8, 0x00, 0x70, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x03, 0xFF, 0xEF, 0xE0, 0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xCF,
  0xE0, 0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFC, 0xFE, 0x00,
  0x0F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xBF,
  0x03, 0xFF, 0xF3, 0xF0, 0x1F, 0xFE, 0x7F, 0x00, 0xFF, 0xC7, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x04, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80,
  0x07, 0xF0, 0x7F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x87, 0xDF, 0x81, 0xF7, 0xE7, 0xEF, 0x80, 0xF9, 0xF3, 0xEF,
  0xC0, 0xFC, 0xFB, 0xF7, 0xE0, 0x7E, 0x7D, 0xF3, 0xF0, 0x3F, 0x3F, 0xF9,
  0xF8, 0x1F, 0x9F, 0xF8, 0xFC, 0x0F, 0xC7, 0xF8, 0x7C, 0x07, 0xC3, 0xFC,
  0x7E, 0x07, 0xE1, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x1F, 0x81, 0xF8, 0x3E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0x07, 0xE0, 0x3F, 0x07,
  0x83, 0xF0, 0x3F, 0x03, 0x81, 0xF8, 0x1F, 0x80, 0xC0, 0xFC, 0x0F, 0xC0,
  0x40, 0x7E, 0x07, 0xE0, 0x40, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x7E,
  0x07, 0xFC, 0x00, 0xFC, 0x0F, 0xF8, 0x01, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0x3F, 0xF0, 0x0F, 0xC0, 0x7F, 0xE0, 0x1F, 0x81, 0xFF, 0xC0, 0x3F, 0x03,
  0xFF, 0x80, 0x7E, 0x07, 0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x01, 0xF8, 0x1F,
  0xFE, 0x07, 0xE0, 0x3F, 0x7C, 0x0F, 0xC0, 0xFC, 0xF8, 0x1F, 0x81, 0xF9,
  0xF8, 0x3F, 0x03, 0xF3, 0xF0, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x0F, 0xC7,
  0xC3, 0xF0, 0x1F, 0x8F, 0x87, 0xE0, 0x7E, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F,
  0x1F, 0x81, 0xF8, 0x7E, 0x3F, 0x03, 0xF0, 0x7C, 0x7E, 0x07, 0xE0, 0xF9,
  0xF8, 0x0F, 0xC1, 0xFB, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0x07, 0xEF,
  0xC0, 0xFC, 0x0F, 0xDF, 0x81, 0xF8, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFC,
  0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0x80, 0x7F, 0xF0, 0x3F, 0x00, 0xFF, 0xE0,
  0x7E, 0x00, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0x81, 0xF8, 0x03, 0xFE, 0x03,
  0xF0, 0x07, 0xFC, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x3F, 0xC7, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xE1, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xF8,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE,
  0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x02, 0x00, 0x03, 0xF0, 0x18, 0x00, 0x1F,
  0xC1, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x3F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x60, 0x1F, 0xC0, 0x01, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x0F, 0xF0, 0x60,
  0x00, 0x3F, 0x83, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0xC0,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0xFE, 0x0F, 0x81, 0xF8, 0x3F, 0x83, 0xE0, 0x7C, 0x1F, 0xE1, 0xF8,
  0x1F, 0x07, 0xF8, 0x7E, 0x0F, 0xC1, 0xFE, 0x1F, 0x83, 0xF0, 0xFF, 0x87,
  0xC0, 0xFC, 0x3F, 0xE3, 0xF0, 0x3F, 0x0F, 0xF8, 0xFC, 0x0F, 0xC7, 0xFE,
  0x3F, 0x03, 0xF1, 0xEF, 0x8F, 0x80, 0xFC, 0x7B, 0xE3, 0xE0, 0x3E, 0x3E,
  0xF9, 0xF8, 0x0F, 0x8F, 0x3E, 0x7E, 0x03, 0xE3, 0xCF, 0x9F, 0x01, 0xF9,
  0xF3, 0xE7, 0xC0, 0x7E, 0x78, 0xFB, 0xF0, 0x1F, 0x9E, 0x3E, 0xFC, 0x07,
  0xEF, 0x8F, 0xBE, 0x01, 0xFB, 0xC3, 0xEF, 0x80, 0x7E, 0xF0, 0xFB, 0xE0,
  0x1F, 0x7C, 0x3F, 0xF8, 0x07, 0xDE, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3,
  0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x07, 0x87, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xFC, 0x7F, 0x03, 0xFF, 0xC7, 0xE0, 0x7F, 0xFE, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0x8F,
  0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x07, 0xE0, 0x0F, 0xF0,
  0x7F, 0x01, 0xFF, 0x07, 0xF8, 0x77, 0xFE, 0x7F, 0xFF, 0x7F, 0xE3, 0xFF,
  0xE7, 0xFE, 0x3F, 0xFC, 0x3F, 0xC1, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE3, 0xFF, 0x00, 0xFE,
  0x7F, 0xF8, 0x0F, 0xCF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFC, 0x1F, 0xDC, 0x1F,
  0xE1, 0xFF, 0x80, 0xFE, 0x1F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0x7E, 0x1F,
  0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x07, 0xF8,
  0xFF, 0xC0, 0xFF, 0x0F, 0xEF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFE, 0x0F, 0xE7,
  0xFF, 0xC0, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0x7E, 0x3F, 0x80, 0x3C, 0x3F, 0x80,
  0x08, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x1F, 0xC0, 0x03, 0xC7,
  0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFF, 0x83, 0xFC,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x01, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0x7F,
  0x03, 0xFF, 0xFD, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x83,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x81, 0xFC, 0x06, 0xFE, 0x07,
  0xF8, 0x3B, 0xF0, 0x1F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0x7F, 0x00, 0xFF,
  0xF9, 0xFC, 0x01, 0xFF, 0x87, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xF9, 0xFC, 0x1F,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x83,
  0xF8, 0x00, 0x30, 0x7E, 0x00, 0x1F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF1, 0xFF, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x20, 0x1F, 0xC0, 0x00, 0x0E, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xE1, 0xF8, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x1F, 0xC0, 0x7F, 0xFC, 0xFE, 0x07,
  0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xBF, 0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x7F,
  0x83, 0xF8, 0x07, 0xFC, 0x1F, 0xC0, 0x7F, 0xE0, 0xFF, 0x07, 0x7F, 0x03,
  0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0x9F, 0x80, 0x7F, 0xF9, 0xFC, 0x01, 0xFF,
  0x8F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x02, 0x00, 0x1F, 0xC0, 0x18, 0x00, 0xFE, 0x01,
  0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0xFE, 0x3F, 0xF0, 0x1F, 0xCF, 0xFF, 0x03, 0xFB, 0xFF,
  0xF0, 0x7E, 0x7F, 0xFE, 0x0F, 0xDC, 0x3F, 0xC3, 0xFB, 0x03, 0xFC, 0x7F,
  0xC0, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8,
  0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x40, 0x1F, 0xC0, 0x70, 0x0F, 0xE0, 0x7E, 0x07,
  0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0xFF, 0x00,
  0x7E, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x06, 0x01, 0xFC, 0x01, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x1F, 0xF0, 0x07,
  0xF3, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0x01, 0xF9, 0xFF, 0xF8, 0x0F, 0xDC,
  0x3F, 0xE0, 0xFE, 0xC0, 0x7F, 0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFE, 0x00, 0x7E, 0x7F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x7F, 0x01, 0x0F, 0xE3, 0xF8, 0x1C, 0x7F, 0x0F, 0xE1, 0xF3,
  0xF0, 0x7F, 0x1F, 0xDF, 0x81, 0xF9, 0xF9, 0xFC, 0x0F, 0xFF, 0x8F, 0xE0,
  0x3F, 0xF8, 0x7F, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0x80, 0xFE, 0x07,
  0x81, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x87, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x7F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0xF8,
  0x1F, 0x9F, 0xC7, 0xF8, 0x3F, 0x7F, 0x8F, 0xF8, 0x7D, 0xFF, 0x3F, 0xF0,
  0xFB, 0xFF, 0xFF, 0xE1, 0xFC, 0x7F, 0x8F, 0xC7, 0xF0, 0xFE, 0x1F, 0x8F,
  0xC1, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x3E, 0x07, 0xE0, 0xFC, 0x7C,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x03, 0xE3, 0xF0, 0x7E, 0x07, 0xC7, 0xE0,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F, 0x03, 0xE0, 0x7E, 0x3E, 0x07,
  0xC0, 0xF8, 0xFC, 0x0F, 0x81, 0xF1, 0xF8, 0x3F, 0x03, 0xE3, 0xF0, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0x3F, 0x1F, 0x03, 0xE0,
  0x7C, 0x7E, 0x07, 0xC0, 0xF8, 0xFC, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0x7F, 0xE0, 0x3F, 0x9F, 0xFE, 0x07, 0xF7, 0xFF, 0xE0, 0xFC,
  0xFF, 0xFC, 0x1F, 0xB8, 0x7F, 0x87, 0xF6, 0x07, 0xF8, 0xFF, 0x80, 0x7F,
  0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x07, 0xFC, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFE,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xE3, 0xFF, 0x00, 0x3F, 0x9F, 0xFE, 0x00, 0xFC, 0xFF, 0xFC, 0x03, 0xF7,
  0xFF, 0xF0, 0x1F, 0xDC, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0x81, 0xFF, 0x00,
  0xFE, 0x07, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF0, 0x3F, 0xBF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0xF0,
  0x0F, 0xC3, 0xFF, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFC, 0x7F, 0x03, 0xFF, 0xE7, 0xF0, 0x7F, 0xFF, 0x7F,
  0x0F, 0xFF, 0xF7, 0xF1, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0xFF,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x87,
  0xF0, 0x0F, 0xF8, 0x7F, 0x01, 0xFF, 0x87, 0xF8, 0x3B, 0xF0, 0x7F, 0xFF,
  0x3F, 0x03, 0xFF, 0xF7, 0xF0, 0x3F, 0xFE, 0x7F, 0x01, 0xFF, 0xC7, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x07, 0xEF, 0xFF, 0x87, 0xF9, 0xFF, 0xF1,
  0xFF, 0x3F, 0xFE, 0x7F, 0xEF, 0xFF, 0xDF, 0xFC, 0x03, 0xFB, 0xFF, 0x80,
  0x7E, 0xE0, 0x00, 0x1F, 0xD8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xE0, 0xFE, 0x00, 0x70, 0x3F, 0x00,
  0x08, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x10, 0x00, 0x3F, 0x86, 0x00, 0x0F, 0xE3, 0xC0,
  0x07, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0x00, 0xFE,
  0x03, 0xC0, 0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xF8, 0x1F,
  0xC7, 0xF8, 0x0F, 0xEF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03,
  0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xF1, 0xFC, 0x06, 0xFC, 0x3F,
  0xC1, 0xFF, 0x83, 0xFF, 0xF7, 0xF0, 0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0x9F,
  0xC0, 0x7F, 0xC3, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8F,
  0xFF, 0x01, 0xF9, 0xFF, 0xE0, 0x7F, 0x3F, 0xF8, 0x0F, 0xE7, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xE0,
  0xFF, 0x00, 0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x30, 0xFC, 0x1F, 0x8F, 0x87, 0xE0, 0xF8, 0x7E, 0x3E, 0x07, 0xC3,
  0xF1, 0xF0, 0x3E, 0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0x7C, 0x0F, 0x83, 0xE7,
  0xE0, 0xFC, 0x1F, 0x3F, 0x07, 0xE0, 0xF9, 0xF0, 0x3E, 0x07, 0xCF, 0x81,
  0xF0, 0x3E, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x0F, 0xBF, 0x07, 0xE0,
  0x7D, 0xF8, 0x3F, 0x03, 0xEF, 0xC1, 0xF0, 0x3F, 0x7C, 0x0F, 0x81, 0xFB,
  0xE0, 0x7C, 0x0F, 0x9F, 0x03, 0xE0, 0x7D, 0xF8, 0x3F, 0x07, 0xEF, 0xC1,
  0xF8, 0x3E, 0x7E, 0x0F, 0xC1, 0xF3, 0xF0, 0xFC, 0x1F, 0x1F, 0x8F, 0xF0,
  0xF8, 0xFF, 0xEF, 0x8F, 0x87, 0xFF, 0x7F, 0xF8, 0x1F, 0xF1, 0xFF, 0x80,
  0xFF, 0x0F, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xCF, 0xFE,
  0x0F, 0xFF, 0xCF, 0xFF, 0x1F, 0xE7, 0xCE, 0x3F, 0x3F, 0xC7, 0xDC, 0x3F,
  0x1F, 0x07, 0xD8, 0x3F, 0x0E, 0x07, 0xD8, 0x3F, 0x08, 0x07, 0xF0, 0x3F,
  0x00, 0x07, 0xF0, 0x40, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0x0F, 0xE0, 0x00,
  0xFC, 0x1F, 0xE0, 0x30, 0xFC, 0x1B, 0xE0, 0x70, 0xFC, 0x1B, 0xE1, 0xF8,
  0xFC, 0x3B, 0xE3, 0xFC, 0xFC, 0x73, 0xE7, 0xF8, 0xFF, 0xF3, 0xFF, 0xF0,
  0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0,
  0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x00, 0xFF, 0x83, 0xFC, 0x0D, 0xF8, 0x0F, 0xF0, 0xEF, 0xC0,
  0x7F, 0xFE, 0xFE, 0x03, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0x3F, 0x80, 0x3F,
  0xF1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x40, 0x03, 0xF8, 0x07, 0x00, 0x3F, 0xC0,
  0x7E, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x7E, 0x0F, 0xFF, 0xF3,
  0xF0, 0xFF, 0xFF, 0xDF, 0x87, 0xE0, 0xFF, 0xFC, 0x3E, 0x01, 0xFF, 0xC1,
  0xF0, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0xC0, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x80,
  0x07, 0xF8, 0x3E, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0xFF,
  0x00, 0x3E, 0x0F, 0xF0, 0x01, 0xF0, 0xFF, 0xF8, 0x07, 0x8F, 0xFF, 0xFE,
  0x3E, 0x7E, 0xFF, 0xFF, 0xE3, 0xF1, 0xFF, 0xFF, 0x1F, 0x81, 0xFF, 0xF0,
  0xF8, 0x03, 0xFF, 0x08, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x08, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x60, 0x0F, 0xF8, 0x01, 0xF0, 0x7F, 0xF0, 0x0F,
  0x83, 0xFF, 0xC0, 0x3E, 0x1F, 0xFF, 0x80, 0xF8, 0x7E, 0x7F, 0x07, 0xC3,
  0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF8, 0xFC, 0x7E, 0x07, 0xFF, 0xE1, 0xF0,
  0x0F, 0xFF, 0x07, 0xC0, 0x1F, 0xF8, 0x1F, 0x00, 0x3F, 0xC0, 0x98, 0x00,
  0x7C, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 14, 38, 32, 9, -37 },
  { 68, 20, 16, 32, 9, -39 },
  { 108, 33, 37, 32, 0, -37 },
  { 261, 30, 49, 32, 1, -43 },
  { 445, 37, 39, 32, -2, -38 },
  { 626, 32, 39, 32, 0, -38 },
  { 782, 9, 16, 32, 14, -39 },
  { 800, 21, 47, 32, 10, -40 },
  { 924, 21, 47, 32, 2, -40 },
  { 1048, 28, 27, 32, 2, -29 },
  { 1143, 26, 25, 32, 3, -29 },
  { 1225, 15, 17, 32, 6, -9 },
  { 1257, 17, 6, 32, 8, -19 },
  { 1270, 10, 10, 32, 9, -9 },
  { 1283, 32, 47, 32, 0, -40 },
  { 1471, 29, 39, 32, 2, -38 },
  { 1613, 27, 37, 32, 2, -37 },
  { 1738, 29, 38, 32, 1, -38 },
  { 1876, 29, 39, 32, 1, -38 },
  { 2018, 30, 37, 32, 0, -37 },
  { 2157, 30, 38, 32, 1, -37 },
  { 2300, 27, 38, 32, 2, -37 },
  { 2429, 28, 37, 32, 4, -37 },
  { 2559, 29, 39, 32, 2, -38 },
  { 2701, 27, 38, 32, 4, -38 },
  { 2830, 13, 29, 32, 9, -28 },
  { 2878, 16, 36, 32, 6, -28 },
  { 2950, 26, 31, 32, 4, -32 },
  { 3051, 28, 17, 32, 2, -25 },
  { 3111, 26, 31, 32, 2, -32 },
  { 3212, 24, 39, 32, 6, -38 },
  { 3329, 29, 44, 32, 2, -38 },
  { 3489, 31, 37, 32, -2, -37 },
  { 3633, 28, 37, 32, 2, -37 },
  { 3763, 29, 39, 32, 3, -38 },
  { 3905, 29, 37, 32, 2, -37 },
  { 4040, 30, 37, 32, 2, -37 },
  { 4179, 30, 37, 32, 2, -37 },
  { 4318, 28, 39, 32, 3, -38 },
  { 4455, 31, 37, 32, 1, -37 },
  { 4599, 30, 37, 32, 2, -37 },
  { 4738, 28, 38, 32, 2, -37 },
  { 4871, 33, 37, 32, 2, -37 },
  { 5024, 24, 37, 32, 3, -37 },
  { 5135, 33, 37, 32, 0, -37 },
  { 5288, 31, 37, 32, 1, -37 },
  { 5432, 29, 39, 32, 2, -38 },
  { 5574, 29, 37, 32, 2, -37 },
  { 5709, 29, 49, 32, 2, -38 },
  { 5887, 29, 37, 32, 2, -37 },
  { 6022, 30, 39, 32, 1, -38 },
  { 6169, 30, 37, 32, 4, -37 },
  { 6308, 29, 38, 32, 3, -37 },
  { 6446, 30, 37, 32, 5, -37 },
  { 6585, 34, 37, 32, 1, -37 },
  { 6743, 35, 37, 32, -1, -37 },
  { 6905, 31, 37, 32, 4, -37 },
  { 7049, 32, 37, 32, 0, -37 },
  { 7197, 24, 47, 32, 7, -40 },
  { 7338, 15, 47, 32, 9, -40 },
  { 7427, 25, 47, 32, 1, -40 },
  { 7574, 28, 23, 32, 2, -37 },
  { 7655, 26, 5, 32, 0, 5 },
  { 7672, 10, 12, 32, 10, -42 },
  { 7687, 28, 29, 32, 2, -28 },
  { 7789, 28, 40, 32, 2, -39 },
  { 7929, 25, 29, 32, 3, -28 },
  { 8020, 30, 40, 32, 2, -39 },
  { 8170, 26, 29, 32, 3, -28 },
  { 8265, 35, 50, 32, -1, -39 },
  { 8484, 29, 39, 32, 1, -28 },
  { 8626, 27, 39, 32, 2, -39 },
  { 8758, 25, 41, 32, 4, -40 },
  { 8887, 27, 51, 32, 1, -40 },
  { 9060, 29, 40, 32, 2, -39 },
  { 9205, 23, 40, 32, 5, -39 },
  { 9320, 31, 28, 32, 0, -28 },
  { 9429, 27, 28, 32, 2, -28 },
  { 9524, 26, 29, 32, 3, -28 },
  { 9619, 30, 39, 32, 0, -28 },
  { 9766, 28, 39, 32, 2, -28 },
  { 9903, 27, 27, 32, 5, -27 },
  { 9995, 26, 29, 32, 2, -28 },
  { 10090, 25, 38, 32, 4, -37 },
  { 10209, 27, 28, 32, 3, -27 },
  { 10304, 27, 29, 32, 2, -28 },
  { 10402, 29, 29, 32, 1, -28 },
  { 10508, 32, 29, 32, 0, -28 },
  { 10624, 29, 38, 32, 1, -27 },
  { 10762, 29, 29, 32, 1, -28 },
  { 10868, 26, 47, 32, 5, -40 },
  { 11021, 13, 47, 32, 10, -40 },
  { 11098, 25, 47, 32, 2, -40 },
  { 11245, 30, 13, 32, 1, -22 },
};

const GFXfont IBMPlexMono_SemiBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC53PT7B_H_
