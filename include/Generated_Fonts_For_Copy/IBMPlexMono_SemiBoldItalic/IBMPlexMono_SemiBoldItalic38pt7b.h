#ifndef _IBMPLEXMONO_SEMIBOLDITALIC38PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x07, 0x80, 0x3E,
  0x3E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE3, 0xE7, 0xC7, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFE, 0x01, 0xE3, 0xC0, 0x01, 0xE3,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x7F, 0x87,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0x0F, 0x0F, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0x9C, 0xF8, 0xF8, 0xE3, 0x87, 0x87, 0x10,
  0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x9C, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0x3F, 0x00, 0x38, 0xF8, 0x01, 0xC7, 0xC0, 0x0E, 0x3E, 0x20, 0xF1,
  0xF3, 0x87, 0x1F, 0x3F, 0x39, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0xFF, 0x00, 0xE0, 0x7F, 0xC0,
  0x78, 0x3C, 0x78, 0x3C, 0x0E, 0x0E, 0x1E, 0x07, 0x83, 0x87, 0x81, 0xE1,
  0xE3, 0xC0, 0x78, 0x79, 0xE0, 0x1C, 0x1E, 0x70, 0x07, 0x87, 0x3C, 0x01,
  0xE3, 0xDE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x1E, 0x00, 0xF3,
  0x83, 0x80, 0x39, 0xE0, 0xE0, 0x1E, 0x78, 0x78, 0x0F, 0x1E, 0x1E, 0x03,
  0x87, 0x07, 0x81, 0xE1, 0xC1, 0xC0, 0xF0, 0x78, 0xF0, 0x78, 0x0F, 0xF8,
  0x1E, 0x03, 0xFC, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x0F, 0x8F, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1E,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x07, 0x87, 0x80, 0x0F, 0x9F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x78, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x4F, 0x81, 0xF1, 0xFF, 0x05, 0xE7, 0xBF, 0x1B,
  0xDF, 0x3F, 0xF7, 0xFC, 0x7F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0x7C, 0x07,
  0x00, 0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE7, 0xC0,
  0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x06, 0x0F, 0x06, 0x7C, 0xF3, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x03, 0x80, 0xE0, 0x10, 0x0C, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFD, 0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0x83, 0xE3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F,
  0x1F, 0xF9, 0xF1, 0xFF, 0x8F, 0x3F, 0xF8, 0x03, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x7C, 0x1F, 0x87,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x3F, 0x3C,
  0x0F, 0xCF, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x07, 0x07, 0xC0, 0x40, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x80, 0xFC, 0xF8, 0x07, 0xE0, 0xC0, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE1, 0xF8, 0x3F, 0x07, 0x00, 0xFC, 0x10, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC3, 0x00, 0x3E, 0x7C, 0x03, 0xF3,
  0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0x7C, 0x00,
  0xF9, 0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF1, 0xF8, 0x07, 0xBF, 0xE0, 0x3D, 0xFF, 0x81,
  0xDF, 0xFE, 0x1F, 0x83, 0xF8, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE3, 0x00, 0x3E, 0x3C,
  0x03, 0xF3, 0xF8, 0x3F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0xFB, 0xFE, 0x3E, 0xFF, 0xE7, 0xFF, 0xFD, 0xFE, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0x07, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78,
  0x07, 0xCF, 0x80, 0x7C, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFC, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xE0, 0xFC, 0x7C, 0x03,
  0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7E,
  0x01, 0xF3, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE7, 0xF0, 0xFC, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x3F,
  0xBF, 0xFF, 0xF3, 0xFF, 0xBE, 0x3F, 0xEF, 0x81, 0xF3, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x0F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF1, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x87, 0x80, 0x01, 0xE0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x10, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF7, 0xE1, 0xFF, 0xC0,
  0x7C, 0xE0, 0x3E, 0x20, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1F, 0x01, 0xF1, 0xE0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x3C, 0xF7, 0x87, 0xEF, 0x78,
  0xFF, 0xF7, 0x8F, 0x1F, 0xF1, 0xE0, 0xEF, 0x1E, 0x0E, 0xF3, 0xC1, 0xEF,
  0x3C, 0x1E, 0xF3, 0xC1, 0xEF, 0x3C, 0x1E, 0xE3, 0xC1, 0xEE, 0x3C, 0x3C,
  0xE3, 0xC7, 0xCE, 0x3F, 0xFC, 0xE1, 0xFB, 0xCE, 0x1F, 0x3C, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00,
  0x3E, 0x78, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x3C,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xC0,
  0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x78, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0xFC, 0x03,
  0xE7, 0xC0, 0x1E, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x81, 0xF0, 0x07, 0x87, 0x80,
  0x3E, 0x3E, 0x03, 0xE1, 0xF8, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0x3E,
  0x3E, 0x03, 0xE1, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0xEF, 0x83,
  0xFE, 0xF8, 0x3F, 0xEF, 0x87, 0xFE, 0xF8, 0x03, 0xEF, 0x80, 0x3C, 0xF8,
  0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0x7E, 0x1F, 0xC7,
  0xFF, 0x78, 0x3F, 0xF7, 0x81, 0xFE, 0x78, 0x0F, 0x87, 0x80, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x30, 0x0F, 0x8F, 0x80, 0xF8, 0x3E,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0x07, 0x80, 0x3F, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFC,
  0x0F, 0x81, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0x07, 0xC0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x80,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x07, 0xC0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xF3,
  0xFE, 0x1E, 0xF3, 0xBC, 0x1E, 0x77, 0xBC, 0x1E, 0x77, 0x3C, 0x1E, 0x7F,
  0x3C, 0x1E, 0x7E, 0x7C, 0x3E, 0x7E, 0x7C, 0x3E, 0x3C, 0x78, 0x3C, 0x3C,
  0x78, 0x3C, 0x38, 0x78, 0x3C, 0x38, 0x78, 0x3C, 0x30, 0xF8, 0x7C, 0x10,
  0xF8, 0x7C, 0x20, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x0F, 0xE0,
  0x3C, 0x3F, 0x81, 0xF0, 0xFE, 0x07, 0xC3, 0xF8, 0x1E, 0x0F, 0xE0, 0x78,
  0x7F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xBC, 0x1E, 0x1E, 0xF0, 0xF8, 0x7B,
  0xC3, 0xC1, 0xEF, 0x0F, 0x0F, 0x9E, 0x3C, 0x3E, 0x78, 0xF0, 0xF1, 0xE3,
  0xC3, 0xC7, 0x9F, 0x0F, 0x1E, 0x7C, 0x3C, 0x3D, 0xE0, 0xF0, 0xF7, 0x87,
  0xC3, 0xDE, 0x1F, 0x0F, 0x78, 0x78, 0x3F, 0xE1, 0xE0, 0x7F, 0x87, 0x81,
  0xFC, 0x1E, 0x07, 0xF0, 0xF8, 0x1F, 0xC3, 0xE0, 0x7F, 0x0F, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0x83, 0xE3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0x7C, 0x1F, 0x87, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF0, 0x3F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3F, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x7E, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE3, 0xF0, 0x1F, 0x3E,
  0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0xFC, 0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xC0, 0x0F, 0x9E, 0x00,
  0xFB, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xF8,
  0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xF1, 0xF0, 0x0F,
  0x87, 0x80, 0x7C, 0x3E, 0x03, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFC, 0x1F,
  0x8F, 0xC0, 0x38, 0x7C, 0x00, 0x83, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE2, 0x00, 0x3E, 0x3C, 0x01, 0xF3, 0xF0, 0x3F, 0x9F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF3,
  0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xF0,
  0x7E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF0, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x3E, 0x3C,
  0x3C, 0x7E, 0x3C, 0x3C, 0x7E, 0x3C, 0x3C, 0x7E, 0x3C, 0x7C, 0xFE, 0x78,
  0x78, 0xFE, 0x78, 0x78, 0xFE, 0x78, 0x79, 0xDE, 0x78, 0x79, 0xDE, 0x78,
  0x79, 0xDE, 0xF0, 0x7B, 0xDE, 0xF0, 0x7B, 0x9E, 0xF0, 0x7B, 0x9E, 0xF0,
  0x7B, 0x9E, 0xE0, 0xF7, 0x1F, 0xE0, 0xF7, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0,
  0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x01,
  0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F,
  0x9F, 0x00, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x07,
  0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xEF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x80, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0,
  0x3C, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xEF, 0x00, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x78, 0x0F, 0x87,
  0xC1, 0xF0, 0x7C, 0x3E, 0x03, 0xC3, 0xE0, 0x3E, 0x7C, 0x01, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xF7, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x39, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x84, 0x03, 0xE3, 0xE1, 0xFF,
  0x7C, 0x7F, 0xEF, 0x9F, 0x87, 0xF7, 0xE0, 0x7E, 0xF8, 0x0F, 0x9F, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xC1, 0xFC, 0xFC, 0x6F,
  0x8F, 0xFD, 0xFD, 0xFF, 0x3F, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x0F, 0x81, 0xF3, 0xFC, 0x1F, 0x7F, 0xE1,
  0xFC, 0x3F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7E, 0x0F, 0xC7, 0xBF,
  0xF8, 0xF9, 0xFF, 0x0F, 0x8F, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0x1F, 0x3E, 0x03, 0x8F, 0x80, 0x87, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0xC7, 0x80, 0x7D, 0xF0, 0x3E, 0x7E, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xF1, 0xF0, 0x7F, 0xCF, 0x07, 0xFF, 0xF8, 0x7E, 0x1F, 0xC7, 0xE0,
  0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07,
  0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xFC, 0x7F, 0x83, 0xFF, 0x7C, 0x1F,
  0xF3, 0xE0, 0x3E, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0x0F, 0xC3, 0xE3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E,
  0x7C, 0x3F, 0xDF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x02, 0x1E, 0x00, 0xE3, 0xE0, 0x3E, 0x7E, 0x0F, 0x87, 0xFF, 0xE0,
  0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x81, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF8, 0xF8, 0x3F, 0xE7, 0x83, 0xFF, 0xFC, 0x3F, 0x0F,
  0xE1, 0xF0, 0x3F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3C, 0x7C,
  0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7E, 0x1F, 0xC1, 0xFF,
  0xBE, 0x07, 0xF9, 0xF0, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x04, 0x03, 0xE0, 0x78, 0x3E, 0x07, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x0F, 0x81, 0xF3, 0xFC, 0x1F, 0x7F, 0xE1, 0xF4, 0x3E, 0x1F, 0x83,
  0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF,
  0x80, 0x78, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x40, 0xF8, 0x3C, 0x3E, 0x1E, 0x0F, 0x8F, 0x03, 0xE7,
  0x80, 0xF3, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0xE0, 0xF8, 0x3C, 0x1F, 0x03,
  0xC3, 0xE0, 0x7C, 0x78, 0x07, 0xCF, 0x00, 0x7B, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x0F, 0x80, 0xF9, 0xFE, 0x07, 0xDF, 0xF8, 0x3F, 0x87,
  0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0x8F, 0xC0, 0x79, 0xF8, 0x03, 0xCF, 0x80,
  0x3E, 0x7C, 0x11, 0xF1, 0xF0, 0xCF, 0x8F, 0x8F, 0x7C, 0x3C, 0xF3, 0xE1,
  0xFF, 0x1E, 0x07, 0xF1, 0xF0, 0x1E, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x04, 0x3E,
  0x0E, 0x3E, 0x1F, 0x3E, 0x3C, 0x3E, 0x78, 0x3E, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x0F, 0x00, 0x1E, 0x78, 0x78, 0x7B, 0xF3, 0xF1, 0xFF, 0xDF, 0xCF,
  0xCF, 0xCF, 0x3E, 0x3E, 0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3, 0xCF, 0x0F,
  0x0F, 0x3C, 0x3C, 0x3C, 0xE1, 0xE1, 0xE7, 0x87, 0x87, 0x9E, 0x1E, 0x1E,
  0x78, 0x78, 0x79, 0xE1, 0xE1, 0xE7, 0x87, 0x87, 0x9C, 0x3C, 0x3C, 0xF0,
  0xF0, 0xF3, 0xC3, 0xC3, 0xCF, 0x0F, 0x0F, 0x3C, 0x3C, 0x3C, 0x1F, 0x0F,
  0x81, 0xF3, 0xFC, 0x1F, 0x7F, 0xE1, 0xF4, 0x3E, 0x1F, 0x83, 0xE1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x78,
  0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x87, 0xE3, 0xE0, 0x3C,
  0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF3,
  0xC0, 0x7C, 0x7C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x7C, 0xFF, 0x03, 0xEF, 0xFC, 0x1F, 0xC3, 0xF0, 0xFC,
  0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xEF, 0xFE, 0x1F,
  0x3F, 0xE0, 0xF8, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF1, 0xF0, 0xFF, 0x9E, 0x1F, 0xFF, 0xE3, 0xF0, 0xFE,
  0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xFC, 0x7F, 0x87, 0xFE, 0xF8, 0x7F,
  0xCF, 0x81, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0xFF, 0xC3, 0xFF, 0xF9, 0xFB, 0xFF, 0x7F, 0x07, 0xCF, 0xE0, 0xFB, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0x3E, 0x01, 0x8F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE2, 0x00, 0xF9, 0xC0, 0x3E,
  0xF8, 0x1F, 0x3F, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x0C, 0x1F, 0x07, 0x87, 0xC3, 0xC1, 0xF3,
  0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x01,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xC0, 0xFC,
  0x7C, 0x6F, 0x8F, 0xF9, 0xF0, 0xFF, 0x3C, 0x0F, 0x8F, 0x80, 0xFF, 0x80,
  0xDF, 0xE0, 0xFB, 0xFC, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x07, 0xC1, 0xE1, 0xF0,
  0x3C, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x3C, 0x3C,
  0x31, 0xE1, 0xE7, 0x8F, 0x0E, 0x1C, 0x78, 0x70, 0xF7, 0x87, 0x87, 0xBC,
  0x3C, 0x3D, 0xE1, 0xE1, 0xEF, 0x0F, 0x0F, 0x78, 0x78, 0x7B, 0xC3, 0x83,
  0xFC, 0x3C, 0x1D, 0xE1, 0xE1, 0xEF, 0x0F, 0x0F, 0x78, 0x78, 0x7B, 0xC3,
  0xC3, 0x9E, 0x3E, 0x3C, 0xF3, 0xF1, 0xC7, 0xF3, 0x9C, 0x3F, 0x9F, 0xC0,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0xE3, 0xF8, 0x7F, 0xE7, 0xF9,
  0xFB, 0xD9, 0xF7, 0xC7, 0xA1, 0xE3, 0x0F, 0xC3, 0xC8, 0x1F, 0x87, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x1F, 0x82, 0x3C, 0x2F, 0x0C, 0x78, 0xDE,
  0x7C, 0xF1, 0xBD, 0xFD, 0xFE, 0x7F, 0xE1, 0xF8, 0x7F, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x1F, 0x0B, 0xE0, 0xFF, 0xDF,
  0x03, 0xFC, 0xF0, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x02, 0x01, 0xF0, 0x38, 0x1F, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x78, 0x7F, 0xE7, 0xC7, 0xFF, 0xFC, 0x3C,
  0x3F, 0xE3, 0xC0, 0x7E, 0x1E, 0x03, 0xE0, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x80, 0x7E,
  0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x87, 0xF0, 0x1C, 0x7F, 0xF8, 0xE7,
  0xDF, 0xFF, 0x3E, 0x3F, 0xF1, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1F, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x30, 0xFF, 0x03, 0xCF, 0xFC,
  0x1C, 0x79, 0xE1, 0xE7, 0x87, 0x9F, 0x38, 0x3F, 0xF3, 0xC0, 0xFF, 0x0E,
  0x01, 0xE0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 27, 23, 7, -27 },
  { 35, 15, 12, 23, 6, -28 },
  { 58, 24, 27, 23, 0, -27 },
  { 139, 21, 35, 23, 1, -31 },
  { 231, 26, 27, 23, -1, -27 },
  { 319, 23, 27, 23, 0, -27 },
  { 397, 7, 12, 23, 10, -28 },
  { 408, 15, 34, 23, 7, -29 },
  { 472, 16, 34, 23, 1, -29 },
  { 540, 20, 19, 23, 2, -21 },
  { 588, 19, 17, 23, 2, -20 },
  { 629, 11, 12, 23, 4, -6 },
  { 646, 13, 4, 23, 5, -14 },
  { 653, 7, 7, 23, 7, -7 },
  { 660, 23, 34, 23, 0, -29 },
  { 758, 20, 27, 23, 2, -27 },
  { 826, 19, 27, 23, 2, -27 },
  { 891, 21, 27, 23, 1, -27 },
  { 962, 21, 27, 23, 1, -27 },
  { 1033, 22, 27, 23, 0, -27 },
  { 1108, 21, 27, 23, 1, -27 },
  { 1179, 19, 27, 23, 2, -27 },
  { 1244, 20, 27, 23, 3, -27 },
  { 1312, 21, 27, 23, 1, -27 },
  { 1383, 19, 27, 23, 3, -27 },
  { 1448, 9, 21, 23, 7, -21 },
  { 1472, 12, 27, 23, 4, -21 },
  { 1513, 19, 22, 23, 3, -23 },
  { 1566, 20, 11, 23, 2, -17 },
  { 1594, 18, 22, 23, 2, -23 },
  { 1644, 17, 27, 23, 4, -27 },
  { 1702, 20, 31, 23, 2, -27 },
  { 1780, 22, 27, 23, -1, -27 },
  { 1855, 21, 27, 23, 1, -27 },
  { 1926, 21, 27, 23, 2, -27 },
  { 1997, 21, 27, 23, 1, -27 },
  { 2068, 21, 27, 23, 2, -27 },
  { 2139, 21, 27, 23, 2, -27 },
  { 2210, 20, 27, 23, 2, -27 },
  { 2278, 22, 27, 23, 1, -27 },
  { 2353, 22, 27, 23, 1, -27 },
  { 2428, 21, 27, 23, 1, -27 },
  { 2499, 24, 27, 23, 1, -27 },
  { 2580, 18, 27, 23, 2, -27 },
  { 2641, 24, 27, 23, 0, -27 },
  { 2722, 22, 27, 23, 1, -27 },
  { 2797, 20, 27, 23, 2, -27 },
  { 2865, 21, 27, 23, 2, -27 },
  { 2936, 20, 35, 23, 2, -27 },
  { 3024, 21, 27, 23, 1, -27 },
  { 3095, 21, 27, 23, 1, -27 },
  { 3166, 22, 27, 23, 3, -27 },
  { 3241, 21, 27, 23, 2, -27 },
  { 3312, 22, 27, 23, 3, -27 },
  { 3387, 24, 27, 23, 1, -27 },
  { 3468, 26, 27, 23, -1, -27 },
  { 3556, 22, 27, 23, 3, -27 },
  { 3631, 23, 27, 23, 0, -27 },
  { 3709, 17, 34, 23, 5, -29 },
  { 3782, 11, 34, 23, 6, -29 },
  { 3829, 17, 34, 23, 1, -29 },
  { 3902, 20, 16, 23, 2, -27 },
  { 3942, 18, 3, 23, 0, 3 },
  { 3949, 7, 8, 23, 7, -30 },
  { 3956, 19, 20, 23, 2, -20 },
  { 4004, 20, 28, 23, 1, -28 },
  { 4074, 18, 20, 23, 2, -20 },
  { 4119, 21, 28, 23, 2, -28 },
  { 4193, 19, 20, 23, 2, -20 },
  { 4241, 26, 36, 23, -1, -28 },
  { 4358, 21, 28, 23, 1, -20 },
  { 4432, 20, 28, 23, 1, -28 },
  { 4502, 18, 30, 23, 3, -30 },
  { 4570, 19, 38, 23, 1, -30 },
  { 4661, 21, 28, 23, 1, -28 },
  { 4735, 16, 28, 23, 4, -28 },
  { 4791, 22, 20, 23, 0, -20 },
  { 4846, 20, 20, 23, 1, -20 },
  { 4896, 19, 20, 23, 2, -20 },
  { 4944, 21, 28, 23, 0, -20 },
  { 5018, 20, 28, 23, 2, -20 },
  { 5088, 19, 20, 23, 4, -20 },
  { 5136, 18, 20, 23, 2, -20 },
  { 5181, 18, 27, 23, 3, -27 },
  { 5242, 19, 20, 23, 2, -20 },
  { 5290, 19, 20, 23, 2, -20 },
  { 5338, 21, 20, 23, 1, -20 },
  { 5391, 23, 20, 23, 0, -20 },
  { 5449, 21, 28, 23, 0, -20 },
  { 5523, 21, 20, 23, 1, -20 },
  { 5576, 18, 34, 23, 4, -29 },
  { 5653, 10, 34, 23, 7, -29 },
  { 5696, 19, 34, 23, 1, -29 },
  { 5777, 21, 8, 23, 1, -15 },
};

const GFXfont IBMPlexMono_SemiBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC38PT7B_H_
