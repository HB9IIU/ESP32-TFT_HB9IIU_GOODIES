#ifndef _IBMPLEXMONO_SEMIBOLDITALIC35PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0xCF,
  0xE7, 0xE3, 0xF0, 0xF0, 0x3C, 0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xE7, 0x8F,
  0x3C, 0x79, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x8F, 0x3C, 0x78, 0x00, 0x3C,
  0x70, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0,
  0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x07, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x1F, 0xF2, 0x3C, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x3C,
  0x07, 0xF8, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE0, 0x3C, 0x70, 0x00,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x71, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0x3B, 0xF3, 0xE3, 0x8C, 0x3E, 0x38, 0x03, 0xE3, 0x00, 0x3E, 0x70,
  0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0xEF, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC2, 0x0E, 0x3C, 0x70,
  0xE7, 0xCF, 0xDC, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x07, 0x07, 0xF8, 0x0E, 0x0F, 0xFC, 0x1E, 0x0E, 0x3C, 0x3C,
  0x1E, 0x1C, 0x38, 0x1C, 0x1C, 0x70, 0x1C, 0x3C, 0xF0, 0x1C, 0x3C, 0xE0,
  0x1C, 0x79, 0xC0, 0x1F, 0xFB, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xCF, 0xF8, 0x03, 0x9E, 0x38,
  0x07, 0x9C, 0x38, 0x0F, 0x3C, 0x38, 0x0E, 0x38, 0x38, 0x1C, 0x38, 0x78,
  0x3C, 0x3C, 0x70, 0x38, 0x1F, 0xF0, 0x70, 0x1F, 0xE0, 0xF0, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xC7, 0x80, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0,
  0x1F, 0x1E, 0x00, 0x79, 0xE0, 0x1F, 0xFE, 0x03, 0xEF, 0x80, 0x3E, 0x78,
  0x01, 0xE3, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xE1, 0x3E,
  0x0F, 0x1F, 0xF0, 0xBC, 0xE7, 0x85, 0xEF, 0x3F, 0xE7, 0xF0, 0xFE, 0x3F,
  0x03, 0xE0, 0xF0, 0x7B, 0xDE, 0xF7, 0xFB, 0xDE, 0xF7, 0xBC, 0x00, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x81, 0xE0, 0x9C, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F,
  0x9E, 0x07, 0xC3, 0xC3, 0xE0, 0xF8, 0x30, 0x18, 0x08, 0x04, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x1F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3C, 0xFF, 0xFF, 0xFF,
  0xCF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0x07, 0xCF, 0x80, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x38,
  0xFF, 0x9E, 0x3F, 0xE7, 0x8F, 0xF1, 0xE7, 0xFC, 0x71, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x01, 0xF3, 0xE0, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0xF9, 0xE0, 0x7D, 0xF0, 0x7C,
  0xF8, 0x7C, 0x78, 0x3C, 0x3C, 0x0E, 0x1E, 0x02, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x3C,
  0x07, 0xCF, 0x80, 0xF8, 0x20, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0x7E, 0x1C, 0x07, 0xC1, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC4, 0x01, 0xF3, 0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x1F,
  0x3C, 0x01, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0xF8, 0x38, 0x0F, 0x87, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x7E, 0x01, 0xCF, 0xF0, 0x3D, 0xFF, 0x83, 0xFF, 0xFC, 0x3E,
  0x0F, 0xC1, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC1,
  0x00, 0x7C, 0x78, 0x0F, 0xCF, 0xC1, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x7C,
  0x3E, 0xFF, 0x1F, 0xFF, 0xDF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xE7,
  0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3,
  0xC0, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF1,
  0xF8, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1F, 0x07, 0xC1,
  0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x7C, 0x1F, 0x9F,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E,
  0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0x0F, 0xDF, 0x01,
  0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0xC0, 0x7D,
  0xF8, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFE, 0xF8, 0x3E, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0x0F, 0xCF, 0xE7, 0xF3, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF9, 0xFC, 0xFE,
  0x7E, 0x1E, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF0, 0x10, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFE, 0x7C, 0x3F, 0xF8, 0x1F, 0x30, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x07, 0xC1, 0xF0, 0xF0, 0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x39,
  0xE1, 0xE7, 0x3C, 0x7E, 0xE7, 0x1F, 0xDD, 0xE3, 0xC7, 0xBC, 0xF0, 0xF7,
  0x9E, 0x1E, 0xF3, 0x83, 0x9C, 0xF0, 0x73, 0x9E, 0x1E, 0x73, 0xC3, 0xDE,
  0x78, 0xFB, 0xC7, 0xFF, 0x78, 0xFD, 0xC7, 0x0F, 0x38, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x78,
  0x3E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3E,
  0x01, 0xE3, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF,
  0x80, 0x1F, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xC3,
  0xC0, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0x01, 0xE1, 0xE0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C,
  0x07, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x7C,
  0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x0C, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x07, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x1F, 0x87, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0,
  0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3C, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0x0F, 0xCF, 0x81, 0xF7, 0xC0, 0x3D, 0xF0, 0x0C, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xFF, 0xF8, 0x7F, 0xBE, 0x1F,
  0xEF, 0x0F, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBE, 0x03, 0xCF, 0x80, 0xF3,
  0xF0, 0xFC, 0x7F, 0xEF, 0x1F, 0xFB, 0xC3, 0xFC, 0xF0, 0x3C, 0x78, 0x0F,
  0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1,
  0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x08, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x1F, 0x07, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0xFC, 0x3C,
  0x07, 0xE0, 0xF0, 0x3F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3E,
  0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x7C, 0x00, 0x7B, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7,
  0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0,
  0x7E, 0x1F, 0xE3, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x87, 0xBB, 0xDE,
  0x1E, 0xEE, 0x70, 0x7B, 0xFB, 0xC3, 0xCF, 0xCF, 0x0F, 0x1F, 0x3C, 0x3C,
  0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x1E, 0x0F, 0x18, 0x78, 0x78, 0x21,
  0xE1, 0xE1, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x0F, 0xC0, 0xF0, 0xFC,
  0x0F, 0x0F, 0xC0, 0xF1, 0xFC, 0x0F, 0x1F, 0xC1, 0xE1, 0xFE, 0x1E, 0x1F,
  0xE1, 0xE1, 0xFE, 0x1E, 0x1F, 0xE1, 0xE3, 0xCE, 0x1E, 0x3C, 0xF3, 0xC3,
  0xCF, 0x3C, 0x3C, 0xF3, 0xC3, 0xCF, 0x3C, 0x78, 0x73, 0xC7, 0x87, 0xBC,
  0x78, 0x7F, 0x87, 0x87, 0xF8, 0x78, 0x7F, 0x87, 0x83, 0xF8, 0xF0, 0x3F,
  0x8F, 0x03, 0xF8, 0xF0, 0x3F, 0x0F, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F, 0xCF, 0x81, 0xF7, 0xC0, 0x3D,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xBC, 0x03,
  0xEF, 0x81, 0xF3, 0xF0, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0x03, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xE0, 0x3E, 0x1E, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0x0F, 0xCF, 0x81, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x81, 0xF3, 0xF0, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xE1, 0x00, 0x78,
  0xE0, 0x1F, 0x7C, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x03,
  0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0,
  0x3E, 0x1E, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xC7, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83,
  0xF1, 0xF0, 0x0C, 0x1E, 0x00, 0x83, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC2, 0x00, 0x7C, 0x70, 0x07, 0xCF,
  0xC1, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E,
  0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78,
  0x78, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x3D, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0,
  0x01, 0xE3, 0x87, 0x87, 0x1E, 0x3E, 0x3C, 0x78, 0xF8, 0xF1, 0xE3, 0xE3,
  0xC7, 0x9F, 0x8E, 0x1E, 0x7E, 0x78, 0x79, 0xF9, 0xE1, 0xEE, 0xE7, 0x87,
  0x3B, 0x9C, 0x1C, 0xEE, 0x70, 0xF7, 0x3B, 0xC3, 0xDC, 0xEF, 0x0F, 0x73,
  0xBC, 0x3F, 0x8E, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x7C,
  0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0,
  0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xCF, 0x80, 0x07, 0xC7, 0x80, 0x0F, 0x87, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x01, 0xE0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0,
  0x7C, 0x7C, 0x0F, 0x83, 0xC0, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x1E,
  0x3C, 0x01, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0,
  0x38, 0x0F, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xE0, 0x7C,
  0x3C, 0x0F, 0x07, 0x83, 0xE0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0xC0,
  0x1F, 0xF0, 0x03, 0xC4, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x11, 0xCF, 0x1E, 0x78, 0xF3, 0xC6, 0x03, 0xE3, 0xE1, 0xFF, 0x78,
  0x7F, 0xEF, 0x1F, 0x87, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC7,
  0x81, 0xF8, 0xF0, 0x3E, 0x1F, 0x1B, 0xC3, 0xFF, 0x7E, 0x3F, 0xCF, 0xC3,
  0xE0, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x1F, 0x03,
  0xCF, 0xF0, 0x7B, 0xFF, 0x1F, 0xC3, 0xE3, 0xF0, 0x3C, 0x7C, 0x07, 0x8F,
  0x80, 0xF1, 0xE0, 0x1F, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xF0, 0x1F, 0x3E,
  0x03, 0xE7, 0x80, 0x78, 0xF8, 0x1F, 0x1F, 0x87, 0xC7, 0xFF, 0xF8, 0xFB,
  0xFE, 0x1F, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xE1,
  0xF3, 0xC0, 0x63, 0xE0, 0x41, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x8F, 0x80, 0xF3, 0xC0, 0xF9, 0xF0, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xF3, 0xE0, 0xFF, 0xBE, 0x1F, 0xFF, 0xC1, 0xF0,
  0xFC, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78,
  0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0x78, 0x0F, 0x87,
  0x81, 0xF8, 0x7C, 0x3F, 0x87, 0xFE, 0xF0, 0x3F, 0xCF, 0x01, 0xF1, 0xF0,
  0x01, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xE1, 0xF3, 0xC0, 0x7B, 0xE0,
  0x3D, 0xE0, 0x3F, 0xF0, 0xFE, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0x63, 0xC0, 0x79, 0xF0, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x30, 0xF8, 0x00, 0xF0, 0xF8, 0x00,
  0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF3, 0xE1, 0xFF, 0x7C, 0x7F,
  0xFF, 0x8F, 0x87, 0xE3, 0xE0, 0x7C, 0x78, 0x07, 0x9F, 0x01, 0xF3, 0xE0,
  0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80,
  0xF8, 0xF0, 0x3F, 0x1F, 0x0F, 0xE3, 0xFF, 0x78, 0x3F, 0xCF, 0x01, 0xF1,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x02, 0x03, 0xE0, 0xE0, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x1E, 0x07, 0x9F, 0xE1, 0xEF, 0xF8, 0x7A, 0x1F, 0x3F, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE7, 0xC0,
  0x79, 0xF0, 0x1E, 0x7C, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x06, 0x0F, 0x0F, 0x1F, 0x1E, 0x1F,
  0x3C, 0x1F, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x20, 0xF8, 0x38, 0x7C, 0x3C, 0x3E, 0x0F, 0x1E, 0x07, 0xCF, 0x01, 0xF7,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x1F, 0x03, 0xCF, 0xF0, 0x7B, 0xFF, 0x0F, 0x43,
  0xE3, 0xF0, 0x7C, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xE0, 0x3C, 0x3C, 0x1F,
  0x07, 0x8F, 0x81, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xCF, 0x0C, 0xF1, 0xF3,
  0xDE, 0x1E, 0xF3, 0xC3, 0xFC, 0xF8, 0x3F, 0x1F, 0x03, 0xC0, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x30, 0xF0, 0xF1,
  0xE3, 0xC7, 0xCF, 0x0F, 0xBC, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C,
  0xF1, 0xE1, 0xDF, 0xBF, 0x3D, 0xFB, 0xF3, 0xE7, 0xCF, 0x3C, 0x7C, 0x73,
  0xC7, 0x87, 0x38, 0x78, 0xF3, 0x87, 0x8F, 0x78, 0x70, 0xF7, 0x87, 0x0F,
  0x78, 0xF0, 0xE7, 0x8F, 0x0E, 0x70, 0xF1, 0xE7, 0x0F, 0x1E, 0xF0, 0xE1,
  0xEF, 0x0E, 0x1E, 0xF1, 0xE1, 0xCF, 0x1E, 0x1C, 0x1F, 0x1E, 0x07, 0x9F,
  0xE1, 0xEF, 0xF8, 0x7A, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C,
  0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0x7C,
  0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03,
  0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC3, 0xE7, 0xC0, 0xFB,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0xF9, 0xF0, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0xF3, 0xFC, 0x0F, 0x7F, 0xE1,
  0xFC, 0x3E, 0x1F, 0x81, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x1F,
  0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03,
  0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0x87, 0xFF, 0xF8, 0x7D, 0xFF, 0x07, 0xCF,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF3, 0xE1, 0xFF, 0x7C,
  0x7F, 0xFF, 0x8F, 0x87, 0xE3, 0xE0, 0x7C, 0x78, 0x07, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x07, 0xC7,
  0x80, 0xF8, 0xF0, 0x3F, 0x1F, 0x0F, 0xE3, 0xFF, 0x78, 0x3F, 0xCF, 0x03,
  0xF1, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xC7, 0xDF, 0xF3, 0xF7,
  0xF9, 0xFA, 0x1E, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x1E, 0x1E, 0x01, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x8C, 0x03, 0xE7, 0xC1, 0xF3, 0xFF, 0xF8,
  0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x02, 0x07, 0x83, 0x83, 0xC3, 0xE3, 0xE7, 0xC1,
  0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0x80, 0x3C, 0x07, 0xCF, 0x01,
  0xF3, 0xC0, 0x79, 0xF0, 0x1E, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0x80, 0xF9,
  0xE0, 0x3E, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x0F, 0xCF, 0x85, 0xE1, 0xFF, 0x78, 0x7F, 0x9E, 0x07, 0x8F,
  0x80, 0xFF, 0x03, 0x7F, 0x87, 0xBF, 0x83, 0xE3, 0xC1, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0xCF, 0x03,
  0xC7, 0x83, 0xE7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x78, 0xC7, 0x0E, 0x3C, 0xE1, 0xC7, 0xBC,
  0x38, 0xF7, 0x8F, 0x1E, 0xF1, 0xE1, 0xDC, 0x3C, 0x7B, 0x87, 0x8F, 0x70,
  0xE1, 0xFE, 0x1C, 0x3F, 0xC7, 0x87, 0x78, 0xF0, 0xEE, 0x1E, 0x3D, 0xC3,
  0xC7, 0x3C, 0xB8, 0xE7, 0xF7, 0x38, 0xFC, 0xFE, 0x0F, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x3F, 0x1F, 0x87, 0xFD, 0xFE, 0x7D, 0xEC, 0xF7, 0xC7, 0x47,
  0x88, 0x3E, 0x3C, 0x01, 0xE1, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x61, 0xE0, 0x0F, 0x1F, 0x06, 0x78, 0xB8, 0xF3,
  0xCD, 0xEF, 0xDF, 0xEF, 0xF8, 0x7E, 0x3F, 0x81, 0xE0, 0xF0, 0x00, 0x0F,
  0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1,
  0xF0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xC3, 0xE0, 0x3C,
  0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x17,
  0x81, 0xFF, 0x78, 0x1F, 0xE7, 0x80, 0x78, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x20, 0x1F, 0x03, 0x83, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x07, 0xE1, 0xE3, 0xFF, 0x3C, 0x7F, 0xF7, 0x9E, 0x1F, 0xF3,
  0xC0, 0xFC, 0x70, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x06, 0x07, 0xC1, 0xC1, 0xF0, 0x3C, 0x7C, 0x07, 0x9F,
  0xFC, 0x77, 0xBF, 0xFE, 0xF1, 0xFF, 0x9E, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1F, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xC1, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x81, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0x80, 0xE3, 0xF8, 0x1C, 0xFF, 0x87, 0xBC, 0xF0, 0xE7, 0x0F,
  0x3D, 0xE0, 0xFF, 0x3C, 0x1F, 0xC3, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 24, 21, 6, -24 },
  { 28, 13, 11, 21, 6, -26 },
  { 46, 22, 24, 21, 0, -24 },
  { 112, 20, 32, 21, 1, -28 },
  { 192, 24, 24, 21, -1, -24 },
  { 264, 21, 24, 21, 0, -24 },
  { 327, 5, 11, 21, 10, -26 },
  { 334, 15, 32, 21, 6, -27 },
  { 394, 14, 32, 21, 1, -27 },
  { 450, 18, 18, 21, 2, -19 },
  { 491, 17, 17, 21, 2, -19 },
  { 528, 10, 11, 21, 4, -6 },
  { 542, 12, 4, 21, 5, -13 },
  { 548, 7, 6, 21, 6, -6 },
  { 554, 21, 32, 21, 0, -27 },
  { 638, 18, 24, 21, 2, -24 },
  { 692, 17, 24, 21, 2, -24 },
  { 743, 19, 24, 21, 1, -24 },
  { 800, 19, 24, 21, 1, -24 },
  { 857, 20, 24, 21, 0, -24 },
  { 917, 20, 24, 21, 1, -24 },
  { 977, 17, 24, 21, 2, -24 },
  { 1028, 18, 24, 21, 3, -24 },
  { 1082, 19, 24, 21, 1, -24 },
  { 1139, 18, 24, 21, 2, -24 },
  { 1193, 9, 19, 21, 6, -19 },
  { 1215, 11, 24, 21, 4, -19 },
  { 1248, 17, 21, 21, 3, -21 },
  { 1293, 18, 11, 21, 2, -16 },
  { 1318, 17, 21, 21, 2, -21 },
  { 1363, 16, 24, 21, 4, -24 },
  { 1411, 19, 28, 21, 1, -24 },
  { 1478, 20, 24, 21, -1, -24 },
  { 1538, 19, 24, 21, 1, -24 },
  { 1595, 19, 24, 21, 2, -24 },
  { 1652, 19, 24, 21, 1, -24 },
  { 1709, 20, 24, 21, 1, -24 },
  { 1769, 20, 24, 21, 1, -24 },
  { 1829, 18, 24, 21, 2, -24 },
  { 1883, 20, 24, 21, 1, -24 },
  { 1943, 20, 24, 21, 1, -24 },
  { 2003, 19, 24, 21, 1, -24 },
  { 2060, 22, 24, 21, 1, -24 },
  { 2126, 16, 24, 21, 2, -24 },
  { 2174, 22, 24, 21, 0, -24 },
  { 2240, 20, 24, 21, 1, -24 },
  { 2300, 18, 24, 21, 2, -24 },
  { 2354, 20, 24, 21, 1, -24 },
  { 2414, 18, 31, 21, 2, -24 },
  { 2484, 20, 24, 21, 1, -24 },
  { 2544, 20, 24, 21, 1, -24 },
  { 2604, 20, 24, 21, 3, -24 },
  { 2664, 19, 24, 21, 2, -24 },
  { 2721, 20, 24, 21, 3, -24 },
  { 2781, 22, 24, 21, 1, -24 },
  { 2847, 24, 24, 21, -1, -24 },
  { 2919, 20, 24, 21, 3, -24 },
  { 2979, 21, 24, 21, 0, -24 },
  { 3042, 16, 32, 21, 5, -27 },
  { 3106, 10, 32, 21, 6, -27 },
  { 3146, 16, 32, 21, 1, -27 },
  { 3210, 19, 15, 21, 1, -24 },
  { 3246, 17, 3, 21, 0, 3 },
  { 3253, 6, 8, 21, 7, -28 },
  { 3259, 19, 18, 21, 1, -18 },
  { 3302, 19, 26, 21, 1, -26 },
  { 3364, 17, 18, 21, 2, -18 },
  { 3403, 20, 26, 21, 1, -26 },
  { 3468, 17, 18, 21, 2, -18 },
  { 3507, 24, 33, 21, -1, -26 },
  { 3606, 19, 25, 21, 1, -18 },
  { 3666, 18, 26, 21, 1, -26 },
  { 3725, 16, 26, 21, 3, -26 },
  { 3777, 17, 33, 21, 1, -26 },
  { 3848, 19, 26, 21, 1, -26 },
  { 3910, 15, 26, 21, 3, -26 },
  { 3959, 20, 18, 21, 0, -18 },
  { 4004, 18, 18, 21, 1, -18 },
  { 4045, 17, 18, 21, 2, -18 },
  { 4084, 20, 25, 21, 0, -18 },
  { 4147, 19, 25, 21, 1, -18 },
  { 4207, 18, 18, 21, 3, -18 },
  { 4248, 18, 18, 21, 1, -18 },
  { 4289, 17, 24, 21, 2, -24 },
  { 4340, 18, 18, 21, 2, -18 },
  { 4381, 17, 18, 21, 2, -18 },
  { 4420, 19, 18, 21, 1, -18 },
  { 4463, 21, 18, 21, 0, -18 },
  { 4511, 20, 25, 21, 0, -18 },
  { 4574, 19, 18, 21, 1, -18 },
  { 4617, 17, 32, 21, 4, -27 },
  { 4685, 9, 32, 21, 6, -27 },
  { 4721, 17, 32, 21, 1, -27 },
  { 4789, 19, 8, 21, 1, -15 },
};

const GFXfont IBMPlexMono_SemiBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC35PT7B_H_
