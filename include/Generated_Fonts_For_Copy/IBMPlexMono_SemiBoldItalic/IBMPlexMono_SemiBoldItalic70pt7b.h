#ifndef _IBMPLEXMONO_SEMIBOLDITALIC70PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xE7, 0xFE, 0x01, 0xFF, 0x87,
  0xE1, 0xFC, 0x01, 0xFF, 0x07, 0xE0, 0xF8, 0x03, 0xFE, 0x07, 0xE0, 0x70,
  0x03, 0xFE, 0x07, 0xE0, 0x20, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xFC,
  0x07, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x03,
  0xFF, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x8F, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x3E, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0x00,
  0x7C, 0x07, 0xFC, 0x04, 0x00, 0x7C, 0x0F, 0xF8, 0x06, 0x00, 0xFC, 0x0F,
  0xF8, 0x0F, 0x00, 0xFC, 0x1F, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFC, 0x7F, 0xF0, 0xFF, 0xFC, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0xF7,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x08, 0x3F, 0xE0,
  0x07, 0xFC, 0x03, 0x8F, 0xF8, 0x00, 0xFF, 0x01, 0xF1, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0x7F, 0x80, 0x1F, 0xF8, 0x3F, 0x9F, 0xF0, 0x06, 0xFE, 0x1F,
  0xC7, 0xFC, 0x03, 0xBF, 0xC7, 0xF1, 0xFF, 0xC3, 0xCF, 0xF3, 0xF8, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x07, 0xF8,
  0x01, 0x87, 0xC0, 0x3F, 0x80, 0x7C, 0x7F, 0x83, 0xFC, 0x1F, 0xE3, 0xFF,
  0x9F, 0xE7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x0F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07,
  0xFD, 0xFF, 0x81, 0xF0, 0x1F, 0xF7, 0xFC, 0x1F, 0xE0, 0x7F, 0xDF, 0xF0,
  0x7F, 0xC3, 0xFF, 0x7F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F,
  0xEF, 0xFC, 0x3F, 0xE0, 0xFF, 0xBF, 0xF0, 0x7F, 0x83, 0xFE, 0xFF, 0xC0,
  0xF8, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0xEF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xE0,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xE0,
  0x1F, 0xF0, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x7F, 0xC0, 0x00,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x00,
  0x3F, 0xF0, 0x01, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x40, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0x80, 0x00, 0x0F,
  0xFC, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFF, 0xE0,
  0x00, 0x7F, 0x8F, 0xFF, 0xF0, 0x00, 0xFE, 0x3F, 0xFF, 0xF0, 0x01, 0xFC,
  0xFF, 0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0x80, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x40, 0x00, 0x07, 0xFE, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xF0, 0x3F, 0xF7, 0xFF, 0xFF, 0x83, 0xFE,
  0xFF, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF0, 0x3F, 0xFE,
  0x7F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x00, 0x07,
  0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xC0,
  0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF,
  0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF,
  0xEF, 0xF8, 0x1F, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xF9, 0xF8, 0x00, 0x1F, 0xF0, 0xE0, 0x00, 0x3F, 0xE0, 0x40, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x7C, 0x1F, 0xC3,
  0xF8, 0x07, 0xFC, 0x7F, 0x1F, 0xC0, 0x7F, 0xFB, 0xFC, 0x7F, 0x03, 0xFF,
  0xEF, 0xE1, 0xFC, 0x0F, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F,
  0x81, 0xFC, 0x07, 0xF8, 0xFE, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x3F, 0x80,
  0x7F, 0x9F, 0xE1, 0xFE, 0x01, 0xFC, 0x7F, 0x87, 0xF0, 0x07, 0xF1, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC3, 0xFC, 0x01,
  0xFC, 0x7F, 0x0F, 0xF0, 0x07, 0xF1, 0xFC, 0x3F, 0x80, 0x3F, 0xCF, 0xF0,
  0xFE, 0x00, 0xFE, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0xFE, 0x01, 0xFE, 0x3F, 0x83,
  0xF8, 0x0F, 0xF8, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x3F, 0xC1, 0xFF,
  0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0x3F, 0x81, 0xFF, 0xF7, 0xF0, 0xFE, 0x07,
  0xFF, 0xDF, 0xC3, 0xF8, 0x1F, 0xFE, 0x7F, 0x0F, 0xE0, 0x3F, 0xF3, 0xF8,
  0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0x81, 0xFF,
  0x80, 0x00, 0x60, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x30, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0xFF, 0x3F, 0xF0,
  0x0F, 0xFF, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xFC,
  0x7F, 0xC0, 0x3F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3D, 0xFE, 0x03, 0xFF, 0xFF,
  0xEF, 0xF0, 0x1F, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0xE7, 0xF8, 0x01,
  0xFF, 0xFE, 0x3F, 0xC0, 0x07, 0xFF, 0xE1, 0xFE, 0x00, 0x1F, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x1F,
  0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x03, 0xFD, 0xFC, 0x3F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC3, 0xFB, 0xFC, 0x03,
  0xFD, 0xFC, 0x7F, 0x3F, 0x80, 0x3F, 0xDF, 0xC7, 0xF3, 0xF8, 0x03, 0xF8,
  0xFE, 0xFE, 0x7F, 0x80, 0x3F, 0x8F, 0xEF, 0xE7, 0xF8, 0x07, 0xF8, 0xFF,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xFF, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0xF8,
  0x7F, 0x00, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xF0, 0xFF,
  0x00, 0x7F, 0x07, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x18, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x10, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xF8,
  0x01, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFB,
  0xFC, 0x03, 0xFC, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0x07, 0xF9, 0xFC, 0x03,
  0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x07,
  0xF9, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F,
  0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xDF, 0xE0, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0,
  0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0x80,
  0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xFF,
  0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F,
  0x80, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0xC0,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x20, 0x00, 0x07, 0xFC, 0x01,
  0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x04, 0x00, 0x00, 0x1F,
  0xF0, 0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFE, 0x01, 0xFC, 0x0F,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xFF,
  0x83, 0xFC, 0x03, 0xF8, 0x1F, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFF, 0xE0,
  0xFE, 0x01, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7D, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xEF, 0xC3, 0xFC, 0x03, 0xFC, 0x3E, 0x7E, 0x1F, 0xC0,
  0x1F, 0xE1, 0xF3, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x9F, 0x87, 0xF0, 0x07,
  0xF0, 0xFC, 0xFC, 0x7F, 0x80, 0x3F, 0x87, 0xC7, 0xE3, 0xF8, 0x01, 0xFC,
  0x7E, 0x3F, 0x1F, 0xC0, 0x1F, 0xE3, 0xF1, 0xF8, 0xFE, 0x00, 0xFF, 0x1F,
  0x0F, 0xCF, 0xF0, 0x07, 0xF9, 0xF8, 0x7E, 0x7F, 0x00, 0x3F, 0xCF, 0xC3,
  0xF3, 0xF8, 0x01, 0xFE, 0x7C, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0x07, 0xEF, 0xF0, 0x03, 0xF9, 0xF0, 0x3F, 0x7F,
  0x00, 0x1F, 0xDF, 0x81, 0xFB, 0xF8, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xC0,
  0x0F, 0xF7, 0xC0, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00,
  0x70, 0x3F, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xC0, 0x30, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xF0,
  0x1F, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xF9,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFC, 0x03, 0xDF,
  0xE0, 0x7F, 0xF0, 0x7B, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xE1,
  0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0x80, 0x03, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xFC,
  0x00, 0xFF, 0x8F, 0xFF, 0xF0, 0x07, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F, 0xCF,
  0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xF8, 0x1F, 0xF7, 0xC1, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0xFE, 0x03,
  0xFC, 0x7F, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xD1, 0xFF, 0x00, 0x03, 0xC0, 0x7F, 0xC0, 0x00, 0xC0, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x40, 0xFF, 0x80, 0x00, 0x3C, 0x3F, 0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF,
  0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xFB, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xBF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xF1, 0xFE, 0x00,
  0x3F, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x07, 0xF8,
  0x00, 0x03, 0xC1, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x0F, 0xF8, 0x03,
  0xFF, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE,
  0xFF, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x7B, 0xFC, 0x03, 0xFF, 0x81, 0xEF, 0xF8, 0x07, 0xFF,
  0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xFC, 0x7F,
  0xC0, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFE, 0x00, 0x0F,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0x38, 0x00, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xFE,
  0x07, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0xFF, 0xC0,
  0x3F, 0xE7, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF,
  0xFE, 0x07, 0xFD, 0xF0, 0x7F, 0xF0, 0x7F, 0xDC, 0x03, 0xFF, 0x07, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x01,
  0x00, 0x03, 0xFE, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xC0, 0x07, 0xF8,
  0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x02, 0x00, 0x3F, 0xE0,
  0x00, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0xFF, 0x00,
  0xFF, 0x9F, 0xFF, 0xFE, 0x01, 0xFF, 0x7C, 0x1F, 0xFC, 0x03, 0xFE, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x20, 0x3F, 0xE1, 0xFF, 0x00,
  0x60, 0x7F, 0xC1, 0xFF, 0x01, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xE1, 0xFF,
  0x03, 0xFE, 0x1F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xE7, 0xF8, 0x0F, 0xF9,
  0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F,
  0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x20, 0x07, 0xFC, 0x01, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x7F,
  0xC0, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF9, 0xFF,
  0x80, 0x3F, 0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xFC, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF,
  0x7F, 0xF1, 0xFF, 0xE0, 0x7F, 0x3F, 0xFC, 0xFF, 0xF8, 0x3F, 0xBF, 0xFE,
  0xFF, 0xFC, 0x1F, 0xDF, 0xFF, 0x7F, 0xFE, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0xF0, 0x03, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0xFC, 0x03,
  0xFE, 0x7F, 0xFF, 0xE0, 0x3F, 0xE7, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0xFF,
  0xE0, 0x7F, 0xDF, 0x07, 0xFF, 0x07, 0xFD, 0xC0, 0x3F, 0xF0, 0x7F, 0xF8,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03,
  0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xFF,
  0x00, 0x7F, 0xDF, 0xFF, 0xFF, 0x00, 0xFF, 0xBE, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0xC0,
  0x3F, 0xE7, 0xFF, 0xFF, 0x00, 0x7F, 0x8F, 0xFF, 0xFC, 0x01, 0xFF, 0x0F,
  0xFF, 0xE0, 0x03, 0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x7F, 0xC0, 0x1F, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F,
  0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xFF, 0xEF, 0xF8, 0x1F, 0xFF, 0xFF, 0x7F,
  0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0x0F,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xC1, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF9, 0xFF,
  0x01, 0xFF, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xFF,
  0x87, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0x07,
  0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0xFC, 0x7F, 0xFD, 0xFF, 0xFF,
  0x9F, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xFC, 0x00,
  0xFF, 0x9F, 0xFF, 0x80, 0x1F, 0xF7, 0xC0, 0x00, 0x03, 0xFE, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x1F, 0xE0,
  0x00, 0x10, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x06, 0x00, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x07,
  0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0x80, 0x07, 0xFC, 0x00, 0xF0, 0x01, 0xFF,
  0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0x8F, 0xFE, 0x00,
  0x3F, 0xE7, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x3B, 0xFE, 0x0F, 0xFE, 0x0F, 0xBF,
  0xE0, 0x7F, 0xFF, 0xF3, 0xFC, 0x07, 0xFF, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF,
  0xE7, 0xFC, 0x03, 0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x8F, 0xFF, 0xF0, 0x01, 0xF1, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xFF,
  0x80, 0x7F, 0xE7, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x81, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x7F, 0x00, 0xFE, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0x1F,
  0xCF, 0xE0, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0x7F,
  0x7F, 0x00, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF7, 0xF0, 0x0F,
  0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x03, 0xF9,
  0xFC, 0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F,
  0x01, 0xFE, 0xFE, 0x03, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8,
  0x1F, 0xE3, 0xF8, 0x3F, 0xE0, 0x7F, 0x0F, 0xF1, 0xFF, 0x83, 0xF8, 0x3F,
  0xFF, 0x7F, 0x1F, 0xE0, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xE3, 0xFF,
  0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0xF9,
  0xFC, 0xF0, 0xFF, 0x1F, 0xFC, 0x7F, 0x78, 0x3F, 0xC7, 0xFC, 0x1F, 0xDC,
  0x07, 0xF0, 0xFE, 0x07, 0xF7, 0x01, 0xFC, 0x1E, 0x01, 0xFF, 0x80, 0x7F,
  0x07, 0x00, 0x7F, 0xE0, 0x1F, 0xC1, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x10, 0x3F, 0x80, 0x7F, 0xE0,
  0x0E, 0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xC3, 0xF8, 0x0E, 0xFE, 0x07, 0xF0,
  0xFE, 0x03, 0xBF, 0x83, 0xFE, 0x3F, 0xC1, 0xEF, 0xE3, 0xFF, 0xCF, 0xF0,
  0xF3, 0xF9, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x3B, 0xFE, 0x00, 0xFF, 0xE0,
  0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFF, 0x9F, 0xE0,
  0x03, 0xFF, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x07, 0xFF,
  0xE1, 0xFF, 0x00, 0x07, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x08, 0x00, 0x03, 0xFE,
  0x00, 0x18, 0x00, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xFF,
  0xE3, 0xFC, 0x1F, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0x80, 0x07,
  0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x06, 0x00, 0x03,
  0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x00, 0xFE, 0x03, 0xFF,
  0x00, 0x01, 0xF8, 0x3F, 0xFF, 0x00, 0x07, 0xF1, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xFC,
  0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xF0,
  0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0xFF,
  0x80, 0x3F, 0x87, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xF1, 0xFF, 0x03, 0xFC,
  0x3F, 0xC1, 0xFF, 0x07, 0xF0, 0x7F, 0x01, 0xFF, 0x1F, 0xE1, 0xFE, 0x03,
  0xFF, 0xFF, 0x83, 0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x03, 0xFF, 0xFC,
  0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0x00,
  0x07, 0xFF, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 19, 50, 42, 12, -49 },
  { 120, 26, 22, 42, 12, -52 },
  { 192, 44, 49, 42, 0, -49 },
  { 462, 40, 65, 42, 1, -57 },
  { 787, 49, 51, 42, -2, -50 },
  { 1100, 42, 51, 42, 0, -50 },
  { 1368, 12, 22, 42, 19, -52 },
  { 1401, 28, 63, 42, 13, -53 },
  { 1622, 29, 63, 42, 2, -53 },
  { 1851, 37, 35, 42, 3, -38 },
  { 2013, 35, 35, 42, 4, -39 },
  { 2167, 19, 21, 42, 8, -11 },
  { 2217, 23, 9, 42, 10, -26 },
  { 2243, 14, 13, 42, 12, -12 },
  { 2266, 41, 63, 42, 1, -53 },
  { 2589, 38, 51, 42, 3, -50 },
  { 2832, 35, 49, 42, 3, -49 },
  { 3047, 39, 50, 42, 1, -50 },
  { 3291, 39, 51, 42, 1, -50 },
  { 3540, 39, 49, 42, 1, -49 },
  { 3779, 39, 50, 42, 2, -49 },
  { 4023, 36, 50, 42, 3, -49 },
  { 4248, 37, 49, 42, 6, -49 },
  { 4475, 39, 51, 42, 2, -50 },
  { 4724, 36, 50, 42, 5, -50 },
  { 4949, 18, 38, 42, 12, -37 },
  { 5035, 22, 47, 42, 8, -37 },
  { 5165, 34, 41, 42, 6, -42 },
  { 5340, 37, 23, 42, 3, -33 },
  { 5447, 34, 41, 42, 3, -42 },
  { 5622, 31, 51, 42, 8, -50 },
  { 5820, 38, 58, 42, 3, -50 },
  { 6096, 40, 49, 42, -2, -49 },
  { 6341, 37, 49, 42, 3, -49 },
  { 6568, 38, 51, 42, 4, -50 },
  { 6811, 39, 49, 42, 2, -49 },
  { 7050, 39, 49, 42, 3, -49 },
  { 7289, 40, 49, 42, 3, -49 },
  { 7534, 37, 51, 42, 4, -50 },
  { 7770, 40, 49, 42, 2, -49 },
  { 8015, 40, 49, 42, 2, -49 },
  { 8260, 37, 50, 42, 3, -49 },
  { 8492, 44, 49, 42, 2, -49 },
  { 8762, 32, 49, 42, 4, -49 },
  { 8958, 44, 49, 42, 0, -49 },
  { 9228, 40, 49, 42, 2, -49 },
  { 9473, 38, 51, 42, 3, -50 },
  { 9716, 38, 49, 42, 3, -49 },
  { 9949, 38, 64, 42, 3, -50 },
  { 10253, 38, 49, 42, 3, -49 },
  { 10486, 40, 51, 42, 1, -50 },
  { 10741, 39, 49, 42, 6, -49 },
  { 10980, 39, 50, 42, 4, -49 },
  { 11224, 40, 49, 42, 6, -49 },
  { 11469, 45, 49, 42, 1, -49 },
  { 11745, 47, 49, 42, -2, -49 },
  { 12033, 40, 49, 42, 6, -49 },
  { 12278, 43, 49, 42, 0, -49 },
  { 12542, 32, 63, 42, 9, -53 },
  { 12794, 19, 63, 42, 12, -53 },
  { 12944, 32, 63, 42, 2, -53 },
  { 13196, 37, 30, 42, 3, -49 },
  { 13335, 35, 7, 42, -1, 6 },
  { 13366, 12, 16, 42, 14, -56 },
  { 13390, 36, 38, 42, 3, -37 },
  { 13561, 37, 53, 42, 2, -52 },
  { 13807, 34, 38, 42, 4, -37 },
  { 13969, 39, 53, 42, 3, -52 },
  { 14228, 34, 38, 42, 4, -37 },
  { 14390, 48, 67, 42, -2, -52 },
  { 14792, 39, 52, 42, 1, -37 },
  { 15046, 36, 52, 42, 2, -52 },
  { 15280, 33, 54, 42, 5, -53 },
  { 15503, 36, 68, 42, 1, -53 },
  { 15809, 39, 53, 42, 2, -52 },
  { 16068, 30, 53, 42, 7, -52 },
  { 16267, 41, 37, 42, 0, -37 },
  { 16457, 36, 37, 42, 2, -37 },
  { 16624, 36, 38, 42, 3, -37 },
  { 16795, 39, 51, 42, 0, -37 },
  { 17044, 37, 51, 42, 3, -37 },
  { 17280, 35, 36, 42, 7, -36 },
  { 17438, 35, 38, 42, 3, -37 },
  { 17605, 34, 50, 42, 5, -49 },
  { 17818, 36, 37, 42, 4, -36 },
  { 17985, 35, 38, 42, 3, -37 },
  { 18152, 38, 38, 42, 2, -37 },
  { 18333, 42, 38, 42, 0, -37 },
  { 18533, 39, 51, 42, 1, -36 },
  { 18782, 38, 38, 42, 2, -37 },
  { 18963, 34, 63, 42, 7, -53 },
  { 19231, 18, 63, 42, 13, -53 },
  { 19373, 34, 63, 42, 2, -53 },
  { 19641, 39, 17, 42, 2, -30 },
};

const GFXfont IBMPlexMono_SemiBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic70pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC70PT7B_H_
