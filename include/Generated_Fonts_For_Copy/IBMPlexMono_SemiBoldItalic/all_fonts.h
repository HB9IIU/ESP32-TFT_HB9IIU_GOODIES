#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/IBMPlexMono_SemiBoldItalic
// Headers: 67

#include "IBMPlexMono_SemiBoldItalic6pt7b.h"
#include "IBMPlexMono_SemiBoldItalic7pt7b.h"
#include "IBMPlexMono_SemiBoldItalic8pt7b.h"
#include "IBMPlexMono_SemiBoldItalic9pt7b.h"
#include "IBMPlexMono_SemiBoldItalic10pt7b.h"
#include "IBMPlexMono_SemiBoldItalic11pt7b.h"
#include "IBMPlexMono_SemiBoldItalic12pt7b.h"
#include "IBMPlexMono_SemiBoldItalic13pt7b.h"
#include "IBMPlexMono_SemiBoldItalic14pt7b.h"
#include "IBMPlexMono_SemiBoldItalic15pt7b.h"
#include "IBMPlexMono_SemiBoldItalic16pt7b.h"
#include "IBMPlexMono_SemiBoldItalic17pt7b.h"
#include "IBMPlexMono_SemiBoldItalic18pt7b.h"
#include "IBMPlexMono_SemiBoldItalic19pt7b.h"
#include "IBMPlexMono_SemiBoldItalic20pt7b.h"
#include "IBMPlexMono_SemiBoldItalic21pt7b.h"
#include "IBMPlexMono_SemiBoldItalic22pt7b.h"
#include "IBMPlexMono_SemiBoldItalic23pt7b.h"
#include "IBMPlexMono_SemiBoldItalic24pt7b.h"
#include "IBMPlexMono_SemiBoldItalic25pt7b.h"
#include "IBMPlexMono_SemiBoldItalic26pt7b.h"
#include "IBMPlexMono_SemiBoldItalic27pt7b.h"
#include "IBMPlexMono_SemiBoldItalic28pt7b.h"
#include "IBMPlexMono_SemiBoldItalic29pt7b.h"
#include "IBMPlexMono_SemiBoldItalic30pt7b.h"
#include "IBMPlexMono_SemiBoldItalic31pt7b.h"
#include "IBMPlexMono_SemiBoldItalic32pt7b.h"
#include "IBMPlexMono_SemiBoldItalic33pt7b.h"
#include "IBMPlexMono_SemiBoldItalic34pt7b.h"
#include "IBMPlexMono_SemiBoldItalic35pt7b.h"
#include "IBMPlexMono_SemiBoldItalic36pt7b.h"
#include "IBMPlexMono_SemiBoldItalic37pt7b.h"
#include "IBMPlexMono_SemiBoldItalic38pt7b.h"
#include "IBMPlexMono_SemiBoldItalic39pt7b.h"
#include "IBMPlexMono_SemiBoldItalic40pt7b.h"
#include "IBMPlexMono_SemiBoldItalic41pt7b.h"
#include "IBMPlexMono_SemiBoldItalic42pt7b.h"
#include "IBMPlexMono_SemiBoldItalic43pt7b.h"
#include "IBMPlexMono_SemiBoldItalic44pt7b.h"
#include "IBMPlexMono_SemiBoldItalic45pt7b.h"
#include "IBMPlexMono_SemiBoldItalic46pt7b.h"
#include "IBMPlexMono_SemiBoldItalic47pt7b.h"
#include "IBMPlexMono_SemiBoldItalic48pt7b.h"
#include "IBMPlexMono_SemiBoldItalic49pt7b.h"
#include "IBMPlexMono_SemiBoldItalic50pt7b.h"
#include "IBMPlexMono_SemiBoldItalic51pt7b.h"
#include "IBMPlexMono_SemiBoldItalic52pt7b.h"
#include "IBMPlexMono_SemiBoldItalic53pt7b.h"
#include "IBMPlexMono_SemiBoldItalic54pt7b.h"
#include "IBMPlexMono_SemiBoldItalic55pt7b.h"
#include "IBMPlexMono_SemiBoldItalic56pt7b.h"
#include "IBMPlexMono_SemiBoldItalic57pt7b.h"
#include "IBMPlexMono_SemiBoldItalic58pt7b.h"
#include "IBMPlexMono_SemiBoldItalic59pt7b.h"
#include "IBMPlexMono_SemiBoldItalic60pt7b.h"
#include "IBMPlexMono_SemiBoldItalic61pt7b.h"
#include "IBMPlexMono_SemiBoldItalic62pt7b.h"
#include "IBMPlexMono_SemiBoldItalic63pt7b.h"
#include "IBMPlexMono_SemiBoldItalic64pt7b.h"
#include "IBMPlexMono_SemiBoldItalic65pt7b.h"
#include "IBMPlexMono_SemiBoldItalic66pt7b.h"
#include "IBMPlexMono_SemiBoldItalic67pt7b.h"
#include "IBMPlexMono_SemiBoldItalic68pt7b.h"
#include "IBMPlexMono_SemiBoldItalic69pt7b.h"
#include "IBMPlexMono_SemiBoldItalic70pt7b.h"
#include "IBMPlexMono_SemiBoldItalic71pt7b.h"
#include "IBMPlexMono_SemiBoldItalic72pt7b.h"
