#ifndef _IBMPLEXMONO_SEMIBOLDITALIC20PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x8E, 0x38, 0xC3, 0x0C, 0x00, 0x07, 0x1C, 0x73, 0xC0,
  0x77, 0x67, 0x66, 0x66, 0x66, 0xE6, 0x03, 0x70, 0x33, 0x01, 0x98, 0x0D,
  0x83, 0xCF, 0xBE, 0x78, 0x36, 0x03, 0x30, 0xF9, 0xE7, 0xDF, 0x0C, 0xC0,
  0x66, 0x03, 0x60, 0x33, 0x00, 0x01, 0x80, 0x18, 0x0F, 0xC1, 0xFE, 0x3B,
  0x73, 0x30, 0x33, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x06, 0xE0, 0x66, 0x46,
  0xE6, 0x4E, 0xFF, 0xC1, 0xF0, 0x0C, 0x00, 0xC0, 0x0E, 0x0C, 0x7C, 0x63,
  0x11, 0x8C, 0xCC, 0x33, 0x60, 0xFD, 0x81, 0xE8, 0x00, 0x3C, 0x0D, 0xF0,
  0x66, 0x61, 0xB1, 0x8C, 0xCC, 0x63, 0xF3, 0x87, 0x80, 0x07, 0x80, 0xFC,
  0x1C, 0xE1, 0xCE, 0x1C, 0xE0, 0xCC, 0x3F, 0x87, 0xE0, 0xE6, 0x0E, 0x70,
  0xE3, 0x2E, 0x7F, 0x7D, 0xE7, 0x9C, 0x76, 0x66, 0x6E, 0x07, 0x0C, 0x18,
  0x30, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x06, 0x06, 0x0C, 0x1C, 0x38, 0x70, 0xE0, 0x06, 0x01, 0x80,
  0xE3, 0xB7, 0xFF, 0xC7, 0xC1, 0xE0, 0xDC, 0x63, 0x38, 0xE0, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x1C, 0x07, 0x00, 0x3C,
  0xE7, 0x1C, 0x63, 0x80, 0xFF, 0xF0, 0x77, 0xF7, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x0F,
  0x87, 0xF8, 0xC3, 0x38, 0x76, 0x0F, 0xD9, 0xFB, 0xBF, 0x66, 0xC0, 0xD8,
  0x3B, 0x07, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC3, 0xB1, 0xDC,
  0xE7, 0x19, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF,
  0xF0, 0x07, 0x83, 0xFC, 0xE3, 0x98, 0x30, 0x06, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x38, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xC3, 0xFC,
  0xE3, 0x88, 0x30, 0x06, 0x01, 0xC3, 0xE0, 0x7C, 0x01, 0xC0, 0x1D, 0x03,
  0xF0, 0xE7, 0xF8, 0x7E, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x83, 0x60, 0xEC,
  0x39, 0x8E, 0x71, 0x8E, 0x61, 0xDF, 0xFF, 0xFF, 0x80, 0xC0, 0x38, 0x07,
  0x00, 0x3F, 0xE7, 0xF8, 0xC0, 0x18, 0x06, 0x00, 0xDE, 0x1F, 0xE3, 0x0E,
  0x01, 0xC0, 0x39, 0x07, 0x71, 0xCF, 0xF0, 0x7C, 0x00, 0x03, 0xC3, 0xC1,
  0xC0, 0xE0, 0x70, 0x1D, 0xEF, 0xFF, 0xC7, 0xE1, 0xF0, 0x7C, 0x1F, 0x8E,
  0x7F, 0x8F, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0x0E, 0xC3, 0x81, 0xC0, 0x60,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x00, 0x0F, 0x87, 0xF9,
  0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x8F, 0xE1, 0xFC, 0xE1, 0xD8, 0x3B, 0x07,
  0x71, 0xEF, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xF9, 0xC7, 0x30, 0x7E, 0x0F,
  0xC1, 0xDC, 0x73, 0xFE, 0x3D, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x00, 0x39, 0xCE, 0x70, 0x00, 0x0E, 0x77, 0x9C, 0x1C, 0x71, 0xC7, 0x00,
  0x00, 0x00, 0x3C, 0xE7, 0x1C, 0x63, 0x80, 0x00, 0x81, 0xC1, 0xE3, 0xC7,
  0x87, 0x03, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xC0, 0x20, 0x7F, 0xDF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x20, 0x0C, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x70, 0x38, 0x3E, 0x3E, 0x3E, 0x0E, 0x02, 0x00, 0x1F, 0x3F, 0xF8, 0xE8,
  0x30, 0x38, 0xF8, 0xF0, 0x70, 0x00, 0x00, 0x0E, 0x0F, 0x07, 0x83, 0x80,
  0x0F, 0x83, 0xF8, 0xC3, 0x30, 0x36, 0x76, 0xDF, 0xB3, 0x36, 0xE6, 0xD8,
  0xDB, 0x3B, 0x7B, 0x67, 0xCC, 0x01, 0xC0, 0x1F, 0x81, 0xF0, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0C, 0x61, 0xC6, 0x1F, 0xE3,
  0xFE, 0x30, 0x63, 0x07, 0x70, 0x7E, 0x07, 0x3F, 0x8F, 0xF3, 0x0D, 0xC3,
  0x70, 0xDC, 0x77, 0xF9, 0xFE, 0x61, 0xD8, 0x7E, 0x1F, 0x86, 0xFF, 0xBF,
  0x80, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x77, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x87, 0x31, 0xC7, 0xF8, 0x7C, 0x00, 0x3F, 0x07, 0xF8,
  0xC7, 0x38, 0x67, 0x0E, 0xE1, 0xD8, 0x3B, 0x06, 0x60, 0xDC, 0x3B, 0x87,
  0x71, 0xCF, 0xF1, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x1F, 0xF3, 0xFC, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0xF9, 0xFF,
  0x00, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1F, 0xF3, 0xFC,
  0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x00, 0x0F, 0x83, 0xF8,
  0xE3, 0x38, 0x76, 0x01, 0xC0, 0x39, 0xF7, 0x3E, 0xE1, 0xDC, 0x3B, 0x86,
  0x71, 0xC7, 0xD8, 0x73, 0x00, 0x30, 0xE6, 0x1D, 0xC3, 0xB8, 0x77, 0x0C,
  0xE1, 0x9F, 0xF3, 0xFE, 0xE1, 0xDC, 0x3B, 0x86, 0x60, 0xCC, 0x39, 0x87,
  0x00, 0x3F, 0xE7, 0xFC, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xC7, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xEC, 0x3B, 0x9C,
  0xFF, 0x0F, 0x00, 0x38, 0x73, 0x0E, 0x31, 0xC7, 0x38, 0x77, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xC1, 0x8C, 0x1C,
  0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x0C, 0x0F, 0xFF, 0xFC, 0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0xDB,
  0x1B, 0xF9, 0xDD, 0x8C, 0xEC, 0x66, 0x63, 0x23, 0x19, 0x18, 0xC1, 0xCE,
  0x0C, 0x60, 0x60, 0x38, 0x67, 0x0D, 0xF3, 0xBE, 0x76, 0xCC, 0xD9, 0x9B,
  0x33, 0x66, 0xE7, 0xDC, 0xFB, 0x1E, 0x63, 0xCC, 0x79, 0x8F, 0x00, 0x0F,
  0x87, 0xF8, 0xC3, 0x38, 0x76, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0xE0, 0xD8,
  0x3B, 0x87, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x3F, 0x87, 0xF8, 0xC3, 0x98,
  0x77, 0x0E, 0xE3, 0x9F, 0xF3, 0xF8, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x00, 0x0F, 0x87, 0xF8, 0xC3, 0x38, 0x76, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xD8, 0x3B, 0x87, 0x71, 0xC7, 0xF0, 0x7C, 0x03, 0x20,
  0x77, 0x07, 0xC0, 0x60, 0x3F, 0x87, 0xF8, 0xC3, 0x98, 0x77, 0x0E, 0xE3,
  0x9F, 0xF3, 0xF8, 0x66, 0x0C, 0xE3, 0x8C, 0x71, 0x8E, 0x39, 0x87, 0x00,
  0x07, 0xC1, 0xFE, 0x38, 0x73, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0xE0, 0x0E, 0x40, 0xE6, 0x1C, 0xFF, 0xC3, 0xF0, 0xFF, 0xFF, 0xFC,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x30, 0x6E, 0x1D, 0xC3, 0xB8, 0x77, 0x0C,
  0xC1, 0x98, 0x37, 0x0E, 0xE1, 0xDC, 0x3B, 0x86, 0x71, 0xC7, 0xF0, 0x7C,
  0x00, 0xE0, 0xFC, 0x1B, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0x18, 0xC3, 0x38,
  0x66, 0x0D, 0xC1, 0xB0, 0x36, 0x07, 0xC0, 0xF0, 0x00, 0x30, 0x19, 0x80,
  0xCC, 0x0C, 0xE6, 0x67, 0x73, 0x33, 0x99, 0x95, 0xCD, 0xAC, 0x6D, 0x63,
  0x4B, 0x1E, 0xD8, 0xF7, 0x87, 0x3C, 0x79, 0xE0, 0x1C, 0x1C, 0x30, 0xE0,
  0xE7, 0x03, 0x98, 0x07, 0xE0, 0x1F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xC0,
  0x37, 0x01, 0xCC, 0x0E, 0x38, 0x30, 0xE3, 0xC1, 0xC0, 0xE0, 0xFC, 0x39,
  0x87, 0x39, 0xC7, 0x70, 0x6C, 0x0F, 0x81, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xFF,
  0xEF, 0xFC, 0x1F, 0x9F, 0xCC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xFC, 0x7E, 0x00, 0xE1,
  0x86, 0x18, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x61, 0x86, 0x0C,
  0x30, 0x1F, 0xC7, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x7E, 0x3F, 0x80,
  0x07, 0x01, 0xE0, 0x7E, 0x0C, 0xC3, 0x98, 0xE3, 0x98, 0x37, 0x06, 0x40,
  0xA0, 0xFF, 0xFF, 0xE0, 0xDD, 0x90, 0x1C, 0xDF, 0xF7, 0x1F, 0x87, 0xE1,
  0xB8, 0x6C, 0x3B, 0x9E, 0xFF, 0xDE, 0x70, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x1D, 0xE7, 0xFD, 0xC7, 0x70, 0xD8, 0x7E, 0x1F, 0x87, 0xE3, 0xB7,
  0xEC, 0xE0, 0x1F, 0x0F, 0xE7, 0x1D, 0x80, 0xE0, 0x38, 0x0E, 0x1B, 0x8F,
  0x7F, 0x0F, 0x80, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x39, 0x9F,
  0xB3, 0x8E, 0xE1, 0xDC, 0x3B, 0x86, 0x61, 0xCE, 0x39, 0xFF, 0x1E, 0xE0,
  0x0F, 0x8F, 0xF7, 0x1D, 0x87, 0xFF, 0xBF, 0x8E, 0x13, 0x87, 0x7F, 0x8F,
  0x80, 0x00, 0x7C, 0x03, 0xF0, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x7F, 0xE1,
  0xFF, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x04, 0x70, 0x39, 0xC0, 0x76, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x0E,
  0x67, 0xEC, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0x9C, 0x73, 0x96, 0x7F, 0xC7,
  0xB8, 0x07, 0x31, 0xCF, 0xF0, 0x7C, 0x00, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x1D, 0xE7, 0xFD, 0xE7, 0x71, 0xD8, 0x7E, 0x1B, 0x86, 0xE1, 0xB0,
  0xEC, 0x38, 0x06, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x1F, 0x87, 0xC2, 0x30,
  0x1C, 0x07, 0x01, 0xC8, 0x67, 0x1B, 0x87, 0xC1, 0xE0, 0x00, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x03, 0x00, 0xC6, 0x73, 0x9C, 0x77, 0x0F, 0x81, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xEF, 0x1F, 0xF3, 0xCE, 0x71, 0xCC, 0x73, 0xB8,
  0x7E, 0x2E, 0xEF, 0x8F, 0xB1, 0xC0, 0xFC, 0xFC, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x71, 0x77, 0x7E, 0x7C, 0x38, 0x3E, 0xE6, 0xEF,
  0x77, 0x36, 0x67, 0x66, 0x66, 0x66, 0x66, 0x6C, 0x66, 0xCC, 0x6C, 0xCC,
  0x77, 0x9F, 0xF7, 0x9D, 0xC7, 0x61, 0xF8, 0x6E, 0x1B, 0x86, 0xC3, 0xB0,
  0xE0, 0x1F, 0x0F, 0xE7, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0x7F,
  0x0F, 0x80, 0x3B, 0xC7, 0xFC, 0xE3, 0x9C, 0x33, 0x0E, 0xE1, 0xDC, 0x3B,
  0x8E, 0x6F, 0xCC, 0xE1, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0xDF,
  0xB7, 0x1F, 0x87, 0xE1, 0xF8, 0x6C, 0x3B, 0x96, 0xFF, 0x9E, 0xE0, 0x38,
  0x0C, 0x03, 0x01, 0xC0, 0xF9, 0xFE, 0xF3, 0xC0, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x00, 0x1F, 0x0F, 0xF7, 0x09, 0xC0, 0x7F, 0x07,
  0xE0, 0x39, 0x0E, 0xFF, 0x1F, 0x80, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x7F,
  0xFF, 0xF1, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x98, 0xEF, 0x3F, 0x07, 0x00,
  0x70, 0xDC, 0x36, 0x1D, 0x87, 0x61, 0xF8, 0x6E, 0x3B, 0x9E, 0xFF, 0x9E,
  0xE0, 0xF9, 0xBC, 0x73, 0x1C, 0xC7, 0x71, 0xDC, 0x76, 0x39, 0x9C, 0x7E,
  0x0F, 0x00, 0x33, 0x66, 0x36, 0x66, 0x66, 0x67, 0x66, 0x66, 0x66, 0x66,
  0x6E, 0xE4, 0xF6, 0xC7, 0x38, 0x1C, 0xE3, 0xEF, 0x77, 0x34, 0x73, 0x06,
  0x00, 0x60, 0xCE, 0x2C, 0xEE, 0xF7, 0xC7, 0x38, 0x38, 0x67, 0x0C, 0xC3,
  0x98, 0x73, 0x0E, 0xE1, 0x9C, 0x73, 0x9E, 0x3F, 0xC7, 0xB8, 0x06, 0x21,
  0xCF, 0xF0, 0xFC, 0x00, 0x3C, 0xEF, 0xF9, 0x8F, 0x01, 0xC0, 0xE0, 0x39,
  0x1C, 0x67, 0xC6, 0xFF, 0xD9, 0xF0, 0x07, 0xC3, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x38, 0xFC, 0x3E, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x7E, 0x0F, 0x80, 0x19, 0xCC, 0x63, 0x18, 0xCE, 0x63, 0x18,
  0xC6, 0x73, 0x18, 0xC6, 0x00, 0x1F, 0x1F, 0x80, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x38, 0x0F, 0x87, 0xC6, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0xFC,
  0x7C, 0x00, 0x38, 0x6F, 0x9B, 0x33, 0x67, 0xC8, 0x70,
};

const GFXglyph IBMPlexMono_SemiBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 14, 12, 3, -14 },
  { 12, 8, 6, 12, 3, -15 },
  { 18, 13, 14, 12, 0, -14 },
  { 41, 12, 18, 12, 0, -16 },
  { 68, 14, 14, 12, -1, -14 },
  { 93, 12, 14, 12, 0, -14 },
  { 114, 4, 6, 12, 5, -15 },
  { 117, 8, 18, 12, 4, -15 },
  { 135, 8, 18, 12, 1, -15 },
  { 153, 10, 10, 12, 1, -11 },
  { 166, 10, 10, 12, 1, -11 },
  { 179, 6, 6, 12, 2, -3 },
  { 184, 6, 2, 12, 3, -7 },
  { 186, 4, 4, 12, 3, -4 },
  { 188, 12, 18, 12, 0, -15 },
  { 215, 11, 14, 12, 1, -14 },
  { 235, 10, 14, 12, 1, -14 },
  { 253, 11, 14, 12, 0, -14 },
  { 273, 11, 14, 12, 0, -14 },
  { 293, 11, 14, 12, 0, -14 },
  { 313, 11, 14, 12, 1, -14 },
  { 333, 10, 14, 12, 1, -14 },
  { 351, 10, 14, 12, 2, -14 },
  { 369, 11, 14, 12, 1, -14 },
  { 389, 11, 14, 12, 1, -14 },
  { 409, 5, 11, 12, 3, -11 },
  { 416, 6, 14, 12, 2, -11 },
  { 427, 9, 12, 12, 2, -12 },
  { 441, 10, 6, 12, 1, -9 },
  { 449, 10, 12, 12, 1, -12 },
  { 464, 9, 14, 12, 2, -14 },
  { 480, 11, 16, 12, 1, -14 },
  { 502, 12, 14, 12, -1, -14 },
  { 523, 10, 14, 12, 1, -14 },
  { 541, 11, 14, 12, 1, -14 },
  { 561, 11, 14, 12, 1, -14 },
  { 581, 11, 14, 12, 1, -14 },
  { 601, 11, 14, 12, 1, -14 },
  { 621, 11, 14, 12, 1, -14 },
  { 641, 11, 14, 12, 1, -14 },
  { 661, 11, 14, 12, 1, -14 },
  { 681, 10, 14, 12, 1, -14 },
  { 699, 12, 14, 12, 1, -14 },
  { 720, 9, 14, 12, 1, -14 },
  { 736, 13, 14, 12, 0, -14 },
  { 759, 11, 14, 12, 1, -14 },
  { 779, 11, 14, 12, 1, -14 },
  { 799, 11, 14, 12, 1, -14 },
  { 819, 11, 18, 12, 1, -14 },
  { 844, 11, 14, 12, 1, -14 },
  { 864, 12, 14, 12, 0, -14 },
  { 885, 11, 14, 12, 2, -14 },
  { 905, 11, 14, 12, 1, -14 },
  { 925, 11, 14, 12, 2, -14 },
  { 945, 13, 14, 12, 0, -14 },
  { 968, 14, 14, 12, -1, -14 },
  { 993, 11, 14, 12, 2, -14 },
  { 1013, 12, 14, 12, 0, -14 },
  { 1034, 9, 18, 12, 3, -15 },
  { 1055, 6, 18, 12, 3, -15 },
  { 1069, 10, 18, 12, 0, -15 },
  { 1092, 11, 9, 12, 1, -14 },
  { 1105, 10, 2, 12, 0, 2 },
  { 1108, 3, 4, 12, 4, -15 },
  { 1110, 10, 10, 12, 1, -10 },
  { 1123, 10, 15, 12, 1, -15 },
  { 1142, 10, 10, 12, 1, -10 },
  { 1155, 11, 15, 12, 1, -15 },
  { 1176, 10, 10, 12, 1, -10 },
  { 1189, 14, 19, 12, -1, -15 },
  { 1223, 11, 14, 12, 0, -10 },
  { 1243, 10, 15, 12, 1, -15 },
  { 1262, 10, 15, 12, 1, -15 },
  { 1281, 10, 19, 12, 0, -15 },
  { 1305, 11, 15, 12, 1, -15 },
  { 1326, 8, 15, 12, 2, -15 },
  { 1341, 12, 10, 12, 0, -10 },
  { 1356, 10, 10, 12, 1, -10 },
  { 1369, 10, 10, 12, 1, -10 },
  { 1382, 11, 14, 12, 0, -10 },
  { 1402, 10, 14, 12, 1, -10 },
  { 1420, 10, 10, 12, 2, -10 },
  { 1433, 10, 10, 12, 1, -10 },
  { 1446, 10, 14, 12, 1, -14 },
  { 1464, 10, 10, 12, 1, -10 },
  { 1477, 10, 10, 12, 1, -10 },
  { 1490, 12, 10, 12, 0, -10 },
  { 1505, 12, 10, 12, 0, -10 },
  { 1520, 11, 14, 12, 0, -10 },
  { 1540, 11, 10, 12, 1, -10 },
  { 1554, 10, 18, 12, 2, -15 },
  { 1577, 5, 18, 12, 4, -15 },
  { 1589, 9, 18, 12, 1, -15 },
  { 1610, 11, 5, 12, 1, -9 },
};

const GFXfont IBMPlexMono_SemiBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC20PT7B_H_
