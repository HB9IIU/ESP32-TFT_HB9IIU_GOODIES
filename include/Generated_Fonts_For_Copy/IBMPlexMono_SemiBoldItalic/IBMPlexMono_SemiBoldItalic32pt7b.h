#ifndef _IBMPLEXMONO_SEMIBOLDITALIC32PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x10, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xFC, 0xF8, 0xF8, 0xF0, 0x3C,
  0x73, 0x8F, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x78, 0xE7, 0x1E, 0x71,
  0xEF, 0x1E, 0x00, 0x79, 0xE0, 0x07, 0x1C, 0x00, 0xF3, 0xC0, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x1E, 0x78, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xCF,
  0xF0, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x79, 0xE0, 0x07, 0x1C, 0x07, 0xF1,
  0xFC, 0xFE, 0x3F, 0xCF, 0xE3, 0xFC, 0x0E, 0x38, 0x01, 0xC7, 0x80, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xF7,
  0x78, 0xF9, 0xC4, 0x3C, 0x70, 0x0F, 0x18, 0x03, 0xC6, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xCF, 0x80,
  0x71, 0xE0, 0x1C, 0x79, 0x07, 0x3E, 0x61, 0xCF, 0x3E, 0x67, 0xCF, 0xFF,
  0xE1, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x1C, 0x1F, 0xC0, 0xE0, 0xFF, 0x83, 0x87, 0x8E, 0x1C, 0x1C,
  0x38, 0xE0, 0x70, 0xE3, 0x81, 0xC7, 0x9C, 0x07, 0x1C, 0xE0, 0x1F, 0xF3,
  0x80, 0x3F, 0x9C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xDF, 0xE0,
  0x1E, 0x7F, 0x80, 0x73, 0x8E, 0x03, 0x8E, 0x1C, 0x1E, 0x78, 0xE0, 0x71,
  0xC3, 0x83, 0x87, 0x8E, 0x0E, 0x0F, 0xF0, 0x70, 0x3F, 0xC3, 0x80, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xE3, 0xC0, 0x78,
  0x78, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0xC7, 0x00, 0x79,
  0xE0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x3C, 0x3C,
  0x07, 0x83, 0x80, 0xF0, 0x78, 0xDE, 0x0F, 0x3F, 0xE2, 0xF7, 0x3F, 0xCF,
  0xC7, 0xF1, 0xF8, 0x3C, 0x1E, 0x00, 0x7B, 0xDE, 0xE7, 0x7B, 0xDE, 0xF7,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x02, 0x0E, 0x0B, 0xEF, 0x3D, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xE7,
  0x81, 0xE1, 0xE1, 0xE0, 0xF0, 0x20, 0x20, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x1F, 0x3F, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3C, 0xFD, 0xFB, 0xFF, 0xCF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C,
  0x3E, 0x1E, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x03,
  0xDE, 0x39, 0xF7, 0x9E, 0x7D, 0xE7, 0x9E, 0xF9, 0xC7, 0xBE, 0x01, 0xEF,
  0x00, 0xFB, 0xC0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0xC3, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xBC, 0x0F, 0x3C, 0x1E, 0x78, 0x3E, 0x78, 0x7C, 0x78, 0x18, 0x78,
  0x10, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0,
  0x78, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xE7, 0xC1, 0xF0, 0xC0, 0x78,
  0x40, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x20,
  0x1F, 0x30, 0x0F, 0x3E, 0x0F, 0x9F, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3D, 0xE0, 0x1E, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF0,
  0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0xF8, 0x0F, 0x7F,
  0x83, 0xBF, 0xF0, 0xF8, 0x7C, 0x18, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x20, 0x0F, 0x1C, 0x07, 0xCF, 0x83, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x7C, 0x1E,
  0xFF, 0x1E, 0xFF, 0xCF, 0xC3, 0xE7, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x0F, 0x9F, 0x0F, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xDE, 0x01, 0xEF,
  0x01, 0xE7, 0x01, 0xF3, 0x80, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x1E,
  0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0x70, 0x1E, 0x1E, 0x0F, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xF8, 0x3C, 0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xFB,
  0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x83, 0xF1, 0xFF, 0xF8, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3,
  0xE7, 0xC0, 0xF3, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0x9F, 0x0F, 0xCF, 0xFD, 0xE3, 0xFD, 0xE0, 0xFC, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0x0F, 0x87, 0xE7, 0xE3, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x87, 0xE3, 0xF1, 0xF9, 0xF8, 0x78, 0x00, 0x07,
  0x83, 0xE0, 0xFC, 0x7E, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x0F, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x38, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0x60, 0x00, 0x40, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF,
  0x80, 0x10, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBE, 0x1F, 0xF0, 0x3C,
  0x80, 0xF0, 0x07, 0xC0, 0x1E, 0x03, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xF3, 0xC7, 0xBC, 0xE3, 0xFF,
  0x79, 0xFF, 0x9E, 0x79, 0xE7, 0x3C, 0x39, 0xCF, 0x0E, 0x73, 0x87, 0x9C,
  0xE1, 0xCF, 0x38, 0x73, 0xCE, 0x3C, 0xF3, 0xFF, 0x38, 0xFD, 0xCF, 0x1E,
  0xF3, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x1E, 0x78, 0x07, 0x9E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D,
  0xE0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x87,
  0xFF, 0xE3, 0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1F,
  0x3C, 0x0F, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xC1, 0xF1, 0xE0,
  0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x0F, 0x8F,
  0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x10, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x18, 0xF0, 0x1F, 0x7C, 0x0F, 0x1E, 0x0F, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0x78, 0x3E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x7C, 0x78, 0x1F, 0x3C,
  0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x83, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xE3, 0xC0,
  0xF3, 0xE0, 0x3D, 0xE0, 0x20, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x3F, 0xDE, 0x1F, 0xEF, 0x0F, 0xE7, 0x80, 0x73, 0xC0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x1F, 0x3E, 0x1F, 0x0F, 0xFB, 0x83, 0xFB, 0xC0, 0xF9,
  0xE0, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0xF0, 0x3C, 0x78, 0x1E, 0x1E, 0x1F, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0x0F, 0x01, 0xF1, 0xF0, 0x3E, 0x1E, 0x07, 0xC1,
  0xE0, 0xF8, 0x1E, 0x1F, 0x01, 0xE3, 0xE0, 0x1E, 0x7C, 0x03, 0xE7, 0x80,
  0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xE7, 0x80, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x3C, 0x07, 0x83,
  0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x80, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x1F, 0x83,
  0xF1, 0xF8, 0x7E, 0x1F, 0xC7, 0xE1, 0xDC, 0xEE, 0x1D, 0xCF, 0xE1, 0xDD,
  0xDE, 0x3D, 0xFD, 0xE3, 0xCF, 0x9C, 0x3C, 0xF9, 0xC3, 0xCF, 0x3C, 0x38,
  0xF3, 0xC3, 0x8E, 0x3C, 0x78, 0x63, 0xC7, 0x84, 0x38, 0x78, 0x83, 0x87,
  0x80, 0x78, 0x70, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x70,
  0x1F, 0x81, 0xC7, 0xE0, 0x71, 0xF8, 0x3C, 0x7E, 0x0F, 0x1F, 0xC3, 0xC7,
  0xF0, 0xE3, 0xDC, 0x38, 0xF7, 0x0E, 0x3D, 0xC7, 0x8F, 0x79, 0xE3, 0x9E,
  0x78, 0xE7, 0x9C, 0x78, 0xE7, 0x1E, 0x3B, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC,
  0x70, 0xFF, 0x1C, 0x1F, 0x8F, 0x07, 0xE3, 0xC1, 0xF8, 0xF0, 0x7E, 0x3C,
  0x1F, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E, 0x1E,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x3D, 0xF0, 0x0F, 0x7C, 0x07, 0xDE, 0x01,
  0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0xFB,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0xC3, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x78,
  0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07,
  0x8F, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x3D, 0xF0, 0x0F,
  0x7C, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0xF8, 0x07, 0xBE,
  0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0xC3,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x3C, 0x10, 0x07, 0x8E,
  0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x78, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xF8, 0x0F, 0x3C, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x7C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0xF8, 0x1E, 0x3C, 0x07, 0xC0, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x7C, 0x1E, 0x1E, 0x03, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x40,
  0x0F, 0x18, 0x07, 0xCF, 0x83, 0xE3, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x9F, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x87, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB,
  0xE0, 0x3C, 0xF8, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C,
  0x03, 0x9E, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0xF3, 0x80, 0x0F,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x8F, 0x1E, 0x78, 0xF1,
  0xC7, 0x9F, 0x1C, 0x79, 0xF1, 0xC7, 0x1F, 0x3C, 0x73, 0xF3, 0x87, 0x3F,
  0x38, 0x73, 0x73, 0x87, 0x77, 0x78, 0xF7, 0x77, 0x8F, 0x67, 0x70, 0xFE,
  0x77, 0x0F, 0xE7, 0x70, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0x87, 0xE0, 0x0F, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF0,
  0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F,
  0x00, 0x7C, 0x3E, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x7C, 0x07, 0xC3,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xF9, 0xE0, 0x7C,
  0x78, 0x1E, 0x0F, 0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x1E, 0xF0, 0x07,
  0xBC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF,
  0xC3, 0xFF, 0x07, 0xFE, 0x00, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0xC0,
  0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x0E,
  0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x70, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3D,
  0xE0, 0x3C, 0xF0, 0x3C, 0x78, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x03, 0x8F,
  0x01, 0xEF, 0x00, 0xFF, 0x00, 0x38, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0x33, 0xC7, 0x9E, 0x38, 0x71, 0x80, 0x07, 0xC7, 0x87, 0xF3,
  0xC7, 0xFF, 0xE7, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x83, 0xE3,
  0xC2, 0xF1, 0xFF, 0x7E, 0x7F, 0x3E, 0x1E, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x78, 0x1E, 0xFE, 0x1E, 0xFF, 0x8F, 0x43, 0xC7, 0xC1, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0x9E,
  0x03, 0xCF, 0x03, 0xE7, 0xC3, 0xE7, 0xBF, 0xE3, 0xDF, 0xE1, 0xE3, 0xE0,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF7, 0xC1, 0xCF, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x47, 0x80, 0xEF, 0x03,
  0xEF, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x1F, 0x9E, 0x0F, 0xF7, 0x87, 0xFD, 0xE3, 0xE1, 0xF8, 0xF0, 0x3E, 0x78,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x07,
  0xCF, 0x01, 0xE3, 0xE0, 0xF8, 0x78, 0x7E, 0x1F, 0xF7, 0x83, 0xF9, 0xE0,
  0x7C, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF7, 0x81, 0xEF,
  0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0xFF, 0xF9, 0xFF, 0x03, 0xC0, 0x07, 0x80,
  0x4F, 0x01, 0xEF, 0x07, 0x9F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x02, 0x0F,
  0x00, 0x1C, 0x3C, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE7, 0x87,
  0xFB, 0xC7, 0xFD, 0xE7, 0xC3, 0xF3, 0xC0, 0xFB, 0xE0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x07, 0x9F, 0x03, 0xC7, 0x83,
  0xE3, 0xE3, 0xF1, 0xFF, 0x78, 0x7F, 0x3C, 0x1F, 0x3C, 0x00, 0x1E, 0x10,
  0x0F, 0x0E, 0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x3C, 0x1E, 0xFE, 0x3E, 0xFF, 0x3F, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x04, 0x0F, 0x0E,
  0x0F, 0x1F, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x10, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x20, 0xF0,
  0xF1, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x3D, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0xF0, 0x1E, 0xFF, 0x0F, 0xFF,
  0xC3, 0xD0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0,
  0xF1, 0xF0, 0x7B, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x11, 0xE7, 0x8E, 0x78,
  0xF7, 0xDE, 0x3F, 0xCF, 0x07, 0xE3, 0xC0, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x10, 0xF0, 0xE3, 0xC7, 0xCF, 0x3C, 0x3D, 0xE0, 0xFF, 0x03, 0xF8,
  0x07, 0xC0, 0x3C, 0xE3, 0xC7, 0xBC, 0xF8, 0xFF, 0xDF, 0x9E, 0x7C, 0xF3,
  0xC7, 0x1E, 0x71, 0xE3, 0xCE, 0x3C, 0x73, 0xC7, 0x0E, 0x78, 0xE1, 0xCE,
  0x1C, 0x79, 0xC3, 0x8F, 0x38, 0xF1, 0xE7, 0x1E, 0x39, 0xE3, 0x87, 0x3C,
  0x70, 0xE7, 0x0E, 0x1C, 0xE1, 0xC7, 0x80, 0x1E, 0x3C, 0x1E, 0xFE, 0x3E,
  0xFF, 0x3D, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C,
  0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x7C,
  0x3E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xC0, 0x0F, 0x1E, 0x07, 0xDF, 0xC1, 0xEF, 0xF8, 0x7A, 0x1E,
  0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x07, 0xCF,
  0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x9F, 0x87, 0xC7, 0xBF,
  0xE1, 0xEF, 0xF0, 0x78, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE7, 0x87, 0xFB, 0xC7,
  0xFD, 0xE7, 0xC3, 0xF3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF8, 0x0F, 0x7C, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x83, 0xE3, 0xC3,
  0xF1, 0xFF, 0x78, 0x7F, 0x3C, 0x1F, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x7F, 0x8F, 0xFF, 0x3F,
  0xFF, 0x7F, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF,
  0x1E, 0x0E, 0x3C, 0x04, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x20, 0x1E, 0x78, 0x3E, 0xFF, 0xFC,
  0x3F, 0xF8, 0x0F, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x0C,
  0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80,
  0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF8, 0xBC, 0xFF, 0x3C, 0x7F, 0x7C, 0x3C, 0x78, 0x7F, 0x02,
  0x3F, 0x8F, 0x9F, 0xC3, 0xD3, 0xC1, 0xE1, 0xE0, 0xF8, 0xF0, 0x7C, 0x78,
  0x3E, 0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x87, 0xC3,
  0xC7, 0xC1, 0xE7, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x38,
  0xF1, 0xBC, 0x73, 0xDE, 0x38, 0xEE, 0x1C, 0x77, 0x0E, 0x3B, 0x8F, 0x1D,
  0xC7, 0x8F, 0xE3, 0x87, 0xF1, 0xC3, 0xF0, 0xE1, 0xF8, 0x71, 0xFC, 0x78,
  0xEE, 0x3C, 0x77, 0x3E, 0x73, 0xF7, 0x39, 0xFB, 0xF8, 0x70, 0xF0, 0x00,
  0x03, 0xC3, 0xC1, 0xF8, 0xFC, 0x7F, 0xBF, 0xBF, 0x74, 0x73, 0x8F, 0x8E,
  0x61, 0xE1, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x70, 0xF0, 0x4E, 0x3E, 0x3D, 0xE7, 0xEF, 0xBF, 0xBF, 0xE3,
  0xE3, 0xF0, 0x38, 0x3C, 0x00, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C,
  0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C,
  0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x8B,
  0xC3, 0xFE, 0xF0, 0x7F, 0x78, 0x0F, 0x9E, 0x00, 0x07, 0x82, 0x03, 0xE0,
  0xC1, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC3, 0x8F,
  0xF9, 0xCF, 0xFF, 0xE7, 0x8F, 0xF3, 0x81, 0xF1, 0xC1, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0x03, 0xE3, 0x83, 0xC0, 0xE7, 0xC0,
  0x77, 0xFF, 0x3B, 0xFF, 0xFD, 0xE7, 0xFE, 0xF0, 0xFC, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x7F, 0xC0,
  0x7E, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0x07, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x0F,
  0xC0, 0xFF, 0x83, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC1, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0x01, 0x87, 0xE0, 0xF3, 0xFC, 0x39, 0xE7, 0x0E,
  0x71, 0xE7, 0x3C, 0x3F, 0xCE, 0x0F, 0xE1, 0x80, 0xF0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 22, 19, 6, -22 },
  { 23, 12, 10, 19, 5, -24 },
  { 38, 20, 22, 19, 0, -22 },
  { 93, 18, 28, 19, 1, -25 },
  { 156, 22, 22, 19, -1, -22 },
  { 217, 19, 22, 19, 0, -22 },
  { 270, 5, 10, 19, 9, -24 },
  { 277, 13, 28, 19, 6, -24 },
  { 323, 13, 28, 19, 1, -24 },
  { 369, 17, 16, 19, 1, -18 },
  { 403, 16, 15, 19, 2, -17 },
  { 433, 8, 10, 19, 4, -5 },
  { 443, 10, 3, 19, 5, -11 },
  { 447, 7, 6, 19, 5, -6 },
  { 453, 19, 28, 19, 0, -24 },
  { 520, 18, 22, 19, 1, -22 },
  { 570, 16, 22, 19, 1, -22 },
  { 614, 17, 22, 19, 1, -22 },
  { 661, 17, 22, 19, 1, -22 },
  { 708, 18, 22, 19, 0, -22 },
  { 758, 18, 22, 19, 1, -22 },
  { 808, 17, 22, 19, 1, -22 },
  { 855, 17, 22, 19, 3, -22 },
  { 902, 18, 22, 19, 1, -22 },
  { 952, 17, 22, 19, 2, -22 },
  { 999, 9, 17, 19, 5, -17 },
  { 1019, 10, 22, 19, 4, -17 },
  { 1047, 15, 19, 19, 3, -19 },
  { 1083, 17, 10, 19, 1, -15 },
  { 1105, 16, 19, 19, 1, -19 },
  { 1143, 14, 22, 19, 4, -22 },
  { 1182, 18, 26, 19, 1, -22 },
  { 1241, 18, 22, 19, -1, -22 },
  { 1291, 17, 22, 19, 1, -22 },
  { 1338, 17, 22, 19, 2, -22 },
  { 1385, 18, 22, 19, 1, -22 },
  { 1435, 18, 22, 19, 1, -22 },
  { 1485, 19, 22, 19, 1, -22 },
  { 1538, 17, 22, 19, 2, -22 },
  { 1585, 18, 22, 19, 1, -22 },
  { 1635, 18, 22, 19, 1, -22 },
  { 1685, 17, 22, 19, 1, -22 },
  { 1732, 20, 22, 19, 1, -22 },
  { 1787, 15, 22, 19, 2, -22 },
  { 1829, 20, 22, 19, 0, -22 },
  { 1884, 18, 22, 19, 1, -22 },
  { 1934, 18, 22, 19, 1, -22 },
  { 1984, 18, 22, 19, 1, -22 },
  { 2034, 18, 28, 19, 1, -22 },
  { 2097, 18, 22, 19, 1, -22 },
  { 2147, 18, 22, 19, 1, -22 },
  { 2197, 18, 22, 19, 3, -22 },
  { 2247, 18, 22, 19, 2, -22 },
  { 2297, 18, 22, 19, 3, -22 },
  { 2347, 20, 22, 19, 1, -22 },
  { 2402, 22, 22, 19, -1, -22 },
  { 2463, 18, 22, 19, 3, -22 },
  { 2513, 20, 22, 19, 0, -22 },
  { 2568, 15, 28, 19, 4, -24 },
  { 2621, 9, 28, 19, 5, -24 },
  { 2653, 14, 28, 19, 1, -24 },
  { 2702, 17, 14, 19, 1, -22 },
  { 2732, 16, 3, 19, 0, 3 },
  { 2738, 6, 7, 19, 6, -25 },
  { 2744, 17, 17, 19, 1, -17 },
  { 2781, 17, 24, 19, 1, -24 },
  { 2832, 15, 17, 19, 2, -17 },
  { 2864, 18, 24, 19, 1, -24 },
  { 2918, 15, 17, 19, 2, -17 },
  { 2950, 22, 30, 19, -1, -24 },
  { 3033, 17, 23, 19, 1, -17 },
  { 3082, 16, 24, 19, 1, -24 },
  { 3130, 16, 25, 19, 2, -25 },
  { 3180, 16, 31, 19, 1, -25 },
  { 3242, 18, 24, 19, 1, -24 },
  { 3296, 14, 24, 19, 3, -24 },
  { 3338, 19, 17, 19, 0, -17 },
  { 3379, 16, 17, 19, 1, -17 },
  { 3413, 16, 17, 19, 2, -17 },
  { 3447, 18, 23, 19, 0, -17 },
  { 3499, 17, 23, 19, 1, -17 },
  { 3548, 16, 17, 19, 3, -17 },
  { 3582, 16, 17, 19, 1, -17 },
  { 3616, 16, 22, 19, 2, -22 },
  { 3660, 16, 17, 19, 2, -17 },
  { 3694, 17, 17, 19, 1, -17 },
  { 3731, 17, 17, 19, 1, -17 },
  { 3768, 19, 17, 19, 0, -17 },
  { 3809, 18, 23, 19, 0, -17 },
  { 3861, 17, 17, 19, 1, -17 },
  { 3898, 16, 28, 19, 3, -24 },
  { 3954, 8, 28, 19, 6, -24 },
  { 3982, 15, 28, 19, 1, -24 },
  { 4035, 18, 8, 19, 1, -14 },
};

const GFXfont IBMPlexMono_SemiBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC32PT7B_H_
