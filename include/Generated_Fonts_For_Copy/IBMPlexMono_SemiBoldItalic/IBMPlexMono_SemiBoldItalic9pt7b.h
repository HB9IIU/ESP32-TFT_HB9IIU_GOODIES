#ifndef _IBMPLEXMONO_SEMIBOLDITALIC9PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xA0, 0xB7, 0x00, 0x38, 0xA7, 0xF6, 0x53, 0x80, 0x11, 0xD6,
  0xC3, 0xD5, 0xC4, 0x66, 0xA7, 0x06, 0x6A, 0x60, 0x3B, 0x4F, 0xC9, 0xFC,
  0x5C, 0x2A, 0x49, 0x22, 0x21, 0x11, 0x12, 0x2C, 0x13, 0x6C, 0xAA, 0x00,
  0x24, 0xF4, 0x40, 0x60, 0xE0, 0xC0, 0x08, 0x44, 0x62, 0x21, 0x10, 0x3A,
  0x53, 0xDC, 0xB8, 0x33, 0x94, 0x23, 0x7C, 0x3A, 0x42, 0x64, 0x7C, 0x3A,
  0x4C, 0x39, 0xB8, 0x19, 0x5E, 0xAF, 0x88, 0x7A, 0x1E, 0x18, 0xB8, 0x1B,
  0x1F, 0x9C, 0xB8, 0xFC, 0x88, 0x44, 0x60, 0x7A, 0x4D, 0x9C, 0xB8, 0x79,
  0x9F, 0x2C, 0xF2, 0x80, 0x6C, 0x05, 0x00, 0x16, 0x84, 0x20, 0x78, 0x3E,
  0x41, 0x82, 0x6C, 0x00, 0x79, 0x60, 0x4C, 0x3A, 0x5F, 0x5B, 0xC1, 0xC0,
  0x31, 0x9C, 0xBF, 0xC4, 0x7A, 0x5C, 0x94, 0xF8, 0x79, 0x88, 0x9E, 0x7A,
  0x52, 0x95, 0xF8, 0x7A, 0x1E, 0x84, 0x78, 0x7D, 0x07, 0x90, 0x43, 0x00,
  0x3A, 0x51, 0xBC, 0xBC, 0x4A, 0x5E, 0x9D, 0xC8, 0x78, 0x8C, 0x42, 0x78,
  0x38, 0x42, 0x3D, 0x38, 0x4D, 0x67, 0x1C, 0x53, 0x60, 0xC8, 0x88, 0x8F,
  0x6D, 0xE7, 0xBA, 0x8A, 0x20, 0x6B, 0x5A, 0xDD, 0xC8, 0x3A, 0x53, 0x9D,
  0xB8, 0x7A, 0x52, 0xF4, 0x60, 0x3A, 0x53, 0x9D, 0xB8, 0xA3, 0x7A, 0x52,
  0xF5, 0x6C, 0x3A, 0x58, 0x38, 0xB8, 0xF9, 0x18, 0x84, 0x20, 0x4A, 0x52,
  0x9D, 0xB8, 0x9C, 0xA5, 0x4A, 0x60, 0x45, 0xD7, 0xB6, 0xDB, 0x60, 0x4C,
  0xE3, 0x0C, 0x52, 0x60, 0x9C, 0x98, 0xC4, 0x20, 0x7C, 0x21, 0x08, 0x43,
  0xE0, 0x74, 0x44, 0x44, 0x8E, 0xC9, 0x24, 0x49, 0x71, 0x11, 0x12, 0x2E,
  0x31, 0x93, 0x10, 0xF0, 0xC0, 0x6A, 0xF3, 0xA7, 0x80, 0x62, 0x16, 0xD4,
  0xAE, 0xC0, 0x6B, 0x89, 0xE0, 0x08, 0x5E, 0x9C, 0xED, 0xC0, 0x79, 0xEA,
  0xF0, 0x1C, 0x47, 0xCC, 0x20, 0x82, 0x28, 0x60, 0x7A, 0x73, 0xB7, 0x0B,
  0xC0, 0x62, 0x16, 0xD4, 0xAF, 0x40, 0x60, 0xC4, 0x47, 0x60, 0x18, 0x1C,
  0x21, 0x0A, 0xDC, 0x60, 0x62, 0x16, 0xD5, 0x37, 0x60, 0xE4, 0x44, 0x4F,
  0xC0, 0x6F, 0xEB, 0x5A, 0x80, 0x5B, 0x52, 0xBD, 0x00, 0x72, 0x73, 0xB7,
  0x00, 0x5B, 0x52, 0xBB, 0x42, 0x00, 0x7A, 0x73, 0xB7, 0x08, 0x40, 0xD6,
  0x44, 0xC0, 0x7A, 0x1D, 0x37, 0x00, 0x4F, 0x44, 0xFE, 0x99, 0x9B, 0xE0,
  0xEA, 0x52, 0xA6, 0x00, 0x7D, 0x6B, 0x5F, 0x00, 0x6D, 0xC9, 0x5F, 0x00,
  0x4A, 0x52, 0xB7, 0x0B, 0x80, 0x7A, 0xC8, 0x9B, 0x80, 0x34, 0x2C, 0x24,
  0x86, 0x56, 0xAA, 0x32, 0x88, 0x32, 0x10, 0x9C, 0x6D, 0xC0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 6, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 6, 6, 5, 0, -6 },
  { 20, 5, 6, 5, 0, -6 },
  { 24, 2, 3, 5, 2, -7 },
  { 25, 3, 8, 5, 2, -7 },
  { 28, 4, 8, 5, 0, -7 },
  { 32, 5, 5, 5, 0, -5 },
  { 36, 4, 5, 5, 1, -5 },
  { 39, 2, 2, 5, 1, -1 },
  { 40, 3, 1, 5, 1, -3 },
  { 41, 1, 2, 5, 2, -2 },
  { 42, 5, 8, 5, 0, -7 },
  { 47, 5, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 5, 6, 5, 0, -6 },
  { 59, 5, 6, 5, 0, -6 },
  { 63, 5, 6, 5, 0, -6 },
  { 67, 5, 6, 5, 0, -6 },
  { 71, 5, 6, 5, 0, -6 },
  { 75, 5, 6, 5, 1, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 4, 6, 5, 1, -6 },
  { 86, 2, 5, 5, 2, -5 },
  { 88, 3, 6, 5, 1, -5 },
  { 91, 4, 5, 5, 1, -5 },
  { 94, 5, 3, 5, 0, -4 },
  { 96, 5, 5, 5, 0, -5 },
  { 100, 4, 6, 5, 1, -6 },
  { 103, 5, 7, 5, 0, -6 },
  { 108, 5, 6, 5, 0, -6 },
  { 112, 5, 6, 5, 0, -6 },
  { 116, 4, 6, 5, 1, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 6, 6, 5, 0, -6 },
  { 132, 5, 6, 5, 0, -6 },
  { 136, 5, 6, 5, 0, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 6, 6, 5, 0, -6 },
  { 153, 4, 6, 5, 1, -6 },
  { 156, 6, 6, 5, 0, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 5, 8, 5, 0, -6 },
  { 178, 5, 6, 5, 0, -6 },
  { 182, 5, 6, 5, 0, -6 },
  { 186, 5, 6, 5, 1, -6 },
  { 190, 5, 6, 5, 0, -6 },
  { 194, 5, 6, 5, 1, -6 },
  { 198, 6, 6, 5, 0, -6 },
  { 203, 6, 6, 5, 0, -6 },
  { 208, 5, 6, 5, 1, -6 },
  { 212, 6, 6, 5, 0, -6 },
  { 217, 4, 8, 5, 1, -7 },
  { 221, 3, 8, 5, 1, -7 },
  { 224, 4, 8, 5, 0, -7 },
  { 228, 5, 4, 5, 0, -6 },
  { 231, 4, 1, 5, 0, 1 },
  { 232, 1, 2, 5, 2, -8 },
  { 233, 5, 5, 5, 0, -5 },
  { 237, 5, 7, 5, 0, -7 },
  { 242, 4, 5, 5, 1, -5 },
  { 245, 5, 7, 5, 0, -7 },
  { 250, 4, 5, 5, 1, -5 },
  { 253, 6, 9, 5, 0, -7 },
  { 260, 5, 7, 5, 0, -5 },
  { 265, 5, 7, 5, 0, -7 },
  { 270, 4, 7, 5, 1, -7 },
  { 274, 5, 9, 5, 0, -7 },
  { 280, 5, 7, 5, 0, -7 },
  { 285, 4, 7, 5, 1, -7 },
  { 289, 5, 5, 5, 0, -5 },
  { 293, 5, 5, 5, 0, -5 },
  { 297, 5, 5, 5, 0, -5 },
  { 301, 5, 7, 5, 0, -5 },
  { 306, 5, 7, 5, 0, -5 },
  { 311, 4, 5, 5, 1, -5 },
  { 314, 5, 5, 5, 0, -5 },
  { 318, 4, 6, 5, 1, -6 },
  { 321, 4, 5, 5, 1, -5 },
  { 324, 5, 5, 5, 0, -5 },
  { 328, 5, 5, 5, 0, -5 },
  { 332, 5, 5, 5, 0, -5 },
  { 336, 5, 7, 5, 0, -5 },
  { 341, 5, 5, 5, 0, -5 },
  { 345, 4, 8, 5, 1, -7 },
  { 349, 2, 8, 5, 2, -7 },
  { 351, 5, 8, 5, 0, -7 },
  { 356, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_SemiBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC9PT7B_H_
