#ifndef _IBMPLEXMONO_SEMIBOLDITALIC27PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x60, 0xC0, 0x00,
  0x00, 0x1C, 0x7C, 0xF9, 0xE3, 0xC0, 0x73, 0xDC, 0xE7, 0x3B, 0x8E, 0xE3,
  0xB8, 0xEE, 0x7B, 0x9C, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71,
  0x80, 0x39, 0xC1, 0xFC, 0xFC, 0xFC, 0x7E, 0x7E, 0x7F, 0x07, 0x38, 0x03,
  0x1C, 0x03, 0x9C, 0x1F, 0xCF, 0xCF, 0xC7, 0xE7, 0xE7, 0xF0, 0x73, 0x80,
  0x31, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0xE0, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x3F, 0x80, 0xFF, 0xC3, 0xFF, 0xCF, 0x37, 0x1C, 0xE4,
  0x39, 0x80, 0x73, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0xDF, 0x01, 0x9E, 0x03, 0x1C, 0x86, 0x7B, 0xCD, 0xE7, 0xFF, 0xC7, 0xFF,
  0x03, 0xF8, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x07, 0x80, 0xE1, 0xF8,
  0x38, 0x7F, 0x86, 0x0E, 0x71, 0xC1, 0x8E, 0x70, 0x71, 0xCC, 0x0E, 0x3B,
  0x80, 0xFE, 0xE0, 0x1F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xFC, 0x03, 0xBF,
  0x80, 0x6E, 0x38, 0x1D, 0xC7, 0x07, 0x38, 0xE1, 0xC7, 0x38, 0x30, 0xFF,
  0x0E, 0x0F, 0xC3, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xFC,
  0x07, 0x1C, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7B, 0x80, 0x73, 0xC0, 0xF1, 0xC0, 0xF1, 0xE4, 0xF0, 0xE7,
  0xF1, 0xF7, 0x7F, 0x7E, 0x7E, 0x7C, 0x3C, 0x38, 0x3B, 0xDC, 0xE7, 0x39,
  0xDE, 0x01, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x10, 0xE1, 0x73, 0x9F, 0xFF, 0xF7, 0xFF, 0x83,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xDE, 0x1E, 0x3C, 0x30, 0x60, 0x82, 0x00,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1E, 0x7C,
  0xF1, 0xC7, 0x8E, 0x1C, 0x70, 0xFF, 0xFF, 0xBF, 0xC0, 0x77, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1,
  0xEF, 0x03, 0xDE, 0x07, 0xB9, 0xCF, 0xF3, 0x9F, 0xE7, 0x3F, 0xCE, 0x77,
  0x80, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x3C, 0x7C, 0x7F, 0xF0, 0x7F,
  0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xB8, 0x1E, 0xE0,
  0xF3, 0x87, 0x9E, 0x0C, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0x80, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0, 0xF1, 0xC0, 0xE4, 0x81,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF,
  0xF0, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0, 0xF0, 0xC0, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x8C, 0x0F, 0x7C, 0x3E, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x73,
  0x81, 0xCF, 0x07, 0x9E, 0x0E, 0x38, 0x38, 0x70, 0xE0, 0xE3, 0x81, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x78, 0x1F, 0xFC, 0x37, 0xF8, 0xF0, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x98, 0x1E, 0x78, 0x7C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xDE, 0x0E, 0xFE, 0x7F, 0xF9, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0x9E, 0x1E, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x7F,
  0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0x81, 0xEF, 0x03, 0x9C, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xE0, 0xF3, 0x81, 0xE7, 0x03, 0x8F, 0x0F,
  0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF1, 0xE1, 0xE7, 0x81, 0xEF, 0x03, 0xDC,
  0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7B, 0xE3, 0xEF, 0xFF, 0x9F, 0xDC, 0x3E, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0x3C, 0xF7, 0xDF,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x3E, 0xFB, 0xEF, 0x00, 0x0F, 0x0F, 0x1F,
  0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x3C, 0x38,
  0x78, 0x70, 0x70, 0xE0, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFE,
  0x0F, 0xC1, 0xF8, 0x0F, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF0, 0x03, 0x80, 0x04, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x10, 0x00,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x00,
  0x78, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x3C, 0x03, 0x80, 0x10, 0x00,
  0x0F, 0x83, 0xFE, 0x7F, 0xFF, 0x0F, 0xE0, 0xF2, 0x0F, 0x00, 0xF0, 0x1E,
  0x1F, 0xC1, 0xF0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x38, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF0,
  0xE3, 0x80, 0xE7, 0x01, 0xDC, 0x7B, 0xB9, 0xF6, 0x73, 0xFC, 0xEF, 0x3B,
  0x9C, 0x77, 0x38, 0xEE, 0x71, 0xDC, 0xE7, 0xB9, 0xFE, 0x73, 0xFC, 0xE3,
  0xB9, 0xC0, 0x01, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xDC, 0x01, 0xDC, 0x03, 0xDC, 0x03,
  0x9C, 0x07, 0x9C, 0x07, 0x1C, 0x0F, 0x1E, 0x0E, 0x1E, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFE, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0xF0,
  0x0F, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x0F, 0x3C, 0x1C, 0xF0, 0x73,
  0xC1, 0xCE, 0x0F, 0x3F, 0xF8, 0xFF, 0x87, 0xFF, 0x9E, 0x0E, 0x78, 0x3D,
  0xC0, 0xF7, 0x03, 0x9C, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x78, 0x3D, 0xE0, 0x6F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x81, 0xEE,
  0x07, 0x3C, 0x3C, 0x7F, 0xE1, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x83, 0xCE, 0x07, 0x9C, 0x0F,
  0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC1, 0xE7, 0x03, 0xCE, 0x07, 0x9C,
  0x1E, 0x78, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF8, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x03, 0x9E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE3, 0xFB, 0xC7, 0xF7, 0x8F, 0xEF, 0x03, 0x9E,
  0x07, 0x1C, 0x0E, 0x3C, 0x3C, 0x7F, 0xB8, 0x7E, 0xF0, 0x79, 0xE0, 0x1C,
  0x0E, 0x38, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0x8E, 0x07,
  0x1C, 0x0E, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xF3, 0x81, 0xC0, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x04,
  0x0E, 0x3C, 0x3C, 0x78, 0x78, 0x7F, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x1C,
  0x0F, 0x8E, 0x0F, 0x87, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xE7, 0x80,
  0xE7, 0x80, 0x77, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xBC,
  0x07, 0x9E, 0x03, 0x87, 0x81, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x38, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x8F,
  0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF3, 0xF1, 0xDD, 0xF8, 0xEF, 0xDC,
  0x77, 0xCE, 0x3B, 0xEF, 0x1C, 0xE7, 0x0E, 0x73, 0x8E, 0x31, 0xC7, 0x18,
  0xE3, 0x88, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x00, 0x1E, 0x0E, 0x3C, 0x1C, 0xFC, 0x39, 0xF8, 0x73, 0xF0, 0xE7,
  0xE3, 0x8E, 0xC7, 0x1D, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9D,
  0xC7, 0x1F, 0x8E, 0x3F, 0x38, 0x7E, 0x70, 0xFC, 0xE1, 0xF9, 0xC1, 0xF3,
  0x83, 0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x81,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x3C, 0x7C, 0x7F, 0xF0, 0x7F, 0xC0,
  0x7E, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x38, 0x3C, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x81,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x3C, 0x7C, 0x7F, 0xF0, 0x7F, 0xC0,
  0x7E, 0x00, 0x3C, 0x40, 0x3D, 0xC0, 0x3F, 0xC0, 0x7E, 0x00, 0x78, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x9C, 0x0F, 0x38, 0x3C, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0x9C, 0x0E,
  0x3C, 0x1C, 0x38, 0x38, 0x78, 0xF0, 0xF1, 0xE0, 0xE3, 0xC1, 0xE0, 0x01,
  0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x0E, 0x1C, 0x04, 0x1C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x20, 0x1C, 0x78, 0x3C, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x38, 0x1D, 0xE0, 0x77, 0x81, 0xDE, 0x0F, 0x70, 0x3D,
  0xC0, 0xF7, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0xC1, 0xEE, 0x07, 0xB8, 0x1E,
  0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x3C, 0x78, 0xFF, 0xE1, 0xFF, 0x03, 0xF8,
  0x00, 0xF0, 0x0F, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x3C, 0x70, 0x3C, 0x78,
  0x38, 0x78, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x38, 0xE0, 0x39,
  0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3B, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7,
  0x1C, 0x73, 0x9E, 0x31, 0xCF, 0x38, 0xE7, 0x9C, 0x76, 0xCE, 0x73, 0x66,
  0x39, 0xB7, 0x1D, 0x9B, 0x8E, 0xCD, 0xC7, 0x66, 0xE3, 0xF3, 0x61, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x3C, 0x00, 0x0F, 0x03, 0xE1, 0xE0,
  0x70, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x39, 0xE0, 0x07, 0xBC, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1E, 0x70, 0x03, 0x8F, 0x00, 0xF0, 0xE0, 0x3C, 0x1E,
  0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x3C,
  0x78, 0x3C, 0x38, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x1C, 0xE0, 0x1D, 0xC0,
  0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x0F,
  0xF0, 0xFF, 0x00, 0xC1, 0xC3, 0x87, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0xE0,
  0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC1, 0x83, 0x87,
  0x0E, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0xFF, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7,
  0x03, 0xC7, 0x07, 0x0E, 0x1E, 0x1C, 0x78, 0x1C, 0xE0, 0x3B, 0x80, 0x79,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x27, 0x9C, 0x63, 0x88, 0x0F,
  0x1C, 0x7E, 0xF3, 0xFF, 0xDF, 0x1E, 0x78, 0x39, 0xC0, 0xEF, 0x03, 0xBC,
  0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0x1F, 0x1F, 0xDF, 0x7E, 0x7C, 0xF0, 0xE0,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF,
  0x0E, 0x7E, 0x3B, 0xFC, 0xF8, 0xF7, 0xC3, 0xDE, 0x07, 0x78, 0x3D, 0xC0,
  0xF7, 0x03, 0xDC, 0x0E, 0xF8, 0x7B, 0xFF, 0xCE, 0xFE, 0x39, 0xF0, 0x07,
  0xC1, 0xFE, 0x3F, 0xF7, 0x87, 0xF0, 0x6F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x2E, 0x07, 0xF0, 0xEF, 0xFE, 0x7F, 0xC1, 0xF0, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x83, 0xE7, 0x0F, 0xEE, 0x3F,
  0xDC, 0xF8, 0x79, 0xE0, 0xF3, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0x3C, 0x1E,
  0x78, 0x3C, 0xF0, 0xF8, 0xFE, 0xE1, 0xFD, 0xC1, 0xE3, 0x80, 0x07, 0xE0,
  0xFF, 0x8F, 0xFE, 0xF0, 0xFF, 0x07, 0xF0, 0x7B, 0xFF, 0x9F, 0xE0, 0xE0,
  0x07, 0x03, 0x3C, 0x3D, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x03,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x87, 0x00, 0x38, 0xE0, 0x0F, 0x3C, 0x00, 0xF7,
  0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xCE, 0x1F,
  0xDC, 0x7F, 0xB9, 0xF0, 0xF3, 0xC1, 0xE7, 0x03, 0x9E, 0x07, 0x3C, 0x0E,
  0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xF1, 0xFD, 0xC3, 0xFB, 0x83, 0xE7, 0x00,
  0x1E, 0x18, 0x78, 0x7F, 0xF1, 0xFF, 0xC0, 0x7E, 0x00, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x0F, 0x7E, 0x3B,
  0xF8, 0xF8, 0xF7, 0xC3, 0xDE, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C,
  0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x38, 0x1C, 0x03, 0x80, 0x3E, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x83, 0xCE, 0x1C, 0xF8,
  0xEF, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x87, 0x8E, 0x3C, 0x79, 0xC1, 0xEE, 0x0F, 0xF0, 0x3F, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x3C, 0x1E, 0xFC, 0x3B, 0xFC, 0x7C, 0x79, 0xF0, 0xE3, 0xC1,
  0xC7, 0x87, 0x0E, 0x78, 0x1D, 0xE0, 0x39, 0xC6, 0xF3, 0xDF, 0xE3, 0xFB,
  0xC7, 0xE7, 0x07, 0x00, 0xFF, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x8E,
  0x3B, 0xCF, 0x7B, 0xCF, 0xF1, 0xFC, 0x1E, 0x00, 0x3B, 0x8E, 0x3F, 0xDF,
  0x3F, 0xFF, 0x39, 0xE7, 0x79, 0xC7, 0x71, 0xC6, 0x71, 0xC6, 0x71, 0x8E,
  0x73, 0x8E, 0x63, 0x8E, 0xE3, 0x8E, 0xE3, 0x8C, 0xE3, 0x9C, 0xE3, 0x1C,
  0x3C, 0xF0, 0xE7, 0xE3, 0xBF, 0x8F, 0x8F, 0x7C, 0x3D, 0xE0, 0xE7, 0x83,
  0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0x81,
  0xC0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x0F, 0x78, 0x3D, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xE7, 0x8F, 0x9F, 0xFC, 0x3F, 0xE0,
  0x7E, 0x00, 0x1E, 0x78, 0x39, 0xF8, 0x77, 0xF8, 0xF8, 0xF3, 0xE1, 0xE7,
  0x81, 0xCF, 0x07, 0x9C, 0x0F, 0x38, 0x1E, 0x70, 0x39, 0xF0, 0xF3, 0xFF,
  0xC7, 0x7F, 0x0E, 0x7C, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x0F, 0x9C, 0x7F, 0x73, 0xFD, 0xDF, 0x0F, 0x78, 0x3D, 0xC0,
  0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x9F, 0xDC, 0x7F,
  0x70, 0xF1, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0xFE, 0x7F, 0xF7, 0xFF, 0xFE, 0x3A, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x07,
  0xE0, 0x7F, 0xE3, 0xFF, 0xCF, 0x04, 0x38, 0x00, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xF8, 0x01, 0xE6, 0x07, 0xBF, 0xFC, 0x7F, 0xE0, 0x7E, 0x00,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x18, 0xF3,
  0xC7, 0xBF, 0x3F, 0xC1, 0xFC, 0x07, 0x80, 0x78, 0x3B, 0x81, 0xDC, 0x1E,
  0xE0, 0xFF, 0x07, 0xF8, 0x3B, 0x81, 0xDC, 0x1E, 0xE0, 0xF7, 0x0F, 0xBC,
  0xFD, 0xFD, 0xCF, 0xCE, 0x3C, 0x70, 0x7E, 0x1B, 0xF0, 0xEF, 0xC3, 0xC7,
  0x0F, 0x1C, 0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x0E, 0x38, 0x78, 0xE3, 0xC3,
  0x9F, 0x0F, 0xF8, 0x3F, 0x80, 0x7C, 0x00, 0x71, 0xCC, 0xE3, 0x39, 0xCE,
  0x33, 0x1C, 0x76, 0x38, 0xFC, 0x71, 0xB8, 0xE3, 0x71, 0x8E, 0xE7, 0x1D,
  0x8E, 0x3B, 0x3C, 0xE7, 0xD9, 0xCF, 0xBF, 0x1E, 0x38, 0x00, 0x07, 0x0E,
  0x1F, 0x9F, 0x3F, 0xBF, 0x79, 0xA7, 0x31, 0xE7, 0x41, 0xC7, 0x03, 0xC0,
  0x03, 0xC0, 0xE3, 0xC4, 0xE3, 0xCE, 0xE7, 0xDE, 0xFD, 0xFC, 0xFD, 0xF8,
  0x78, 0xE0, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xF3, 0xC1, 0xC7,
  0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0xF8, 0xF3, 0xE1, 0xFD,
  0xC3, 0xFB, 0x83, 0xCF, 0x00, 0x1E, 0x18, 0x78, 0x7F, 0xF1, 0xFF, 0xC0,
  0x7E, 0x00, 0x1F, 0x9E, 0x7F, 0xB8, 0xFF, 0xF3, 0x87, 0xE7, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x38, 0x78, 0x33, 0xFC, 0x67, 0xFF,
  0xEE, 0xFF, 0x9C, 0x3E, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC1, 0xFE,
  0x0F, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x0E, 0x1C,
  0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE0, 0x0F, 0xC0, 0x7F, 0x07,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0xF0, 0x0F, 0x83, 0xFC, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFC, 0x1F, 0xE0, 0xFE,
  0x00, 0x1E, 0x0C, 0x7E, 0x1D, 0xFC, 0x73, 0xBC, 0xEE, 0x3F, 0x9C, 0x3F,
  0x30, 0x38, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 19, 16, 5, -19 },
  { 18, 10, 8, 16, 5, -20 },
  { 28, 17, 19, 16, 0, -19 },
  { 69, 15, 25, 16, 1, -22 },
  { 116, 19, 19, 16, -1, -19 },
  { 162, 16, 19, 16, 0, -19 },
  { 200, 5, 8, 16, 7, -20 },
  { 205, 11, 25, 16, 5, -21 },
  { 240, 11, 25, 16, 1, -21 },
  { 275, 14, 14, 16, 1, -15 },
  { 300, 13, 13, 16, 2, -15 },
  { 322, 7, 8, 16, 3, -4 },
  { 329, 9, 3, 16, 4, -10 },
  { 333, 5, 5, 16, 5, -5 },
  { 337, 16, 25, 16, 0, -21 },
  { 387, 15, 19, 16, 1, -19 },
  { 423, 14, 19, 16, 1, -19 },
  { 457, 15, 19, 16, 0, -19 },
  { 493, 15, 19, 16, 0, -19 },
  { 529, 15, 19, 16, 0, -19 },
  { 565, 15, 19, 16, 1, -19 },
  { 601, 14, 19, 16, 1, -19 },
  { 635, 15, 19, 16, 2, -19 },
  { 671, 15, 19, 16, 1, -19 },
  { 707, 14, 19, 16, 2, -19 },
  { 741, 6, 15, 16, 5, -15 },
  { 753, 8, 19, 16, 3, -15 },
  { 772, 13, 16, 16, 2, -16 },
  { 798, 14, 9, 16, 1, -13 },
  { 814, 13, 16, 16, 1, -16 },
  { 840, 12, 19, 16, 3, -19 },
  { 869, 15, 22, 16, 1, -19 },
  { 911, 16, 19, 16, -1, -19 },
  { 949, 14, 19, 16, 1, -19 },
  { 983, 14, 19, 16, 2, -19 },
  { 1017, 15, 19, 16, 1, -19 },
  { 1053, 15, 19, 16, 1, -19 },
  { 1089, 16, 19, 16, 1, -19 },
  { 1127, 15, 19, 16, 1, -19 },
  { 1163, 15, 19, 16, 1, -19 },
  { 1199, 15, 19, 16, 1, -19 },
  { 1235, 15, 19, 16, 1, -19 },
  { 1271, 17, 19, 16, 1, -19 },
  { 1312, 12, 19, 16, 2, -19 },
  { 1341, 17, 19, 16, 0, -19 },
  { 1382, 15, 19, 16, 1, -19 },
  { 1418, 15, 19, 16, 1, -19 },
  { 1454, 15, 19, 16, 1, -19 },
  { 1490, 15, 24, 16, 1, -19 },
  { 1535, 15, 19, 16, 1, -19 },
  { 1571, 16, 19, 16, 0, -19 },
  { 1609, 16, 19, 16, 2, -19 },
  { 1647, 14, 19, 16, 2, -19 },
  { 1681, 16, 19, 16, 2, -19 },
  { 1719, 17, 19, 16, 1, -19 },
  { 1760, 19, 19, 16, -1, -19 },
  { 1806, 16, 19, 16, 2, -19 },
  { 1844, 17, 19, 16, 0, -19 },
  { 1885, 12, 25, 16, 4, -21 },
  { 1923, 7, 25, 16, 5, -21 },
  { 1945, 12, 25, 16, 1, -21 },
  { 1983, 15, 12, 16, 1, -19 },
  { 2006, 13, 3, 16, 0, 2 },
  { 2011, 5, 6, 16, 5, -22 },
  { 2015, 14, 14, 16, 1, -14 },
  { 2040, 14, 20, 16, 1, -20 },
  { 2075, 12, 14, 16, 2, -14 },
  { 2096, 15, 20, 16, 1, -20 },
  { 2134, 13, 14, 16, 2, -14 },
  { 2157, 19, 25, 16, -1, -20 },
  { 2217, 15, 19, 16, 0, -14 },
  { 2253, 14, 20, 16, 1, -20 },
  { 2288, 13, 21, 16, 2, -21 },
  { 2323, 13, 26, 16, 1, -21 },
  { 2366, 15, 20, 16, 1, -20 },
  { 2404, 11, 20, 16, 3, -20 },
  { 2432, 16, 14, 16, 0, -14 },
  { 2460, 14, 14, 16, 1, -14 },
  { 2485, 14, 14, 16, 1, -14 },
  { 2510, 15, 19, 16, 0, -14 },
  { 2546, 14, 19, 16, 1, -14 },
  { 2580, 13, 14, 16, 3, -14 },
  { 2603, 14, 14, 16, 1, -14 },
  { 2628, 13, 19, 16, 2, -19 },
  { 2659, 13, 14, 16, 2, -14 },
  { 2682, 14, 14, 16, 1, -14 },
  { 2707, 15, 14, 16, 1, -14 },
  { 2734, 16, 14, 16, 0, -14 },
  { 2762, 15, 19, 16, 0, -14 },
  { 2798, 15, 14, 16, 1, -14 },
  { 2825, 13, 25, 16, 3, -21 },
  { 2866, 7, 25, 16, 5, -21 },
  { 2888, 13, 25, 16, 1, -21 },
  { 2929, 15, 7, 16, 1, -12 },
};

const GFXfont IBMPlexMono_SemiBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC27PT7B_H_
