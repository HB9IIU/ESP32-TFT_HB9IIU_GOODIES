#ifndef _IBMPLEXMONO_SEMIBOLDITALIC39PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0x80, 0x7C,
  0x3D, 0xF1, 0xF7, 0xC7, 0xDE, 0x1F, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0xBE,
  0x3E, 0xF8, 0xFB, 0xC3, 0xEF, 0x0F, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x1F, 0xF0, 0xFF,
  0x8F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0x3C, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFE, 0x01, 0xF1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xDE, 0xF8, 0x7C, 0x78,
  0xC1, 0xF1, 0xC2, 0x07, 0xC7, 0x00, 0x1F, 0x1C, 0x00, 0x7C, 0x70, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7B, 0xF0, 0x01, 0xC7, 0xE0, 0x07, 0x0F,
  0x80, 0x1C, 0x3E, 0x30, 0x71, 0xF1, 0xE1, 0xC7, 0xCF, 0xCF, 0x7F, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xE0, 0x7F, 0x80, 0x78, 0x1F, 0xF8, 0x1E, 0x07, 0x8F, 0x03, 0xC0,
  0xF0, 0xE0, 0xF0, 0x3C, 0x1C, 0x3C, 0x07, 0x83, 0x8F, 0x00, 0xF0, 0x71,
  0xE0, 0x1E, 0x1E, 0x78, 0x03, 0xC3, 0xDE, 0x00, 0x78, 0xF3, 0x80, 0x07,
  0xFE, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0xEF, 0x0E, 0x00, 0x79, 0xE1, 0xE0, 0x0F,
  0x38, 0x3C, 0x03, 0xCF, 0x07, 0x80, 0xF1, 0xE0, 0xE0, 0x1E, 0x3C, 0x3C,
  0x07, 0x87, 0x87, 0x81, 0xE0, 0xF1, 0xE0, 0x78, 0x0F, 0xFC, 0x0F, 0x00,
  0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x0F, 0x80, 0x3C, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07,
  0xC7, 0xC0, 0x07, 0x9F, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0x9F,
  0x00, 0x3E, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0xF8, 0x4F, 0x81, 0xF1, 0xFF, 0x07, 0xE3, 0xFF, 0x0B, 0xEF,
  0x3F, 0xF3, 0xFE, 0x7F, 0xE7, 0xF8, 0x7F, 0x87, 0xE0, 0x3C, 0x07, 0x80,
  0x3D, 0xF7, 0xDE, 0x79, 0xE7, 0xBE, 0xFB, 0xCF, 0x3C, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x06, 0x0F, 0x83, 0x7C, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xBE, 0x03, 0xF3, 0xE0, 0x7E, 0x1F, 0x07,
  0xC0, 0xF8, 0x38, 0x0E, 0x01, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE8, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x03,
  0xCF, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8,
  0xE1, 0xFF, 0x8F, 0x9F, 0xFC, 0x7C, 0xFF, 0xE3, 0xE7, 0xDF, 0x1E, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x7E, 0x7C, 0x03, 0xE1, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xC1, 0xF8, 0xF0,
  0x7E, 0x3E, 0x07, 0x87, 0xC0, 0xE0, 0xF8, 0x08, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0x8F,
  0xC0, 0xFC, 0x7C, 0x03, 0xE0, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFC, 0x3F, 0x87, 0x80,
  0xFC, 0x18, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x40,
  0x07, 0xE3, 0x00, 0x3E, 0x7C, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0,
  0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0xFC, 0x01, 0xE7, 0xFC, 0x07, 0xBF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC,
  0x1F, 0xC3, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x04, 0x00, 0x7C, 0x38, 0x03, 0xF1, 0xE0, 0x0F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF3, 0xF0, 0x3E, 0xFF, 0x87, 0xDF, 0xFC, 0x7F, 0xFF, 0xEF, 0xF0,
  0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0x7E, 0x1F, 0xC7,
  0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0x80, 0x1F, 0x3C,
  0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xC1, 0xFC, 0x7E,
  0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xE0, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x07,
  0xE7, 0xE0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x07, 0xEF, 0xE0, 0xFE, 0x7F,
  0xFB, 0xE7, 0xFF, 0x7C, 0x3F, 0xE7, 0xC0, 0xFC, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x87, 0xE3, 0xFC,
  0xFE, 0x3F, 0x8F, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0x78, 0x00, 0x01,
  0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x40, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x10, 0x00, 0x03, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFE,
  0x7E, 0x1F, 0xDF, 0x03, 0xFB, 0x80, 0x7C, 0x40, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x1E, 0x7B, 0xC3, 0xFB, 0xDE, 0x3F, 0xFC, 0xF1, 0xE3, 0xEF,
  0x9F, 0x0F, 0x78, 0xF0, 0x7B, 0xC7, 0x83, 0xDE, 0x7C, 0x1E, 0xF3, 0xC0,
  0xE7, 0x9E, 0x0F, 0x3C, 0xF0, 0x79, 0xE7, 0x83, 0xCE, 0x3C, 0x3E, 0x70,
  0xFE, 0xF3, 0x87, 0xFF, 0x1E, 0x1F, 0x78, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x00, 0xF8,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xC0, 0x7C, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F,
  0x3E, 0x01, 0xF9, 0xF0, 0x1F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xE0,
  0x1F, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x41, 0xF0, 0x03, 0xC7, 0xC0, 0x3E, 0x3E,
  0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0x83, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3F,
  0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8,
  0xFC, 0x03, 0xE7, 0xC0, 0x1E, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC3, 0xFF, 0x7E, 0x1F, 0xFB, 0xF0, 0xFF, 0x9F,
  0x07, 0xFC, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x7C, 0x7E, 0x03, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F,
  0xF7, 0xC0, 0xFF, 0x3E, 0x03, 0xF1, 0xE0, 0x0F, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x70, 0x0F, 0x8F, 0x80, 0x7C, 0x3E,
  0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x07, 0xCF,
  0x80, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x9F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xF8,
  0x3E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x0F,
  0xF1, 0xFE, 0x1F, 0xF3, 0xDE, 0x1F, 0x7B, 0xDE, 0x1E, 0x7F, 0x9E, 0x1E,
  0x7F, 0xBE, 0x1E, 0x7F, 0x3E, 0x1E, 0x7E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E,
  0x3C, 0x3C, 0x3E, 0x3C, 0x7C, 0x3C, 0x38, 0x7C, 0x3C, 0x18, 0x7C, 0x3C,
  0x10, 0x78, 0x7C, 0x20, 0x78, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x78,
  0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0x0F, 0xE0, 0x3E, 0x1F, 0xC0, 0x78, 0x3F, 0x80, 0xF0, 0x7F,
  0x01, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0x0F, 0xF8,
  0x3C, 0x1F, 0xF0, 0x78, 0x3D, 0xF0, 0xF0, 0x79, 0xE3, 0xE0, 0xF3, 0xC7,
  0xC3, 0xE7, 0x8F, 0x87, 0xCF, 0x1E, 0x0F, 0x9F, 0x3C, 0x1E, 0x1E, 0x78,
  0x3C, 0x3D, 0xF0, 0x78, 0x7B, 0xE1, 0xF0, 0xF7, 0xC3, 0xE1, 0xFF, 0x07,
  0xC1, 0xFE, 0x0F, 0x03, 0xFC, 0x1E, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0xF8,
  0x1F, 0xE1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8,
  0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x7E, 0x7C, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x7E,
  0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x07,
  0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x7E, 0x7C, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x06, 0x00, 0x7C,
  0x78, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xE1,
  0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x3E, 0x01,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xC0, 0xF8, 0x7E, 0x01, 0xC1, 0xF0, 0x02, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x30, 0x01, 0xF1, 0xE0,
  0x0F, 0xCF, 0xE0, 0x7E, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C,
  0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x3E, 0x00,
  0x79, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x7E,
  0x3E, 0x1E, 0x3F, 0x1E, 0x1F, 0x1F, 0x8F, 0x0F, 0x9F, 0xC7, 0x87, 0xCE,
  0xE7, 0xC3, 0xC7, 0x73, 0xC1, 0xE7, 0x39, 0xE0, 0xF3, 0x9C, 0xF0, 0x79,
  0xCE, 0x78, 0x3D, 0xE7, 0x78, 0x1E, 0xE3, 0xBC, 0x0F, 0x71, 0xDE, 0x0F,
  0xF8, 0xEF, 0x07, 0xF8, 0x77, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xE0,
  0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F,
  0x00, 0x7C, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x07, 0xC0, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xF0,
  0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0xC1, 0xF0, 0x0F, 0x87,
  0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xC7, 0x80, 0x7C, 0x7C, 0x0F,
  0x87, 0xC1, 0xF0, 0x3C, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xE7,
  0xC0, 0x1F, 0xF8, 0x00, 0xF7, 0x00, 0x0F, 0x10, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x10, 0xE3, 0xE7, 0xC7,
  0x8F, 0x8F, 0x0E, 0x1A, 0x03, 0xF1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFF, 0xE3,
  0xF0, 0x7E, 0x3E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xFC, 0x7F, 0x87, 0xFE,
  0xFE, 0x7F, 0xCF, 0xE1, 0xF0, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x07, 0xCF, 0xF8, 0x3E,
  0xFF, 0xE1, 0xFE, 0x3F, 0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xE7, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7E, 0x07, 0xE3,
  0xF8, 0x7E, 0x1F, 0xFF, 0xE1, 0xF3, 0xFE, 0x0F, 0x8F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xC3, 0xF1, 0xF0, 0x3C, 0x7C,
  0x02, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0x1F, 0x00, 0xF3, 0xE0,
  0x3F, 0x7E, 0x1F, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x0F, 0xC7, 0xC0, 0xFF, 0x9F, 0x07, 0xFF, 0x7C, 0x3F, 0x07, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0xC3, 0xF0, 0xDE, 0x07, 0xFE,
  0xF8, 0x0F, 0xF3, 0xE0, 0x1F, 0x8F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0x0F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x3F, 0x7C, 0x3F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x02, 0x1F, 0x00, 0xF3, 0xE0, 0x3F, 0x7E, 0x0F, 0x87,
  0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x10, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x3F,
  0xF7, 0xC3, 0xFF, 0xBE, 0x3F, 0x07, 0xF1, 0xF0, 0x1F, 0x9F, 0x00, 0xF8,
  0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F,
  0x81, 0xFC, 0x7E, 0x1B, 0xC1, 0xFF, 0x9E, 0x07, 0xF9, 0xF0, 0x1F, 0x8F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x04, 0x01, 0xE0, 0x78,
  0x3F, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x1F,
  0x1F, 0xE1, 0xF3, 0xFE, 0x1F, 0x63, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1,
  0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x60, 0xFC, 0x3C, 0x3E, 0x1E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0,
  0x3F, 0xF0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xC3, 0xE0, 0x7C,
  0x7C, 0x07, 0xCF, 0x80, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x3F, 0x01, 0xF3, 0xFE, 0x07, 0xDF, 0xFC, 0x1F,
  0x63, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x01,
  0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0xFC, 0x0F, 0x8F, 0xC0, 0x3E, 0xFC, 0x00,
  0xFB, 0xE0, 0x07, 0xC7, 0xC2, 0x1F, 0x1F, 0x0E, 0x7C, 0x7C, 0x7D, 0xF0,
  0xFB, 0xC7, 0xC3, 0xFE, 0x1F, 0x07, 0xF0, 0xF8, 0x0F, 0x00, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x06, 0x1F, 0x0F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x7C,
  0x3E, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x1E, 0x78, 0x78, 0x3D,
  0xF9, 0xF8, 0x7B, 0xF7, 0xF8, 0xF9, 0xE9, 0xF3, 0xE3, 0xE1, 0xE7, 0x87,
  0xC3, 0xCF, 0x0F, 0x0F, 0x9E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x79, 0xE0, 0xF0, 0xF3, 0xC3, 0xC1, 0xE7, 0x87, 0x87, 0xCF, 0x0F, 0x0F,
  0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0xF0, 0x78, 0x79, 0xE1, 0xE0, 0xF3,
  0xC3, 0xC3, 0xE7, 0x87, 0x87, 0x80, 0x0F, 0x8F, 0x81, 0xF1, 0xFE, 0x1F,
  0x3F, 0xE1, 0xF6, 0x3F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF3,
  0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0x0F, 0x83, 0xE3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF3, 0xC0, 0x7C, 0x7E, 0x1F,
  0x87, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x3E,
  0x7F, 0xC0, 0xFB, 0xFF, 0x83, 0xFC, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0x01,
  0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0xFF, 0xFF, 0x07, 0xCF, 0xF8,
  0x1F, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xF0, 0x7F, 0x3E,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC,
  0xF8, 0x0F, 0xCF, 0x81, 0xFC, 0xFC, 0x37, 0x87, 0xFE, 0xF8, 0x3F, 0xCF,
  0x81, 0xF8, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x83, 0xEF, 0xE0, 0x7F, 0x00, 0x1F,
  0x40, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0x81, 0xE3, 0xE0, 0x18, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x88, 0x01, 0xF3, 0x80,
  0x7C, 0xFC, 0x1F, 0x9F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0xC1, 0xF0,
  0x7C, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xFB, 0xE0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x7C, 0x2F, 0x87, 0xFE,
  0xF8, 0x3F, 0xCF, 0x81, 0xF0, 0xF8, 0xFF, 0x80, 0xDF, 0xF0, 0xFF, 0xFE,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF1, 0xF8, 0x3C, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x3C, 0x3C, 0x11, 0xE1, 0xE3, 0xCF,
  0x0F, 0x1E, 0x78, 0x78, 0xF3, 0xC3, 0xC7, 0xBC, 0x3C, 0x3D, 0xE1, 0xE1,
  0xEF, 0x0F, 0x0F, 0x78, 0x78, 0x7B, 0xC3, 0xC3, 0xDE, 0x1E, 0x1F, 0xE1,
  0xE0, 0xFF, 0x0F, 0x07, 0x78, 0x78, 0x7B, 0xC3, 0xC3, 0xDE, 0x2E, 0x1C,
  0xF3, 0x71, 0xC7, 0xF3, 0x9E, 0x3F, 0x9F, 0xE0, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x0F, 0xF1, 0xFC, 0x7F, 0xE7, 0xF9, 0xFB, 0xDC, 0xF7, 0xE3,
  0xB1, 0xE3, 0x07, 0x43, 0xC4, 0x0F, 0x87, 0x80, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x1E, 0x1F, 0x82, 0x3C, 0x3F, 0x0E, 0x78, 0x5E, 0x3E, 0xF9, 0xBD, 0xF9,
  0xFE, 0x7F, 0xE1, 0xFC, 0x7F, 0x81, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3,
  0xE0, 0x3F, 0x07, 0xC1, 0x78, 0x1F, 0x0F, 0xE0, 0x7F, 0xEF, 0x80, 0xFF,
  0x3E, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x04, 0x03, 0xE0, 0x3C, 0x1F, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x78, 0x7F, 0xE3, 0xC7, 0xFF, 0xDE, 0x3C, 0x3F,
  0xF3, 0xC0, 0x7F, 0x1E, 0x03, 0xF0, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0xC0, 0x7E, 0x1E,
  0x07, 0xE0, 0x70, 0x7E, 0x03, 0xC7, 0xF0, 0x1E, 0x7F, 0xFC, 0xF7, 0xDF,
  0xFF, 0xBE, 0x3F, 0xF9, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xE0, 0x1F,
  0xE0, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x03, 0xFF,
  0x80, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x3F, 0x80, 0xF1, 0xFF, 0x07, 0x8F,
  0xFC, 0x1E, 0x3C, 0xF8, 0x79, 0xE1, 0xF3, 0xC7, 0x87, 0xFF, 0x3C, 0x0F,
  0xF8, 0xF0, 0x1F, 0xC1, 0xC0, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 27, 23, 7, -27 },
  { 35, 14, 12, 23, 7, -29 },
  { 56, 25, 27, 23, 0, -27 },
  { 141, 22, 35, 23, 1, -31 },
  { 238, 27, 27, 23, -1, -27 },
  { 330, 23, 27, 23, 0, -27 },
  { 408, 6, 12, 23, 11, -29 },
  { 417, 16, 35, 23, 7, -30 },
  { 487, 16, 35, 23, 1, -30 },
  { 557, 20, 20, 23, 2, -21 },
  { 607, 20, 19, 23, 2, -21 },
  { 655, 11, 12, 23, 4, -6 },
  { 672, 12, 4, 23, 6, -14 },
  { 678, 7, 7, 23, 7, -7 },
  { 685, 23, 35, 23, 0, -30 },
  { 786, 21, 27, 23, 2, -27 },
  { 857, 19, 27, 23, 2, -27 },
  { 922, 21, 27, 23, 1, -27 },
  { 993, 21, 27, 23, 1, -27 },
  { 1064, 22, 27, 23, 0, -27 },
  { 1139, 22, 27, 23, 1, -27 },
  { 1214, 20, 27, 23, 2, -27 },
  { 1282, 21, 27, 23, 3, -27 },
  { 1353, 22, 27, 23, 1, -27 },
  { 1428, 20, 27, 23, 3, -27 },
  { 1496, 10, 21, 23, 7, -21 },
  { 1523, 13, 27, 23, 4, -21 },
  { 1567, 19, 23, 23, 3, -23 },
  { 1622, 20, 12, 23, 2, -18 },
  { 1652, 19, 23, 23, 2, -23 },
  { 1707, 18, 27, 23, 4, -27 },
  { 1768, 21, 31, 23, 2, -27 },
  { 1850, 22, 27, 23, -1, -27 },
  { 1925, 21, 27, 23, 1, -27 },
  { 1996, 21, 27, 23, 2, -27 },
  { 2067, 22, 27, 23, 1, -27 },
  { 2142, 21, 27, 23, 2, -27 },
  { 2213, 22, 27, 23, 2, -27 },
  { 2288, 21, 27, 23, 2, -27 },
  { 2359, 23, 27, 23, 1, -27 },
  { 2437, 22, 27, 23, 1, -27 },
  { 2512, 21, 27, 23, 1, -27 },
  { 2583, 25, 27, 23, 1, -27 },
  { 2668, 18, 27, 23, 2, -27 },
  { 2729, 24, 27, 23, 0, -27 },
  { 2810, 23, 27, 23, 1, -27 },
  { 2888, 21, 27, 23, 2, -27 },
  { 2959, 21, 27, 23, 2, -27 },
  { 3030, 21, 35, 23, 2, -27 },
  { 3122, 21, 27, 23, 2, -27 },
  { 3193, 22, 27, 23, 1, -27 },
  { 3268, 22, 27, 23, 3, -27 },
  { 3343, 22, 27, 23, 2, -27 },
  { 3418, 21, 27, 23, 4, -27 },
  { 3489, 25, 27, 23, 1, -27 },
  { 3574, 26, 27, 23, -1, -27 },
  { 3662, 23, 27, 23, 3, -27 },
  { 3740, 24, 27, 23, 0, -27 },
  { 3821, 18, 35, 23, 5, -30 },
  { 3900, 10, 35, 23, 7, -30 },
  { 3944, 18, 35, 23, 1, -30 },
  { 4023, 20, 17, 23, 2, -27 },
  { 4066, 19, 4, 23, 0, 3 },
  { 4076, 7, 9, 23, 8, -31 },
  { 4084, 20, 20, 23, 2, -20 },
  { 4134, 21, 29, 23, 1, -29 },
  { 4211, 19, 20, 23, 2, -20 },
  { 4259, 22, 29, 23, 2, -29 },
  { 4339, 19, 20, 23, 2, -20 },
  { 4387, 26, 37, 23, -1, -29 },
  { 4508, 21, 28, 23, 1, -20 },
  { 4582, 20, 29, 23, 1, -29 },
  { 4655, 18, 30, 23, 3, -30 },
  { 4723, 19, 38, 23, 1, -30 },
  { 4814, 22, 29, 23, 1, -29 },
  { 4894, 16, 29, 23, 4, -29 },
  { 4952, 23, 20, 23, 0, -20 },
  { 5010, 20, 20, 23, 1, -20 },
  { 5060, 19, 20, 23, 2, -20 },
  { 5108, 22, 28, 23, 0, -20 },
  { 5185, 20, 28, 23, 2, -20 },
  { 5255, 19, 20, 23, 4, -20 },
  { 5303, 19, 20, 23, 2, -20 },
  { 5351, 19, 27, 23, 3, -27 },
  { 5416, 20, 20, 23, 2, -20 },
  { 5466, 19, 20, 23, 2, -20 },
  { 5514, 21, 20, 23, 1, -20 },
  { 5567, 23, 20, 23, 0, -20 },
  { 5625, 22, 28, 23, 0, -20 },
  { 5702, 21, 20, 23, 1, -20 },
  { 5755, 19, 35, 23, 4, -30 },
  { 5839, 10, 35, 23, 7, -30 },
  { 5883, 19, 35, 23, 1, -30 },
  { 5967, 22, 10, 23, 1, -17 },
};

const GFXfont IBMPlexMono_SemiBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC39PT7B_H_
