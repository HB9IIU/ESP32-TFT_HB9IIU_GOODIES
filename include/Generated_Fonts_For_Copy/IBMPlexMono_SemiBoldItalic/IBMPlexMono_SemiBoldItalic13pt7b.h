#ifndef _IBMPLEXMONO_SEMIBOLDITALIC13PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x24, 0x0E, 0xC0, 0x5A, 0xF7, 0xA0, 0x0B, 0x1A, 0x16,
  0x77, 0x34, 0xEE, 0x68, 0x48, 0x58, 0x0C, 0x3E, 0x6B, 0x68, 0x68, 0x1C,
  0x1E, 0x12, 0x56, 0xFC, 0x10, 0x31, 0xA5, 0x13, 0x0B, 0x07, 0xE0, 0x50,
  0xEC, 0xB4, 0x8E, 0x00, 0x1C, 0x36, 0x32, 0x36, 0x78, 0xD8, 0xC8, 0xDB,
  0x66, 0xEA, 0x1C, 0xC2, 0x18, 0x41, 0x0C, 0x30, 0xC1, 0x06, 0x0C, 0x30,
  0x60, 0x83, 0x0C, 0x30, 0xC2, 0x08, 0x43, 0x38, 0x10, 0x4F, 0xDE, 0x73,
  0x69, 0x00, 0x10, 0x43, 0x3F, 0x30, 0x82, 0x00, 0x36, 0x6C, 0xF0, 0xFC,
  0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x3C, 0x8B, 0x1F, 0xBB, 0x70, 0xA3, 0x44, 0x70, 0x39, 0xED, 0x86, 0x18,
  0x41, 0x0C, 0xFC, 0x3C, 0xCC, 0x08, 0x30, 0x43, 0x0C, 0x30, 0xFE, 0x3E,
  0xCC, 0x08, 0x31, 0x80, 0xC1, 0xE3, 0x7C, 0x06, 0x1C, 0x79, 0xB6, 0x58,
  0xBF, 0x86, 0x0C, 0x3F, 0x20, 0x20, 0x7C, 0x66, 0x06, 0x06, 0x46, 0xF8,
  0x1C, 0xC6, 0x3E, 0xCE, 0x38, 0xF3, 0x78, 0x7F, 0x8F, 0x30, 0x61, 0x86,
  0x0C, 0x30, 0x60, 0x1E, 0x22, 0x63, 0x22, 0x1C, 0x66, 0xC6, 0xC6, 0x7C,
  0x38, 0x8B, 0x1E, 0x3C, 0xCF, 0x82, 0x18, 0xE0, 0x67, 0x00, 0x0E, 0xE0,
  0x31, 0xC0, 0x00, 0x19, 0x8C, 0xC0, 0x04, 0x33, 0xB8, 0xC1, 0xC1, 0x82,
  0xFC, 0x00, 0x3F, 0x41, 0x83, 0x83, 0x1D, 0xCC, 0x20, 0x79, 0x38, 0x43,
  0x38, 0x80, 0x18, 0x60, 0x3C, 0x8B, 0x1C, 0xEA, 0x54, 0xA9, 0x5E, 0x80,
  0xE0, 0x1C, 0x38, 0x51, 0xA2, 0x6F, 0xD1, 0xE3, 0xC6, 0x3E, 0x44, 0x8B,
  0x37, 0xCC, 0xD9, 0xA3, 0xFC, 0x3C, 0xCF, 0x06, 0x0C, 0x10, 0x22, 0x66,
  0x78, 0x3C, 0x22, 0x23, 0x63, 0x62, 0x62, 0x66, 0x44, 0xF8, 0x7E, 0x81,
  0x06, 0x0F, 0xD8, 0x30, 0x40, 0xF8, 0x7E, 0x81, 0x06, 0x0F, 0xD8, 0x30,
  0x40, 0x80, 0x3C, 0xCB, 0x0E, 0x0D, 0xD1, 0xA3, 0x66, 0x7C, 0x33, 0x23,
  0x62, 0x62, 0x7E, 0x66, 0x46, 0x46, 0xC4, 0x3F, 0x08, 0x08, 0x18, 0x18,
  0x18, 0x18, 0x10, 0xFC, 0x1E, 0x4C, 0x18, 0x30, 0x60, 0xC1, 0x66, 0x78,
  0x33, 0x93, 0x0B, 0x0F, 0x07, 0x83, 0x61, 0xB0, 0x8C, 0xC6, 0x00, 0x61,
  0x86, 0x10, 0x43, 0x0C, 0x30, 0xFC, 0x33, 0x77, 0x77, 0x5F, 0x5A, 0x5A,
  0xD2, 0xC6, 0xC6, 0x33, 0x33, 0x72, 0x7A, 0x7A, 0x4E, 0x4E, 0x4E, 0xCC,
  0x3C, 0x8B, 0x1E, 0x38, 0x70, 0xA3, 0x64, 0x70, 0x7C, 0x8D, 0x1E, 0x2F,
  0x98, 0x30, 0x40, 0x80, 0x3C, 0x8B, 0x1E, 0x38, 0x70, 0xA3, 0x64, 0x70,
  0x68, 0x60, 0x3E, 0x23, 0x23, 0x62, 0x7C, 0x6C, 0x6C, 0x44, 0xC6, 0x1E,
  0x23, 0x60, 0x60, 0x3C, 0x06, 0x06, 0x46, 0xFC, 0xFE, 0x20, 0x41, 0x83,
  0x06, 0x0C, 0x10, 0x20, 0x46, 0x8F, 0x1E, 0x2C, 0x59, 0xA3, 0x44, 0xF8,
  0xC7, 0x8F, 0x12, 0x64, 0xCB, 0x16, 0x38, 0x70, 0x61, 0xA0, 0x92, 0x4B,
  0x65, 0xA2, 0xD1, 0xA9, 0xDC, 0xEE, 0x00, 0x63, 0x36, 0x36, 0x1C, 0x18,
  0x3C, 0x2C, 0x64, 0xC6, 0xC7, 0x46, 0x6C, 0x78, 0x38, 0x30, 0x30, 0x20,
  0x20, 0x3F, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xFE, 0x3D, 0x86,
  0x10, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x3C, 0xCC, 0x44, 0x46, 0x62, 0x22,
  0x33, 0x3C, 0x10, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0x61, 0xBC, 0x18, 0xE6,
  0xD3, 0xC6, 0x20, 0xFC, 0xA4, 0x77, 0x3C, 0xE3, 0x8E, 0x6E, 0xC0, 0x30,
  0x40, 0x83, 0x77, 0x6C, 0x59, 0xA3, 0x67, 0xB8, 0x39, 0x3C, 0x30, 0x83,
  0x37, 0x80, 0x06, 0x0C, 0x13, 0xAC, 0xD9, 0xA3, 0x46, 0x9D, 0xD0, 0x39,
  0x3C, 0xFE, 0x8B, 0x37, 0x80, 0x07, 0x0C, 0x0C, 0x3F, 0x48, 0x18, 0x18,
  0x18, 0x18, 0x10, 0x90, 0xD0, 0x70, 0x3A, 0xCD, 0x9A, 0x34, 0x69, 0xDD,
  0x02, 0x8C, 0xF0, 0x30, 0x40, 0x83, 0x77, 0x6C, 0xD9, 0xA3, 0x47, 0x88,
  0x18, 0xC0, 0x3C, 0x30, 0xC2, 0x19, 0x68, 0xC0, 0x06, 0x0C, 0x01, 0xE0,
  0xC1, 0x83, 0x04, 0x08, 0x13, 0x63, 0xC3, 0x00, 0x30, 0x20, 0x20, 0x6E,
  0x76, 0x66, 0x6C, 0x58, 0x4B, 0xCC, 0xF0, 0xC3, 0x0C, 0x20, 0x86, 0x1B,
  0x79, 0xC0, 0x5A, 0x7F, 0x5A, 0xDA, 0xD2, 0xD2, 0x96, 0x6E, 0xED, 0x9B,
  0x34, 0x68, 0xF1, 0x00, 0x7B, 0x3C, 0x63, 0x8F, 0x27, 0x00, 0x6E, 0xED,
  0x8B, 0x34, 0x6C, 0xD7, 0x60, 0xC1, 0x80, 0x77, 0x3C, 0xE3, 0x8E, 0x7E,
  0x82, 0x18, 0x60, 0xF6, 0x70, 0x81, 0x06, 0x0C, 0x18, 0x00, 0x7B, 0x3C,
  0x1E, 0x0E, 0x2F, 0x80, 0x30, 0xCF, 0xC8, 0x61, 0x86, 0x5A, 0x70, 0xC7,
  0x3C, 0xF3, 0x8F, 0x6E, 0x80, 0xED, 0x34, 0xF3, 0xCF, 0x67, 0x00, 0x4A,
  0x95, 0x6A, 0xDD, 0x3A, 0x7F, 0x00, 0x37, 0xDB, 0x18, 0x18, 0x18, 0x9A,
  0xEC, 0x62, 0xCD, 0x9B, 0x34, 0x6D, 0x9D, 0x02, 0x8D, 0xF0, 0x3A, 0x8C,
  0x30, 0xC3, 0x6C, 0x77, 0x80, 0x1E, 0x20, 0x40, 0xC1, 0x9C, 0x04, 0x08,
  0x20, 0xC1, 0x83, 0xC0, 0x32, 0x22, 0x26, 0x64, 0x44, 0x4C, 0x3C, 0x18,
  0x30, 0xC1, 0x01, 0xC4, 0x18, 0x10, 0x20, 0x47, 0x80, 0x33, 0x5A, 0xCC,
};

const GFXglyph IBMPlexMono_SemiBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 5, 4, 8, 2, -10 },
  { 9, 8, 9, 8, 0, -9 },
  { 18, 8, 11, 8, 0, -10 },
  { 29, 9, 9, 8, 0, -9 },
  { 40, 8, 9, 8, 0, -9 },
  { 49, 2, 4, 8, 4, -10 },
  { 50, 6, 12, 8, 2, -10 },
  { 59, 6, 12, 8, 0, -10 },
  { 68, 6, 7, 8, 1, -7 },
  { 74, 6, 7, 8, 1, -7 },
  { 80, 4, 4, 8, 1, -2 },
  { 82, 4, 1, 8, 2, -4 },
  { 83, 3, 2, 8, 2, -2 },
  { 84, 8, 12, 8, 0, -10 },
  { 96, 7, 9, 8, 1, -9 },
  { 104, 6, 9, 8, 1, -9 },
  { 111, 7, 9, 8, 0, -9 },
  { 119, 7, 9, 8, 0, -9 },
  { 127, 7, 9, 8, 0, -9 },
  { 135, 8, 9, 8, 0, -9 },
  { 144, 6, 9, 8, 1, -9 },
  { 151, 7, 9, 8, 1, -9 },
  { 159, 8, 9, 8, 0, -9 },
  { 168, 7, 9, 8, 1, -9 },
  { 176, 4, 7, 8, 2, -7 },
  { 180, 5, 9, 8, 1, -7 },
  { 186, 6, 8, 8, 1, -8 },
  { 192, 6, 4, 8, 1, -6 },
  { 195, 6, 8, 8, 1, -8 },
  { 201, 6, 9, 8, 1, -9 },
  { 208, 7, 10, 8, 1, -9 },
  { 217, 7, 9, 8, 0, -9 },
  { 225, 7, 9, 8, 0, -9 },
  { 233, 7, 9, 8, 1, -9 },
  { 241, 8, 9, 8, 0, -9 },
  { 250, 7, 9, 8, 1, -9 },
  { 258, 7, 9, 8, 1, -9 },
  { 266, 7, 9, 8, 1, -9 },
  { 274, 8, 9, 8, 0, -9 },
  { 283, 8, 9, 8, 0, -9 },
  { 292, 7, 9, 8, 0, -9 },
  { 300, 9, 9, 8, 0, -9 },
  { 311, 6, 9, 8, 1, -9 },
  { 318, 8, 9, 8, 0, -9 },
  { 327, 8, 9, 8, 0, -9 },
  { 336, 7, 9, 8, 1, -9 },
  { 344, 7, 9, 8, 1, -9 },
  { 352, 7, 11, 8, 1, -9 },
  { 362, 8, 9, 8, 0, -9 },
  { 371, 8, 9, 8, 0, -9 },
  { 380, 7, 9, 8, 1, -9 },
  { 388, 7, 9, 8, 1, -9 },
  { 396, 7, 9, 8, 1, -9 },
  { 404, 9, 9, 8, 0, -9 },
  { 415, 8, 9, 8, 0, -9 },
  { 424, 8, 9, 8, 1, -9 },
  { 433, 8, 9, 8, 0, -9 },
  { 442, 6, 12, 8, 2, -10 },
  { 451, 4, 12, 8, 2, -10 },
  { 457, 6, 12, 8, 0, -10 },
  { 466, 6, 6, 8, 1, -9 },
  { 471, 6, 1, 8, 0, 1 },
  { 472, 2, 3, 8, 3, -11 },
  { 473, 6, 7, 8, 1, -7 },
  { 479, 7, 10, 8, 0, -10 },
  { 488, 6, 7, 8, 1, -7 },
  { 494, 7, 10, 8, 1, -10 },
  { 503, 6, 7, 8, 1, -7 },
  { 509, 8, 13, 8, 0, -10 },
  { 522, 7, 10, 8, 0, -7 },
  { 531, 7, 10, 8, 0, -10 },
  { 540, 6, 10, 8, 1, -10 },
  { 548, 7, 13, 8, 0, -10 },
  { 560, 8, 10, 8, 0, -10 },
  { 570, 6, 10, 8, 1, -10 },
  { 578, 8, 7, 8, 0, -7 },
  { 585, 7, 7, 8, 0, -7 },
  { 592, 6, 7, 8, 1, -7 },
  { 598, 7, 10, 8, 0, -7 },
  { 607, 6, 10, 8, 1, -7 },
  { 615, 7, 7, 8, 1, -7 },
  { 622, 6, 7, 8, 1, -7 },
  { 628, 6, 9, 8, 1, -9 },
  { 635, 6, 7, 8, 1, -7 },
  { 641, 6, 7, 8, 1, -7 },
  { 647, 7, 7, 8, 0, -7 },
  { 654, 8, 7, 8, 0, -7 },
  { 661, 7, 10, 8, 0, -7 },
  { 670, 7, 7, 8, 0, -7 },
  { 677, 7, 12, 8, 1, -10 },
  { 688, 4, 12, 8, 2, -10 },
  { 694, 7, 12, 8, 0, -10 },
  { 705, 8, 3, 8, 0, -5 },
};

const GFXfont IBMPlexMono_SemiBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC13PT7B_H_
