#ifndef _IBMPLEXMONO_SEMIBOLDITALIC54PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF0,
  0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7F,
  0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0xFC, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xCF, 0xBF, 0xC0, 0xFF, 0x1F, 0x1F, 0x01, 0xFC,
  0x3C, 0x1C, 0x07, 0xF0, 0x78, 0x10, 0x0F, 0xE0, 0xF0, 0x00, 0x1F, 0xC3,
  0xE0, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0xFF, 0x9E,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF9, 0xFF,
  0x00, 0x01, 0xF1, 0xFE, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x07, 0x83, 0xF8,
  0x00, 0x0F, 0x07, 0xF0, 0x20, 0x1E, 0x0F, 0xE0, 0xC0, 0x7C, 0x1F, 0xC3,
  0xC0, 0xF8, 0x7F, 0x0F, 0xE1, 0xF1, 0xFE, 0x3F, 0xF3, 0xCF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0xC3,
  0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0x7C, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0x3F, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x7C, 0x00,
  0x1F, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x1F, 0x9F, 0x80, 0x01, 0xFF, 0xFC,
  0x7C, 0x00, 0x03, 0xFF, 0xE3, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF1, 0xFF, 0xF0, 0x00,
  0x0F, 0x8F, 0xFF, 0xE0, 0x00, 0x7E, 0x3F, 0x1F, 0x80, 0x01, 0xF1, 0xF8,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0xF8, 0x00, 0x7E, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x7E,
  0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0xFF,
  0x80, 0x7E, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x10, 0xFE, 0x01, 0xFC, 0x1C,
  0xFE, 0x01, 0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x3F, 0xFE, 0x01, 0x7E, 0x7E,
  0x7F, 0x03, 0x7E, 0x7E, 0x7F, 0x87, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0x01, 0xF8, 0x06, 0x3E, 0x0F, 0xC1, 0xF1, 0xFE, 0x7E, 0x7F,
  0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x78, 0x01, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F,
  0x87, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8,
  0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x3F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFD, 0xFC, 0x1F, 0x0F, 0xE7, 0xF0, 0xFC,
  0x3F, 0x9F, 0xC3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC3, 0xFB, 0xFC, 0x7F, 0x0F,
  0xEF, 0xF0, 0xF8, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0xFF, 0x1F, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x1F,
  0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xC0, 0x7F, 0x00, 0x30, 0x0F, 0xC0, 0x04,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x3F, 0x80, 0x0F, 0xF0, 0x1C, 0x00, 0x3F, 0xC0, 0x10, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0x01, 0xE0, 0x03, 0xFC, 0x03,
  0x00, 0x0F, 0xF0, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x08, 0x00,
  0x0F, 0xE0, 0x70, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x7E, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xF1, 0xFF, 0xC0, 0x03, 0xE7, 0xFF, 0xE0, 0x0F, 0xDF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x40, 0x00, 0x7F,
  0x01, 0xC0, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE7, 0xFF, 0x01, 0xFC, 0xFF, 0xF8,
  0x1F, 0xDF, 0xFF, 0xC3, 0xFB, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xF0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x40, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x7F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF,
  0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFC, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F,
  0xF1, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFC,
  0x7F, 0xFF, 0x7F, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xF3, 0xF8, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x3C, 0x00, 0x7F, 0x0C, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xF8, 0x7E, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x01, 0xF1, 0xF1, 0xF8, 0x3F, 0xCF,
  0x9F, 0x83, 0xFF, 0x7C, 0xFC, 0x3F, 0xFB, 0xE7, 0xE1, 0xFF, 0xFF, 0x3E,
  0x1F, 0xC3, 0xFB, 0xF0, 0xFC, 0x0F, 0x9F, 0x8F, 0xC0, 0x7C, 0xFC, 0x7E,
  0x03, 0xE7, 0xE3, 0xF0, 0x1F, 0x3F, 0x1F, 0x01, 0xF9, 0xF0, 0xF8, 0x0F,
  0xCF, 0x8F, 0xC0, 0x7C, 0xFC, 0x7E, 0x03, 0xE7, 0xE3, 0xF0, 0x3F, 0x3F,
  0x1F, 0x81, 0xF9, 0xF8, 0x7C, 0x1F, 0xCF, 0xC3, 0xFB, 0xFE, 0x7E, 0x1F,
  0xFF, 0xE3, 0xF0, 0xFF, 0xDF, 0x1F, 0x83, 0xFC, 0xF8, 0xFC, 0x0F, 0xC7,
  0xC3, 0xE0, 0x18, 0x40, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0xFE,
  0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8,
  0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x02, 0x01, 0xFC, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xC0, 0x7F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80,
  0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x03,
  0xF3, 0xF8, 0x00, 0x38, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x03, 0xFF, 0xEF, 0xF0, 0x3F, 0xFE, 0xFE, 0x03, 0xFF, 0xEF,
  0xE0, 0x7F, 0xFE, 0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFC, 0xFE, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0,
  0x07, 0xF8, 0x7F, 0xC1, 0xDF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xBF,
  0x03, 0xFF, 0xF3, 0xF0, 0x1F, 0xFE, 0x3F, 0x00, 0xFF, 0xC3, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x04, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x0F,
  0xE3, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0x80, 0x00, 0xFF, 0xCF,
  0xF0, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x7E, 0xF8, 0xFB, 0xF0,
  0x1F, 0xBE, 0x3E, 0xFC, 0x07, 0xCF, 0x9F, 0x3F, 0x03, 0xF3, 0xE7, 0xCF,
  0xC0, 0xFC, 0xFF, 0xE7, 0xE0, 0x3F, 0x1F, 0xF9, 0xF8, 0x0F, 0xC7, 0xFC,
  0x7E, 0x03, 0xF1, 0xFF, 0x1F, 0x80, 0xFC, 0x7F, 0x87, 0xE0, 0x7E, 0x1F,
  0xE3, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x07, 0xE0, 0xF8, 0x3F, 0x01, 0xF8,
  0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x03, 0xF0, 0x1F, 0x83, 0xC0, 0xFC, 0x0F,
  0xE0, 0x60, 0x7F, 0x03, 0xF0, 0x18, 0x1F, 0x80, 0xFC, 0x04, 0x07, 0xE0,
  0x3F, 0x01, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x03,
  0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7E, 0x03,
  0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x7E, 0x07,
  0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFC, 0x07,
  0xEF, 0x80, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0x0F,
  0xEF, 0xC1, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F, 0xC7, 0xC1, 0xF8, 0x0F,
  0xC7, 0xC1, 0xF8, 0x0F, 0xC7, 0xE1, 0xF8, 0x0F, 0xC7, 0xE1, 0xF8, 0x1F,
  0xC7, 0xE3, 0xF8, 0x1F, 0x87, 0xE3, 0xF0, 0x1F, 0x83, 0xE3, 0xF0, 0x1F,
  0x83, 0xF3, 0xF0, 0x1F, 0x83, 0xF3, 0xF0, 0x1F, 0x83, 0xF3, 0xF0, 0x3F,
  0x83, 0xF7, 0xF0, 0x3F, 0x01, 0xF7, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x3F,
  0x01, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x7F,
  0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E,
  0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E,
  0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0xFF,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x04, 0x00, 0x07, 0xF0, 0x38, 0x00,
  0x1F, 0xC1, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80,
  0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF8, 0x7F, 0x00, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x03,
  0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x70, 0x0F, 0xE0, 0x00, 0x40, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0x00, 0x00, 0x7F,
  0x03, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x7F, 0x7E, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x1F, 0x87, 0xF8, 0x3E, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xF0, 0x7F,
  0x87, 0xE0, 0xFC, 0x3F, 0xE1, 0xF8, 0x3F, 0x0F, 0xF8, 0x7E, 0x0F, 0xC3,
  0xDE, 0x1F, 0x03, 0xF1, 0xF7, 0x8F, 0xC0, 0xFC, 0x79, 0xE3, 0xF0, 0x3F,
  0x1E, 0x78, 0xFC, 0x0F, 0xCF, 0x9E, 0x3E, 0x03, 0xE3, 0xC7, 0x8F, 0x80,
  0xF8, 0xF1, 0xE7, 0xE0, 0x7E, 0x7C, 0x79, 0xF8, 0x1F, 0x9E, 0x1E, 0x7C,
  0x07, 0xE7, 0x87, 0x9F, 0x01, 0xFB, 0xE1, 0xEF, 0xC0, 0x7E, 0xF0, 0x7B,
  0xF0, 0x1F, 0xBC, 0x3E, 0xFC, 0x07, 0xFF, 0x0F, 0xBE, 0x01, 0xFF, 0x83,
  0xEF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x3F,
  0x80, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0x30,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x07, 0x87, 0xE3,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7C, 0x08, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0x03, 0xFF, 0xE7, 0xF0, 0x7F, 0xFE,
  0x7F, 0x0F, 0xFF, 0xF7, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x80,
  0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x87, 0xF0, 0x1B, 0xF8, 0x7F,
  0x87, 0xBF, 0xF7, 0xFF, 0xF3, 0xFE, 0x3F, 0xFE, 0x3F, 0xE3, 0xFF, 0xC3,
  0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xE1, 0xFF, 0x80, 0xFE, 0x7F, 0xFC, 0x0F, 0xEF, 0xFF,
  0xC0, 0xFC, 0xFF, 0xFE, 0x0F, 0xDE, 0x1F, 0xE1, 0xFD, 0x80, 0xFF, 0x1F,
  0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xFC,
  0x0F, 0xF8, 0xFE, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0xE0, 0xFE, 0x7F, 0xFC,
  0x0F, 0xE3, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xFC, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3C, 0x3F, 0x80,
  0x08, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x10, 0x7E, 0x00, 0x0F, 0x1F, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFE,
  0x01, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xFC, 0x3F,
  0x80, 0x7F, 0xFC, 0x7E, 0x01, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x07,
  0xFE, 0x03, 0xFC, 0x1D, 0xFC, 0x07, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xE7,
  0xF0, 0x07, 0xFF, 0x8F, 0xC0, 0x07, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF1, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01,
  0xFD, 0xFC, 0x01, 0xFF, 0x7F, 0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x20, 0xFE, 0x00, 0x0E, 0x1F, 0x80, 0x03,
  0xC7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x0F, 0xE0, 0x00, 0x03, 0x80,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC7,
  0xF0, 0x1F, 0xFF, 0x1F, 0xC0, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xE0,
  0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x06, 0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xFF, 0xDF, 0xC0, 0x7F, 0xFE, 0x7F, 0x00, 0xFF, 0xF1, 0xFC, 0x01, 0xFF,
  0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x10, 0x00, 0x7F, 0x00, 0x70, 0x03, 0xF8,
  0x03, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x1F, 0xF0, 0x1F, 0xC7, 0xFF, 0x03, 0xF9,
  0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0x0F, 0xFE, 0x1F, 0xE1, 0xFB, 0x01, 0xFC,
  0x7F, 0xC0, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC7, 0xF0,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x01, 0x80, 0x1F, 0x80, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x03,
  0xF3, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x08, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x02, 0x00, 0xFC, 0x00, 0xE0, 0x1F, 0x80, 0x3C, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFE,
  0x1F, 0xF8, 0x07, 0xF1, 0xFF, 0xE0, 0x3F, 0x9F, 0xFF, 0x81, 0xFD, 0xFF,
  0xFC, 0x0F, 0xDC, 0x1F, 0xE0, 0x7E, 0xC0, 0x7F, 0x07, 0xFC, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFB, 0xFC, 0x00,
  0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x0C, 0x7F,
  0x0F, 0xE0, 0xF3, 0xF8, 0x7F, 0x0F, 0xDF, 0xC1, 0xFC, 0xFC, 0xFC, 0x0F,
  0xEF, 0xEF, 0xE0, 0x7F, 0xFE, 0x7F, 0x01, 0xFF, 0xE3, 0xF8, 0x0F, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0x81, 0xFC, 0x07, 0x83, 0xF8,
  0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0x3F,
  0xC0, 0xFE, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x0F, 0xCF,
  0xE1, 0xFE, 0x0F, 0xDF, 0xE3, 0xFE, 0x0F, 0xDF, 0xF7, 0xFE, 0x0F, 0xBF,
  0xF7, 0xFF, 0x0F, 0xA3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0x1F, 0x83,
  0xF8, 0x3E, 0x1F, 0x83, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0x3E, 0x1F, 0x03,
  0xF0, 0x7E, 0x1F, 0x03, 0xF0, 0x7E, 0x3F, 0x03, 0xE0, 0x7E, 0x3F, 0x03,
  0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0x7C, 0x3F, 0x07, 0xE0, 0x7C, 0x3E, 0x07,
  0xE0, 0xFC, 0x3E, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xC0, 0xFC, 0x7E, 0x07,
  0xC0, 0xFC, 0x7E, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC0, 0xF8, 0x7C, 0x0F,
  0xC1, 0xF8, 0x7C, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0x81, 0xF8, 0xFC, 0x0F,
  0x81, 0xF8, 0xFC, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x81, 0xF0, 0xF8, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x3F, 0xE0, 0x3F, 0x8F, 0xFE,
  0x07, 0xF3, 0xFF, 0xE0, 0xFE, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3, 0xF6,
  0x03, 0xF8, 0xFF, 0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7E,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0x8F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF,
  0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xCF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x07,
  0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xE1, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0x00, 0xFE, 0xFF,
  0xFC, 0x03, 0xF3, 0xFF, 0xF8, 0x0F, 0xDE, 0x1F, 0xE0, 0x7F, 0x60, 0x3F,
  0xC1, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFE, 0xFF, 0xFF, 0x03,
  0xFB, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF, 0xC0, 0x3F, 0x8F, 0xFE, 0x00, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE, 0x1F, 0xC0,
  0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x0F,
  0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC1,
  0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0x83, 0xBF, 0x83, 0xFF,
  0xFD, 0xFC, 0x0F, 0xFF, 0xCF, 0xE0, 0x3F, 0xFC, 0x7E, 0x00, 0xFF, 0xC7,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xFE, 0x07, 0xEF, 0xFF, 0xC3, 0xFD,
  0xFF, 0xF0, 0xFF, 0xBF, 0xFE, 0x3F, 0xEF, 0xFF, 0xCF, 0xFC, 0x03, 0xFB,
  0xFF, 0x80, 0x7F, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F,
  0x83, 0xF8, 0x01, 0xE0, 0x7F, 0x00, 0x08, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x10, 0x00, 0x3F, 0x06, 0x00, 0x0F, 0xE1, 0xF0, 0x01,
  0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x38, 0x07, 0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC, 0x03, 0xF9, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0xFF, 0x03,
  0xFF, 0x0F, 0xF8, 0x77, 0xF0, 0x7F, 0xFE, 0x7E, 0x07, 0xFF, 0xE7, 0xE0,
  0x3F, 0xFC, 0xFE, 0x01, 0xFF, 0x8F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0xC7, 0xFF, 0x80, 0x7C, 0x7F, 0xF8, 0x1F, 0xE7, 0xFF, 0x80,
  0xFE, 0x7F, 0xF0, 0x0F, 0xE8, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xE0,
  0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0xFF,
  0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC3, 0xFE, 0x01, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x18, 0x7E, 0x07, 0xC3,
  0xE1, 0xF8, 0x3F, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x1F, 0x03, 0xE0, 0xFC,
  0x7C, 0x0F, 0x83, 0xF1, 0xF0, 0x3E, 0x0F, 0xCF, 0xC0, 0xF8, 0x3F, 0x3F,
  0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0x83, 0xF3, 0xE0, 0x7E, 0x0F, 0xCF, 0x81,
  0xF0, 0x3F, 0x3E, 0x07, 0xC0, 0xFD, 0xF8, 0x1F, 0x03, 0xF7, 0xE0, 0xFC,
  0x0F, 0xDF, 0x83, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xF9, 0xF0, 0x3E, 0x07,
  0xE7, 0xC0, 0xF8, 0x1F, 0xBF, 0x03, 0xE0, 0x7C, 0xFC, 0x1F, 0x81, 0xF3,
  0xF0, 0x7E, 0x0F, 0x8F, 0xC3, 0xF8, 0x3E, 0x3F, 0x1F, 0xE1, 0xF0, 0xFF,
  0xEF, 0x8F, 0xC3, 0xFF, 0x9F, 0xFE, 0x07, 0xFC, 0x7F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0xBE, 0x71, 0xF8, 0xFF, 0x1F, 0xB0, 0x7C, 0x3F,
  0x0F, 0xF8, 0x3F, 0x0E, 0x07, 0xF8, 0x1F, 0x06, 0x03, 0xFC, 0x0F, 0x80,
  0x01, 0xFE, 0x04, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x01, 0x07, 0xE0, 0xDF, 0x03,
  0xC3, 0xF0, 0x6F, 0x83, 0xF1, 0xF8, 0x77, 0xC7, 0xFC, 0xFC, 0x73, 0xF7,
  0xF8, 0x7F, 0xF9, 0xFF, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x7F,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x1D, 0xFC,
  0x07, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0x9F, 0x80, 0x3F, 0xFC, 0x7E, 0x00,
  0x7F, 0xE3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x04, 0x00, 0x3F, 0xC0, 0x38, 0x00,
  0xFE, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0xFF, 0x0F,
  0xC1, 0xFF, 0xFE, 0x3F, 0x0F, 0xFF, 0xFD, 0xF8, 0x3F, 0x07, 0xFF, 0xE0,
  0xF8, 0x03, 0xFF, 0x83, 0xE0, 0x07, 0xFC, 0x1F, 0x80, 0x3F, 0xC0, 0x7E,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x40, 0x03, 0xFE, 0x07, 0x00, 0x1F, 0xE0, 0x3E,
  0x00, 0xFF, 0x00, 0xF8, 0x07, 0xF8, 0x03, 0xE0, 0x3F, 0xC0, 0x0F, 0xC1,
  0xFE, 0x00, 0x1F, 0x0F, 0xFF, 0xC0, 0x7C, 0x7F, 0xFF, 0xF1, 0xF1, 0xFB,
  0xFF, 0xFF, 0xC7, 0xE1, 0xFF, 0xFE, 0x1F, 0x81, 0xFF, 0xF8, 0x7E, 0x01,
  0xFF, 0xC2, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x0F, 0xF8,
  0x01, 0xF0, 0x7F, 0xF0, 0x07, 0xC3, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0x80,
  0xF8, 0x7E, 0x7F, 0x03, 0xE3, 0xF0, 0xFE, 0x1F, 0x8F, 0x81, 0xF8, 0xFC,
  0x7E, 0x03, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0x87, 0xC0, 0x1F, 0xFC, 0x1F,
  0x00, 0x3F, 0xE0, 0x98, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 15, 39, 32, 9, -38 },
  { 75, 20, 17, 32, 9, -40 },
  { 118, 34, 38, 32, 0, -38 },
  { 280, 31, 51, 32, 1, -44 },
  { 478, 38, 39, 32, -2, -38 },
  { 664, 32, 39, 32, 0, -38 },
  { 820, 9, 17, 32, 15, -40 },
  { 840, 22, 48, 32, 10, -41 },
  { 972, 22, 48, 32, 2, -41 },
  { 1104, 29, 27, 32, 2, -30 },
  { 1202, 27, 25, 32, 3, -29 },
  { 1287, 15, 17, 32, 6, -9 },
  { 1319, 17, 6, 32, 8, -19 },
  { 1332, 11, 10, 32, 9, -9 },
  { 1346, 32, 48, 32, 0, -41 },
  { 1538, 30, 39, 32, 2, -38 },
  { 1685, 27, 38, 32, 2, -38 },
  { 1814, 30, 38, 32, 1, -38 },
  { 1957, 30, 39, 32, 1, -38 },
  { 2104, 31, 38, 32, 0, -38 },
  { 2252, 31, 39, 32, 1, -38 },
  { 2404, 28, 39, 32, 2, -38 },
  { 2541, 29, 38, 32, 4, -38 },
  { 2679, 29, 39, 32, 2, -38 },
  { 2821, 27, 38, 32, 4, -38 },
  { 2950, 14, 29, 32, 9, -28 },
  { 3001, 17, 36, 32, 6, -28 },
  { 3078, 27, 32, 32, 4, -33 },
  { 3186, 29, 17, 32, 2, -25 },
  { 3248, 26, 32, 32, 3, -33 },
  { 3352, 24, 39, 32, 6, -38 },
  { 3469, 29, 44, 32, 2, -38 },
  { 3629, 31, 38, 32, -2, -38 },
  { 3777, 29, 38, 32, 2, -38 },
  { 3915, 29, 39, 32, 3, -38 },
  { 4057, 29, 38, 32, 2, -38 },
  { 4195, 30, 38, 32, 2, -38 },
  { 4338, 31, 38, 32, 2, -38 },
  { 4486, 28, 39, 32, 3, -38 },
  { 4623, 32, 38, 32, 1, -38 },
  { 4775, 30, 38, 32, 2, -38 },
  { 4918, 29, 39, 32, 2, -38 },
  { 5060, 34, 38, 32, 2, -38 },
  { 5222, 25, 38, 32, 3, -38 },
  { 5341, 34, 38, 32, 0, -38 },
  { 5503, 32, 38, 32, 1, -38 },
  { 5655, 30, 39, 32, 2, -38 },
  { 5802, 30, 38, 32, 2, -38 },
  { 5945, 30, 49, 32, 2, -38 },
  { 6129, 30, 38, 32, 2, -38 },
  { 6272, 31, 39, 32, 1, -38 },
  { 6424, 31, 38, 32, 4, -38 },
  { 6572, 30, 39, 32, 3, -38 },
  { 6719, 30, 38, 32, 5, -38 },
  { 6862, 34, 38, 32, 1, -38 },
  { 7024, 37, 38, 32, -2, -38 },
  { 7200, 32, 38, 32, 4, -38 },
  { 7352, 33, 38, 32, 0, -38 },
  { 7509, 25, 48, 32, 7, -41 },
  { 7659, 15, 48, 32, 9, -41 },
  { 7749, 25, 48, 32, 1, -41 },
  { 7899, 29, 23, 32, 2, -38 },
  { 7983, 26, 5, 32, 0, 5 },
  { 8000, 10, 12, 32, 10, -43 },
  { 8015, 28, 30, 32, 2, -29 },
  { 8120, 28, 41, 32, 2, -40 },
  { 8264, 26, 30, 32, 3, -29 },
  { 8362, 31, 41, 32, 2, -40 },
  { 8521, 26, 30, 32, 3, -29 },
  { 8619, 36, 51, 32, -1, -40 },
  { 8849, 30, 40, 32, 1, -29 },
  { 8999, 27, 40, 32, 2, -40 },
  { 9134, 26, 42, 32, 4, -41 },
  { 9271, 27, 52, 32, 1, -41 },
  { 9447, 29, 41, 32, 2, -40 },
  { 9596, 23, 41, 32, 5, -40 },
  { 9714, 32, 29, 32, 0, -29 },
  { 9830, 27, 29, 32, 2, -29 },
  { 9928, 27, 30, 32, 3, -29 },
  { 10030, 30, 40, 32, 0, -29 },
  { 10180, 29, 40, 32, 2, -29 },
  { 10325, 27, 28, 32, 5, -28 },
  { 10420, 27, 30, 32, 2, -29 },
  { 10522, 26, 39, 32, 4, -38 },
  { 10649, 28, 29, 32, 3, -28 },
  { 10751, 28, 29, 32, 2, -28 },
  { 10853, 30, 29, 32, 1, -28 },
  { 10962, 33, 30, 32, 0, -29 },
  { 11086, 30, 39, 32, 1, -28 },
  { 11233, 30, 30, 32, 1, -29 },
  { 11346, 26, 48, 32, 6, -41 },
  { 11502, 14, 48, 32, 10, -41 },
  { 11586, 26, 48, 32, 2, -41 },
  { 11742, 30, 13, 32, 1, -23 },
};

const GFXfont IBMPlexMono_SemiBoldItalic54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC54PT7B_H_
