#ifndef _IBMPLEXMONO_MEDIUM7PT7B_H_
#define _IBMPLEXMONO_MEDIUM7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x76, 0xFF, 0xA0, 0x47, 0xC6, 0x5F, 0x40, 0xDE, 0x4B,
  0xB0, 0x68, 0x5A, 0xF0, 0xC0, 0x72, 0x48, 0xC0, 0x95, 0x60, 0x4D, 0x6A,
  0x44, 0xF4, 0x60, 0xC0, 0xC0, 0x69, 0x49, 0x00, 0x69, 0xB9, 0x60, 0x6A,
  0x22, 0x70, 0x69, 0x24, 0xF0, 0x69, 0x61, 0xE0, 0x26, 0xAF, 0x20, 0x78,
  0x71, 0xE0, 0x24, 0xF9, 0x60, 0xFA, 0x22, 0x40, 0x69, 0x69, 0x70, 0x69,
  0x52, 0x60, 0x63, 0x61, 0x80, 0x72, 0x30, 0xFF, 0x8D, 0x40, 0x69, 0x20,
  0x60, 0x6B, 0xDD, 0xA6, 0x66, 0x67, 0x90, 0xD7, 0x5E, 0x69, 0x88, 0x70,
  0xD6, 0xDC, 0xF3, 0xCE, 0xF3, 0xC8, 0x69, 0xB9, 0x70, 0x99, 0xF9, 0x90,
  0xF2, 0x4E, 0x64, 0x9E, 0xBB, 0x6A, 0x92, 0x4E, 0x9F, 0xBD, 0x90, 0xDD,
  0xDB, 0xB0, 0x69, 0x99, 0x60, 0xD7, 0xC8, 0x69, 0x99, 0x67, 0xD7, 0xEA,
  0x78, 0x61, 0xF0, 0xF4, 0x44, 0x40, 0x99, 0x99, 0x60, 0x99, 0x66, 0x60,
  0x9B, 0xFF, 0xD0, 0x96, 0x26, 0x90, 0x96, 0x64, 0x40, 0xF2, 0x24, 0xF0,
  0xF2, 0x49, 0xC0, 0x92, 0x24, 0xC0, 0xD5, 0x70, 0x66, 0x90, 0xF0, 0xC0,
  0x62, 0xE7, 0x9A, 0xDE, 0xD6, 0x70, 0x15, 0xB9, 0x70, 0x69, 0xE7, 0x7F,
  0x44, 0x70, 0x79, 0x66, 0xF0, 0x9A, 0xDA, 0x59, 0x2E, 0x75, 0x70, 0x97,
  0x6A, 0x92, 0x4E, 0xDF, 0xDD, 0xD6, 0xD0, 0x69, 0x96, 0xD6, 0xF8, 0x5B,
  0x97, 0x10, 0xBA, 0x70, 0x69, 0x7F, 0x4F, 0x44, 0x70, 0xB6, 0xF0, 0x9A,
  0x66, 0xBB, 0xF5, 0x96, 0x69, 0x9A, 0x62, 0x40, 0xEA, 0x70, 0xE9, 0x68,
  0xC0, 0xFC, 0xD2, 0x75, 0x80, 0x5A,
};

const GFXglyph IBMPlexMono_Medium7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 3, 6, 4, 1, -5 },
  { 20, 2, 6, 4, 1, -5 },
  { 22, 4, 4, 4, 0, -4 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 2, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -3 },
  { 28, 2, 1, 4, 1, -1 },
  { 29, 3, 6, 4, 1, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 5, 4, 1, -4 },
  { 65, 3, 4, 4, 1, -4 },
  { 67, 4, 2, 4, 0, -3 },
  { 68, 3, 4, 4, 1, -4 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 4, 6, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 3, 5, 4, 1, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 4, 1, -5 },
  { 98, 3, 5, 4, 0, -5 },
  { 100, 3, 5, 4, 1, -5 },
  { 102, 3, 5, 4, 1, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 3, 5, 4, 1, -5 },
  { 115, 4, 6, 4, 0, -5 },
  { 118, 3, 5, 4, 1, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 3, 6, 4, 1, -5 },
  { 147, 3, 6, 4, 1, -5 },
  { 150, 2, 6, 4, 1, -5 },
  { 152, 4, 3, 4, 0, -5 },
  { 154, 4, 1, 4, 0, 0 },
  { 155, 1, 2, 4, 1, -6 },
  { 156, 4, 4, 4, 0, -4 },
  { 158, 3, 5, 4, 1, -5 },
  { 160, 3, 4, 4, 1, -4 },
  { 162, 4, 5, 4, 0, -5 },
  { 165, 4, 4, 4, 0, -4 },
  { 167, 4, 5, 4, 0, -5 },
  { 170, 4, 5, 4, 0, -4 },
  { 173, 3, 5, 4, 1, -5 },
  { 175, 3, 5, 4, 1, -5 },
  { 177, 2, 6, 4, 1, -5 },
  { 179, 3, 5, 4, 1, -5 },
  { 181, 3, 5, 4, 1, -5 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 4, 4, 1, -4 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 3, 5, 4, 1, -4 },
  { 191, 4, 5, 4, 0, -4 },
  { 194, 3, 4, 4, 1, -4 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 4, 5, 4, 0, -5 },
  { 201, 3, 4, 4, 1, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 5, 4, 0, -4 },
  { 212, 3, 4, 4, 1, -4 },
  { 214, 3, 6, 4, 1, -5 },
  { 217, 1, 6, 4, 2, -5 },
  { 218, 3, 6, 4, 1, -5 },
  { 221, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_Medium7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_MEDIUM7PT7B_H_
