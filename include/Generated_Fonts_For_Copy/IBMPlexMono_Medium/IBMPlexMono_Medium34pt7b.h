#ifndef _IBMPLEXMONO_MEDIUM34PT7B_H_
#define _IBMPLEXMONO_MEDIUM34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium34pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x8C, 0x30, 0xC3,
  0x00, 0x00, 0x07, 0x9F, 0xFF, 0xF7, 0xDE, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x01, 0xE3, 0x80, 0x1C,
  0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03,
  0xC7, 0x03, 0xF8, 0x7F, 0x3F, 0x8F, 0xF3, 0xF8, 0xFF, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0xFF, 0x1F, 0xEF, 0xF1, 0xFE,
  0xFF, 0x1F, 0xE0, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xF8,
  0xF3, 0xBF, 0x78, 0xE3, 0x1E, 0x38, 0x87, 0x8E, 0x01, 0xE3, 0x80, 0x7C,
  0xE0, 0x0F, 0xB8, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x0E, 0x7C, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x38, 0xF2, 0x0E, 0x3D,
  0xE3, 0x8F, 0xFC, 0xEF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x73, 0xF8, 0x0E, 0x7F,
  0xC0, 0xE7, 0x1E, 0x1C, 0x60, 0xE1, 0xC6, 0x0E, 0x38, 0x60, 0xE3, 0x86,
  0x0E, 0x70, 0x71, 0xEF, 0x07, 0xFC, 0xE0, 0x3F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFC, 0x07, 0xBF, 0xE0, 0x73, 0x8F, 0x0E, 0x30,
  0x70, 0xE3, 0x07, 0x1C, 0x30, 0x71, 0xC3, 0x07, 0x38, 0x38, 0xF3, 0x83,
  0xFE, 0x70, 0x1F, 0xCF, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x1E, 0x1E, 0x03, 0x81, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x1F, 0x0F, 0x83, 0xE3, 0xF8,
  0x7C, 0xF7, 0x8E, 0x3C, 0x79, 0xC7, 0x87, 0xB0, 0xE0, 0x7E, 0x1C, 0x0F,
  0xC3, 0x80, 0xF8, 0x78, 0x0F, 0x0F, 0x87, 0xF0, 0xFF, 0xCF, 0x0F, 0xF0,
  0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC1, 0xC0, 0xF0,
  0x78, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x38, 0x67, 0xEE, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x03,
  0xC7, 0x81, 0xE1, 0xE0, 0x70, 0x3C, 0x0C, 0x04, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C,
  0x78, 0x78, 0x70, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0x39, 0xE0, 0x0F, 0x70, 0x03, 0xDC, 0x38, 0xF7,
  0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xDC, 0x38, 0xF7, 0x00, 0x3D, 0xC0,
  0x0F, 0x78, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x78, 0xF0, 0x1E, 0x3E, 0x1F,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xDC, 0x07, 0xCE, 0x03, 0xC7, 0x03, 0xC3, 0x81, 0xE1, 0xC0,
  0x60, 0xE0, 0x20, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xE0,
  0x0F, 0xFC, 0x1F, 0xFF, 0x0F, 0x87, 0xCF, 0x01, 0xE7, 0x80, 0x78, 0x80,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE3, 0x80, 0xF0,
  0x80, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xCC, 0x01, 0xEF, 0x01, 0xFF, 0xC1, 0xF1, 0xFF, 0xF8,
  0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xDE, 0x00, 0xF7, 0x80, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x1E,
  0x03, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x78, 0x38, 0x1E, 0x1E, 0x07, 0x87,
  0x01, 0xE3, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0xF8, 0x1D, 0xFF, 0x0E, 0xFF, 0xC7,
  0xC3, 0xF3, 0x80, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC8, 0x03, 0xCE, 0x01, 0xEF, 0xC3, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F,
  0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0xF8, 0x3D, 0xFF,
  0x1F, 0xFF, 0xCF, 0xC1, 0xF7, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x8F, 0x83,
  0xEF, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3C, 0xE0, 0x1E, 0x78, 0x0F, 0x1E,
  0x0F, 0x07, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xE0, 0xF3, 0xC0, 0x3D,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xEF, 0xC1,
  0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x0F, 0x83, 0xCF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0E,
  0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xEF, 0x83, 0xE7, 0xFF, 0x71, 0xFF,
  0x78, 0x3F, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7,
  0x80, 0x3C, 0x7E, 0x7E, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x70, 0x70, 0xF0,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0x80, 0x04, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x0F,
  0x10, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x78, 0x0F, 0x70, 0x07,
  0x70, 0x07, 0xE0, 0xF7, 0xE1, 0xFF, 0xE3, 0xFF, 0xE3, 0x87, 0xE3, 0x87,
  0xE7, 0x87, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0xFF, 0xE3, 0xFF, 0xE1, 0xF7, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x70, 0x01, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0xC0, 0x38, 0x78, 0x0F, 0x0F,
  0x01, 0xE0, 0xE0, 0x38, 0x1E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x3D, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0,
  0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0,
  0x3C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x3D, 0xC0, 0x11, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x02, 0x1E, 0x01, 0xEF, 0x01, 0xE3,
  0xE1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDE, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1F,
  0x70, 0x0F, 0xF0, 0x0C, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x37, 0x3F, 0xF7, 0x1F, 0xE7,
  0x0F, 0x87, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0x81,
  0xE7, 0x87, 0xCF, 0xFF, 0x0F, 0xFC, 0x07, 0xE0, 0xE0, 0x0F, 0xF0, 0x0F,
  0xB8, 0x0F, 0x9C, 0x07, 0x8E, 0x07, 0x87, 0x07, 0x83, 0x87, 0xC1, 0xC3,
  0xC0, 0xE3, 0xC0, 0x73, 0xC0, 0x3B, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xEF, 0x03, 0xE7, 0x81, 0xE1, 0xE0, 0xE0, 0xF8, 0x70, 0x3C, 0x38, 0x0F,
  0x1C, 0x07, 0x8E, 0x01, 0xE7, 0x00, 0xFB, 0x80, 0x3D, 0xC0, 0x1F, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0x71, 0xFF, 0xB8, 0xFF, 0xDC, 0xEF, 0xE7, 0x77,
  0xF3, 0xB3, 0xF9, 0xF9, 0xFC, 0x7C, 0xFE, 0x3C, 0x7F, 0x0E, 0x3F, 0x87,
  0x1F, 0xC3, 0x0F, 0xE0, 0x87, 0xF0, 0x83, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xF7, 0x07,
  0xF7, 0x87, 0xF3, 0x87, 0xF3, 0x87, 0xF3, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0xF1, 0xE7, 0xF0, 0xE7, 0xF0, 0xF7, 0xF0, 0x77, 0xF0, 0x77, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x01,
  0xE7, 0x80, 0x78, 0xF0, 0x1E, 0x3E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x0E, 0x78, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x1E, 0x3E,
  0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF8, 0xF8, 0x3E, 0x7C, 0x03, 0x1E, 0x00, 0x87,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF2, 0x00, 0x39, 0xC0, 0x1E, 0xFC, 0x0F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70,
  0x0F, 0x70, 0x0F, 0x78, 0x0E, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF0, 0xF0, 0x03, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x78, 0xF0, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xE0, 0x0F, 0x3C, 0x00, 0xE7, 0x80, 0x1E, 0xE0, 0x03, 0xDC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xE0, 0x01,
  0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xE0, 0x03,
  0xBC, 0x78, 0x77, 0x8F, 0x0E, 0xF1, 0xF1, 0xCE, 0x3E, 0x39, 0xCF, 0xC7,
  0x39, 0xD8, 0xE7, 0x3B, 0x1C, 0xE7, 0x77, 0x9C, 0xCE, 0xF3, 0x99, 0xDC,
  0x77, 0x3B, 0x8E, 0xE3, 0x71, 0xDC, 0x7E, 0x3B, 0x0F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0xF8, 0x03, 0xCF, 0x00, 0x78,
  0xF0, 0x1E, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3C, 0x03, 0xC7, 0x80,
  0x7D, 0xE0, 0x07, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x03,
  0xE3, 0xC0, 0x78, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E,
  0x00, 0xF7, 0x80, 0x1F, 0xF8, 0x00, 0xF7, 0x80, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0,
  0x07, 0x8E, 0x00, 0x79, 0xE0, 0x03, 0xDC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0x3C, 0x03,
  0xCF, 0x00, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0x80,
  0x79, 0xE0, 0x0E, 0x70, 0x03, 0xFC, 0x00, 0x72, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x23, 0xC7, 0x1E, 0x38, 0x71, 0x80, 0x0F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFF, 0x0F, 0x07, 0x83, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF8, 0xFF, 0xFF, 0x7F, 0xCF, 0x8F, 0xC3,
  0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE3, 0xF0, 0xE7, 0xF8, 0xEF, 0xFC, 0xF8, 0x3E, 0xF0,
  0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0xEF, 0xFC, 0xE7,
  0xF8, 0xE3, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xEF, 0x01,
  0xFE, 0x02, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x9E, 0x03, 0x9F, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x0F, 0x8F, 0x3F, 0xCF, 0x7F, 0xEF, 0x7C, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xEF, 0x3F,
  0xCF, 0x0F, 0x8F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x1E, 0x78,
  0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x04, 0x78, 0x06, 0x7C, 0x1F, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF8,
  0xF0, 0x3C, 0x78, 0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x87, 0xC3, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F,
  0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFB, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x79, 0xF0,
  0xF7, 0xF9, 0xFF, 0xFB, 0xE1, 0xF7, 0x81, 0xEF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xEF, 0xFE,
  0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0xF0, 0x3C, 0x78, 0x3C, 0x3C,
  0x3C, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x7C, 0xF0, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0x81,
  0xE3, 0xC0, 0x79, 0xE0, 0x3E, 0xF0, 0x0F, 0x80, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0x8F, 0x3D, 0xF7, 0xEF,
  0xFD, 0xFB, 0xC7, 0xCF, 0xF1, 0xE1, 0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3,
  0x87, 0xF0, 0xE1, 0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3, 0x87, 0xF0, 0xE1,
  0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3, 0x87, 0xF0, 0xE1, 0xFC, 0x38, 0x70,
  0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xDE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x07, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x87, 0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0,
  0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x00, 0xEF,
  0x00, 0xF3, 0xC0, 0x79, 0xF0, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0xE3, 0xF0, 0xE7, 0xF8, 0xEF, 0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xE0,
  0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0xEF, 0xFC, 0xE7, 0xF8, 0xE3,
  0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x0F, 0x8F, 0x3F, 0xCF, 0x7F, 0xEF, 0x7C, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xEF, 0x3F,
  0xCF, 0x0F, 0x8F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x0F,
  0x40, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C,
  0x1F, 0x78, 0x04, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x60, 0x0F, 0xF8, 0x1F, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x1F,
  0xBF, 0xEF, 0x3F, 0xDE, 0x3E, 0x3C, 0xF0, 0x07, 0xF8, 0x03, 0x9C, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x1C,
  0x3C, 0x0E, 0x1C, 0x07, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0x7B, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xE1, 0xE0, 0xFC,
  0x3C, 0x1F, 0x87, 0xC7, 0x70, 0xF8, 0xEE, 0x1F, 0x1D, 0xC7, 0x63, 0x9C,
  0xEC, 0x73, 0x99, 0x8E, 0x73, 0x39, 0xCE, 0x67, 0x31, 0xCC, 0xEE, 0x3B,
  0x8D, 0xC7, 0x71, 0xB8, 0x6C, 0x37, 0x0D, 0x87, 0xE1, 0xF0, 0xFC, 0x3E,
  0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x0F, 0xBC, 0x07, 0x8F, 0x07, 0x87, 0x87,
  0x81, 0xE3, 0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x01,
  0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0xF0,
  0xF0, 0x3C, 0x78, 0x0F, 0x78, 0x07, 0xC0, 0xF0, 0x03, 0xDE, 0x00, 0xE7,
  0x80, 0x78, 0xE0, 0x1E, 0x3C, 0x07, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78,
  0x38, 0x0E, 0x1E, 0x03, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x07, 0xB8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFE,
  0x0F, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xC0,
  0x3F, 0x07, 0xFC, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xFF, 0xC3,
  0xFE, 0x0F, 0xF8, 0x00, 0x1E, 0x03, 0x9F, 0x81, 0xDF, 0xE0, 0xEE, 0x78,
  0xEE, 0x1E, 0x77, 0x0F, 0xF3, 0x83, 0xF9, 0x80, 0x78,
};

const GFXglyph IBMPlexMono_Medium34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 10, 10, 20, 5, -25 },
  { 32, 20, 24, 20, 0, -24 },
  { 92, 18, 31, 20, 1, -28 },
  { 162, 20, 24, 20, 0, -24 },
  { 222, 19, 24, 20, 1, -24 },
  { 279, 4, 10, 20, 8, -25 },
  { 284, 10, 31, 20, 7, -26 },
  { 323, 11, 31, 20, 3, -26 },
  { 366, 18, 17, 20, 1, -19 },
  { 405, 16, 17, 20, 2, -19 },
  { 439, 8, 10, 20, 6, -5 },
  { 449, 10, 3, 20, 5, -12 },
  { 453, 6, 6, 20, 7, -5 },
  { 458, 15, 31, 20, 3, -26 },
  { 517, 18, 24, 20, 1, -24 },
  { 571, 17, 24, 20, 2, -24 },
  { 622, 17, 24, 20, 2, -24 },
  { 673, 17, 24, 20, 1, -24 },
  { 724, 18, 24, 20, 1, -24 },
  { 778, 17, 24, 20, 2, -24 },
  { 829, 17, 24, 20, 2, -24 },
  { 880, 16, 24, 20, 2, -24 },
  { 928, 17, 24, 20, 2, -24 },
  { 979, 17, 24, 20, 2, -24 },
  { 1030, 6, 19, 20, 7, -18 },
  { 1045, 8, 23, 20, 6, -18 },
  { 1068, 15, 20, 20, 3, -20 },
  { 1106, 16, 10, 20, 2, -15 },
  { 1126, 15, 20, 20, 3, -20 },
  { 1164, 16, 24, 20, 2, -24 },
  { 1212, 16, 28, 20, 2, -24 },
  { 1268, 19, 24, 20, 1, -24 },
  { 1325, 16, 24, 20, 3, -24 },
  { 1373, 17, 24, 20, 2, -24 },
  { 1424, 16, 24, 20, 3, -24 },
  { 1472, 15, 24, 20, 3, -24 },
  { 1517, 15, 24, 20, 3, -24 },
  { 1562, 16, 24, 20, 2, -24 },
  { 1610, 16, 24, 20, 2, -24 },
  { 1658, 15, 24, 20, 3, -24 },
  { 1703, 15, 24, 20, 2, -24 },
  { 1748, 17, 24, 20, 3, -24 },
  { 1799, 14, 24, 20, 4, -24 },
  { 1841, 17, 24, 20, 2, -24 },
  { 1892, 16, 24, 20, 2, -24 },
  { 1940, 18, 24, 20, 1, -24 },
  { 1994, 16, 24, 20, 3, -24 },
  { 2042, 18, 30, 20, 1, -24 },
  { 2110, 16, 24, 20, 3, -24 },
  { 2158, 18, 24, 20, 1, -24 },
  { 2212, 19, 24, 20, 1, -24 },
  { 2269, 16, 24, 20, 2, -24 },
  { 2317, 19, 24, 20, 1, -24 },
  { 2374, 19, 24, 20, 1, -24 },
  { 2431, 19, 24, 20, 1, -24 },
  { 2488, 20, 24, 20, 0, -24 },
  { 2548, 17, 24, 20, 2, -24 },
  { 2599, 10, 31, 20, 7, -26 },
  { 2638, 15, 31, 20, 3, -26 },
  { 2697, 10, 31, 20, 3, -26 },
  { 2736, 18, 15, 20, 1, -24 },
  { 2770, 16, 3, 20, 2, 3 },
  { 2776, 6, 7, 20, 6, -27 },
  { 2782, 17, 18, 20, 2, -18 },
  { 2821, 16, 25, 20, 3, -25 },
  { 2871, 15, 18, 20, 3, -18 },
  { 2905, 16, 25, 20, 2, -25 },
  { 2955, 16, 18, 20, 2, -18 },
  { 2991, 17, 25, 20, 2, -25 },
  { 3045, 17, 28, 20, 2, -21 },
  { 3105, 15, 25, 20, 3, -25 },
  { 3152, 16, 26, 20, 3, -26 },
  { 3204, 12, 33, 20, 3, -26 },
  { 3254, 17, 25, 20, 3, -25 },
  { 3308, 15, 25, 20, 3, -25 },
  { 3355, 18, 18, 20, 1, -18 },
  { 3396, 15, 18, 20, 3, -18 },
  { 3430, 17, 18, 20, 2, -18 },
  { 3469, 16, 25, 20, 3, -18 },
  { 3519, 16, 25, 20, 2, -18 },
  { 3569, 16, 18, 20, 3, -18 },
  { 3605, 16, 18, 20, 2, -18 },
  { 3641, 17, 24, 20, 1, -24 },
  { 3692, 15, 18, 20, 3, -18 },
  { 3726, 17, 18, 20, 2, -18 },
  { 3765, 19, 18, 20, 1, -18 },
  { 3808, 17, 18, 20, 2, -18 },
  { 3847, 18, 25, 20, 1, -18 },
  { 3904, 15, 18, 20, 3, -18 },
  { 3938, 14, 31, 20, 3, -26 },
  { 3993, 3, 31, 20, 9, -26 },
  { 4005, 14, 31, 20, 3, -26 },
  { 4060, 17, 8, 20, 2, -14 },
};

const GFXfont IBMPlexMono_Medium34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_MEDIUM34PT7B_H_
