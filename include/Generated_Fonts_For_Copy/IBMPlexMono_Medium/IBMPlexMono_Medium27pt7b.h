#ifndef _IBMPLEXMONO_MEDIUM27PT7B_H_
#define _IBMPLEXMONO_MEDIUM27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x76, 0x66, 0x62, 0x00, 0x0F, 0xFF, 0xF0, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x03, 0x1C, 0x03, 0x18, 0x03,
  0x18, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x7E, 0x3F, 0x7E, 0x3F, 0x0E,
  0x30, 0x0E, 0x70, 0x0E, 0x70, 0xFC, 0x7E, 0xFC, 0x7E, 0x0C, 0x60, 0x1C,
  0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x03, 0xF8, 0x3F, 0xF9, 0xEC, 0xF7, 0x31, 0x1C, 0xC0, 0x73,
  0x01, 0xCC, 0x07, 0xB0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x33, 0xC0,
  0xC7, 0x03, 0x1C, 0x0C, 0x76, 0x31, 0xFE, 0xCE, 0x7F, 0xF0, 0x7F, 0x80,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x3E, 0x07, 0x7F, 0x06, 0x63, 0x0E, 0x63,
  0x0C, 0xE3, 0x9C, 0xE3, 0x98, 0x63, 0x30, 0x63, 0x30, 0x7F, 0x40, 0x1C,
  0x3C, 0x00, 0x7E, 0x0E, 0xC6, 0x0C, 0xC7, 0x1C, 0xC3, 0x18, 0xC3, 0x38,
  0xC7, 0x30, 0xC6, 0x70, 0x7E, 0xE0, 0x3C, 0x0F, 0x80, 0x7F, 0x80, 0xE3,
  0x83, 0x82, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x7C, 0x79, 0xDC, 0xF7, 0x39, 0x8E, 0x3B, 0x18, 0x3E, 0x30, 0x38, 0x70,
  0x78, 0xF1, 0xB8, 0xFE, 0x78, 0xF8, 0x78, 0xFF, 0xFF, 0x07, 0x87, 0x07,
  0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x70, 0x70, 0xF0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x63, 0x1F, 0xFF, 0xF7, 0xFF, 0x83, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xCE, 0x0E, 0x1C, 0x38, 0x30, 0x41, 0x00, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xE0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x7D, 0xE7, 0x9C, 0x71, 0x8E, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x70,
  0x39, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE3, 0x9F, 0x9E, 0x7E, 0x39, 0xF8,
  0x07, 0xE0, 0x1D, 0x80, 0x77, 0x03, 0x9C, 0x0E, 0x38, 0x70, 0x7F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x01, 0xDC, 0x0E, 0x70, 0x71, 0xC3, 0xC7,
  0x06, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC1, 0xFF, 0xF7, 0xFF, 0xC0,
  0x0F, 0xC0, 0xFF, 0x87, 0x87, 0x1C, 0x1E, 0xA0, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xC1,
  0xFF, 0x9E, 0x1C, 0x40, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x0F,
  0xE0, 0x7F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1D, 0x00, 0xEC, 0x07,
  0xF0, 0x7B, 0xFF, 0x87, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xDC,
  0x07, 0x70, 0x39, 0xC0, 0xC7, 0x07, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x7F, 0xF3, 0xFF, 0x98, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0xF8, 0xEF, 0xE7, 0x87, 0x88, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x1D, 0x01, 0xFC, 0x0E, 0xF0, 0xF3, 0xFF, 0x07, 0xE0, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0xF8,
  0x77, 0xF1, 0xE1, 0xEF, 0x03, 0xBC, 0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x01,
  0xDC, 0x0E, 0x38, 0x78, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0xEC, 0x07, 0x60, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0xE7, 0x03, 0x8E, 0x1C, 0x1F, 0xE0, 0x7F, 0x87, 0x87, 0x9C, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x0F, 0x78, 0x78, 0xFF, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFF, 0x87, 0x87, 0x1C, 0x0E, 0x70, 0x3B, 0x80, 0x7E,
  0x01, 0xFC, 0x0F, 0x70, 0x3D, 0xE1, 0x73, 0xFB, 0x83, 0xCE, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xDE, 0x79, 0xC7, 0x18, 0xE3, 0x80, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x70, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0x87, 0xFE,
  0xF0, 0xEE, 0x07, 0x20, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0,
  0x0E, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x0C, 0x0E, 0x70, 0x19, 0x80,
  0x66, 0x1D, 0x98, 0xFF, 0xE7, 0x1F, 0x98, 0x7E, 0x61, 0xF9, 0x87, 0xE6,
  0x1F, 0x98, 0x76, 0x71, 0xD8, 0xFF, 0x63, 0xDD, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xEC, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x18, 0x70, 0x70, 0xE0,
  0xE1, 0xC1, 0xFF, 0xC7, 0xFF, 0x8E, 0x07, 0x1C, 0x0E, 0x30, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0x78, 0xFF, 0x87, 0xFF, 0x38, 0x3D, 0xC0, 0xEE,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1C, 0xFF, 0xC7, 0xFF, 0x38, 0x1D, 0xC0,
  0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0x77, 0xFF, 0x3F, 0xF0,
  0x0F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xFE, 0x03, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0xCE, 0x0F, 0x78, 0xF1, 0xFF, 0x03, 0xF0, 0xFF, 0x87, 0xFE, 0x38, 0x39,
  0xC0, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0xFE,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0xC0, 0xFF, 0x8E, 0x1E, 0xE0, 0x77, 0x03, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0x01, 0xB8, 0x0D, 0xC0,
  0xEE, 0x07, 0x38, 0x59, 0xFE, 0xC3, 0xC6, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xD8, 0x3F, 0x07, 0xF1, 0xEF, 0xF8, 0xFC, 0x00, 0xE0, 0x3F, 0x81, 0xEE,
  0x0F, 0x38, 0x78, 0xE1, 0xC3, 0x8E, 0x0E, 0x78, 0x3B, 0xC0, 0xEF, 0x03,
  0xFC, 0x0F, 0xB8, 0x3C, 0xF0, 0xF1, 0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x3C,
  0xE0, 0x73, 0x80, 0xEE, 0x03, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0,
  0x7F, 0x83, 0xFC, 0x3F, 0xF1, 0xFF, 0x9F, 0xEC, 0xDF, 0x76, 0xF9, 0xF7,
  0xCF, 0x3E, 0x79, 0xF1, 0x8F, 0x8C, 0x7C, 0x23, 0xE2, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0E, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83,
  0xFC, 0x3F, 0xC3, 0xEC, 0x3E, 0xE3, 0xEE, 0x3E, 0x63, 0xE7, 0x3E, 0x33,
  0xE3, 0xBE, 0x3B, 0xE1, 0xBE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xF0, 0x0F,
  0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x70, 0x39, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77,
  0x03, 0x9C, 0x0E, 0x38, 0x70, 0x7F, 0x80, 0xFC, 0x00, 0xFF, 0xC7, 0xFF,
  0x38, 0x1D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x77,
  0xFF, 0x3F, 0xF1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x70,
  0x39, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x0E, 0x38, 0x70, 0x7F, 0xC0,
  0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0xC7, 0xFF,
  0x38, 0x1D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x77,
  0xFF, 0x3F, 0xF1, 0xC7, 0x0E, 0x1C, 0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0,
  0x77, 0x03, 0xB8, 0x0E, 0x0F, 0xE0, 0xFF, 0xE7, 0x83, 0xDC, 0x04, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x1F, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x74, 0x01, 0xD8, 0x0E, 0xF8, 0x79, 0xFF, 0xC1,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x70, 0xE7, 0xFE, 0x1F, 0x80, 0xE0, 0x1F, 0xC0, 0x3B, 0xC0,
  0x73, 0x81, 0xE7, 0x03, 0x8E, 0x07, 0x1E, 0x0E, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0x71, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x03, 0xB0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xC0, 0x0F, 0x80, 0x1B, 0x00,
  0x37, 0x00, 0x6E, 0x00, 0xDC, 0x71, 0xB9, 0xE3, 0x73, 0xCE, 0xE7, 0x9D,
  0xCF, 0xBB, 0x9B, 0x77, 0x66, 0xE6, 0xCD, 0xCD, 0x9B, 0x9B, 0x37, 0x36,
  0x7C, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xE0, 0xF0, 0x1C, 0xE0, 0x79, 0xE0,
  0xE1, 0xC3, 0x81, 0xC7, 0x03, 0x9C, 0x03, 0xB8, 0x07, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xEE, 0x03, 0x9C, 0x0E, 0x1C, 0x1C,
  0x3C, 0x70, 0x39, 0xE0, 0x7B, 0x80, 0x78, 0xF0, 0x0F, 0x70, 0x0E, 0x38,
  0x1E, 0x38, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFD, 0xFF,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0xFF, 0xFF,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x07,
  0x80, 0x1E, 0x00, 0xFC, 0x03, 0x38, 0x1C, 0xE0, 0x61, 0xC3, 0x87, 0x0C,
  0x0E, 0x70, 0x39, 0x80, 0x7E, 0x01, 0xD0, 0x04, 0xFF, 0xFF, 0xFF, 0xC0,
  0x47, 0x38, 0xE3, 0x1C, 0x1F, 0x83, 0xFE, 0x38, 0x78, 0x81, 0xC0, 0x0E,
  0x00, 0x70, 0xFF, 0x8F, 0xFC, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xCF,
  0xF7, 0x9F, 0x3C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x9F, 0x1D, 0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x87, 0xBB, 0xF9, 0xCF, 0x80,
  0x0F, 0xC3, 0xFE, 0x78, 0xF7, 0x06, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x27, 0x87, 0x3F, 0xE0, 0xFC, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7C, 0xE7, 0xF7, 0x78, 0x7B,
  0x81, 0xDC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xEE, 0x07, 0x70,
  0x3B, 0xC3, 0xCF, 0xEE, 0x3E, 0x70, 0x1F, 0x81, 0xFE, 0x1C, 0x39, 0xC0,
  0xEE, 0x07, 0x70, 0x1B, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x38, 0x08,
  0xE0, 0xE3, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0xC1, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F, 0xFD,
  0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC7, 0xF0, 0x7F, 0xC7, 0x0E, 0x70, 0x3B,
  0x81, 0xDC, 0x0E, 0x70, 0xE3, 0xFE, 0x07, 0xE0, 0xC0, 0x06, 0x00, 0x7F,
  0xF1, 0xFF, 0xEC, 0x07, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0xFF, 0xE3, 0xFC,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0xCE,
  0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1D, 0xFE, 0x7F, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0xB8, 0x3C, 0xE1,
  0xC3, 0x8E, 0x0E, 0x70, 0x3B, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0x3C, 0x38,
  0x70, 0xE0, 0xE3, 0x83, 0xCE, 0x07, 0xB8, 0x0F, 0xFF, 0x0F, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xEE, 0x3B, 0xFD, 0xFE, 0x79, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C,
  0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3,
  0x1F, 0x8C, 0x70, 0xE7, 0xCE, 0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x1C, 0x0E, 0x70, 0x39, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0x70, 0x1D, 0xC0, 0xE7, 0x03, 0x8E, 0x1C, 0x1F, 0xF0, 0x3F,
  0x00, 0xE7, 0xC7, 0x7F, 0x3C, 0x3D, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xE1, 0xEE, 0xFE, 0x73, 0xE3,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x1F, 0x39, 0xFD, 0xDE,
  0x1E, 0xE0, 0x77, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x81,
  0xDC, 0x0E, 0xF0, 0xF3, 0xFB, 0x8F, 0x9C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0xFE, 0x7F, 0xF7, 0xC3, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xFF,
  0x7F, 0xF8, 0x1F, 0xC7, 0xFE, 0x70, 0x7E, 0x02, 0xE0, 0x07, 0x80, 0x7F,
  0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x40, 0x7F, 0x0F, 0x7F, 0xE1, 0xF8, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xE1, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x3F, 0xC0, 0xFE, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F,
  0x7F, 0x71, 0xE7, 0xF0, 0x1D, 0xC0, 0xE7, 0x03, 0x8C, 0x0E, 0x38, 0x70,
  0xE1, 0xC1, 0x87, 0x07, 0x18, 0x1C, 0xE0, 0x33, 0x80, 0xEC, 0x03, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xC3, 0x8F, 0x8F, 0x1B, 0x1E, 0x36, 0x3C, 0x6E,
  0x78, 0xDC, 0xD9, 0xB9, 0x37, 0x36, 0x6E, 0x6C, 0xDC, 0xD9, 0xB1, 0xB1,
  0x63, 0x63, 0xC7, 0x87, 0x8F, 0x0F, 0x00, 0xF0, 0x3C, 0xE0, 0xE3, 0xC7,
  0x07, 0x38, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x7F,
  0x81, 0xCE, 0x0E, 0x1C, 0x70, 0x3B, 0xC0, 0xF0, 0xE0, 0x1D, 0xC0, 0x77,
  0x03, 0x8C, 0x0E, 0x38, 0x70, 0xE1, 0xC1, 0xC6, 0x07, 0x38, 0x0C, 0xE0,
  0x3B, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE3, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x18, 0x7E, 0x0F, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x70,
  0x07, 0xF0, 0xFE, 0x38, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x87, 0xF0, 0xFC, 0x00, 0x1C, 0x0C, 0xF8, 0x36,
  0x71, 0xD8, 0xE6, 0xE1, 0xFB, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Medium27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 8, 8, 16, 4, -20 },
  { 19, 16, 19, 16, 0, -19 },
  { 57, 14, 25, 16, 1, -22 },
  { 101, 16, 19, 16, 0, -19 },
  { 139, 15, 19, 16, 1, -19 },
  { 175, 2, 8, 16, 7, -20 },
  { 177, 9, 25, 16, 5, -21 },
  { 206, 9, 25, 16, 2, -21 },
  { 235, 14, 14, 16, 1, -15 },
  { 260, 13, 12, 16, 2, -14 },
  { 280, 6, 8, 16, 5, -4 },
  { 286, 8, 2, 16, 4, -9 },
  { 288, 4, 4, 16, 6, -4 },
  { 290, 12, 25, 16, 2, -21 },
  { 328, 14, 19, 16, 1, -19 },
  { 362, 14, 19, 16, 1, -19 },
  { 396, 14, 19, 16, 1, -19 },
  { 430, 13, 19, 16, 1, -19 },
  { 461, 14, 19, 16, 1, -19 },
  { 495, 13, 19, 16, 2, -19 },
  { 526, 14, 19, 16, 1, -19 },
  { 560, 13, 19, 16, 2, -19 },
  { 591, 14, 19, 16, 1, -19 },
  { 625, 14, 19, 16, 1, -19 },
  { 659, 4, 14, 16, 6, -14 },
  { 666, 6, 18, 16, 5, -14 },
  { 680, 12, 16, 16, 2, -16 },
  { 704, 13, 8, 16, 2, -12 },
  { 717, 12, 16, 16, 2, -16 },
  { 741, 12, 19, 16, 2, -19 },
  { 770, 14, 22, 16, 1, -19 },
  { 809, 15, 19, 16, 1, -19 },
  { 845, 13, 19, 16, 2, -19 },
  { 876, 13, 19, 16, 2, -19 },
  { 907, 13, 19, 16, 2, -19 },
  { 938, 12, 19, 16, 2, -19 },
  { 967, 12, 19, 16, 2, -19 },
  { 996, 13, 19, 16, 1, -19 },
  { 1027, 12, 19, 16, 2, -19 },
  { 1056, 12, 19, 16, 2, -19 },
  { 1085, 11, 19, 16, 2, -19 },
  { 1112, 14, 19, 16, 2, -19 },
  { 1146, 12, 19, 16, 3, -19 },
  { 1175, 13, 19, 16, 2, -19 },
  { 1206, 12, 19, 16, 2, -19 },
  { 1235, 14, 19, 16, 1, -19 },
  { 1269, 13, 19, 16, 2, -19 },
  { 1300, 14, 23, 16, 1, -19 },
  { 1341, 13, 19, 16, 2, -19 },
  { 1372, 14, 19, 16, 1, -19 },
  { 1406, 15, 19, 16, 1, -19 },
  { 1442, 12, 19, 16, 2, -19 },
  { 1471, 15, 19, 16, 1, -19 },
  { 1507, 15, 19, 16, 1, -19 },
  { 1543, 15, 19, 16, 1, -19 },
  { 1579, 16, 19, 16, 0, -19 },
  { 1617, 14, 19, 16, 1, -19 },
  { 1651, 8, 25, 16, 6, -21 },
  { 1676, 12, 25, 16, 2, -21 },
  { 1714, 8, 25, 16, 3, -21 },
  { 1739, 14, 12, 16, 1, -19 },
  { 1760, 13, 2, 16, 2, 3 },
  { 1764, 5, 6, 16, 5, -22 },
  { 1768, 13, 14, 16, 2, -14 },
  { 1791, 13, 20, 16, 2, -20 },
  { 1824, 12, 14, 16, 2, -14 },
  { 1845, 13, 20, 16, 1, -20 },
  { 1878, 13, 14, 16, 2, -14 },
  { 1901, 13, 20, 16, 2, -20 },
  { 1934, 13, 21, 16, 2, -16 },
  { 1969, 12, 20, 16, 2, -20 },
  { 1999, 12, 20, 16, 3, -20 },
  { 2029, 10, 25, 16, 2, -20 },
  { 2061, 14, 20, 16, 2, -20 },
  { 2096, 12, 20, 16, 2, -20 },
  { 2126, 14, 14, 16, 1, -14 },
  { 2151, 12, 14, 16, 2, -14 },
  { 2172, 14, 14, 16, 1, -14 },
  { 2197, 13, 19, 16, 2, -14 },
  { 2228, 13, 19, 16, 1, -14 },
  { 2259, 13, 14, 16, 2, -14 },
  { 2282, 12, 14, 16, 2, -14 },
  { 2303, 13, 19, 16, 1, -19 },
  { 2334, 12, 14, 16, 2, -14 },
  { 2355, 14, 14, 16, 1, -14 },
  { 2380, 15, 14, 16, 1, -14 },
  { 2407, 14, 14, 16, 1, -14 },
  { 2432, 14, 19, 16, 1, -14 },
  { 2466, 12, 14, 16, 2, -14 },
  { 2487, 11, 25, 16, 3, -21 },
  { 2522, 2, 25, 16, 7, -21 },
  { 2529, 11, 25, 16, 3, -21 },
  { 2564, 14, 6, 16, 1, -11 },
};

const GFXfont IBMPlexMono_Medium27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_MEDIUM27PT7B_H_
