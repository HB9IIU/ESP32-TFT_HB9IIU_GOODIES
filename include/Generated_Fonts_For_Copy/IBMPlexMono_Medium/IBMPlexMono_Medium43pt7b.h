#ifndef _IBMPLEXMONO_MEDIUM43PT7B_H_
#define _IBMPLEXMONO_MEDIUM43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x3C, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xE0,
  0x01, 0xE1, 0xE0, 0x7F, 0xE1, 0xFF, 0x7F, 0xE1, 0xFF, 0x7F, 0xE1, 0xFF,
  0x7F, 0xC1, 0xFF, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFE,
  0xFF, 0x87, 0xFE, 0xFF, 0x87, 0xFE, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0x39, 0xFD, 0xF0, 0xE1,
  0xC7, 0xC3, 0x82, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xF0, 0xE0, 0x07,
  0xC3, 0x80, 0x1F, 0xCE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xEF, 0xE0, 0x03, 0x8F,
  0xC0, 0x0E, 0x1F, 0x00, 0x38, 0x7C, 0x00, 0xE1, 0xF2, 0x03, 0x87, 0xDC,
  0x0E, 0x1F, 0xFC, 0x38, 0xFB, 0xFC, 0xE7, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0x8F, 0xF0, 0x03,
  0xCF, 0xFC, 0x03, 0xCF, 0x0F, 0x01, 0xE7, 0x83, 0x81, 0xE3, 0x81, 0xE0,
  0xE1, 0xC0, 0xF0, 0xF0, 0xE0, 0x78, 0x70, 0x70, 0x3C, 0x78, 0x38, 0x1E,
  0x38, 0x1E, 0x0E, 0x3C, 0x0F, 0x0F, 0x1C, 0x03, 0xFF, 0x1E, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0xF3, 0xFF, 0x80, 0xF1, 0xE3, 0xC0, 0x79, 0xE0, 0xF0, 0x78, 0xF0, 0x78,
  0x3C, 0x78, 0x1C, 0x3C, 0x3C, 0x0E, 0x1E, 0x1E, 0x07, 0x1E, 0x0F, 0x07,
  0x8F, 0x07, 0x83, 0xCF, 0x01, 0xE3, 0xC7, 0x80, 0xFF, 0xE7, 0x80, 0x3F,
  0xE7, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0xC0, 0x1E, 0x03, 0x80, 0x3E, 0x03,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0xE0,
  0x7E, 0x3F, 0xF0, 0x7E, 0x3F, 0xF8, 0x7E, 0x7C, 0xFC, 0x70, 0xF8, 0x7E,
  0xF0, 0xF8, 0x3E, 0xF0, 0xF0, 0x1F, 0xF0, 0xF0, 0x0F, 0xE0, 0xF0, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xF8, 0x7F, 0xFE,
  0xF8, 0x3F, 0xFC, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x06, 0x07, 0x81, 0xBF, 0x1E, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x1F,
  0x01, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x0E, 0x01, 0xC0, 0x10, 0x04, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x78, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x78, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3F, 0x1F,
  0xF8, 0xF8, 0x7F, 0xE1, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x79, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x01,
  0xF0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F,
  0x80, 0xFC, 0x3E, 0x01, 0xE0, 0xF8, 0x03, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xF0, 0x7E, 0x3E, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0x08,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F, 0x3E, 0x01,
  0xF8, 0x60, 0x07, 0xC2, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0xC0, 0x03, 0xEE, 0x00, 0x3F,
  0xF8, 0x01, 0xF7, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x78,
  0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF1, 0xFC, 0x07, 0x9F, 0xF8, 0x3D, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xC0,
  0xFC, 0x78, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0xC0, 0x07, 0xCE, 0x00, 0x3E, 0xF8, 0x03,
  0xF7, 0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x0F, 0xC0, 0x7C,
  0xFF, 0xC1, 0xF7, 0xFF, 0x87, 0xBF, 0xFF, 0x3F, 0xC0, 0xFE, 0xFE, 0x01,
  0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D,
  0xE0, 0x01, 0xF7, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF8, 0xFC,
  0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x07, 0xCF,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x07, 0xC0,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0x03, 0xF1, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0x7C, 0x00,
  0xF9, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x3F,
  0xFC, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFE, 0xF8, 0x3F, 0xF3, 0xE0, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7C, 0x3E, 0x3F, 0x9F, 0xEF, 0xF7, 0xFB, 0xF8, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF9, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xF0, 0x3F, 0x1F, 0x00, 0x78, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x1E,
  0x7B, 0xC3, 0xFB, 0xDC, 0x1F, 0xFE, 0xE1, 0xFF, 0xFF, 0x0F, 0x0F, 0xF8,
  0x78, 0x3F, 0xC3, 0x81, 0xFE, 0x3C, 0x0F, 0xF1, 0xE0, 0x7F, 0x8F, 0x03,
  0xFC, 0x78, 0x1F, 0xE3, 0xC0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3,
  0xFF, 0xEE, 0x1F, 0xFF, 0x70, 0x7F, 0x7B, 0xC1, 0xFB, 0xDE, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x03, 0xE7, 0x80, 0x03, 0xE7, 0xC0,
  0x03, 0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x83, 0xE0,
  0x07, 0x83, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x00, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xF0, 0x0F, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x00, 0x7C,
  0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x07, 0xE3, 0xE0,
  0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x41, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0x87, 0xC0, 0x07, 0x8F, 0x80, 0x3F,
  0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xF0, 0x1F, 0x8F, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00,
  0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3E,
  0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x0F, 0xCF, 0x01, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xC7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x01, 0xF9, 0xFC, 0x1F,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFD, 0xF0, 0xFF, 0xCF, 0x81, 0xF8, 0x7C, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xDF, 0x87,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3,
  0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE1,
  0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0x7C, 0x03, 0xF8, 0xF8, 0x0F,
  0xE3, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFB, 0xC7, 0x7F, 0xDE, 0x7B, 0xFE, 0xF3, 0x9F, 0xF3, 0xFC,
  0xFF, 0x9F, 0xE7, 0xFC, 0x7E, 0x3F, 0xE3, 0xF1, 0xFF, 0x1F, 0x0F, 0xF8,
  0x78, 0x7F, 0xC3, 0xC3, 0xFE, 0x0C, 0x1F, 0xF0, 0x60, 0xFF, 0x83, 0x07,
  0xFC, 0x10, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3C,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0x78, 0x1F, 0xF7, 0xC1, 0xFF, 0x3C,
  0x1F, 0xF3, 0xC1, 0xFF, 0x3E, 0x1F, 0xF1, 0xE1, 0xFF, 0x1E, 0x1F, 0xF0,
  0xF1, 0xFF, 0x0F, 0x1F, 0xF0, 0xF9, 0xFF, 0x07, 0x9F, 0xF0, 0x79, 0xFF,
  0x03, 0xDF, 0xF0, 0x3D, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00,
  0x3E, 0x78, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x79, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x01, 0xF0,
  0xFC, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00,
  0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x78, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E,
  0x01, 0xF0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00,
  0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF0,
  0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F,
  0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x7E,
  0xF0, 0x03, 0xEF, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0x03, 0xF9, 0xF8, 0x03, 0xC7, 0xC0, 0x06,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF2, 0x00, 0x07, 0x9C, 0x00, 0x3E, 0xFC,
  0x01, 0xFB, 0xFC, 0x0F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x7C, 0x03,
  0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x3F,
  0xC0, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xE7,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E,
  0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0xFF,
  0x1E, 0x78, 0xEF, 0x1E, 0x78, 0xE7, 0x1E, 0x78, 0xE7, 0x1E, 0x78, 0xE7,
  0x1C, 0x79, 0xE7, 0xBC, 0x79, 0xE7, 0xBC, 0x3D, 0xC7, 0xBC, 0x3D, 0xC3,
  0xBC, 0x3D, 0xC3, 0xBC, 0x3F, 0xC3, 0xBC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE7,
  0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xDF, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF8, 0x03, 0xE1, 0xE0, 0x0F, 0x07,
  0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xF1,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xC0,
  0x00, 0xE2, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x18, 0x78, 0xFC, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x04,
  0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xC0,
  0xFC, 0x38, 0x03, 0xE0, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC0, 0x3C, 0x7C, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0xFE, 0x3F,
  0xFE, 0xFE, 0xFF, 0xF7, 0xF3, 0xFF, 0x1F, 0x87, 0xE0, 0x7C, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x1F, 0x81, 0xF3, 0xFF, 0x0F, 0xBF, 0xFC, 0x7D, 0xFF, 0xF3, 0xF8,
  0x1F, 0x9F, 0x80, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0xFD, 0xFC, 0x0F, 0xCF,
  0xBF, 0xFE, 0x7D, 0xFF, 0xE3, 0xE7, 0xFE, 0x1F, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xE0,
  0x3E, 0x7C, 0x01, 0x87, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x01, 0x07,
  0xC0, 0x0C, 0x7E, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xF0, 0xF0, 0xFF, 0x8F, 0x1F,
  0xFC, 0xF3, 0xFF, 0xEF, 0x7F, 0x07, 0xF7, 0xE0, 0x1F, 0x7C, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0xC0, 0x1F, 0x7E, 0x01,
  0xF7, 0xF0, 0x7F, 0x3F, 0xFE, 0xF1, 0xFF, 0xCF, 0x0F, 0xF8, 0xF0, 0x3F,
  0x0F, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E,
  0x07, 0xE7, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x08, 0x7C, 0x01, 0xC7, 0xF0, 0x7F, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFB, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x0F, 0x87,
  0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xE0,
  0x7C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0x80,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE7, 0x00, 0x0F, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x80, 0x1F, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x0F, 0xC3, 0xC7, 0xFC,
  0xF3, 0xFF, 0xBD, 0xFF, 0xEF, 0x61, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xFD, 0xE0, 0x0F, 0x8F, 0x00,
  0xF8, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x07,
  0x8F, 0x80, 0x3C, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x7C,
  0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x3C,
  0x07, 0xE1, 0xE0, 0x1F, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xF3, 0xC0, 0x0F,
  0xDE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xC1, 0xF3, 0xDF, 0x8F, 0xEF, 0x7F, 0x7F, 0xBF, 0xFD, 0xFE, 0xF8, 0xFC,
  0x7F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0,
  0xF0, 0xFC, 0x3C, 0x7F, 0xCF, 0x3F, 0xFB, 0xDF, 0xFE, 0xF6, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xF0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xBC, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x01, 0xF1, 0xF8,
  0x1F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFE, 0x00,
  0xF8, 0x7E, 0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xF1, 0xF7, 0xFF, 0xCF, 0xE0,
  0x7E, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xF7,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x3E,
  0xFF, 0xF9, 0xF7, 0xFF, 0x8F, 0x9F, 0xF8, 0x7C, 0x3F, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0xF0, 0xFF, 0x8F, 0x1F, 0xFC, 0xF3, 0xFF, 0xEF, 0x7F, 0x07, 0xF7, 0xE0,
  0x1F, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7,
  0xC0, 0x1F, 0x7E, 0x01, 0xF7, 0xF0, 0x7F, 0x3F, 0xFE, 0xF1, 0xFF, 0xCF,
  0x0F, 0xF8, 0xF0, 0x3F, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xDF, 0xF0, 0x3E, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7E, 0x03, 0xC7, 0xC0, 0x08, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x01, 0xF2, 0x00, 0x1F, 0x70, 0x01, 0xFF, 0xC0, 0x7E, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0xC1, 0xFD, 0xFF,
  0xFF, 0x9F, 0xFD, 0xF1, 0xFF, 0xBE, 0x0F, 0xC7, 0xC0, 0xF8, 0x00, 0x7D,
  0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x3C,
  0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0E, 0xF0, 0x7E,
  0x0E, 0x78, 0x7E, 0x1E, 0x78, 0xEE, 0x1E, 0x78, 0xE7, 0x1E, 0x78, 0xE7,
  0x1E, 0x78, 0xE7, 0x1E, 0x78, 0xE7, 0x1C, 0x78, 0xE7, 0x1C, 0x39, 0xC7,
  0x9C, 0x39, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC, 0x3D, 0xC3,
  0xBC, 0x3F, 0xC3, 0xB8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x07, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x1E, 0x00, 0x7C, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0,
  0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x7C,
  0x01, 0xFB, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x07, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x38, 0x7F, 0x00, 0xF3, 0xFE, 0x03,
  0xCF, 0xFC, 0x0E, 0x78, 0xF8, 0x79, 0xE1, 0xF3, 0xEF, 0x03, 0xFF, 0x3C,
  0x0F, 0xFC, 0xF0, 0x1F, 0xE1, 0x80, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_Medium43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 30, 26, 9, -30 },
  { 31, 12, 13, 26, 7, -32 },
  { 51, 24, 30, 26, 1, -30 },
  { 141, 22, 38, 26, 2, -34 },
  { 246, 25, 30, 26, 0, -30 },
  { 340, 24, 30, 26, 1, -30 },
  { 430, 4, 13, 26, 11, -32 },
  { 437, 14, 39, 26, 8, -33 },
  { 506, 14, 39, 26, 4, -33 },
  { 575, 22, 22, 26, 2, -24 },
  { 636, 20, 22, 26, 3, -24 },
  { 691, 9, 13, 26, 8, -7 },
  { 706, 13, 4, 26, 6, -15 },
  { 713, 8, 7, 26, 9, -7 },
  { 720, 18, 39, 26, 4, -33 },
  { 808, 22, 30, 26, 2, -30 },
  { 891, 22, 30, 26, 2, -30 },
  { 974, 21, 30, 26, 2, -30 },
  { 1053, 21, 30, 26, 2, -30 },
  { 1132, 23, 30, 26, 1, -30 },
  { 1219, 21, 30, 26, 3, -30 },
  { 1298, 22, 30, 26, 2, -30 },
  { 1381, 20, 30, 26, 3, -30 },
  { 1456, 22, 30, 26, 2, -30 },
  { 1539, 22, 30, 26, 2, -30 },
  { 1622, 8, 23, 26, 9, -23 },
  { 1645, 9, 29, 26, 8, -23 },
  { 1678, 18, 25, 26, 4, -26 },
  { 1735, 20, 13, 26, 3, -20 },
  { 1768, 18, 25, 26, 4, -26 },
  { 1825, 19, 30, 26, 3, -30 },
  { 1897, 21, 35, 26, 2, -30 },
  { 1989, 24, 30, 26, 1, -30 },
  { 2079, 20, 30, 26, 4, -30 },
  { 2154, 22, 30, 26, 2, -30 },
  { 2237, 20, 30, 26, 4, -30 },
  { 2312, 18, 30, 26, 4, -30 },
  { 2380, 19, 30, 26, 4, -30 },
  { 2452, 21, 30, 26, 2, -30 },
  { 2531, 20, 30, 26, 3, -30 },
  { 2606, 19, 30, 26, 3, -30 },
  { 2678, 18, 30, 26, 3, -30 },
  { 2746, 22, 30, 26, 3, -30 },
  { 2829, 18, 30, 26, 5, -30 },
  { 2897, 21, 30, 26, 2, -30 },
  { 2976, 20, 30, 26, 3, -30 },
  { 3051, 22, 30, 26, 2, -30 },
  { 3134, 20, 30, 26, 4, -30 },
  { 3209, 22, 38, 26, 2, -30 },
  { 3314, 20, 30, 26, 4, -30 },
  { 3389, 22, 30, 26, 2, -30 },
  { 3472, 24, 30, 26, 1, -30 },
  { 3562, 20, 30, 26, 3, -30 },
  { 3637, 24, 30, 26, 1, -30 },
  { 3727, 24, 30, 26, 1, -30 },
  { 3817, 24, 30, 26, 1, -30 },
  { 3907, 24, 30, 26, 1, -30 },
  { 3997, 22, 30, 26, 2, -30 },
  { 4080, 13, 39, 26, 9, -33 },
  { 4144, 18, 39, 26, 4, -33 },
  { 4232, 13, 39, 26, 4, -33 },
  { 4296, 22, 19, 26, 2, -30 },
  { 4349, 20, 4, 26, 3, 4 },
  { 4359, 8, 9, 26, 7, -34 },
  { 4368, 21, 22, 26, 3, -22 },
  { 4426, 21, 32, 26, 3, -32 },
  { 4510, 20, 22, 26, 3, -22 },
  { 4565, 20, 32, 26, 2, -32 },
  { 4645, 20, 22, 26, 3, -22 },
  { 4700, 21, 32, 26, 3, -32 },
  { 4784, 22, 35, 26, 3, -26 },
  { 4881, 18, 32, 26, 4, -32 },
  { 4953, 20, 32, 26, 4, -32 },
  { 5033, 16, 41, 26, 4, -32 },
  { 5115, 21, 32, 26, 4, -32 },
  { 5199, 20, 32, 26, 3, -32 },
  { 5279, 22, 22, 26, 2, -22 },
  { 5340, 18, 22, 26, 4, -22 },
  { 5390, 21, 22, 26, 2, -22 },
  { 5448, 21, 31, 26, 3, -22 },
  { 5530, 20, 31, 26, 2, -22 },
  { 5608, 21, 22, 26, 3, -22 },
  { 5666, 20, 22, 26, 3, -22 },
  { 5721, 21, 30, 26, 2, -30 },
  { 5800, 19, 22, 26, 3, -22 },
  { 5853, 22, 22, 26, 2, -22 },
  { 5914, 24, 22, 26, 1, -22 },
  { 5980, 22, 22, 26, 2, -22 },
  { 6041, 22, 31, 26, 2, -22 },
  { 6127, 19, 22, 26, 3, -22 },
  { 6180, 18, 39, 26, 4, -33 },
  { 6268, 4, 39, 26, 11, -33 },
  { 6288, 18, 39, 26, 4, -33 },
  { 6376, 22, 10, 26, 2, -18 },
};

const GFXfont IBMPlexMono_Medium43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_MEDIUM43PT7B_H_
