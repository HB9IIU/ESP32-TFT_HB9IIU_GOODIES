#ifndef _IBMPLEXMONO_MEDIUM23PT7B_H_
#define _IBMPLEXMONO_MEDIUM23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium23pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x40, 0x00, 0xEF, 0xFE, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0x80, 0x06, 0x70, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0C,
  0x61, 0xF3, 0xF7, 0xCF, 0xC3, 0x30, 0x0C, 0xC3, 0xF3, 0xEF, 0x8F, 0x86,
  0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0C, 0x60, 0x06, 0x00, 0x60, 0x1F,
  0x83, 0xFE, 0x76, 0x76, 0x64, 0x66, 0x06, 0x60, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x6E, 0x06, 0x70, 0x67, 0x46, 0x7F, 0x6E, 0x7F, 0xE1, 0xF8, 0x06,
  0x00, 0x60, 0x3C, 0x1D, 0xF8, 0x66, 0x63, 0x31, 0x8C, 0xC6, 0x61, 0x99,
  0x87, 0xEC, 0x0F, 0x00, 0x00, 0xF0, 0x37, 0xE1, 0x99, 0x86, 0xC2, 0x33,
  0x08, 0xC6, 0x66, 0x1F, 0xB8, 0x3C, 0x0F, 0x00, 0xFE, 0x0E, 0x30, 0x61,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x8F, 0x3E, 0x7B, 0x3B, 0x18, 0xF9,
  0xC3, 0xC6, 0x0E, 0x38, 0xF1, 0xFD, 0xC3, 0xC7, 0xFF, 0xFC, 0x07, 0x0C,
  0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x60, 0x60, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x0C, 0x07, 0xE0, 0x60, 0x60, 0xE0, 0xC1, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x1C, 0x30, 0xC7, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x0C, 0x62, 0xFF, 0xF7, 0xFE, 0x0F, 0x01, 0xF0,
  0x1B, 0x83, 0x9C, 0x70, 0xC2, 0x08, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3B,
  0xDC, 0xE6, 0x33, 0x80, 0xFF, 0xFC, 0xEF, 0xFE, 0x01, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0x1F, 0x03, 0xFC,
  0x70, 0xE6, 0x06, 0xE0, 0x6E, 0x07, 0xE6, 0x7E, 0xE7, 0xE6, 0x7E, 0x07,
  0xE0, 0x7E, 0x06, 0x60, 0x67, 0x0E, 0x3F, 0xC1, 0xF0, 0x0F, 0x01, 0xF0,
  0x3B, 0x07, 0x30, 0xE3, 0x04, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x7F, 0xF7, 0xFF, 0x1F, 0x03, 0xFC,
  0x71, 0xEE, 0x0E, 0x20, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0xFB,
  0xC7, 0x90, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x7C, 0x0F, 0x80, 0x1C, 0x03,
  0x80, 0x34, 0x0F, 0xC1, 0xDF, 0xF0, 0xF8, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0xDC, 0x0D, 0xC1, 0x9C, 0x39, 0xC3, 0x1C, 0x61, 0xCE, 0x1C, 0xC1, 0xCF,
  0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0xE7, 0xFE, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x67, 0x86, 0xFC, 0x70, 0xE0, 0x06, 0x00, 0x70,
  0x07, 0x60, 0x6F, 0x0E, 0x7F, 0xC1, 0xF8, 0x07, 0xC0, 0xE0, 0x1C, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x67, 0x8F, 0xFC, 0xF0, 0xEE, 0x07, 0xE0, 0x7E,
  0x07, 0x60, 0x67, 0x0E, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0x81, 0xF0,
  0x7E, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60,
  0x66, 0x06, 0x70, 0xC1, 0xF8, 0x3F, 0xC7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0,
  0x77, 0x0E, 0x7F, 0xE1, 0xF8, 0x1F, 0x03, 0xFC, 0x70, 0xEE, 0x06, 0xE0,
  0x6E, 0x07, 0xE0, 0x77, 0x0E, 0x7F, 0x61, 0xEE, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x38, 0x0F, 0x03, 0xC0, 0xEF, 0xFE, 0x00, 0x00, 0x0E, 0xFF, 0xE0,
  0x73, 0xDE, 0xE0, 0x00, 0x00, 0x01, 0xDE, 0xE7, 0x31, 0x9C, 0x00, 0x40,
  0x70, 0x7C, 0x7C, 0x3C, 0x3C, 0x0C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0x00, 0x40, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x80, 0x38, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0C, 0x0F, 0x0F, 0x0F,
  0x0F, 0x83, 0x80, 0x80, 0x00, 0x3E, 0x1F, 0xEE, 0x1F, 0x07, 0x01, 0xC0,
  0x70, 0x78, 0x7C, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1F, 0x87, 0xF9, 0xC3, 0xB0, 0x36, 0x07, 0x8E, 0xF1, 0xFE, 0x63,
  0xCC, 0x79, 0x8F, 0x31, 0xE6, 0x3C, 0xFE, 0x8F, 0xD8, 0x03, 0x00, 0x30,
  0x07, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xDC,
  0x06, 0x60, 0x73, 0x83, 0x1C, 0x18, 0x61, 0xC3, 0x0F, 0xFC, 0x7F, 0xE7,
  0x03, 0x38, 0x1D, 0xC0, 0xFC, 0x07, 0xFF, 0x1F, 0xF3, 0x07, 0x60, 0xEC,
  0x1D, 0x83, 0xB0, 0x67, 0xF8, 0xFF, 0x98, 0x3B, 0x03, 0x60, 0x7C, 0x0F,
  0x83, 0xBF, 0xF7, 0xF8, 0x0F, 0x83, 0xFC, 0x38, 0xE7, 0x07, 0x60, 0x46,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x04, 0x70, 0x73,
  0x8E, 0x3F, 0xC0, 0xF8, 0xFE, 0x1F, 0xF3, 0x0F, 0x60, 0xEC, 0x0D, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x6C, 0x1D, 0x87, 0xBF,
  0xE7, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF,
  0xFF, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xF8, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0x87, 0xF9, 0xC3, 0xB0, 0x7E,
  0x09, 0xC0, 0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x81, 0xF0, 0x36, 0x06,
  0xE1, 0xCF, 0xD8, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x3F, 0xCF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xE0,
  0xDC, 0x77, 0xF8, 0x7C, 0xC0, 0xEC, 0x1C, 0xC3, 0x8C, 0x38, 0xC7, 0x0C,
  0xE0, 0xDC, 0x0D, 0xE0, 0xFE, 0x0E, 0x70, 0xC3, 0x0C, 0x38, 0xC1, 0x8C,
  0x1C, 0xC0, 0xEC, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xF9, 0xFF, 0xF7, 0xEF, 0x7E, 0xF7,
  0xE6, 0x7E, 0x67, 0xE4, 0x7E, 0x47, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xF6, 0x3D, 0x8F, 0x33, 0xCC, 0xF3,
  0xBC, 0x6F, 0x1B, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0x1F, 0x03, 0xFC, 0x70,
  0xE6, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x06, 0x60, 0xE7, 0x0E, 0x3F, 0xC1, 0xF0, 0xFF, 0x1F, 0xFB, 0x87,
  0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0xFE, 0xFF, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0x03, 0xFC, 0x70, 0xE6, 0x0E,
  0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06,
  0x60, 0xE7, 0x0E, 0x3F, 0xC1, 0xF8, 0x06, 0x00, 0x60, 0x07, 0xE0, 0x3E,
  0xFF, 0x1F, 0xFB, 0x07, 0x60, 0x7C, 0x0F, 0x81, 0xF0, 0x77, 0xFE, 0xFF,
  0x18, 0xE3, 0x1C, 0x61, 0xCC, 0x39, 0x83, 0xB0, 0x76, 0x07, 0x1F, 0x83,
  0xFE, 0x70, 0xE6, 0x04, 0xE0, 0x06, 0x00, 0x78, 0x03, 0xF8, 0x0F, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x40, 0x6F, 0x0E, 0x7F, 0xC1, 0xF8, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF8, 0x77, 0xF8, 0xFC, 0xC0, 0x7E, 0x07, 0xE0, 0x76, 0x06,
  0x70, 0xE7, 0x0E, 0x70, 0xC3, 0x0C, 0x39, 0xC3, 0x9C, 0x19, 0x81, 0x98,
  0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC6, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xB7, 0xD9, 0x6F, 0x9E,
  0xF9, 0xE7, 0x9E, 0x71, 0xE7, 0x0E, 0x70, 0x39, 0xC1, 0x8E, 0x1C, 0x39,
  0xC1, 0xCC, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0x03, 0x70,
  0x39, 0xC1, 0x8E, 0x1C, 0x39, 0xC0, 0xDC, 0x07, 0xE0, 0x3D, 0xC0, 0xE3,
  0x87, 0x0E, 0x1C, 0x1C, 0xE0, 0x73, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x07, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0x98, 0x39, 0xC3, 0x0C, 0x70, 0xE6,
  0x06, 0xC0, 0x74, 0x02, 0xFF, 0xFF, 0xFC, 0x4E, 0x63, 0x30, 0x1F, 0x07,
  0xFC, 0x61, 0xC4, 0x0C, 0x00, 0xC3, 0xFC, 0x7F, 0xCE, 0x0C, 0xE0, 0xCE,
  0x1C, 0x7F, 0xF3, 0xE7, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x9E,
  0x37, 0xE7, 0x0E, 0xC0, 0xD8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xB8,
  0x76, 0xFC, 0xCF, 0x00, 0x1F, 0x1F, 0xE6, 0x1F, 0x82, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xE0, 0x9C, 0x77, 0xF8, 0x7C, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x3D, 0xDF, 0xFB, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xDC, 0x3B, 0xFF, 0x1E, 0xE0, 0x1F, 0x07, 0xF9, 0xC3, 0xB0,
  0x36, 0x07, 0xFF, 0xFF, 0xFB, 0x00, 0x60, 0x4E, 0x1C, 0xFF, 0x07, 0xC0,
  0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0xF0, 0x0F, 0x1F, 0x83, 0xFC, 0x70, 0xC6, 0x0E, 0x60, 0xE7, 0x0C,
  0x3F, 0xC1, 0xF0, 0x20, 0x06, 0x00, 0x7F, 0xC3, 0xFF, 0x60, 0x7E, 0x03,
  0xE0, 0x77, 0xFE, 0x3F, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33,
  0xCD, 0xFB, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0xFF, 0xFF, 0xFC, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xFF, 0xFE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC3, 0xF8,
  0xE7, 0x38, 0xEE, 0x1F, 0x83, 0xF8, 0x7F, 0x0E, 0x71, 0xC7, 0x38, 0x77,
  0x0E, 0xE0, 0xE0, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF,
  0xC0, 0xDC, 0xEF, 0xFE, 0xC6, 0x7C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C,
  0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xCF, 0x37, 0xEE, 0x1F, 0x87,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x1F, 0x03,
  0xFC, 0x70, 0xE6, 0x06, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x06, 0x60, 0x67,
  0x0E, 0x3F, 0xC1, 0xF0, 0xCF, 0x1B, 0xF3, 0x87, 0x60, 0x6C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xDC, 0x3B, 0x7E, 0x67, 0x8C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x00, 0x1E, 0xEF, 0xFD, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x1D, 0xFF, 0x8F, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0xF8, 0xFF, 0x3C, 0x68, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0x87, 0xFD,
  0xC3, 0x30, 0x07, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0x40, 0x6C, 0x1F, 0xFF,
  0x0F, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F, 0xFF, 0xFF, 0xC3, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x3F,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8,
  0x77, 0xFC, 0xF7, 0xE0, 0x76, 0x06, 0x70, 0xE7, 0x0C, 0x30, 0xC3, 0x1C,
  0x39, 0x81, 0x98, 0x1B, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0xE3, 0x1B, 0x38,
  0xD9, 0xE6, 0xCF, 0x36, 0x59, 0xB2, 0xCD, 0x92, 0x4D, 0x96, 0x3C, 0xF1,
  0xE7, 0x8E, 0x3C, 0x70, 0xE0, 0xE0, 0x77, 0x0C, 0x39, 0xC1, 0xF8, 0x1F,
  0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1B, 0x83, 0x1C, 0x70, 0xEE, 0x07, 0xE0,
  0x7E, 0x06, 0x60, 0xE7, 0x0E, 0x30, 0xC3, 0x9C, 0x39, 0x81, 0x98, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0C, 0x07, 0xC0, 0x78,
  0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x0F, 0xFF, 0xFF, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x06, 0x3F, 0x0F, 0xC0, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x03, 0xF0, 0xFC,
  0x60, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x8F, 0xE3, 0xF0, 0x38,
  0x37, 0xC3, 0x66, 0x6C, 0x7E, 0xC3, 0xC0,
};

const GFXglyph IBMPlexMono_Medium23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 7, 7, 14, 3, -17 },
  { 16, 14, 16, 14, 0, -16 },
  { 44, 12, 20, 14, 1, -18 },
  { 74, 14, 16, 14, 0, -16 },
  { 102, 13, 16, 14, 0, -16 },
  { 128, 2, 7, 14, 6, -17 },
  { 130, 8, 20, 14, 4, -17 },
  { 150, 7, 20, 14, 2, -17 },
  { 168, 12, 12, 14, 1, -13 },
  { 186, 11, 12, 14, 1, -13 },
  { 203, 5, 7, 14, 4, -4 },
  { 208, 7, 2, 14, 3, -8 },
  { 210, 4, 4, 14, 5, -4 },
  { 212, 10, 20, 14, 2, -17 },
  { 237, 12, 16, 14, 1, -16 },
  { 261, 12, 16, 14, 1, -16 },
  { 285, 12, 16, 14, 1, -16 },
  { 309, 11, 16, 14, 1, -16 },
  { 331, 12, 16, 14, 1, -16 },
  { 355, 12, 16, 14, 1, -16 },
  { 379, 12, 16, 14, 1, -16 },
  { 403, 11, 16, 14, 1, -16 },
  { 425, 12, 16, 14, 1, -16 },
  { 449, 12, 16, 14, 1, -16 },
  { 473, 4, 13, 14, 5, -13 },
  { 480, 5, 16, 14, 4, -13 },
  { 490, 10, 13, 14, 2, -14 },
  { 507, 11, 6, 14, 1, -10 },
  { 516, 10, 13, 14, 2, -14 },
  { 533, 10, 16, 14, 2, -16 },
  { 553, 11, 19, 14, 1, -16 },
  { 580, 13, 16, 14, 0, -16 },
  { 606, 11, 16, 14, 2, -16 },
  { 628, 12, 16, 14, 1, -16 },
  { 652, 11, 16, 14, 2, -16 },
  { 674, 10, 16, 14, 2, -16 },
  { 694, 10, 16, 14, 2, -16 },
  { 714, 11, 16, 14, 1, -16 },
  { 736, 10, 16, 14, 2, -16 },
  { 756, 10, 16, 14, 2, -16 },
  { 776, 10, 16, 14, 1, -16 },
  { 796, 12, 16, 14, 2, -16 },
  { 820, 10, 16, 14, 2, -16 },
  { 840, 12, 16, 14, 1, -16 },
  { 864, 10, 16, 14, 2, -16 },
  { 884, 12, 16, 14, 1, -16 },
  { 908, 11, 16, 14, 2, -16 },
  { 930, 12, 20, 14, 1, -16 },
  { 960, 11, 16, 14, 2, -16 },
  { 982, 12, 16, 14, 1, -16 },
  { 1006, 12, 16, 14, 1, -16 },
  { 1030, 10, 16, 14, 2, -16 },
  { 1050, 12, 16, 14, 1, -16 },
  { 1074, 12, 16, 14, 1, -16 },
  { 1098, 13, 16, 14, 0, -16 },
  { 1124, 14, 16, 14, 0, -16 },
  { 1152, 12, 16, 14, 1, -16 },
  { 1176, 7, 20, 14, 5, -17 },
  { 1194, 10, 20, 14, 2, -17 },
  { 1219, 7, 20, 14, 2, -17 },
  { 1237, 12, 10, 14, 1, -16 },
  { 1252, 11, 2, 14, 1, 2 },
  { 1255, 4, 5, 14, 4, -18 },
  { 1258, 12, 12, 14, 1, -12 },
  { 1276, 11, 17, 14, 2, -17 },
  { 1300, 10, 12, 14, 2, -12 },
  { 1315, 11, 17, 14, 1, -17 },
  { 1339, 11, 12, 14, 1, -12 },
  { 1356, 11, 17, 14, 2, -17 },
  { 1380, 12, 19, 14, 1, -14 },
  { 1409, 10, 17, 14, 2, -17 },
  { 1431, 11, 18, 14, 2, -18 },
  { 1456, 8, 23, 14, 2, -18 },
  { 1479, 11, 17, 14, 2, -17 },
  { 1503, 10, 17, 14, 2, -17 },
  { 1525, 12, 12, 14, 1, -12 },
  { 1543, 10, 12, 14, 2, -12 },
  { 1558, 12, 12, 14, 1, -12 },
  { 1576, 11, 17, 14, 2, -12 },
  { 1600, 11, 17, 14, 1, -12 },
  { 1624, 11, 12, 14, 2, -12 },
  { 1641, 11, 12, 14, 1, -12 },
  { 1658, 11, 16, 14, 1, -16 },
  { 1680, 10, 12, 14, 2, -12 },
  { 1695, 12, 12, 14, 1, -12 },
  { 1713, 13, 12, 14, 0, -12 },
  { 1733, 12, 12, 14, 1, -12 },
  { 1751, 12, 17, 14, 1, -12 },
  { 1777, 10, 12, 14, 2, -12 },
  { 1792, 10, 20, 14, 2, -17 },
  { 1817, 2, 20, 14, 6, -17 },
  { 1822, 10, 20, 14, 2, -17 },
  { 1847, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_Medium23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_MEDIUM23PT7B_H_
