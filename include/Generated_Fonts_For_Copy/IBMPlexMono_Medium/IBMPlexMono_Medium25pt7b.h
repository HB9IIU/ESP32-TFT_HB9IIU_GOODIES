#ifndef _IBMPLEXMONO_MEDIUM25PT7B_H_
#define _IBMPLEXMONO_MEDIUM25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium25pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xC4, 0x21, 0x00, 0x00, 0x3B, 0xFF, 0x70,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0x80, 0x07, 0x38, 0x0E, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0x67, 0x0F, 0xCF, 0xDF, 0x9F, 0x86, 0x30, 0x0C, 0x60,
  0x18, 0xC3, 0xF3, 0xF7, 0xE7, 0xE1, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C,
  0xE0, 0x39, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0x83, 0xFF, 0x39,
  0xBD, 0x8C, 0x8C, 0x60, 0x63, 0x03, 0x98, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x01, 0x9C, 0x0C, 0xE0, 0x67, 0x63, 0x3F, 0x9B, 0x9F, 0xF8, 0x3F, 0x80,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x3C, 0x0E, 0xFC, 0x19, 0x9C, 0x66, 0x18,
  0xCC, 0x33, 0x18, 0x6E, 0x19, 0xD8, 0x3F, 0x00, 0x3C, 0x78, 0x01, 0xF8,
  0x37, 0x30, 0xEC, 0x31, 0x98, 0x66, 0x31, 0xCC, 0x73, 0x30, 0x7E, 0xE0,
  0x78, 0x0F, 0x80, 0x3F, 0x80, 0xE3, 0x81, 0xC2, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x3E, 0x3C, 0xEE, 0x79, 0xCE, 0xC3, 0x0F, 0x8E,
  0x0F, 0x0C, 0x0E, 0x1C, 0x2E, 0x1F, 0xDC, 0x1F, 0x1E, 0xFF, 0xFF, 0xF8,
  0x0F, 0x1C, 0x18, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0F, 0xF0, 0x38,
  0x18, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC1, 0x0E, 0x2F, 0x77, 0xFF, 0xFC, 0x7F, 0x01, 0xF0, 0x0D, 0x80, 0xEE,
  0x0E, 0x38, 0x60, 0xC1, 0x08, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7B,
  0x9D, 0xEE, 0x73, 0x18, 0xFF, 0xFC, 0x77, 0xFE, 0xE0, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xE6, 0x03,
  0x70, 0x1F, 0x80, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF8, 0x0F, 0xC0, 0x76,
  0x03, 0x38, 0x39, 0xE3, 0xC7, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x0E,
  0xE0, 0xF7, 0x0F, 0x38, 0x31, 0xC1, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0x7F, 0xF8,
  0x1F, 0x81, 0xFF, 0x1C, 0x39, 0xC0, 0xE2, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0x83, 0xFE, 0x70, 0xF2, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0xFC, 0x0F, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x76,
  0x07, 0xF0, 0xF7, 0xFE, 0x1F, 0x80, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0D,
  0xC0, 0xEE, 0x06, 0x70, 0x73, 0x87, 0x1C, 0x30, 0xE3, 0x87, 0x38, 0x39,
  0x81, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x3F, 0xF1,
  0xFF, 0x8C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xDF, 0x0D, 0xFC, 0x78,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xB0, 0x3B, 0xC3, 0xC7, 0xFC,
  0x1F, 0x80, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xDF, 0x0F, 0xFC, 0xE8, 0xF7, 0x83, 0xB8, 0x0F, 0xC0, 0x76, 0x03, 0xB8,
  0x39, 0xE1, 0xC7, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1D, 0xC0,
  0xEE, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x1F, 0xC1,
  0xFF, 0x1C, 0x1C, 0xE0, 0xE6, 0x03, 0x38, 0x38, 0xC1, 0x83, 0xF8, 0x3F,
  0xE3, 0x83, 0xB8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0xC1, 0xC7, 0xFC,
  0x1F, 0xC0, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xEE, 0x03, 0x70, 0x1F,
  0x80, 0xFE, 0x0F, 0x70, 0xB1, 0xFF, 0x87, 0xDC, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x03,
  0xBF, 0xF7, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x03, 0xDC, 0xEF, 0x73,
  0x98, 0xC0, 0x00, 0x20, 0x1C, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x07,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x08, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x01, 0xE0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x01, 0xC0, 0x20, 0x00, 0x1F, 0x0F, 0xFB, 0xC7, 0x70, 0x74,
  0x0E, 0x01, 0xC0, 0x70, 0x7E, 0x0F, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x0F, 0x83, 0xFE, 0x38, 0x77, 0x03,
  0x60, 0x36, 0x3B, 0xE7, 0xFE, 0x63, 0xE6, 0x3E, 0xE3, 0xEE, 0x3E, 0x63,
  0xE6, 0x3E, 0x7F, 0x63, 0xB6, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xC0, 0xFC,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x36, 0x00, 0xEE, 0x01, 0xDC, 0x03,
  0x18, 0x0E, 0x38, 0x1C, 0x70, 0x30, 0x60, 0xFF, 0xE1, 0xFF, 0xC3, 0x83,
  0x86, 0x03, 0x1C, 0x07, 0x38, 0x0E, 0xE0, 0x1E, 0xFF, 0x8F, 0xFC, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCF, 0xF8, 0xFF, 0xCE, 0x0E, 0xE0,
  0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEF, 0xFC, 0xFF, 0x80, 0x0F, 0xC0,
  0xFF, 0x0E, 0x1C, 0xE0, 0x77, 0x02, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x02, 0x38, 0x1C, 0xE1, 0xC3, 0xFC,
  0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xE1, 0xCE, 0x0E, 0xE0, 0x6E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE1,
  0xCF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xFE, 0x38, 0xF7, 0x07, 0x60, 0x2E,
  0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xE0, 0x3E, 0x03, 0x60, 0x37,
  0x07, 0x78, 0xF3, 0xFB, 0x1F, 0x30, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xE0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xE0, 0x3F, 0xE7, 0xFC, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x32, 0x0F,
  0xC1, 0xDC, 0x39, 0xFE, 0x1F, 0x00, 0xE0, 0x7F, 0x07, 0x38, 0x79, 0xC7,
  0x8E, 0x38, 0x73, 0x83, 0xB8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3D, 0xE1,
  0xC7, 0x0E, 0x1C, 0x70, 0xF3, 0x83, 0x9C, 0x0E, 0xE0, 0x78, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xF0, 0x7F, 0x83, 0xFE,
  0x3F, 0xF1, 0xFF, 0xDF, 0xF6, 0xDF, 0xBE, 0xFC, 0xE7, 0xE7, 0x3F, 0x39,
  0xF8, 0x8F, 0xC4, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x38,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3D, 0x87, 0xB8, 0xF7, 0x1E, 0x63, 0xCE,
  0x78, 0xCF, 0x1D, 0xE3, 0xBC, 0x37, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xE0,
  0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xE6, 0x03, 0x70, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x76, 0x03, 0x38, 0x39, 0xE3,
  0xC7, 0xFC, 0x0F, 0x80, 0xFF, 0x8F, 0xFE, 0xE0, 0xEE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0E, 0xFF, 0xEF, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0,
  0xE6, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x76, 0x03, 0x38, 0x39, 0xE3, 0xC7, 0xFC, 0x0F, 0x80, 0x38, 0x01,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0x8F, 0xFE, 0xE0, 0xEE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xFF, 0xEF, 0xF8, 0xE7, 0x0E, 0x38, 0xE1,
  0x8E, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0x70, 0x0F, 0xC1, 0xFF, 0x9E, 0x1E,
  0xE0, 0x46, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xB0, 0x1B, 0xC1, 0xCF, 0xFC, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x7B,
  0xFE, 0x3F, 0x80, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0, 0x67, 0x07, 0x38,
  0x38, 0xC1, 0xC7, 0x1C, 0x38, 0xE1, 0xC7, 0x06, 0x30, 0x3B, 0x81, 0xDC,
  0x06, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x71, 0xE3, 0x8F, 0x1C, 0x7D, 0xB3, 0xED, 0xBF, 0x6D, 0xFB,
  0x6F, 0xDB, 0x77, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF0, 0x70,
  0x1C, 0x70, 0x70, 0xE0, 0xE0, 0xE3, 0x80, 0xE7, 0x01, 0xDC, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x3B, 0x80, 0x77, 0x01, 0xC7, 0x03,
  0x8E, 0x0E, 0x0E, 0x38, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x38, 0xE0,
  0xE1, 0xC1, 0xC1, 0xC7, 0x03, 0x8E, 0x03, 0xB8, 0x07, 0x70, 0x07, 0xC0,
  0x0F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x7F, 0xF3, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x07, 0x00,
  0x7C, 0x03, 0x60, 0x3B, 0x81, 0x8C, 0x1C, 0x70, 0xC1, 0x8E, 0x0E, 0x60,
  0x37, 0x01, 0xD0, 0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0x67, 0x9C, 0x71, 0x00,
  0x1F, 0x81, 0xFE, 0x1C, 0x38, 0x41, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0x8F,
  0xFC, 0x70, 0x67, 0x03, 0x1C, 0x38, 0xFE, 0xF3, 0xE3, 0x80, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8F, 0xFC, 0xF1, 0xEE,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xF1, 0xEF,
  0xFC, 0xE7, 0x80, 0x1F, 0x87, 0xF9, 0xC3, 0xF0, 0x2E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x09, 0xC3, 0x9F, 0xE1, 0xF8, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x1E, 0x73, 0xFF, 0x78, 0xF7, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0xF3, 0xFF,
  0x1E, 0x70, 0x0F, 0x81, 0xFF, 0x0E, 0x3C, 0xE0, 0xE6, 0x03, 0x3F, 0xFB,
  0xFF, 0xEC, 0x00, 0x60, 0x03, 0x81, 0x0E, 0x1C, 0x7F, 0xC0, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC3, 0xF0, 0x7F, 0xC3,
  0x8E, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x38, 0xE1, 0xFE, 0x07, 0xE0, 0x60,
  0x07, 0x00, 0x1F, 0xF0, 0x7F, 0xEC, 0x07, 0xE0, 0x1B, 0x01, 0xDF, 0xFC,
  0x7F, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xE7,
  0x7E, 0xF1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0x80, 0x0E, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0x81, 0xC0, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFD, 0xFE, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xDC, 0x38,
  0xE3, 0x87, 0x38, 0x3B, 0x81, 0xFC, 0x0F, 0xF0, 0x7B, 0x83, 0x8E, 0x1C,
  0x38, 0xE1, 0xE7, 0x07, 0x38, 0x1E, 0xFE, 0x1F, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF, 0xFF, 0x80, 0xCC, 0x76, 0xF7,
  0xB9, 0xCF, 0xCE, 0x7C, 0x71, 0xE3, 0x8F, 0x1C, 0x78, 0xE3, 0xC7, 0x1E,
  0x38, 0xF1, 0xC7, 0x8E, 0x3C, 0x71, 0x80, 0xE7, 0x9D, 0xFB, 0xC7, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0E, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xE6, 0x03, 0x70, 0x1F, 0x80,
  0xFC, 0x07, 0x60, 0x33, 0x83, 0x9E, 0x3C, 0x7F, 0xC0, 0xF8, 0x00, 0xE7,
  0x8F, 0xFC, 0xF1, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0E, 0xF1, 0xEF, 0xFC, 0xE7, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x1E, 0x73, 0xFF, 0x78, 0xF7, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0xF3, 0xFF, 0x1E, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xFC, 0xFF, 0xDF, 0x1D, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xC3, 0xFF, 0x70, 0x67, 0x04, 0x70, 0x03, 0xF0, 0x1F, 0xE0,
  0x3F, 0x00, 0x74, 0x07, 0x70, 0x7F, 0xFE, 0x1F, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x07, 0xF0, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xC7, 0xBF, 0xF3, 0xEE, 0xE0, 0x3B, 0x81, 0x9C, 0x1C, 0xE0, 0xE3,
  0x06, 0x1C, 0x70, 0x63, 0x83, 0x18, 0x1D, 0xC0, 0x6C, 0x03, 0x60, 0x1F,
  0x00, 0x70, 0x00, 0xE3, 0x8E, 0xC7, 0x19, 0x8E, 0x33, 0x14, 0x66, 0x6C,
  0xCC, 0xD9, 0x9D, 0xB3, 0x1B, 0x6C, 0x34, 0x58, 0x68, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x80, 0xF0, 0x7B, 0xC3, 0x8E, 0x38, 0x3B, 0x80, 0xF8,
  0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x1D, 0xC0, 0xCE, 0x0E, 0x38, 0xE0, 0xEE,
  0x07, 0x80, 0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0xE0, 0xE3, 0x86, 0x1C, 0x70,
  0x63, 0x03, 0xB8, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x7F,
  0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0xE3, 0xF8, 0x7F, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x3F, 0x87, 0xF1, 0xC0,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x0F, 0xE1, 0xFC,
  0x00, 0x3C, 0x1B, 0xF0, 0xD9, 0x8C, 0xC6, 0x6C, 0x3F, 0x60, 0xF0,
};

const GFXglyph IBMPlexMono_Medium25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 17, 15, 5, -17 },
  { 12, 7, 7, 15, 4, -19 },
  { 19, 15, 17, 15, 0, -17 },
  { 51, 13, 23, 15, 1, -20 },
  { 89, 15, 17, 15, 0, -17 },
  { 121, 15, 17, 15, 0, -17 },
  { 153, 3, 7, 15, 6, -19 },
  { 156, 8, 22, 15, 5, -19 },
  { 178, 8, 22, 15, 2, -19 },
  { 200, 13, 13, 15, 1, -14 },
  { 222, 11, 12, 15, 2, -14 },
  { 239, 5, 8, 15, 5, -4 },
  { 244, 7, 2, 15, 4, -9 },
  { 246, 5, 4, 15, 5, -4 },
  { 249, 11, 22, 15, 2, -19 },
  { 280, 13, 17, 15, 1, -17 },
  { 308, 13, 17, 15, 1, -17 },
  { 336, 13, 17, 15, 1, -17 },
  { 364, 12, 17, 15, 1, -17 },
  { 390, 13, 17, 15, 1, -17 },
  { 418, 13, 17, 15, 1, -17 },
  { 446, 13, 17, 15, 1, -17 },
  { 474, 13, 17, 15, 1, -17 },
  { 502, 13, 17, 15, 1, -17 },
  { 530, 13, 17, 15, 1, -17 },
  { 558, 5, 13, 15, 5, -13 },
  { 567, 5, 17, 15, 5, -13 },
  { 578, 11, 15, 15, 2, -15 },
  { 599, 11, 7, 15, 2, -11 },
  { 609, 11, 15, 15, 2, -15 },
  { 630, 11, 17, 15, 2, -17 },
  { 654, 12, 20, 15, 1, -17 },
  { 684, 15, 17, 15, 0, -17 },
  { 716, 12, 17, 15, 2, -17 },
  { 742, 13, 17, 15, 1, -17 },
  { 770, 12, 17, 15, 2, -17 },
  { 796, 11, 17, 15, 2, -17 },
  { 820, 11, 17, 15, 2, -17 },
  { 844, 12, 17, 15, 1, -17 },
  { 870, 11, 17, 15, 2, -17 },
  { 894, 11, 17, 15, 2, -17 },
  { 918, 11, 17, 15, 1, -17 },
  { 942, 13, 17, 15, 2, -17 },
  { 970, 10, 17, 15, 3, -17 },
  { 992, 13, 17, 15, 1, -17 },
  { 1020, 11, 17, 15, 2, -17 },
  { 1044, 13, 17, 15, 1, -17 },
  { 1072, 12, 17, 15, 2, -17 },
  { 1098, 13, 21, 15, 1, -17 },
  { 1133, 12, 17, 15, 2, -17 },
  { 1159, 13, 17, 15, 1, -17 },
  { 1187, 13, 17, 15, 1, -17 },
  { 1215, 11, 17, 15, 2, -17 },
  { 1239, 13, 17, 15, 1, -17 },
  { 1267, 13, 17, 15, 1, -17 },
  { 1295, 15, 17, 15, 0, -17 },
  { 1327, 15, 17, 15, 0, -17 },
  { 1359, 13, 17, 15, 1, -17 },
  { 1387, 8, 22, 15, 5, -19 },
  { 1409, 11, 22, 15, 2, -19 },
  { 1440, 8, 22, 15, 2, -19 },
  { 1462, 13, 11, 15, 1, -17 },
  { 1480, 13, 2, 15, 1, 2 },
  { 1484, 5, 5, 15, 4, -19 },
  { 1488, 13, 13, 15, 1, -13 },
  { 1510, 12, 19, 15, 2, -19 },
  { 1539, 11, 13, 15, 2, -13 },
  { 1557, 12, 19, 15, 1, -19 },
  { 1586, 13, 13, 15, 1, -13 },
  { 1608, 12, 19, 15, 2, -19 },
  { 1637, 13, 20, 15, 1, -15 },
  { 1670, 11, 19, 15, 2, -19 },
  { 1697, 11, 19, 15, 3, -19 },
  { 1724, 9, 24, 15, 2, -19 },
  { 1751, 13, 19, 15, 2, -19 },
  { 1782, 11, 19, 15, 2, -19 },
  { 1809, 13, 13, 15, 1, -13 },
  { 1831, 11, 13, 15, 2, -13 },
  { 1849, 13, 13, 15, 1, -13 },
  { 1871, 12, 18, 15, 2, -13 },
  { 1898, 12, 18, 15, 1, -13 },
  { 1925, 12, 13, 15, 2, -13 },
  { 1945, 12, 13, 15, 1, -13 },
  { 1965, 12, 17, 15, 1, -17 },
  { 1991, 11, 13, 15, 2, -13 },
  { 2009, 13, 13, 15, 1, -13 },
  { 2031, 15, 13, 15, 0, -13 },
  { 2056, 13, 13, 15, 1, -13 },
  { 2078, 13, 18, 15, 1, -13 },
  { 2108, 11, 13, 15, 2, -13 },
  { 2126, 11, 22, 15, 2, -19 },
  { 2157, 3, 22, 15, 6, -19 },
  { 2166, 11, 22, 15, 2, -19 },
  { 2197, 13, 6, 15, 1, -10 },
};

const GFXfont IBMPlexMono_Medium25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_MEDIUM25PT7B_H_
