#ifndef _IBMPLEXMONO_MEDIUM12PT7B_H_
#define _IBMPLEXMONO_MEDIUM12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium12pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x8F, 0xB6, 0xD0, 0x14, 0x49, 0xB9, 0x42, 0x9D, 0xCA, 0x2C,
  0x21, 0xEA, 0xE8, 0xE0, 0xE2, 0xEB, 0xF8, 0x80, 0x63, 0x2A, 0x73, 0x00,
  0xE6, 0x54, 0xE7, 0x38, 0x91, 0x01, 0x37, 0x5B, 0xB3, 0x3B, 0xF0, 0x36,
  0x44, 0x88, 0x84, 0x46, 0x30, 0xC2, 0x21, 0x11, 0x11, 0x22, 0xC0, 0x10,
  0x21, 0xFC, 0xC2, 0x8C, 0x80, 0x21, 0x3E, 0x42, 0x00, 0x69, 0x40, 0xE0,
  0xF0, 0x08, 0xC4, 0x23, 0x10, 0x88, 0x42, 0x20, 0x72, 0x28, 0xEB, 0xAE,
  0x38, 0x9C, 0x73, 0xCB, 0x0C, 0x30, 0xC3, 0x3F, 0x72, 0x20, 0x82, 0x11,
  0x8C, 0x3F, 0x39, 0x10, 0x4E, 0x04, 0x14, 0x7E, 0x0C, 0x38, 0xB3, 0x64,
  0xDF, 0xC3, 0x06, 0xFA, 0x08, 0x2E, 0xC8, 0x38, 0x9C, 0x31, 0x8C, 0x2E,
  0xCA, 0x38, 0x9C, 0xFC, 0x46, 0x21, 0x18, 0x8C, 0x7A, 0x28, 0x9C, 0x8A,
  0x38, 0x9E, 0x72, 0x28, 0xE3, 0xF8, 0x21, 0x18, 0xF0, 0xF0, 0x6C, 0x06,
  0x94, 0x09, 0xD9, 0x06, 0x1C, 0x20, 0xF8, 0x3E, 0x87, 0x0E, 0x13, 0xF2,
  0x00, 0x74, 0x42, 0x62, 0x01, 0x8C, 0x74, 0x6F, 0x5A, 0xD6, 0xF0, 0x70,
  0x18, 0x50, 0xA1, 0x66, 0x4F, 0x91, 0xE3, 0xFA, 0x28, 0xBC, 0x8A, 0x38,
  0xBE, 0x7B, 0x28, 0x60, 0x82, 0x0C, 0xDE, 0xF2, 0x28, 0xA3, 0x8E, 0x28,
  0xBC, 0xFC, 0x21, 0xF8, 0x42, 0x1F, 0xFC, 0x21, 0xF8, 0x42, 0x10, 0x74,
  0x61, 0x09, 0xC6, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF9, 0x08, 0x42,
  0x10, 0x9F, 0x78, 0x42, 0x10, 0x86, 0x6E, 0x8E, 0x6B, 0x28, 0xF3, 0x68,
  0xA3, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xCF, 0x7D, 0xEF, 0xAE, 0xB8, 0xE3,
  0xCE, 0x7B, 0x5A, 0xCE, 0x73, 0x72, 0x28, 0xE3, 0x8E, 0x38, 0x9C, 0xFA,
  0x28, 0xE2, 0xFA, 0x08, 0x20, 0x72, 0x28, 0xE3, 0x8E, 0x38, 0x9C, 0x20,
  0xE0, 0xFA, 0x28, 0xE2, 0xFA, 0x49, 0xA3, 0x3C, 0x89, 0x03, 0x80, 0xC0,
  0xD1, 0x7E, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x8C, 0x63, 0x18,
  0xC6, 0x2F, 0xC6, 0x89, 0x13, 0x22, 0xC5, 0x0E, 0x0C, 0xC3, 0x87, 0x4A,
  0xD6, 0xED, 0x9B, 0x36, 0xC6, 0xC8, 0xA0, 0xC3, 0x85, 0x19, 0x63, 0xC6,
  0x89, 0xB1, 0x43, 0x82, 0x04, 0x08, 0xF8, 0x21, 0x0C, 0x61, 0x08, 0x3F,
  0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0x82, 0x10, 0x82, 0x10, 0xC2, 0x10,
  0xC2, 0xF1, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x50, 0xB2, 0x2C, 0x60,
  0xF8, 0xB4, 0x72, 0x60, 0xBE, 0x8B, 0xF0, 0x82, 0x08, 0x2E, 0xCA, 0x38,
  0xE2, 0xF8, 0x7E, 0x61, 0x0C, 0xBC, 0x08, 0x42, 0xD9, 0xC6, 0x31, 0x78,
  0x74, 0x7F, 0x0C, 0xBC, 0x3C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0xF8, 0x0D,
  0xE8, 0xA2, 0x72, 0x07, 0xA1, 0xF8, 0x84, 0x21, 0x7C, 0xC6, 0x31, 0x88,
  0x30, 0xC0, 0x3C, 0x30, 0xC3, 0x0C, 0xFC, 0x11, 0x0F, 0x11, 0x11, 0x11,
  0xF0, 0x82, 0x08, 0x23, 0x92, 0x8D, 0x26, 0x8C, 0xE1, 0x08, 0x42, 0x10,
  0x84, 0xF8, 0xFA, 0xBA, 0x69, 0xA6, 0x90, 0xBE, 0x63, 0x18, 0xC4, 0x72,
  0x28, 0xE3, 0x89, 0xC0, 0xBB, 0x28, 0xE3, 0x8B, 0xE8, 0x20, 0x6C, 0xE3,
  0x18, 0xBC, 0x21, 0xEC, 0xC2, 0x08, 0x23, 0xE0, 0x7C, 0x78, 0x78, 0xFC,
  0x30, 0xCF, 0xCC, 0x30, 0xC3, 0x07, 0x8C, 0x63, 0x18, 0xBC, 0x8E, 0x25,
  0x94, 0x50, 0xC0, 0x93, 0xB5, 0xAB, 0x66, 0xCD, 0x80, 0xCD, 0x43, 0x1C,
  0x5A, 0x30, 0xC6, 0x88, 0xB1, 0x43, 0x82, 0x04, 0x30, 0xF8, 0xCC, 0xCC,
  0x7C, 0x39, 0x08, 0x61, 0x70, 0xC6, 0x21, 0x0E, 0xFF, 0xE0, 0xE1, 0x88,
  0x46, 0x0D, 0x84, 0x21, 0xB8, 0xC6, 0xA9, 0x80,
};

const GFXglyph IBMPlexMono_Medium12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 3, -8 },
  { 3, 3, 4, 7, 2, -9 },
  { 5, 7, 8, 7, 0, -8 },
  { 12, 6, 10, 7, 1, -9 },
  { 20, 7, 8, 7, 0, -8 },
  { 27, 7, 8, 7, 0, -8 },
  { 34, 1, 4, 7, 3, -9 },
  { 35, 4, 11, 7, 2, -9 },
  { 41, 4, 11, 7, 1, -9 },
  { 47, 7, 6, 7, 0, -7 },
  { 53, 5, 5, 7, 1, -6 },
  { 57, 3, 4, 7, 2, -2 },
  { 59, 3, 1, 7, 2, -4 },
  { 60, 2, 2, 7, 3, -2 },
  { 61, 5, 11, 7, 1, -9 },
  { 68, 6, 8, 7, 1, -8 },
  { 74, 6, 8, 7, 1, -8 },
  { 80, 6, 8, 7, 1, -8 },
  { 86, 6, 8, 7, 0, -8 },
  { 92, 7, 8, 7, 0, -8 },
  { 99, 6, 8, 7, 1, -8 },
  { 105, 6, 8, 7, 1, -8 },
  { 111, 5, 8, 7, 1, -8 },
  { 116, 6, 8, 7, 1, -8 },
  { 122, 6, 8, 7, 1, -8 },
  { 128, 2, 6, 7, 3, -6 },
  { 130, 3, 8, 7, 2, -6 },
  { 133, 5, 7, 7, 1, -7 },
  { 138, 5, 3, 7, 1, -5 },
  { 140, 5, 7, 7, 1, -7 },
  { 145, 5, 8, 7, 1, -8 },
  { 150, 5, 9, 7, 1, -8 },
  { 156, 7, 8, 7, 0, -8 },
  { 163, 6, 8, 7, 1, -8 },
  { 169, 6, 8, 7, 1, -8 },
  { 175, 6, 8, 7, 1, -8 },
  { 181, 5, 8, 7, 1, -8 },
  { 186, 5, 8, 7, 1, -8 },
  { 191, 5, 8, 7, 1, -8 },
  { 196, 5, 8, 7, 1, -8 },
  { 201, 5, 8, 7, 1, -8 },
  { 206, 5, 8, 7, 1, -8 },
  { 211, 6, 8, 7, 1, -8 },
  { 217, 5, 8, 7, 1, -8 },
  { 222, 6, 8, 7, 1, -8 },
  { 228, 5, 8, 7, 1, -8 },
  { 233, 6, 8, 7, 1, -8 },
  { 239, 6, 8, 7, 1, -8 },
  { 245, 6, 10, 7, 1, -8 },
  { 253, 6, 8, 7, 1, -8 },
  { 259, 7, 8, 7, 0, -8 },
  { 266, 7, 8, 7, 0, -8 },
  { 273, 5, 8, 7, 1, -8 },
  { 278, 7, 8, 7, 0, -8 },
  { 285, 7, 8, 7, 0, -8 },
  { 292, 7, 8, 7, 0, -8 },
  { 299, 7, 8, 7, 0, -8 },
  { 306, 6, 8, 7, 1, -8 },
  { 312, 4, 11, 7, 2, -9 },
  { 318, 5, 11, 7, 1, -9 },
  { 325, 4, 11, 7, 1, -9 },
  { 331, 7, 5, 7, 0, -8 },
  { 336, 5, 1, 7, 1, 1 },
  { 337, 2, 3, 7, 2, -10 },
  { 338, 6, 6, 7, 1, -6 },
  { 343, 6, 9, 7, 1, -9 },
  { 350, 5, 6, 7, 1, -6 },
  { 354, 5, 9, 7, 1, -9 },
  { 360, 5, 6, 7, 1, -6 },
  { 364, 6, 9, 7, 1, -9 },
  { 371, 6, 9, 7, 1, -7 },
  { 378, 5, 9, 7, 1, -9 },
  { 384, 6, 9, 7, 1, -9 },
  { 391, 4, 11, 7, 1, -9 },
  { 397, 6, 9, 7, 1, -9 },
  { 404, 5, 9, 7, 1, -9 },
  { 410, 6, 6, 7, 1, -6 },
  { 415, 5, 6, 7, 1, -6 },
  { 419, 6, 6, 7, 1, -6 },
  { 424, 6, 8, 7, 1, -6 },
  { 430, 5, 8, 7, 1, -6 },
  { 435, 6, 6, 7, 1, -6 },
  { 440, 5, 6, 7, 1, -6 },
  { 444, 6, 8, 7, 0, -8 },
  { 450, 5, 6, 7, 1, -6 },
  { 454, 6, 6, 7, 1, -6 },
  { 459, 7, 6, 7, 0, -6 },
  { 465, 6, 6, 7, 1, -6 },
  { 470, 7, 8, 7, 0, -6 },
  { 477, 5, 6, 7, 1, -6 },
  { 481, 5, 11, 7, 1, -9 },
  { 488, 1, 11, 7, 3, -9 },
  { 490, 5, 11, 7, 1, -9 },
  { 497, 6, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_Medium12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_MEDIUM12PT7B_H_
