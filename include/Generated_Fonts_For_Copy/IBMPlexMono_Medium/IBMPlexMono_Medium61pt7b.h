#ifndef _IBMPLEXMONO_MEDIUM61PT7B_H_
#define _IBMPLEXMONO_MEDIUM61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium61pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0xFC, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0xF9, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F,
  0xFE, 0x07, 0xFF, 0xE7, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFE, 0x7F,
  0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x3C, 0xFF,
  0xC7, 0xF0, 0x78, 0x7F, 0x9F, 0xC0, 0xF0, 0x3C, 0x3F, 0x81, 0xE0, 0x30,
  0x7F, 0x03, 0xC0, 0x40, 0xFE, 0x07, 0x80, 0x01, 0xFC, 0x0F, 0x00, 0x03,
  0xF8, 0x1E, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x0F,
  0xF0, 0xF0, 0x00, 0x1F, 0xF9, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xEF, 0xFE, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x0F,
  0x03, 0xF8, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x78,
  0x0F, 0xC4, 0x00, 0xF0, 0x1F, 0x8C, 0x01, 0xE0, 0x7F, 0x3C, 0x03, 0xC0,
  0xFE, 0xFC, 0x07, 0x83, 0xFB, 0xFE, 0x0F, 0x0F, 0xF7, 0xFF, 0x1E, 0x7F,
  0xC7, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE1, 0xFF, 0x80, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x3F,
  0x1F, 0xFF, 0x80, 0x07, 0xC7, 0xFF, 0xF8, 0x01, 0xF8, 0xFC, 0x3F, 0x80,
  0x3E, 0x3F, 0x03, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xF0, 0x7C,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xE0,
  0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0xC7,
  0xE0, 0x0F, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xFC, 0x3F, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xC7, 0xFF, 0xF0, 0x03, 0xF1, 0xFF, 0xFE, 0x00, 0x7C, 0x3F,
  0x07, 0xE0, 0x1F, 0x87, 0xC0, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0x80, 0xFC,
  0x3E, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x1F, 0x00, 0x7C, 0x3F, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x01,
  0xF1, 0xF8, 0x0F, 0xC0, 0x7C, 0x3E, 0x00, 0xF8, 0x0F, 0x8F, 0xC0, 0x1F,
  0x83, 0xF1, 0xF0, 0x03, 0xFF, 0xFC, 0x7C, 0x00, 0x3F, 0xFF, 0x9F, 0x80,
  0x03, 0xFF, 0xE3, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x06, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0x8F, 0xE0,
  0xFF, 0xC7, 0xE1, 0xFC, 0x1F, 0x01, 0xFC, 0x1F, 0xC3, 0xE0, 0x3F, 0x01,
  0xFC, 0x7C, 0x07, 0xE0, 0x1F, 0xCF, 0x81, 0xFC, 0x01, 0xF9, 0xE0, 0x3F,
  0x80, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xF8,
  0x1E, 0x7F, 0x81, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0x01,
  0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x40, 0x07, 0xE0, 0x02, 0x38, 0x07, 0xE0,
  0x1E, 0x7F, 0x07, 0xE0, 0xFE, 0x7F, 0xE7, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xF1, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F,
  0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x0F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xFF,
  0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF,
  0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC,
  0x0F, 0x81, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x08,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x87, 0x80, 0x00, 0xFE, 0x04, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x0E, 0x00, 0x07, 0xF8, 0x08, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x04, 0x00,
  0x01, 0xFE, 0x18, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x03, 0xF0, 0xFF, 0xF0,
  0x1F, 0x8F, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0x87, 0xEF, 0xFF, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF1, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x08, 0x00, 0x03, 0xF8, 0xE0, 0x00, 0x1F, 0xCF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x3F,
  0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x1F, 0xFE, 0x00, 0xFC, 0xFF, 0xFF,
  0x03, 0xFB, 0xFF, 0xFF, 0x07, 0xF7, 0xFF, 0xFF, 0x0F, 0xDE, 0x03, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x01,
  0xFC, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xFE, 0x7E, 0x07,
  0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0x8F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0x0F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0xDF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0x00, 0x1F, 0x83, 0xFE,
  0x7F, 0xE7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF3, 0xFE,
  0x3F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7,
  0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7E, 0x00,
  0x0F, 0xE0, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0xF8, 0xFD, 0xF0, 0x0F,
  0xF3, 0xF7, 0xC0, 0x7F, 0xE7, 0xDF, 0x03, 0xFF, 0xDF, 0x7C, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xC1, 0xF8, 0x0F, 0xFF, 0x07, 0xC0, 0x3F,
  0xFC, 0x1F, 0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xC3, 0xF0, 0x07, 0xFF,
  0x0F, 0xC0, 0x1F, 0xFC, 0x3F, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0xC3,
  0xF0, 0x07, 0xFF, 0x0F, 0xC0, 0x1F, 0xFC, 0x3F, 0x00, 0x7F, 0xF0, 0x7C,
  0x03, 0xFF, 0xC1, 0xF0, 0x0F, 0xFF, 0x07, 0xE0, 0x3F, 0x7C, 0x1F, 0xE3,
  0xFD, 0xF0, 0x3F, 0xFD, 0xF7, 0xC0, 0xFF, 0xE7, 0xDF, 0x01, 0xFF, 0x9F,
  0x7C, 0x03, 0xFC, 0x7D, 0xF8, 0x03, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xE7, 0xF0,
  0x00, 0x18, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x30, 0x7F,
  0x00, 0x01, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x07, 0xF8,
  0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80,
  0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xE7,
  0xF0, 0x00, 0x18, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F,
  0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0,
  0x77, 0xE1, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0x8F,
  0xC0, 0x7F, 0xF8, 0x7E, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x1C, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x9F, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x1F,
  0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0xFF,
  0x00, 0x03, 0xFB, 0xFE, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xF8,
  0x00, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF7, 0xC0, 0x7F,
  0xFF, 0xDF, 0x83, 0xEF, 0xFF, 0x3E, 0x0F, 0xBF, 0xFC, 0xF8, 0x3E, 0xFF,
  0xF3, 0xF1, 0xF3, 0xFF, 0xC7, 0xC7, 0xCF, 0xFF, 0x1F, 0x9F, 0x3F, 0xFC,
  0x7E, 0xF8, 0xFF, 0xF0, 0xFB, 0xE3, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x07,
  0xFC, 0x3F, 0xFC, 0x1F, 0xF0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC0, 0xFE,
  0x0F, 0xFF, 0x03, 0xF8, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x1F, 0x03,
  0xFF, 0xC0, 0x78, 0x0F, 0xFF, 0x00, 0xE0, 0x3F, 0xFC, 0x03, 0x80, 0xFF,
  0xF0, 0x0C, 0x03, 0xFF, 0xC0, 0x10, 0x0F, 0xFF, 0x00, 0x80, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xF8, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC,
  0xFC, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xC7, 0xE0,
  0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x3F, 0x03, 0xFF,
  0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x0F,
  0xC3, 0xFF, 0xC0, 0xFC, 0x3F, 0xFC, 0x0F, 0xC3, 0xFF, 0xC0, 0x7E, 0x3F,
  0xFC, 0x07, 0xE3, 0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x03, 0xF3, 0xFF, 0xC0,
  0x3F, 0x3F, 0xFC, 0x01, 0xFB, 0xFF, 0xC0, 0x1F, 0xBF, 0xFC, 0x01, 0xFB,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFD,
  0xFC, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF3, 0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x01, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x8F, 0xF0, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0x60, 0xFE, 0x00, 0x00, 0x81,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x00,
  0xFE, 0x18, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xCF, 0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE,
  0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xBF, 0x01, 0xFC, 0x07, 0xDF,
  0x80, 0xFE, 0x03, 0xEF, 0xC0, 0x7F, 0x01, 0xF7, 0xE0, 0x7F, 0x81, 0xF9,
  0xF0, 0x3F, 0xE0, 0xFC, 0xF8, 0x1F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF8, 0x3F,
  0x3F, 0x07, 0xFC, 0x1F, 0x9F, 0x87, 0xDE, 0x0F, 0xCF, 0xC3, 0xEF, 0x87,
  0xE7, 0xE1, 0xF7, 0xC3, 0xF3, 0xF0, 0xF3, 0xE1, 0xF9, 0xF8, 0x79, 0xF0,
  0xFC, 0xFC, 0x7C, 0x78, 0x7C, 0x7E, 0x3E, 0x3C, 0x3E, 0x3F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x8F, 0x8F, 0x8F, 0x8F, 0xC7, 0x87, 0xC7, 0xC3, 0xE3, 0xC3,
  0xE3, 0xE1, 0xF3, 0xE0, 0xF3, 0xF0, 0xF9, 0xF0, 0x7D, 0xF8, 0x7C, 0xF8,
  0x3E, 0xFC, 0x3E, 0x7C, 0x1F, 0x7E, 0x1F, 0xBC, 0x0F, 0xBF, 0x0F, 0xFE,
  0x07, 0xDF, 0x87, 0xFF, 0x01, 0xEF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0x3C, 0x00, 0x00, 0x3E, 0x0C, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x01, 0xE0, 0x7E, 0x0F, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x01, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xE0, 0x03, 0xF8, 0x0F, 0x00, 0x0F, 0xF0, 0x08, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x3F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x3B, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFC, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFC, 0x3F, 0xC3, 0xFF,
  0xC0, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x1F, 0xFC, 0x0F, 0xC7,
  0xFF, 0xF0, 0xFC, 0x7F, 0xFF, 0x8F, 0xCF, 0xFF, 0xF8, 0xFD, 0xE0, 0x7F,
  0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFD, 0xE0, 0x7F, 0xCF, 0xCF, 0xFF, 0xF8, 0xFC, 0x7F, 0xFF,
  0x8F, 0xC7, 0xFF, 0xF0, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x8F, 0xE0, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x83, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x7F, 0x00, 0x07, 0x8F,
  0xE0, 0x00, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x1F, 0xE1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0x0F, 0xE0, 0xFF, 0xFC,
  0x7F, 0x0F, 0xFF, 0xF3, 0xF8, 0xFF, 0xFF, 0xDF, 0xCF, 0xFC, 0x0E, 0xFE,
  0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x1F,
  0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x3B, 0xF8, 0xFF, 0xFF, 0xDF, 0xC3,
  0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xC7, 0xF0, 0x3F, 0xFC, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x30, 0x7F, 0x00, 0x01, 0xC1, 0xFC, 0x00, 0x1F,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F,
  0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xFF, 0x07, 0xF1,
  0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0x1F, 0xDF, 0xFF, 0xF3, 0xFB, 0x83, 0xFE,
  0x7F, 0xC0, 0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC3, 0xF8,
  0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFE, 0xFE, 0x00, 0x3F, 0xF1, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00,
  0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F,
  0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xE1, 0xF1, 0xFC, 0x1F, 0xF3,
  0xE7, 0xFC, 0x7F, 0xE7, 0xDF, 0xFC, 0xFF, 0xEF, 0xBF, 0xFB, 0xFF, 0xDF,
  0xC3, 0xF6, 0x1F, 0xBF, 0x03, 0xF8, 0x1F, 0xFE, 0x07, 0xE0, 0x3F, 0xF8,
  0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xC0,
  0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x0F, 0xFE, 0x03,
  0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F,
  0x80, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x80, 0xFC,
  0x07, 0xFF, 0x01, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xE0,
  0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFF, 0xE0, 0x3F, 0x01,
  0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x0F,
  0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F,
  0xC3, 0xFF, 0x83, 0xF8, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0x8F, 0xEF, 0xFF,
  0xF9, 0xFD, 0xC1, 0xFF, 0x3F, 0xE0, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x7E,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xC1, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0x0F, 0xC7,
  0xFF, 0xF8, 0xFC, 0xFF, 0xFF, 0x8F, 0xDE, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xDE,
  0x07, 0xFC, 0xFC, 0xFF, 0xFF, 0x8F, 0xC7, 0xFF, 0xF8, 0xFC, 0x7F, 0xFF,
  0x0F, 0xC1, 0xFF, 0xC0, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF8, 0xFE, 0x1F, 0xFF, 0xE7,
  0xF1, 0xFF, 0xFF, 0xBF, 0x9F, 0xF8, 0x1D, 0xFC, 0xFF, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE,
  0x7F, 0xE0, 0x77, 0xF1, 0xFF, 0xFF, 0xBF, 0x87, 0xFF, 0xF9, 0xFC, 0x1F,
  0xFF, 0x8F, 0xE0, 0x7F, 0xF8, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0x7F, 0xFC,
  0x03, 0xFB, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFE, 0x01, 0xFF, 0x3F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0x18, 0x7F,
  0x00, 0x01, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF1, 0x00, 0x00, 0x3F, 0x38, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xFC, 0x0E,
  0xFC, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xCF, 0xC7, 0xFF, 0xE3, 0xF0, 0x7F,
  0xF0, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x00,
  0xFE, 0x01, 0xF7, 0xC0, 0x3F, 0x80, 0x7D, 0xF0, 0x0F, 0xE0, 0x1F, 0x7C,
  0x07, 0xF8, 0x0F, 0xDF, 0x81, 0xFF, 0x03, 0xF7, 0xE0, 0x7F, 0xC0, 0xF9,
  0xF8, 0x1E, 0xF0, 0x3E, 0x7E, 0x07, 0xBC, 0x0F, 0x8F, 0x83, 0xEF, 0x03,
  0xE3, 0xE0, 0xF3, 0xE0, 0xF8, 0xF8, 0x3C, 0xF8, 0x3E, 0x3E, 0x0F, 0x1E,
  0x1F, 0x8F, 0x83, 0xC7, 0x87, 0xC3, 0xF0, 0xF1, 0xE1, 0xF0, 0xFC, 0x7C,
  0x78, 0x7C, 0x1F, 0x1E, 0x1F, 0x1F, 0x07, 0xC7, 0x87, 0xC7, 0xC1, 0xF1,
  0xE0, 0xF1, 0xF0, 0x7C, 0x78, 0x3C, 0x7C, 0x1F, 0x3E, 0x0F, 0x3E, 0x07,
  0xCF, 0x03, 0xCF, 0x81, 0xFB, 0xC0, 0xFB, 0xE0, 0x3E, 0xF0, 0x3E, 0xF8,
  0x0F, 0xBC, 0x07, 0xBE, 0x03, 0xEF, 0x01, 0xEF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x0F, 0xF8, 0x00, 0x7C, 0x3F,
  0xF8, 0x01, 0xF8, 0xFF, 0xF8, 0x03, 0xE3, 0xFF, 0xF8, 0x07, 0xC7, 0xE3,
  0xF0, 0x0F, 0x9F, 0x83, 0xF0, 0x3F, 0x3E, 0x07, 0xF0, 0x7C, 0x7C, 0x07,
  0xF1, 0xF9, 0xF8, 0x07, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0xC7, 0xC0, 0x07,
  0xFF, 0x0F, 0x80, 0x07, 0xFC, 0x07, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_Medium61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 10, 44, 37, 13, -43 },
  { 56, 18, 18, 37, 9, -45 },
  { 97, 35, 43, 37, 1, -43 },
  { 286, 31, 56, 37, 3, -49 },
  { 503, 35, 44, 37, 1, -43 },
  { 696, 35, 44, 37, 1, -43 },
  { 889, 6, 18, 37, 15, -45 },
  { 903, 19, 54, 37, 12, -46 },
  { 1032, 19, 54, 37, 6, -46 },
  { 1161, 32, 31, 37, 2, -33 },
  { 1285, 29, 29, 37, 4, -33 },
  { 1391, 12, 18, 37, 12, -9 },
  { 1418, 19, 6, 37, 9, -22 },
  { 1433, 11, 10, 37, 13, -9 },
  { 1447, 27, 54, 37, 5, -46 },
  { 1630, 31, 44, 37, 3, -43 },
  { 1801, 31, 43, 37, 3, -43 },
  { 1968, 30, 43, 37, 3, -43 },
  { 2130, 31, 44, 37, 2, -43 },
  { 2301, 33, 43, 37, 2, -43 },
  { 2479, 29, 44, 37, 4, -43 },
  { 2639, 31, 44, 37, 3, -43 },
  { 2810, 29, 43, 37, 4, -43 },
  { 2966, 31, 44, 37, 3, -43 },
  { 3137, 30, 43, 37, 3, -43 },
  { 3299, 11, 33, 37, 13, -32 },
  { 3345, 12, 41, 37, 12, -32 },
  { 3407, 26, 36, 37, 5, -37 },
  { 3524, 29, 18, 37, 4, -28 },
  { 3590, 26, 36, 37, 5, -37 },
  { 3707, 28, 44, 37, 4, -43 },
  { 3861, 30, 50, 37, 3, -43 },
  { 4049, 34, 43, 37, 1, -43 },
  { 4232, 28, 43, 37, 5, -43 },
  { 4383, 29, 44, 37, 4, -43 },
  { 4543, 29, 43, 37, 5, -43 },
  { 4699, 27, 43, 37, 5, -43 },
  { 4845, 28, 43, 37, 5, -43 },
  { 4996, 29, 44, 37, 3, -43 },
  { 5156, 28, 43, 37, 4, -43 },
  { 5307, 27, 43, 37, 5, -43 },
  { 5453, 26, 44, 37, 4, -43 },
  { 5596, 31, 43, 37, 5, -43 },
  { 5763, 26, 43, 37, 7, -43 },
  { 5903, 30, 43, 37, 3, -43 },
  { 6065, 28, 43, 37, 4, -43 },
  { 6216, 31, 44, 37, 3, -43 },
  { 6387, 29, 43, 37, 5, -43 },
  { 6543, 31, 53, 37, 3, -43 },
  { 6749, 29, 43, 37, 5, -43 },
  { 6905, 31, 44, 37, 2, -43 },
  { 7076, 33, 43, 37, 2, -43 },
  { 7254, 28, 44, 37, 4, -43 },
  { 7408, 33, 43, 37, 2, -43 },
  { 7586, 33, 43, 37, 2, -43 },
  { 7764, 35, 43, 37, 1, -43 },
  { 7953, 35, 43, 37, 1, -43 },
  { 8142, 31, 43, 37, 3, -43 },
  { 8309, 18, 54, 37, 13, -46 },
  { 8431, 27, 54, 37, 5, -46 },
  { 8614, 18, 54, 37, 6, -46 },
  { 8736, 32, 26, 37, 2, -43 },
  { 8840, 29, 6, 37, 4, 5 },
  { 8862, 12, 13, 37, 10, -48 },
  { 8882, 30, 33, 37, 4, -32 },
  { 9006, 28, 46, 37, 5, -45 },
  { 9167, 27, 33, 37, 5, -32 },
  { 9279, 29, 46, 37, 3, -45 },
  { 9446, 29, 33, 37, 4, -32 },
  { 9566, 29, 45, 37, 4, -45 },
  { 9730, 31, 49, 37, 4, -36 },
  { 9920, 27, 45, 37, 5, -45 },
  { 10072, 28, 45, 37, 6, -45 },
  { 10230, 22, 57, 37, 6, -45 },
  { 10387, 30, 45, 37, 5, -45 },
  { 10556, 27, 45, 37, 5, -45 },
  { 10708, 31, 32, 37, 3, -32 },
  { 10832, 27, 32, 37, 5, -32 },
  { 10940, 30, 33, 37, 3, -32 },
  { 11064, 28, 44, 37, 5, -32 },
  { 11218, 29, 44, 37, 3, -32 },
  { 11378, 29, 31, 37, 5, -31 },
  { 11491, 28, 33, 37, 4, -32 },
  { 11607, 30, 43, 37, 2, -43 },
  { 11769, 26, 32, 37, 5, -31 },
  { 11873, 31, 31, 37, 3, -31 },
  { 11994, 34, 31, 37, 1, -31 },
  { 12126, 31, 31, 37, 3, -31 },
  { 12247, 32, 43, 37, 2, -31 },
  { 12419, 27, 31, 37, 5, -31 },
  { 12524, 25, 54, 37, 6, -46 },
  { 12693, 6, 54, 37, 15, -46 },
  { 12734, 25, 54, 37, 6, -46 },
  { 12903, 31, 14, 37, 3, -26 },
};

const GFXfont IBMPlexMono_Medium61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_MEDIUM61PT7B_H_
