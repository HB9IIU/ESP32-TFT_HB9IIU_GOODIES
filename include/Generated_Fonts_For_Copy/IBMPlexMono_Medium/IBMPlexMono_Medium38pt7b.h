#ifndef _IBMPLEXMONO_MEDIUM38PT7B_H_
#define _IBMPLEXMONO_MEDIUM38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF0, 0xE1, 0xC3,
  0x87, 0x0E, 0x18, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0x7F, 0xFF, 0xF9,
  0xF0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E,
  0x1E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xC0,
  0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xC0, 0xFF, 0x87, 0xFB, 0xFE, 0x1F, 0xEF, 0xF8, 0xFF, 0x81, 0xE3, 0xC0,
  0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0F,
  0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xF3, 0xF7, 0x3F, 0x78, 0xE1, 0xCF, 0x1C, 0x11, 0xE3, 0x80, 0x3C, 0x70,
  0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1F, 0x38, 0x01, 0xFF, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x77, 0xE0, 0x0E, 0x3E, 0x01, 0xC3,
  0xC0, 0x38, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xEC, 0x1C, 0x3F, 0xC3, 0x8F,
  0xFE, 0x73, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x1C, 0xFF,
  0x00, 0xF3, 0xFE, 0x03, 0x9E, 0x3C, 0x1E, 0x70, 0x70, 0x71, 0xC1, 0xC3,
  0x87, 0x07, 0x1E, 0x1C, 0x1C, 0x70, 0x70, 0x73, 0xC1, 0xC1, 0xCE, 0x07,
  0x8F, 0x78, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x03, 0xDE, 0x3C, 0x0E, 0x70, 0x70, 0x71, 0xC1,
  0xC3, 0xC7, 0x07, 0x0E, 0x1C, 0x1C, 0x78, 0x70, 0x71, 0xC1, 0xC1, 0xCF,
  0x07, 0x8F, 0x38, 0x0F, 0xF9, 0xE0, 0x1F, 0xCF, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3C, 0x3E, 0x03, 0xC0, 0xE0,
  0x1E, 0x04, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x8F, 0xE0, 0xFC,
  0xFF, 0x87, 0xEF, 0x3E, 0x38, 0xF0, 0xF3, 0xC7, 0x83, 0xDC, 0x3C, 0x0F,
  0xE1, 0xE0, 0x7F, 0x0F, 0x01, 0xF8, 0x78, 0x07, 0xC3, 0xE0, 0x3F, 0x0F,
  0x87, 0x78, 0x7F, 0xF1, 0xE1, 0xFF, 0x8F, 0x83, 0xF0, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x3E, 0x03, 0x80, 0x78, 0x0F, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x04, 0x07, 0x02, 0x78, 0x71, 0xF7, 0xF7, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3D, 0xE0, 0x07, 0x8F, 0x00, 0xF8, 0xF8, 0x1F, 0x07, 0x80, 0xE0, 0x3C,
  0x04, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x78, 0xF0,
  0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC3,
  0x87, 0xF8, 0xF8, 0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x38, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x9F, 0x01, 0xE1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xBC, 0x03, 0xE7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x07, 0xC3, 0xC0, 0x70,
  0x78, 0x0C, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0x80, 0xF9, 0xF0, 0x0F, 0x8C,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x07, 0xE7,
  0xC0, 0x7C, 0x30, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF1, 0x00, 0x1E, 0x60, 0x07, 0xDE, 0x00, 0xFF, 0xF0, 0x7E, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07,
  0x9E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE3, 0xF0, 0x3D, 0xFF, 0x87, 0xBF,
  0xF8, 0xFC, 0x1F, 0x9E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF2, 0x00, 0x3E, 0x60, 0x07, 0x9E, 0x01,
  0xF7, 0xF0, 0x7C, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF3,
  0xF0, 0x3C, 0xFF, 0x8F, 0xBF, 0xF9, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xC0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x3E, 0xF0, 0x07, 0x9F, 0x01, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x07, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF0, 0xF8, 0x3E, 0x0F,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0x83, 0xE3, 0xC0, 0x1E, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xDE, 0x00, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x07, 0xC7,
  0xC0, 0x79, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x7E, 0xFC, 0x1F, 0xCF,
  0xFE, 0xF0, 0xFF, 0x9E, 0x07, 0xE7, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0xFF, 0xFF, 0xF3,
  0xE0, 0x3E, 0x7E, 0x7F, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0x70, 0xF0, 0xF0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x8F, 0x87, 0xEF, 0x80,
  0xF7, 0x80, 0x78, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x3C, 0x03, 0x9E,
  0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x79, 0xFC, 0x3F, 0x7F, 0x1F,
  0xFF, 0x87, 0x8F, 0xE1, 0xC1, 0xF8, 0xF0, 0x7E, 0x3C, 0x1F, 0x8F, 0x07,
  0xE3, 0xC1, 0xF8, 0xF0, 0x7E, 0x3C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xFC,
  0x7F, 0xF7, 0x0F, 0xDD, 0xC1, 0xF7, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00,
  0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3E, 0xFF, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x78,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xC0, 0x3E, 0xF0, 0x07, 0xBC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7B, 0xC0, 0x3E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x87, 0xE3, 0xE0, 0x3C, 0x78, 0x07,
  0xDE, 0x00, 0x73, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1C,
  0x78, 0x07, 0xCF, 0x80, 0xF0, 0xF8, 0x7E, 0x1F, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC,
  0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E,
  0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x3C, 0x07, 0xDE,
  0x00, 0xF7, 0x80, 0x3B, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDE,
  0x00, 0xF7, 0xC0, 0x7C, 0xF8, 0x3F, 0x1F, 0xFB, 0xC3, 0xFC, 0xF0, 0x7E,
  0x3C, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF1, 0x00, 0xFF, 0xC0, 0x79, 0xE0, 0x3C, 0xF8, 0x3E,
  0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB,
  0xC0, 0x3E, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x3C, 0x1F, 0x07,
  0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x3E, 0x03, 0xCF, 0x80, 0x7B, 0xE0, 0x0F,
  0x7E, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xF7, 0xC0, 0xFC, 0xF8, 0x1F,
  0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x1F, 0x0F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C,
  0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x07, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0x80,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0x7F, 0xB8,
  0xEF, 0xF7, 0x1D, 0xFE, 0xF7, 0x3F, 0xCE, 0xE7, 0xF9, 0xFC, 0xFF, 0x1F,
  0x1F, 0xE3, 0xE3, 0xFC, 0x78, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x18,
  0x3F, 0xC1, 0x07, 0xF8, 0x20, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xBC, 0x1F, 0xDE, 0x0F, 0xE7, 0x07, 0xF3, 0xC3, 0xF9, 0xE1, 0xFC, 0x78,
  0xFE, 0x3C, 0x7F, 0x0E, 0x3F, 0x87, 0x9F, 0xC3, 0xCF, 0xE0, 0xE7, 0xF0,
  0x7B, 0xF8, 0x3D, 0xFC, 0x0E, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0x9E,
  0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0x9F, 0x01, 0xE1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x3E, 0xF0,
  0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07,
  0xC7, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9F, 0x01, 0xE1, 0xF0, 0x7C,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1E, 0xF0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F,
  0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7C, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xF0, 0x3F, 0x3E, 0x01, 0xC3,
  0xC0, 0x08, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x20, 0x01, 0xF3, 0x00, 0x1E, 0x78, 0x03, 0xEF, 0xE0, 0x7E, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3C, 0xF8, 0x3E, 0x7F, 0xFE, 0x1F,
  0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9E, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81,
  0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xF1, 0xF0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x1F, 0x0E,
  0x70, 0xF8, 0x73, 0x87, 0xC3, 0x9C, 0x3E, 0x1C, 0xE3, 0xF0, 0xE7, 0x1D,
  0xCF, 0x38, 0xEE, 0x79, 0xE7, 0x73, 0xCF, 0x3B, 0x9E, 0x79, 0x9C, 0xF3,
  0xDC, 0x77, 0x9E, 0xE3, 0xBC, 0xF7, 0x1D, 0xC7, 0xB8, 0xEE, 0x3D, 0xC7,
  0x70, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x7C, 0x07,
  0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07,
  0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3E,
  0xF8, 0x01, 0xE3, 0xC0, 0x1F, 0x1F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xE0,
  0xF8, 0x0F, 0x07, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0x80, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x79, 0xF0, 0x07,
  0x8F, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0x81, 0xE0, 0x7C, 0x1E, 0x03, 0xC3,
  0xC0, 0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0xFB, 0x00, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x78, 0xF8, 0x3C,
  0x3C, 0x1E, 0x0E, 0x05, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3E,
  0x0F, 0x83, 0x00, 0xF0, 0x60, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xC0, 0x79, 0xF0,
  0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x7C, 0x7C, 0x1F, 0x8F, 0xFE, 0xFC, 0xFF,
  0x8F, 0x87, 0xE0, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xF8,
  0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xF0, 0x7C, 0xF8, 0x0F, 0xBC, 0x01, 0xEF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x3E, 0xF4, 0x1F,
  0x3D, 0xFF, 0xCF, 0x3F, 0xE3, 0xC3, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0x0F,
  0xFF, 0xC7, 0xC3, 0xE7, 0x80, 0x7B, 0xC0, 0x23, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x08, 0xF0, 0x0F, 0x3E, 0x0F, 0x9F, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0xC3, 0xC7, 0xFC,
  0xF3, 0xFF, 0xBD, 0xF8, 0x2F, 0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0x7E, 0x0B, 0xCF, 0xFE,
  0xF1, 0xFF, 0x3C, 0x1F, 0x0F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0x07, 0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x43, 0xE0, 0x1C, 0x3E, 0x0F, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3E,
  0x0F, 0x83, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x3C, 0x07, 0x83, 0xE0, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE3, 0x80, 0x1E, 0x70, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3E, 0x7F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0xF8, 0x79, 0xFF, 0x3D,
  0xFF, 0x9E, 0x83, 0xEF, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xDE, 0x01, 0xF3, 0xC0, 0x7C, 0x78,
  0x1F, 0x0F, 0x07, 0xC1, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xF7,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7C, 0x0F, 0x87, 0xC1, 0xE0,
  0xF8, 0x3C, 0x0F, 0x87, 0x80, 0xF8, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0,
  0x1F, 0x78, 0x01, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x87, 0x9D, 0xF9, 0xFB, 0xBF, 0x7F, 0xF8,
  0xF8, 0xFE, 0x1E, 0x1F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0,
  0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1,
  0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83,
  0x83, 0xF0, 0x70, 0x70, 0xF0, 0xF8, 0x79, 0xFF, 0x3D, 0xFF, 0x9E, 0x83,
  0xEF, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x78, 0xF0,
  0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xE0,
  0x3C, 0x3E, 0x0F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xF0,
  0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xF0, 0x7C, 0xF8, 0x0F, 0xBC, 0x01,
  0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x3E, 0xF4,
  0x1F, 0x3D, 0xFF, 0xCF, 0x3F, 0xE3, 0xC3, 0xE0, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD, 0xF8, 0x2F, 0x7C,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7D,
  0xF0, 0x1F, 0x7E, 0x0B, 0xCF, 0xFE, 0xF1, 0xFF, 0x3C, 0x1F, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xFC,
  0x1E, 0xC0, 0x07, 0xA0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xF8, 0x1F, 0x7C,
  0x03, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF2, 0x00, 0x3D,
  0xC0, 0x0F, 0xFC, 0x0F, 0x9F, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xE0, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0x7C, 0x1F,
  0xBF, 0xFF, 0xCF, 0xFB, 0xE1, 0xF1, 0xF0, 0xF0, 0x01, 0xFF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x38, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x0E, 0x38, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x03, 0xB8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xE0, 0xF8, 0x3F, 0x07, 0xC3,
  0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0D, 0x87, 0x38, 0x6C, 0x39, 0xC7,
  0x71, 0xCE, 0x3B, 0x8E, 0x71, 0xDC, 0x73, 0x8C, 0xE3, 0x9C, 0x63, 0x3C,
  0xF7, 0x19, 0xC7, 0xB8, 0xEE, 0x1D, 0xC7, 0x70, 0xEE, 0x3B, 0x87, 0x61,
  0xDC, 0x3B, 0x06, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0x80,
  0xF8, 0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0x81, 0xF1, 0xF0,
  0x1F, 0x3C, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xC7, 0x80,
  0xF0, 0xF8, 0x3E, 0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1F, 0x7C, 0x01, 0xF0,
  0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03,
  0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00, 0x3D, 0xE0, 0x03,
  0xDE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x7F, 0xE0, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xE0, 0x03, 0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0x3E, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x00, 0x0F, 0x00, 0xE7, 0xF0, 0x1C, 0xFF, 0x03, 0xBC, 0xF0, 0xF7,
  0x1E, 0x1D, 0xE1, 0xE7, 0xB8, 0x1F, 0xE7, 0x01, 0xFC, 0xE0, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_Medium38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 27, 23, 8, -27 },
  { 25, 11, 11, 23, 6, -28 },
  { 41, 22, 27, 23, 0, -27 },
  { 116, 19, 35, 23, 2, -31 },
  { 200, 22, 27, 23, 0, -27 },
  { 275, 21, 27, 23, 1, -27 },
  { 346, 4, 11, 23, 9, -28 },
  { 352, 12, 34, 23, 7, -29 },
  { 403, 13, 34, 23, 3, -29 },
  { 459, 20, 19, 23, 1, -21 },
  { 507, 18, 19, 23, 2, -21 },
  { 550, 8, 12, 23, 7, -6 },
  { 562, 11, 4, 23, 6, -14 },
  { 568, 7, 6, 23, 8, -6 },
  { 574, 17, 34, 23, 3, -29 },
  { 647, 19, 27, 23, 2, -27 },
  { 712, 19, 27, 23, 2, -27 },
  { 777, 19, 27, 23, 2, -27 },
  { 842, 19, 27, 23, 1, -27 },
  { 907, 21, 27, 23, 1, -27 },
  { 978, 19, 27, 23, 2, -27 },
  { 1043, 19, 27, 23, 2, -27 },
  { 1108, 19, 27, 23, 2, -27 },
  { 1173, 19, 27, 23, 2, -27 },
  { 1238, 19, 27, 23, 2, -27 },
  { 1303, 7, 20, 23, 8, -20 },
  { 1321, 8, 26, 23, 7, -20 },
  { 1347, 17, 22, 23, 3, -23 },
  { 1394, 18, 11, 23, 2, -17 },
  { 1419, 17, 22, 23, 3, -23 },
  { 1466, 17, 27, 23, 3, -27 },
  { 1524, 18, 31, 23, 2, -27 },
  { 1594, 21, 27, 23, 1, -27 },
  { 1665, 18, 27, 23, 3, -27 },
  { 1726, 19, 27, 23, 2, -27 },
  { 1791, 18, 27, 23, 3, -27 },
  { 1852, 17, 27, 23, 3, -27 },
  { 1910, 17, 27, 23, 3, -27 },
  { 1968, 18, 27, 23, 2, -27 },
  { 2029, 17, 27, 23, 3, -27 },
  { 2087, 17, 27, 23, 3, -27 },
  { 2145, 17, 27, 23, 2, -27 },
  { 2203, 19, 27, 23, 3, -27 },
  { 2268, 16, 27, 23, 4, -27 },
  { 2322, 19, 27, 23, 2, -27 },
  { 2387, 17, 27, 23, 3, -27 },
  { 2445, 19, 27, 23, 2, -27 },
  { 2510, 18, 27, 23, 3, -27 },
  { 2571, 19, 33, 23, 2, -27 },
  { 2650, 18, 27, 23, 3, -27 },
  { 2711, 20, 27, 23, 1, -27 },
  { 2779, 21, 27, 23, 1, -27 },
  { 2850, 17, 27, 23, 3, -27 },
  { 2908, 21, 27, 23, 1, -27 },
  { 2979, 21, 27, 23, 1, -27 },
  { 3050, 21, 27, 23, 1, -27 },
  { 3121, 22, 27, 23, 0, -27 },
  { 3196, 19, 27, 23, 2, -27 },
  { 3261, 11, 34, 23, 8, -29 },
  { 3308, 17, 34, 23, 3, -29 },
  { 3381, 11, 34, 23, 4, -29 },
  { 3428, 20, 16, 23, 1, -27 },
  { 3468, 19, 3, 23, 2, 4 },
  { 3476, 8, 8, 23, 6, -30 },
  { 3484, 19, 20, 23, 2, -20 },
  { 3532, 18, 28, 23, 3, -28 },
  { 3595, 17, 20, 23, 3, -20 },
  { 3638, 18, 28, 23, 2, -28 },
  { 3701, 19, 20, 23, 2, -20 },
  { 3749, 18, 28, 23, 3, -28 },
  { 3812, 20, 31, 23, 2, -23 },
  { 3890, 17, 28, 23, 3, -28 },
  { 3950, 17, 29, 23, 4, -29 },
  { 4012, 14, 37, 23, 3, -29 },
  { 4077, 19, 28, 23, 3, -28 },
  { 4144, 17, 28, 23, 3, -28 },
  { 4204, 19, 20, 23, 2, -20 },
  { 4252, 17, 20, 23, 3, -20 },
  { 4295, 19, 20, 23, 2, -20 },
  { 4343, 18, 28, 23, 3, -20 },
  { 4406, 18, 28, 23, 2, -20 },
  { 4469, 18, 20, 23, 3, -20 },
  { 4514, 18, 20, 23, 2, -20 },
  { 4559, 18, 27, 23, 2, -27 },
  { 4620, 17, 20, 23, 3, -20 },
  { 4663, 19, 20, 23, 2, -20 },
  { 4711, 21, 20, 23, 1, -20 },
  { 4764, 19, 20, 23, 2, -20 },
  { 4812, 20, 28, 23, 1, -20 },
  { 4882, 17, 20, 23, 3, -20 },
  { 4925, 15, 34, 23, 4, -29 },
  { 4989, 3, 34, 23, 10, -29 },
  { 5002, 15, 34, 23, 4, -29 },
  { 5066, 19, 9, 23, 2, -16 },
};

const GFXfont IBMPlexMono_Medium38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_MEDIUM38PT7B_H_
