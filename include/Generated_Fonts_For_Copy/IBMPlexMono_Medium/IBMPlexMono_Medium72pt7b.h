#ifndef _IBMPLEXMONO_MEDIUM72PT7B_H_
#define _IBMPLEXMONO_MEDIUM72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x7F, 0xCF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE7, 0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF1, 0xF3, 0xFF, 0xC3, 0xFE, 0x0F, 0x83, 0xFF, 0x3F, 0xE0, 0x7C,
  0x0F, 0xE1, 0xFE, 0x03, 0xE0, 0x3C, 0x0F, 0xF0, 0x1F, 0x00, 0xC0, 0x7F,
  0x80, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x3E, 0x00,
  0x00, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0x01, 0xFF, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0x00, 0x00,
  0x3F, 0xF8, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3E, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0x81, 0xFF,
  0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x1F,
  0x01, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x84,
  0x00, 0x3E, 0x03, 0xFC, 0x30, 0x01, 0xF0, 0x1F, 0xE3, 0xC0, 0x0F, 0x80,
  0xFF, 0x3F, 0x00, 0x7C, 0x0F, 0xFB, 0xFE, 0x03, 0xE0, 0x7F, 0xBF, 0xF8,
  0x1F, 0x0F, 0xFC, 0xFF, 0xF8, 0xF9, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC3,
  0xFF, 0xF0, 0x00, 0x0F, 0xE3, 0xFF, 0xFC, 0x00, 0x07, 0xE3, 0xFF, 0xFF,
  0x00, 0x07, 0xF1, 0xFC, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x07, 0xE0, 0x03,
  0xF8, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x07, 0xE0,
  0x01, 0xFF, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xFF, 0x83, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x1F, 0xFF, 0xE0, 0x00,
  0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x7E, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x03, 0xF1, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0xFE, 0x00, 0x1F,
  0xC3, 0xFC, 0x7E, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0x00, 0x03, 0xFF, 0xFC,
  0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x10, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xFF,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF, 0x1F, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x1F, 0x80,
  0x7F, 0x80, 0x7F, 0x8F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE7, 0xE0, 0x1F, 0xC0,
  0x0F, 0xF3, 0xF0, 0x0F, 0xE0, 0x03, 0xFD, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0xFC, 0x03, 0xFE, 0x00, 0x7D, 0xFE, 0x01, 0xFF, 0xC0, 0xFC, 0x7F, 0x80,
  0x7F, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x7F, 0x00, 0x0C, 0xFC,
  0x03, 0xF8, 0x03, 0xE7, 0xFC, 0x1F, 0xC0, 0xFF, 0x3F, 0xFC, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFB, 0xFF, 0x8F, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x03,
  0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x03,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x7C,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00,
  0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x07, 0xF8, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xC3, 0xF8, 0x00, 0x0F, 0xF8, 0x3E, 0x00,
  0x01, 0xFF, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x30, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC1, 0x00, 0x00, 0x07, 0xF8, 0x70, 0x00, 0x00, 0xFF, 0x1E, 0x00, 0x00,
  0x3F, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xF0,
  0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x3F,
  0xFE, 0x00, 0x7F, 0x1F, 0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0xFF, 0x01, 0xFC,
  0xFF, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x08, 0x00, 0x00, 0x3F, 0xC3, 0x80, 0x00, 0x0F, 0xF8, 0xF8, 0x00, 0x01,
  0xFF, 0x3F, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x80,
  0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFF, 0xF0,
  0x07, 0xF8, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xFE, 0x07, 0xFB, 0xFF,
  0xFF, 0xF0, 0x7F, 0xBF, 0xFF, 0xFF, 0x8F, 0xF7, 0xC0, 0x7F, 0xF8, 0xFF,
  0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F,
  0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0xFB, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0x8F, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF,
  0xFF, 0xF3, 0xFC, 0x07, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xFE, 0x1F, 0xE0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x8F, 0xFC, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF7, 0xFF, 0x1F, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0xFF, 0x0E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xC3, 0xF3, 0xF0, 0x07, 0xFE, 0x7F, 0x7E, 0x01, 0xFF, 0xEF, 0xEF,
  0xC0, 0x7F, 0xFD, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x03, 0xF8,
  0x03, 0xFF, 0xE0, 0x7F, 0x00, 0x7F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFF, 0x81,
  0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0xFE, 0x07, 0xE0, 0x07, 0xFF,
  0xC0, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0x03, 0xF0, 0x03,
  0xFF, 0xE0, 0x7E, 0x00, 0x7F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFF, 0x81, 0xF8,
  0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xEF, 0xC0, 0x7F, 0xFD,
  0xFD, 0xF8, 0x07, 0xFF, 0x3F, 0xBF, 0x00, 0x3F, 0xC7, 0xF7, 0xF0, 0x01,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0xF9, 0x7F, 0xC0, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0x83, 0xFC, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x03, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x03, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x7F, 0x80,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xE0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0E, 0xFE, 0x1F, 0xFE, 0x07, 0xDF, 0xC1,
  0xFF, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0x8F,
  0xE0, 0x1F, 0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x0F,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xEF,
  0xE0, 0x7E, 0xFF, 0xFD, 0xFC, 0x0F, 0xDF, 0xFF, 0x9F, 0x83, 0xF3, 0xFF,
  0xF3, 0xF8, 0x7E, 0x7F, 0xFE, 0x3F, 0x1F, 0xCF, 0xFF, 0xC7, 0xF3, 0xF1,
  0xFF, 0xF8, 0xFE, 0x7E, 0x3F, 0xFF, 0x0F, 0xDF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80,
  0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0xF0, 0x0F,
  0x80, 0x7F, 0xFE, 0x00, 0xE0, 0x0F, 0xFF, 0xC0, 0x1C, 0x01, 0xFF, 0xF8,
  0x01, 0x80, 0x3F, 0xFF, 0x00, 0x20, 0x07, 0xFF, 0xE0, 0x04, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xEF,
  0xE0, 0x03, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xF9, 0xFC, 0x00, 0xFF, 0xFC,
  0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0x80, 0x3F, 0xFF, 0x1F, 0xC0, 0x1F, 0xFF,
  0x87, 0xF0, 0x0F, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xE1, 0xFC, 0x03, 0xFF,
  0xF0, 0x7F, 0x01, 0xFF, 0xF8, 0x3F, 0x80, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x0F,
  0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xF0, 0x0F, 0xE1,
  0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xFC, 0x01, 0xFC, 0x7F, 0xFE, 0x00, 0xFE,
  0x3F, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xC0, 0x0F,
  0xE7, 0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0xF0, 0x01, 0xFD, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x00, 0x1F, 0xFC, 0xFF,
  0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xEF, 0xF0,
  0x00, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xE0, 0x1F, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0xE0, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x00, 0x30, 0x3F, 0xC0, 0x00,
  0x02, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0xC0,
  0x00, 0x00, 0xFF, 0x1E, 0x00, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xFC, 0x01,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF,
  0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x0F, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0xC0,
  0x3F, 0x3F, 0x80, 0xFF, 0x80, 0x7E, 0x7F, 0x01, 0xFF, 0x80, 0xFC, 0xFE,
  0x03, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0xF8, 0x1F, 0xCF, 0xE0, 0x7D, 0xF8, 0x3F, 0x9F,
  0xC0, 0xFB, 0xF0, 0x7F, 0x3F, 0x81, 0xF7, 0xE0, 0xFE, 0x3F, 0x07, 0xE7,
  0xC1, 0xFC, 0x7E, 0x0F, 0xCF, 0x83, 0xF8, 0xFC, 0x1F, 0x1F, 0x07, 0xF1,
  0xFC, 0x3E, 0x3F, 0x0F, 0xC3, 0xF8, 0x7C, 0x7E, 0x1F, 0x87, 0xF1, 0xF8,
  0xFC, 0x3F, 0x0F, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0xC7, 0xC1, 0xF0, 0xFC,
  0x3F, 0x8F, 0x83, 0xF1, 0xF8, 0x7F, 0x1F, 0x07, 0xE7, 0xF0, 0xFE, 0x7E,
  0x0F, 0xCF, 0xE1, 0xFC, 0xFC, 0x1F, 0x9F, 0xC3, 0xF9, 0xF8, 0x1F, 0x3F,
  0x83, 0xF3, 0xE0, 0x3F, 0x7F, 0x07, 0xE7, 0xC0, 0x7E, 0xFE, 0x0F, 0xDF,
  0x80, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xFB, 0xF8, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x9F,
  0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x06,
  0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x06,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xC3,
  0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0x7F,
  0xFF, 0xFC, 0x3F, 0xCF, 0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0x03, 0xFC,
  0x3F, 0xFF, 0x80, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x0C, 0x0F, 0xF0, 0x00,
  0x08, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x03, 0xC1,
  0xFE, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xF0, 0x01, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF,
  0xE3, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xCF, 0xFF,
  0x01, 0xEF, 0xF3, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F,
  0xFC, 0xFF, 0xF0, 0x1E, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0xFF,
  0x8F, 0xF0, 0x7F, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x06, 0x03, 0xFC, 0x00,
  0x00, 0xE0, 0x7F, 0xC0, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0x80, 0x00, 0x03, 0xFD, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0x78, 0x1F, 0xFC, 0xFF,
  0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xF8,
  0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF7,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xF3, 0xFE,
  0x00, 0x0F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x07, 0xF1, 0xFF,
  0x03, 0xFE, 0x3F, 0x9F, 0xF8, 0x3F, 0xF9, 0xFD, 0xFF, 0xE3, 0xFF, 0xEF,
  0xEF, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFB, 0xFE, 0x1F, 0xFC,
  0x3F, 0xDF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFC, 0x03,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF,
  0xF8, 0xFF, 0x78, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0xFE,
  0x03, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0xF8, 0x3F, 0xDF, 0xFF,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xDF, 0xFF, 0xFF,
  0x0F, 0xF3, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF,
  0xE0, 0x3F, 0xC1, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x0F, 0xF0, 0x3F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xC7, 0xFF, 0xFF, 0xCF, 0xF3, 0xFF, 0xC0, 0x7B, 0xFC, 0xFF,
  0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F,
  0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xFC, 0x07,
  0xBF, 0xC7, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xFF,
  0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xC0, 0x0F, 0xF3, 0xFF, 0xF8, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0xDC,
  0x00, 0x00, 0x07, 0xFB, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x03, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x0C, 0x00, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xF8, 0x03, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0xFD,
  0xFE, 0x7F, 0xFF, 0xFB, 0xFC, 0x7F, 0xFF, 0xE7, 0xF8, 0x7F, 0xFF, 0x8F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0xC0, 0x1F, 0xDF,
  0x80, 0x3F, 0xE0, 0x0F, 0xCF, 0xE0, 0x1F, 0xF0, 0x07, 0xE7, 0xF0, 0x0F,
  0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xFF, 0x00,
  0xFC, 0xFE, 0x01, 0xFF, 0x80, 0xFE, 0x3F, 0x01, 0xF7, 0xC0, 0x7F, 0x1F,
  0x80, 0xFB, 0xE0, 0x3F, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F, 0x87, 0xE0, 0x3E,
  0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x3E, 0x07, 0xE1, 0xFC, 0x0F, 0x1F, 0x03,
  0xF0, 0xFE, 0x0F, 0x8F, 0x81, 0xF8, 0x3F, 0x07, 0xC7, 0xC0, 0xFC, 0x1F,
  0x83, 0xE3, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0xF8, 0x7E, 0x07, 0xE0, 0xF8,
  0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x3E, 0x1F, 0x81, 0xFC, 0x7C, 0x1F, 0x0F,
  0xC0, 0xFE, 0x3E, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0x81, 0xF1, 0xF0, 0x0F, 0xC7, 0x80, 0xF9, 0xF8, 0x07, 0xE7, 0xC0,
  0x7C, 0xFC, 0x03, 0xF3, 0xE0, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x1F, 0x3F,
  0x00, 0xFC, 0xF8, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x03, 0xEF, 0xC0, 0x1F,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x1F, 0xFC, 0x00,
  0x0F, 0xC1, 0xFF, 0xF0, 0x00, 0x7E, 0x1F, 0xFF, 0xC0, 0x07, 0xF0, 0xFF,
  0xFF, 0x00, 0x3F, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x7F, 0x1F, 0xE0, 0x0F,
  0xC7, 0xF0, 0x7F, 0x80, 0xFC, 0x3F, 0x01, 0xFE, 0x07, 0xE3, 0xF8, 0x07,
  0xF8, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0x87,
  0xE0, 0x03, 0xFF, 0xF8, 0x7E, 0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0x1F,
  0xF8, 0x03, 0x80, 0x00, 0x3F, 0x00,
};

const GFXglyph IBMPlexMono_Medium72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 12, 51, 43, 16, -50 },
  { 78, 21, 21, 43, 11, -53 },
  { 134, 41, 50, 43, 1, -50 },
  { 391, 37, 66, 43, 3, -58 },
  { 697, 41, 52, 43, 1, -51 },
  { 964, 41, 52, 43, 1, -51 },
  { 1231, 7, 21, 43, 18, -53 },
  { 1250, 23, 65, 43, 14, -55 },
  { 1437, 22, 65, 43, 7, -55 },
  { 1616, 37, 36, 43, 3, -40 },
  { 1783, 35, 34, 43, 4, -39 },
  { 1932, 15, 21, 43, 14, -11 },
  { 1972, 21, 7, 43, 11, -25 },
  { 1991, 13, 12, 43, 15, -11 },
  { 2011, 31, 65, 43, 6, -55 },
  { 2263, 37, 52, 43, 3, -51 },
  { 2504, 38, 50, 43, 3, -50 },
  { 2742, 35, 51, 43, 4, -51 },
  { 2966, 35, 52, 43, 3, -51 },
  { 3194, 39, 50, 43, 2, -50 },
  { 3438, 35, 51, 43, 4, -50 },
  { 3662, 36, 51, 43, 4, -50 },
  { 3892, 35, 50, 43, 4, -50 },
  { 4111, 37, 52, 43, 3, -51 },
  { 4352, 35, 51, 43, 4, -51 },
  { 4576, 13, 39, 43, 15, -38 },
  { 4640, 15, 48, 43, 14, -38 },
  { 4730, 31, 42, 43, 6, -43 },
  { 4893, 35, 22, 43, 4, -33 },
  { 4990, 31, 42, 43, 6, -43 },
  { 5153, 32, 52, 43, 5, -51 },
  { 5361, 35, 59, 43, 4, -51 },
  { 5620, 41, 50, 43, 1, -50 },
  { 5877, 33, 50, 43, 6, -50 },
  { 6084, 36, 52, 43, 4, -51 },
  { 6318, 34, 50, 43, 6, -50 },
  { 6531, 32, 50, 43, 6, -50 },
  { 6731, 33, 50, 43, 6, -50 },
  { 6938, 35, 52, 43, 3, -51 },
  { 7166, 33, 50, 43, 5, -50 },
  { 7373, 31, 50, 43, 6, -50 },
  { 7567, 32, 51, 43, 4, -50 },
  { 7771, 36, 50, 43, 6, -50 },
  { 7996, 31, 50, 43, 8, -50 },
  { 8190, 35, 50, 43, 4, -50 },
  { 8409, 33, 50, 43, 5, -50 },
  { 8616, 37, 52, 43, 3, -51 },
  { 8857, 34, 50, 43, 6, -50 },
  { 9070, 37, 64, 43, 3, -51 },
  { 9366, 34, 50, 43, 6, -50 },
  { 9579, 36, 52, 43, 3, -51 },
  { 9813, 39, 50, 43, 2, -50 },
  { 10057, 33, 51, 43, 5, -50 },
  { 10268, 39, 50, 43, 2, -50 },
  { 10512, 39, 50, 43, 2, -50 },
  { 10756, 41, 50, 43, 1, -50 },
  { 11013, 41, 50, 43, 1, -50 },
  { 11270, 37, 50, 43, 3, -50 },
  { 11502, 21, 65, 43, 15, -55 },
  { 11673, 31, 65, 43, 6, -55 },
  { 11925, 21, 65, 43, 7, -55 },
  { 12096, 38, 31, 43, 3, -50 },
  { 12244, 35, 7, 43, 4, 6 },
  { 12275, 14, 15, 43, 12, -57 },
  { 12302, 36, 39, 43, 4, -38 },
  { 12478, 34, 54, 43, 6, -53 },
  { 12708, 33, 39, 43, 5, -38 },
  { 12869, 34, 54, 43, 4, -53 },
  { 13099, 35, 39, 43, 4, -38 },
  { 13270, 35, 53, 43, 5, -53 },
  { 13502, 37, 58, 43, 4, -43 },
  { 13771, 32, 53, 43, 6, -53 },
  { 13983, 33, 54, 43, 7, -54 },
  { 14206, 26, 68, 43, 7, -54 },
  { 14427, 36, 53, 43, 6, -53 },
  { 14666, 33, 53, 43, 5, -53 },
  { 14885, 37, 38, 43, 3, -38 },
  { 15061, 32, 38, 43, 6, -38 },
  { 15213, 35, 39, 43, 4, -38 },
  { 15384, 34, 52, 43, 6, -38 },
  { 15605, 34, 52, 43, 4, -38 },
  { 15826, 35, 37, 43, 5, -37 },
  { 15988, 34, 39, 43, 4, -38 },
  { 16154, 35, 50, 43, 3, -50 },
  { 16373, 31, 38, 43, 6, -37 },
  { 16521, 37, 37, 43, 3, -37 },
  { 16693, 41, 37, 43, 1, -37 },
  { 16883, 37, 37, 43, 3, -37 },
  { 17055, 37, 51, 43, 3, -37 },
  { 17291, 32, 37, 43, 6, -37 },
  { 17439, 29, 65, 43, 7, -55 },
  { 17675, 7, 65, 43, 18, -55 },
  { 17732, 29, 65, 43, 7, -55 },
  { 17968, 37, 16, 43, 3, -30 },
};

const GFXfont IBMPlexMono_Medium72pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium72pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium72pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _IBMPLEXMONO_MEDIUM72PT7B_H_
