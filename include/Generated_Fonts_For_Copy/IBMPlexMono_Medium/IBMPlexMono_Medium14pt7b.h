#ifndef _IBMPLEXMONO_MEDIUM14PT7B_H_
#define _IBMPLEXMONO_MEDIUM14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x54, 0xF0, 0xDD, 0xDD, 0x12, 0x16, 0x16, 0x77, 0x34, 0x24,
  0xE7, 0x2C, 0x2C, 0x68, 0x10, 0xFB, 0x5C, 0x8D, 0x0E, 0x07, 0x0B, 0x17,
  0x29, 0xE0, 0x80, 0x71, 0xD2, 0x92, 0xD4, 0x70, 0x06, 0x39, 0x29, 0x49,
  0xC6, 0x38, 0x64, 0x60, 0x60, 0x30, 0x53, 0xCA, 0xCE, 0x46, 0x7B, 0xFF,
  0x36, 0x48, 0x88, 0x88, 0x88, 0x46, 0x30, 0xC1, 0x0C, 0x21, 0x0C, 0x63,
  0x10, 0x8C, 0x4C, 0x00, 0x10, 0x23, 0x5B, 0xE3, 0x8D, 0x33, 0x00, 0x10,
  0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xFB, 0x40, 0xF0, 0xF0, 0x04, 0x30,
  0x82, 0x18, 0x41, 0x0C, 0x21, 0x84, 0x10, 0xC0, 0x79, 0x9A, 0x14, 0x3B,
  0x76, 0xE1, 0xC2, 0xCC, 0xF0, 0x38, 0xB3, 0x64, 0xC1, 0x83, 0x06, 0x0C,
  0x19, 0xFC, 0x79, 0x9A, 0x10, 0x20, 0xC3, 0x0C, 0x30, 0xC1, 0xFC, 0x7B,
  0x30, 0x43, 0x30, 0x30, 0x41, 0x8D, 0xE0, 0x0E, 0x0E, 0x16, 0x36, 0x26,
  0x66, 0x46, 0xFF, 0x06, 0x06, 0xFD, 0x83, 0x06, 0x0F, 0x98, 0x81, 0x83,
  0xC4, 0xF0, 0x18, 0x41, 0x86, 0x0B, 0xD8, 0xA1, 0xC3, 0xC4, 0xF0, 0xFF,
  0x0E, 0x30, 0x60, 0x83, 0x04, 0x18, 0x30, 0xC0, 0x79, 0x8A, 0x16, 0x23,
  0x98, 0xA1, 0xC3, 0xC4, 0xF0, 0x79, 0x8A, 0x1C, 0x3C, 0x6F, 0x81, 0x06,
  0x18, 0xE0, 0xF0, 0x3C, 0xD8, 0x01, 0xF6, 0x80, 0x04, 0x73, 0x30, 0xC0,
  0xC1, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x83, 0x83, 0x83, 0x0C, 0xEE, 0x20,
  0x7B, 0x30, 0x43, 0x1C, 0xC3, 0x00, 0x30, 0xC0, 0x78, 0x8A, 0x14, 0xFA,
  0x74, 0xE9, 0xD3, 0x9F, 0x01, 0x01, 0xC0, 0x18, 0x1C, 0x3C, 0x34, 0x26,
  0x26, 0x7E, 0x62, 0x43, 0xC3, 0xF9, 0x8B, 0x16, 0x2F, 0x98, 0xB1, 0xE3,
  0xC5, 0xF8, 0x3C, 0x8B, 0x1E, 0x08, 0x10, 0x30, 0x62, 0x46, 0x78, 0xF9,
  0x9B, 0x16, 0x3C, 0x78, 0xF1, 0xE2, 0xCD, 0xF0, 0xFF, 0x0C, 0x30, 0xFF,
  0x0C, 0x30, 0xC3, 0xF0, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC3, 0x00,
  0x7B, 0x3C, 0xA0, 0x82, 0x78, 0x71, 0xC5, 0xF0, 0xC7, 0x1C, 0x71, 0xFF,
  0x1C, 0x71, 0xC7, 0x10, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0,
  0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xCD, 0xE0, 0xC7, 0x9B, 0x66, 0x8F,
  0x1F, 0x32, 0x66, 0xC5, 0x8C, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83,
  0xF0, 0xC7, 0x9F, 0xBD, 0xFB, 0x72, 0xE9, 0xC3, 0x87, 0x0C, 0xC7, 0x9A,
  0x69, 0xB6, 0x59, 0x67, 0x8E, 0x30, 0x79, 0x9A, 0x14, 0x38, 0x70, 0xE1,
  0xC2, 0xCC, 0xF0, 0xFD, 0x8B, 0x1E, 0x3C, 0x5F, 0xB0, 0x60, 0xC1, 0x80,
  0x79, 0x9A, 0x14, 0x38, 0x70, 0xE1, 0xC2, 0xCC, 0xF0, 0x40, 0xE0, 0xFD,
  0x8B, 0x1E, 0x3C, 0x5F, 0xB6, 0x64, 0xCD, 0x8C, 0x7D, 0x8E, 0x06, 0x07,
  0x03, 0x81, 0x83, 0x84, 0xF0, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCD, 0xE0, 0xC3,
  0x43, 0x62, 0x62, 0x26, 0x26, 0x34, 0x34, 0x1C, 0x18, 0xC1, 0xC1, 0x59,
  0x59, 0x5B, 0x57, 0x57, 0x57, 0x66, 0x66, 0xC3, 0x66, 0x36, 0x3C, 0x18,
  0x1C, 0x3C, 0x26, 0x62, 0xC3, 0xC3, 0x62, 0x66, 0x36, 0x3C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0xFE, 0x18, 0x30, 0xC1, 0x06, 0x18, 0x20, 0xC1, 0xFC,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC1, 0x04, 0x18, 0x20, 0xC1,
  0x04, 0x18, 0x20, 0x83, 0x04, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x3F, 0x80, 0x30, 0x71, 0xA2, 0x68, 0x50, 0xC0, 0xFE, 0x58, 0x80, 0x79,
  0x18, 0x33, 0xE8, 0xD1, 0x9D, 0x80, 0xC1, 0x83, 0x07, 0xEC, 0x58, 0xF1,
  0xE3, 0xC5, 0xF8, 0x39, 0x1C, 0x30, 0xC1, 0x13, 0xC0, 0x04, 0x10, 0x5D,
  0xCE, 0x18, 0x61, 0xCD, 0xD0, 0x79, 0x8A, 0x17, 0xF8, 0x18, 0x9E, 0x00,
  0x1E, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x31, 0xF8, 0x06, 0xF3, 0x36,
  0x2C, 0xCF, 0x20, 0x3E, 0x87, 0x0F, 0xF0, 0xC3, 0x0C, 0x36, 0xEF, 0x1C,
  0x71, 0xC7, 0x10, 0x18, 0x30, 0x07, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC,
  0x18, 0xC1, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80, 0xC1, 0x83, 0x06,
  0x7D, 0x9E, 0x3C, 0x6C, 0xCD, 0x8C, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x33, 0xF0, 0xAD, 0xEE, 0x5C, 0xB9, 0x72, 0xE5, 0x80, 0xDB, 0xBC, 0x71,
  0xC7, 0x1C, 0x40, 0x79, 0x8A, 0x1C, 0x38, 0x78, 0x9E, 0x00, 0xFD, 0x8B,
  0x1E, 0x3C, 0x78, 0xBF, 0x60, 0xC1, 0x80, 0x77, 0x38, 0x61, 0x87, 0x37,
  0x41, 0x04, 0x10, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x3F, 0x00, 0x7F, 0x1C,
  0x1F, 0x06, 0x17, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0xF0,
  0xC7, 0x1C, 0x71, 0xC7, 0x37, 0x40, 0x87, 0x89, 0x32, 0x46, 0x87, 0x0C,
  0x00, 0xD9, 0xD9, 0x59, 0x57, 0x56, 0x66, 0x66, 0xC6, 0xD8, 0xE1, 0x83,
  0x89, 0xB1, 0x80, 0x87, 0x89, 0x32, 0x46, 0x87, 0x0C, 0x18, 0x21, 0xC0,
  0xFC, 0x31, 0x8C, 0x63, 0x0F, 0xC0, 0x3C, 0x82, 0x0C, 0x18, 0x6E, 0x04,
  0x18, 0xC2, 0x08, 0x3C, 0xFF, 0xF8, 0xF0, 0x41, 0x0C, 0x20, 0x81, 0xC8,
  0x20, 0xC1, 0x04, 0xF0, 0x63, 0x2A, 0x70,
};

const GFXglyph IBMPlexMono_Medium14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 7, 12, 8, 1, -11 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 8, 10, 8, 0, -10 },
  { 47, 2, 4, 8, 3, -10 },
  { 48, 4, 13, 8, 3, -11 },
  { 55, 5, 13, 8, 1, -11 },
  { 64, 7, 7, 8, 1, -8 },
  { 71, 7, 7, 8, 1, -8 },
  { 78, 3, 4, 8, 3, -2 },
  { 80, 4, 1, 8, 2, -5 },
  { 81, 2, 2, 8, 3, -2 },
  { 82, 6, 13, 8, 1, -11 },
  { 92, 7, 10, 8, 1, -10 },
  { 101, 7, 10, 8, 1, -10 },
  { 110, 7, 10, 8, 1, -10 },
  { 119, 6, 10, 8, 1, -10 },
  { 127, 8, 10, 8, 0, -10 },
  { 137, 7, 10, 8, 1, -10 },
  { 146, 7, 10, 8, 1, -10 },
  { 155, 7, 10, 8, 1, -10 },
  { 164, 7, 10, 8, 1, -10 },
  { 173, 7, 10, 8, 1, -10 },
  { 182, 2, 7, 8, 3, -7 },
  { 184, 3, 9, 8, 3, -7 },
  { 188, 6, 8, 8, 1, -8 },
  { 194, 7, 4, 8, 1, -6 },
  { 198, 6, 8, 8, 1, -8 },
  { 204, 6, 10, 8, 1, -10 },
  { 212, 7, 12, 8, 1, -10 },
  { 223, 8, 10, 8, 0, -10 },
  { 233, 7, 10, 8, 1, -10 },
  { 242, 7, 10, 8, 1, -10 },
  { 251, 7, 10, 8, 1, -10 },
  { 260, 6, 10, 8, 1, -10 },
  { 268, 6, 10, 8, 1, -10 },
  { 276, 6, 10, 8, 1, -10 },
  { 284, 6, 10, 8, 1, -10 },
  { 292, 6, 10, 8, 1, -10 },
  { 300, 6, 10, 8, 1, -10 },
  { 308, 7, 10, 8, 1, -10 },
  { 317, 6, 10, 8, 2, -10 },
  { 325, 7, 10, 8, 1, -10 },
  { 334, 6, 10, 8, 1, -10 },
  { 342, 7, 10, 8, 1, -10 },
  { 351, 7, 10, 8, 1, -10 },
  { 360, 7, 12, 8, 1, -10 },
  { 371, 7, 10, 8, 1, -10 },
  { 380, 7, 10, 8, 1, -10 },
  { 389, 8, 10, 8, 0, -10 },
  { 399, 6, 10, 8, 1, -10 },
  { 407, 8, 10, 8, 0, -10 },
  { 417, 8, 10, 8, 0, -10 },
  { 427, 8, 10, 8, 0, -10 },
  { 437, 8, 10, 8, 0, -10 },
  { 447, 7, 10, 8, 1, -10 },
  { 456, 4, 13, 8, 3, -11 },
  { 463, 6, 13, 8, 1, -11 },
  { 473, 5, 13, 8, 1, -11 },
  { 482, 7, 6, 8, 1, -10 },
  { 488, 7, 1, 8, 1, 1 },
  { 489, 3, 3, 8, 2, -11 },
  { 491, 7, 7, 8, 1, -7 },
  { 498, 7, 10, 8, 1, -10 },
  { 507, 6, 7, 8, 1, -7 },
  { 513, 6, 10, 8, 1, -10 },
  { 521, 7, 7, 8, 1, -7 },
  { 528, 7, 10, 8, 1, -10 },
  { 537, 7, 11, 8, 1, -8 },
  { 547, 6, 10, 8, 1, -10 },
  { 555, 7, 10, 8, 1, -10 },
  { 564, 5, 13, 8, 1, -10 },
  { 573, 7, 10, 8, 1, -10 },
  { 582, 6, 10, 8, 1, -10 },
  { 590, 7, 7, 8, 1, -7 },
  { 597, 6, 7, 8, 1, -7 },
  { 603, 7, 7, 8, 1, -7 },
  { 610, 7, 10, 8, 1, -7 },
  { 619, 6, 10, 8, 1, -7 },
  { 627, 7, 7, 8, 1, -7 },
  { 634, 6, 7, 8, 1, -7 },
  { 640, 6, 10, 8, 1, -10 },
  { 648, 6, 7, 8, 1, -7 },
  { 654, 7, 7, 8, 1, -7 },
  { 661, 8, 7, 8, 0, -7 },
  { 668, 7, 7, 8, 1, -7 },
  { 675, 7, 10, 8, 1, -7 },
  { 684, 6, 7, 8, 1, -7 },
  { 690, 6, 13, 8, 1, -11 },
  { 700, 1, 13, 8, 4, -11 },
  { 702, 6, 13, 8, 1, -11 },
  { 712, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_Medium14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_MEDIUM14PT7B_H_
