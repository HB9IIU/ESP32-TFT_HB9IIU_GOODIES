#ifndef _IBMPLEXMONO_MEDIUM24PT7B_H_
#define _IBMPLEXMONO_MEDIUM24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x76, 0x66, 0x62, 0x00, 0x07, 0xFF, 0x70, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0x80, 0x07, 0x30, 0x18, 0xC0, 0x67, 0x01, 0x98,
  0x06, 0x61, 0xF9, 0xF7, 0xC7, 0xC3, 0x18, 0x0C, 0xE0, 0x33, 0x0F, 0xCF,
  0xBF, 0x3E, 0x18, 0xC0, 0x67, 0x01, 0x9C, 0x06, 0x60, 0x39, 0x80, 0x06,
  0x00, 0x60, 0x1F, 0xC3, 0xFE, 0x72, 0x76, 0x22, 0x62, 0x06, 0x20, 0x72,
  0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0x02, 0x70, 0x23, 0x02, 0x34, 0x23, 0xF2,
  0x77, 0xFE, 0x1F, 0x80, 0x60, 0x06, 0x00, 0x3C, 0x0D, 0xF8, 0x66, 0x61,
  0xB0, 0xCC, 0xC3, 0x33, 0x0D, 0x86, 0x6E, 0x1F, 0x80, 0x3C, 0x70, 0x07,
  0xE0, 0xD8, 0xC6, 0x63, 0x19, 0x8C, 0xC6, 0x33, 0x18, 0xD8, 0x7E, 0xE0,
  0x70, 0x0F, 0x80, 0x7F, 0x03, 0x8E, 0x0C, 0x20, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x3E, 0x3D, 0xDC, 0xF6, 0x3B, 0x18, 0x6C, 0xE1, 0xE1,
  0x83, 0x87, 0x1F, 0x0F, 0xCE, 0x1E, 0x1C, 0xFF, 0xFC, 0x0E, 0x30, 0xE3,
  0x86, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60,
  0xE0, 0xE0, 0xC0, 0xE0, 0xE0, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x08, 0x61, 0xF6, 0xFF, 0xFF, 0x1F, 0x80,
  0xF0, 0x1F, 0x83, 0x9C, 0x30, 0xE1, 0x04, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x7B, 0xBD, 0xCE, 0x63, 0x00, 0xFF, 0xFC, 0x7F, 0xF7, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x00, 0x0F, 0x83, 0xFC, 0x70, 0xE7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x63, 0xE7, 0x3E, 0x63, 0xE0, 0x3E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0xE3,
  0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x0E, 0xE0, 0xE7, 0x0F, 0x38, 0x31,
  0xC1, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0x83, 0xFC, 0x70, 0xEE,
  0x0E, 0x20, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0x87, 0xFC,
  0x70, 0xE2, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0xF8, 0x0F, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x74, 0x07, 0xF0, 0xE7, 0xFC, 0x1F, 0x80, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0D, 0x80, 0xCC, 0x0E, 0x60, 0x63, 0x07, 0x18,
  0x30, 0xC3, 0x06, 0x38, 0x31, 0x81, 0x8F, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x3F, 0xE7, 0xFE, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x67, 0x86, 0xFE, 0x70, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x76, 0x07,
  0xF0, 0xE7, 0xFC, 0x1F, 0x80, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x77, 0x86, 0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x76, 0x07, 0x70, 0xE3, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E,
  0x07, 0xE0, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0x83, 0xFE,
  0x70, 0xE6, 0x07, 0x60, 0x76, 0x07, 0x70, 0xE1, 0xFC, 0x3F, 0xC7, 0x0E,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xF3, 0xFE, 0x1F, 0x80, 0x0F,
  0x83, 0xFC, 0x70, 0xE6, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70,
  0xF3, 0xF7, 0x1E, 0x60, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x00, 0x7F, 0xF7, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x77, 0xBC, 0xE0, 0x00,
  0x00, 0x03, 0xDD, 0xEE, 0x73, 0x18, 0x00, 0x40, 0x30, 0x3C, 0x3E, 0x3E,
  0x3E, 0x0E, 0x03, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xC0, 0x10,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80,
  0x38, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1C, 0x07, 0x07, 0xC3, 0xC3,
  0xC3, 0xE0, 0xE0, 0x20, 0x00, 0x3F, 0x1F, 0xEE, 0x1F, 0x03, 0x40, 0xC0,
  0x70, 0x1C, 0x7E, 0x1F, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xE0,
  0x78, 0x1C, 0x00, 0x0F, 0x83, 0xFC, 0x30, 0xE6, 0x07, 0x60, 0x36, 0x3B,
  0xE7, 0xFC, 0x67, 0xCC, 0x3C, 0xC3, 0xCC, 0x3C, 0xC3, 0xCE, 0x3E, 0x7F,
  0x67, 0xB6, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x03, 0xF0, 0x0E, 0xC0, 0x33, 0x81, 0xCE, 0x07, 0x18, 0x18,
  0x60, 0x61, 0xC3, 0xFF, 0x0F, 0xFC, 0x30, 0x39, 0xC0, 0xE7, 0x03, 0x9C,
  0x07, 0xE0, 0x1C, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x0F, 0xC1, 0xB8,
  0x77, 0xFC, 0xFF, 0x9C, 0x3B, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F,
  0xFE, 0xFF, 0x80, 0x0F, 0x81, 0xFE, 0x38, 0xF7, 0x07, 0x70, 0x46, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x67, 0x07,
  0x38, 0xF1, 0xFE, 0x0F, 0x80, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0x6E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xB8, 0x77, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xFC, 0x78, 0xE7, 0x07, 0x60,
  0x4E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xE0, 0x7E, 0x07, 0x60,
  0x77, 0x07, 0x78, 0xF3, 0xFF, 0x1E, 0x70, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0xFF, 0xFF, 0xF0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xC1,
  0xDC, 0x71, 0xFE, 0x1F, 0x00, 0xE0, 0xFE, 0x0E, 0xE1, 0xCE, 0x38, 0xE7,
  0x0E, 0x70, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x0E, 0x38, 0xE3,
  0xCE, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0x70, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xF0, 0x7F, 0x0F, 0xF8, 0xFF, 0x8F, 0xF9,
  0xBF, 0xDB, 0xED, 0xBE, 0xF3, 0xE7, 0x3E, 0x63, 0xE6, 0x3E, 0x23, 0xE4,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7D, 0x8F, 0xB1, 0xF7, 0x3E, 0x67, 0xCC, 0xF9, 0xDF, 0x1B, 0xE3, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xE0, 0x0F, 0x83, 0xFC, 0x70, 0xE7,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x77, 0x07, 0x70, 0xE3, 0xFC, 0x0F, 0x80, 0xFF, 0x9F, 0xFB,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xDF, 0xF3, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xFC,
  0x70, 0xE7, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x60,
  0x06, 0x00, 0x7E, 0x03, 0xE0, 0xFF, 0x9F, 0xFB, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xDF, 0xF3, 0x9C, 0x71, 0xCE, 0x39, 0xC3,
  0xB8, 0x77, 0x07, 0xE0, 0xE0, 0x1F, 0xC3, 0xFE, 0x70, 0x76, 0x02, 0x60,
  0x06, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x00,
  0x74, 0x07, 0xF0, 0xF7, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xB8, 0x73, 0xFE, 0x3F, 0x00, 0xE0,
  0x3F, 0x01, 0xB8, 0x1C, 0xC0, 0xE7, 0x07, 0x38, 0x31, 0xC3, 0x86, 0x1C,
  0x38, 0xC1, 0xC6, 0x06, 0x70, 0x33, 0x81, 0xD8, 0x0E, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x73, 0x63,
  0x9B, 0x3C, 0xD9, 0xE6, 0xCD, 0x37, 0x6D, 0xBB, 0x6D, 0xD3, 0x6F, 0x9B,
  0x3C, 0xD9, 0xE3, 0xCF, 0x1E, 0x78, 0xF0, 0x70, 0x1C, 0xE0, 0xE3, 0x87,
  0x07, 0x1C, 0x1C, 0xE0, 0x3B, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0xFC, 0x03, 0xB8, 0x1C, 0xE0, 0x61, 0xC3, 0x83, 0x1C, 0x0E, 0xF0,
  0x1C, 0xF0, 0x1D, 0xC0, 0xE3, 0x83, 0x8E, 0x1C, 0x1C, 0x70, 0x73, 0x80,
  0xCE, 0x03, 0xB0, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x07, 0xFF, 0xE0, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F,
  0xFF, 0xE0, 0x07, 0x00, 0x78, 0x07, 0xE0, 0x33, 0x03, 0x9C, 0x18, 0x61,
  0xC3, 0x8C, 0x0E, 0xE0, 0x76, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x67, 0x1C,
  0x61, 0x80, 0x1F, 0x83, 0xFC, 0x71, 0xE2, 0x0E, 0x00, 0xE1, 0xFE, 0x7F,
  0xE7, 0x0E, 0xE0, 0xE6, 0x1E, 0x7F, 0x73, 0xE7, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFE, 0xE1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xFF, 0xDD, 0xF0, 0x1F, 0x0F, 0xF9,
  0xC7, 0x70, 0x4E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x8E, 0x1D, 0xFF,
  0x0F, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x1E,
  0x73, 0xF7, 0x70, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x77, 0x0F, 0x3F, 0x71, 0xE7, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0x60,
  0x7F, 0xFF, 0xFF, 0xF6, 0x00, 0x60, 0x47, 0x06, 0x3F, 0xF0, 0xF8, 0x07,
  0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xFF, 0xFF, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0xFF, 0xFF, 0xFC,
  0x00, 0x70, 0x07, 0x83, 0xE0, 0x7F, 0x87, 0x0E, 0x38, 0x31, 0xC1, 0x8E,
  0x1C, 0x3F, 0xC0, 0xFC, 0x0C, 0x00, 0xC0, 0x07, 0xFE, 0x1F, 0xF9, 0x80,
  0xFC, 0x07, 0xE0, 0x3B, 0xFF, 0x8F, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3B, 0xC7, 0xFE, 0xE1, 0xDC, 0x1B, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x0E, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x03, 0x83, 0xC0,
  0xE0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x37, 0xFB, 0xF8, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xEE, 0x1C, 0xE3,
  0x8E, 0x70, 0xEE, 0x0F, 0xE0, 0xF7, 0x0E, 0x70, 0xE3, 0x8E, 0x1C, 0xE0,
  0xEE, 0x0F, 0xFE, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0xFF, 0xFF, 0xFC, 0xDC, 0xED, 0xFF, 0xE7, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xEF, 0x1F, 0xFB,
  0x87, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x70, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x60, 0x77, 0x0E, 0x3F, 0xC1, 0xF8, 0xEF, 0x9F, 0xFB, 0x87,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xFF, 0x77,
  0xCE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x73, 0xF7, 0x70,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x3F,
  0x71, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFC, 0xFF,
  0xBC, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x83,
  0xFF, 0x7F, 0xE0, 0x1F, 0x83, 0xFE, 0x70, 0x67, 0x00, 0x78, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0x40, 0x77, 0x0E, 0xFF, 0xE1, 0xF8, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x07, 0xF0, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x77,
  0xEC, 0xF3, 0xE0, 0x76, 0x07, 0x70, 0x67, 0x0E, 0x30, 0xE3, 0x8C, 0x19,
  0xC1, 0x98, 0x1D, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0xE3, 0x8D, 0x8E, 0x36,
  0x79, 0xD9, 0xE6, 0x66, 0x99, 0x9B, 0x66, 0x4D, 0x8D, 0x36, 0x3C, 0xD8,
  0xF1, 0x63, 0xC7, 0x0F, 0x1C, 0xF0, 0x77, 0x0E, 0x39, 0xC1, 0xD8, 0x0F,
  0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x19, 0xC3, 0x9C, 0x70, 0xEE, 0x07, 0xE0,
  0x36, 0x07, 0x70, 0x67, 0x0E, 0x30, 0xE3, 0x8C, 0x19, 0xC1, 0xD8, 0x1D,
  0x80, 0xF8, 0x0F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x07, 0xC0, 0x78,
  0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x1C, 0x06, 0x3F, 0x0F, 0xC0, 0x18, 0x07, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x7F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x3F, 0x80, 0x60, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x1C, 0x03, 0xF0, 0xFC, 0x70, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x63, 0xF8, 0xFC, 0x00, 0x3C, 0x37, 0xE3, 0x67, 0x3C, 0x3E,
  0xC1, 0xC0,
};

const GFXglyph IBMPlexMono_Medium24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 7, 7, 14, 4, -18 },
  { 17, 14, 17, 14, 0, -17 },
  { 47, 12, 21, 14, 1, -19 },
  { 79, 14, 17, 14, 0, -17 },
  { 109, 14, 17, 14, 0, -17 },
  { 139, 2, 7, 14, 6, -18 },
  { 141, 7, 21, 14, 5, -18 },
  { 160, 8, 21, 14, 2, -18 },
  { 181, 12, 12, 14, 1, -13 },
  { 199, 12, 12, 14, 1, -13 },
  { 217, 5, 7, 14, 5, -4 },
  { 222, 7, 2, 14, 4, -8 },
  { 224, 4, 4, 14, 5, -4 },
  { 226, 10, 21, 14, 2, -18 },
  { 253, 12, 17, 14, 1, -17 },
  { 279, 13, 17, 14, 1, -17 },
  { 307, 12, 17, 14, 1, -17 },
  { 333, 12, 17, 14, 1, -17 },
  { 359, 13, 17, 14, 1, -17 },
  { 387, 12, 17, 14, 1, -17 },
  { 413, 12, 17, 14, 1, -17 },
  { 439, 12, 17, 14, 1, -17 },
  { 465, 12, 17, 14, 1, -17 },
  { 491, 12, 17, 14, 1, -17 },
  { 517, 4, 13, 14, 5, -13 },
  { 524, 5, 16, 14, 5, -13 },
  { 534, 10, 14, 14, 2, -14 },
  { 552, 12, 7, 14, 1, -11 },
  { 563, 10, 14, 14, 2, -14 },
  { 581, 10, 17, 14, 2, -17 },
  { 603, 12, 20, 14, 1, -17 },
  { 633, 14, 17, 14, 0, -17 },
  { 663, 11, 17, 14, 2, -17 },
  { 687, 12, 17, 14, 1, -17 },
  { 713, 11, 17, 14, 2, -17 },
  { 737, 11, 17, 14, 2, -17 },
  { 761, 11, 17, 14, 2, -17 },
  { 785, 12, 17, 14, 1, -17 },
  { 811, 11, 17, 14, 2, -17 },
  { 835, 10, 17, 14, 2, -17 },
  { 857, 11, 17, 14, 1, -17 },
  { 881, 12, 17, 14, 2, -17 },
  { 907, 10, 17, 14, 3, -17 },
  { 929, 12, 17, 14, 1, -17 },
  { 955, 11, 17, 14, 2, -17 },
  { 979, 12, 17, 14, 1, -17 },
  { 1005, 11, 17, 14, 2, -17 },
  { 1029, 12, 21, 14, 1, -17 },
  { 1061, 11, 17, 14, 2, -17 },
  { 1085, 12, 17, 14, 1, -17 },
  { 1111, 13, 17, 14, 1, -17 },
  { 1139, 11, 17, 14, 2, -17 },
  { 1163, 13, 17, 14, 1, -17 },
  { 1191, 13, 17, 14, 1, -17 },
  { 1219, 14, 17, 14, 0, -17 },
  { 1249, 14, 17, 14, 0, -17 },
  { 1279, 12, 17, 14, 1, -17 },
  { 1305, 7, 21, 14, 5, -18 },
  { 1324, 10, 21, 14, 2, -18 },
  { 1351, 7, 21, 14, 2, -18 },
  { 1370, 13, 10, 14, 1, -17 },
  { 1387, 12, 2, 14, 1, 2 },
  { 1390, 5, 5, 14, 4, -19 },
  { 1394, 12, 12, 14, 1, -12 },
  { 1412, 11, 18, 14, 2, -18 },
  { 1437, 11, 12, 14, 2, -12 },
  { 1454, 12, 18, 14, 1, -18 },
  { 1481, 12, 12, 14, 1, -12 },
  { 1499, 11, 18, 14, 2, -18 },
  { 1524, 13, 19, 14, 1, -14 },
  { 1555, 11, 18, 14, 2, -18 },
  { 1580, 11, 18, 14, 2, -18 },
  { 1605, 9, 23, 14, 2, -18 },
  { 1631, 12, 18, 14, 2, -18 },
  { 1658, 11, 18, 14, 2, -18 },
  { 1683, 12, 12, 14, 1, -12 },
  { 1701, 11, 12, 14, 2, -12 },
  { 1718, 12, 12, 14, 1, -12 },
  { 1736, 11, 17, 14, 2, -12 },
  { 1760, 12, 17, 14, 1, -12 },
  { 1786, 11, 12, 14, 2, -12 },
  { 1803, 12, 12, 14, 1, -12 },
  { 1821, 12, 17, 14, 1, -17 },
  { 1847, 10, 12, 14, 2, -12 },
  { 1862, 12, 12, 14, 1, -12 },
  { 1880, 14, 12, 14, 0, -12 },
  { 1901, 12, 12, 14, 1, -12 },
  { 1919, 12, 17, 14, 1, -12 },
  { 1945, 11, 12, 14, 2, -12 },
  { 1962, 10, 21, 14, 2, -18 },
  { 1989, 2, 21, 14, 6, -18 },
  { 1995, 10, 21, 14, 2, -18 },
  { 2022, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_Medium24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_MEDIUM24PT7B_H_
