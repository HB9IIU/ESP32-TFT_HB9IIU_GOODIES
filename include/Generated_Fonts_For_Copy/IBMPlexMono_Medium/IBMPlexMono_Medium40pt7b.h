#ifndef _IBMPLEXMONO_MEDIUM40PT7B_H_
#define _IBMPLEXMONO_MEDIUM40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium40pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xC3,
  0x0C, 0x30, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00,
  0xF0, 0xF0, 0x7F, 0xC3, 0xFD, 0xFF, 0x0F, 0xF7, 0xFC, 0x3F, 0xDF, 0xF1,
  0xFF, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0,
  0xFF, 0x8F, 0xFB, 0xFC, 0x3F, 0xEF, 0xF0, 0xFF, 0xBF, 0xC3, 0xFE, 0x0F,
  0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7E, 0x73, 0xF7, 0xC7, 0x1E, 0x78, 0x70,
  0x47, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00, 0x7E, 0x70, 0x03, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x77, 0xF0, 0x07, 0x1F, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x20, 0x70, 0xF7,
  0x07, 0x0F, 0xF8, 0x71, 0xFF, 0xE7, 0x3E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0x1F, 0xE0, 0x1E, 0x3F, 0xF0, 0x1C,
  0x78, 0xF0, 0x3C, 0x70, 0x70, 0x38, 0x70, 0x78, 0x78, 0x70, 0x78, 0x70,
  0x70, 0x78, 0xF0, 0x70, 0x78, 0xE0, 0x70, 0x71, 0xE0, 0x78, 0xF3, 0xC0,
  0x3F, 0xF3, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xF8, 0x03, 0xCF, 0xFC, 0x03, 0xCF, 0x1E, 0x07, 0x9E, 0x0E,
  0x07, 0x1E, 0x0E, 0x0F, 0x1E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1E, 0x1E, 0x0E,
  0x1C, 0x1E, 0x0E, 0x3C, 0x0F, 0x1E, 0x38, 0x0F, 0xFC, 0x78, 0x07, 0xF8,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0x0F, 0x00, 0xF8, 0x1E, 0x03, 0xC0, 0x40, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC1, 0xFC, 0x7F, 0x07, 0xF3, 0xFE, 0x1F, 0xDF, 0x7C, 0x7F, 0x78,
  0xF9, 0xE3, 0xE1, 0xF7, 0x8F, 0x07, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x1F,
  0xC3, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x07, 0xF8, 0x7F, 0xFD, 0xF0,
  0xFF, 0xE3, 0xC1, 0xFF, 0x0F, 0x83, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x7C,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x08, 0x0F, 0x02, 0xF0, 0xF0, 0xFF, 0xEF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0x9E, 0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x1C,
  0x03, 0x80, 0x40, 0x30, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0x0F, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03,
  0xE3, 0xE0, 0x7C, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0x70, 0x7C,
  0x01, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0x7E, 0xF8, 0x03, 0xE3, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0,
  0xFC, 0xF0, 0x07, 0xC4, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF2, 0x00, 0x1E, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7E, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xDF,
  0x00, 0x0F, 0x7C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x1F, 0x00,
  0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x38, 0x1F, 0x01, 0xE0,
  0x7C, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x00, 0x7C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x7C, 0x03, 0x9F, 0xF0, 0x3B, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x10, 0x01, 0xF3, 0x80, 0x1F, 0x7C, 0x03, 0xEF, 0xE0,
  0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x7E, 0x07, 0xDF, 0xF8, 0x7B, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x07,
  0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xE3, 0xE0, 0x7E, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xEF, 0x00, 0x3E,
  0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E, 0x78,
  0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xE0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0xFF, 0xE3, 0xFF, 0xDE, 0x1F, 0xFB, 0xE0,
  0x7E, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0x3C, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x1F,
  0xBE, 0x01, 0xFF, 0x00, 0x7C, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE3, 0xE0, 0x7C, 0x78, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x70,
  0x3C, 0xFE, 0x1F, 0xDF, 0xC3, 0xFF, 0xF8, 0xF0, 0xFF, 0x1E, 0x0F, 0xE3,
  0x81, 0xFC, 0x70, 0x3F, 0x8E, 0x07, 0xF1, 0xC0, 0xFE, 0x38, 0x1F, 0xC7,
  0x03, 0xF8, 0xF0, 0x7F, 0x1E, 0x0F, 0xE1, 0xFF, 0xDC, 0x3F, 0xBB, 0x83,
  0xF7, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00,
  0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x3C, 0x0F, 0x00, 0xF0,
  0x3C, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x78, 0x00, 0xF9, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x80,
  0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x7C,
  0x01, 0xF7, 0xC0, 0x0E, 0x78, 0x01, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x10, 0x7C, 0x01,
  0xE7, 0xC0, 0x1F, 0x3E, 0x03, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0,
  0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x03,
  0xF7, 0xC0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xC0, 0x0E, 0xF8, 0x02, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x03, 0xDF,
  0x00, 0xF9, 0xF8, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xBC, 0x3F, 0xE7, 0x81,
  0xF0, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x38, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xF9,
  0xF8, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xC0, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7,
  0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFE, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x03,
  0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xF7, 0x0E, 0xFF, 0x78, 0xEF,
  0xF7, 0x9E, 0xFF, 0x39, 0xCF, 0xF3, 0xDC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8,
  0xFF, 0x1F, 0x8F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x06,
  0x0F, 0xF0, 0x60, 0xFF, 0x06, 0x0F, 0xF0, 0x40, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xDC, 0x0F, 0xF7, 0x83, 0xFD, 0xE0,
  0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F,
  0xC3, 0xCF, 0xF0, 0xF3, 0xFC, 0x3C, 0xFF, 0x07, 0xBF, 0xC1, 0xEF, 0xF0,
  0x3B, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7D, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0,
  0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0x80, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7D, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0x0F, 0x03, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0xF8,
  0x07, 0x9F, 0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7E, 0x07, 0xF7, 0xC0, 0x1C,
  0x78, 0x00, 0x87, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x20,
  0x01, 0xF7, 0x00, 0x1F, 0xF8, 0x03, 0xEF, 0xE0, 0x7E, 0x7F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xE0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xDC, 0x1E, 0x0E, 0x70, 0x7C, 0x39, 0xE3, 0xF0, 0xE7,
  0x8F, 0xC3, 0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x79, 0xE3, 0xF9, 0xE7, 0x9C,
  0xE7, 0x9E, 0x73, 0x9E, 0x79, 0xCE, 0x79, 0xE7, 0x39, 0xE7, 0x9C, 0xE7,
  0x9E, 0xF3, 0xDE, 0x7B, 0x87, 0x78, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C,
  0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0xBC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x87, 0xC0, 0x3C,
  0x1F, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x03,
  0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xDF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF8, 0x01, 0xE1, 0xE0, 0x0F,
  0x07, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xB0, 0x00, 0x34,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xF1,
  0xE3, 0xE3, 0xC3, 0xC7, 0x86, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF8, 0x7C, 0x0F, 0x83, 0x80, 0x7C, 0x10, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7C,
  0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x0B, 0xC7,
  0xFF, 0xBF, 0x7F, 0xF3, 0xF3, 0xFF, 0x1F, 0x0F, 0xC0, 0xF0, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0x83, 0xE7, 0xFC,
  0x7D, 0xFF, 0xCF, 0xFF, 0xF9, 0xFC, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xDF, 0xC1, 0xFB,
  0xFF, 0xFE, 0x7D, 0xFF, 0xCF, 0x9F, 0xF1, 0xF1, 0xF8, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x01, 0xFF,
  0x80, 0x33, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x31, 0xF0, 0x0F, 0x7E, 0x0F,
  0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x7C, 0x7F, 0xCF,
  0x9F, 0xFD, 0xF3, 0xFF, 0xFE, 0xFC, 0x1F, 0xDF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0xC1, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFD, 0xF1, 0xFF, 0x3E, 0x0F, 0xC7, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xC7, 0xC0,
  0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x01, 0x07,
  0xC0, 0x18, 0x3F, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0xA0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF8,
  0x3E, 0x07, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x83, 0xC0,
  0x3C, 0x1F, 0x03, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xC0, 0x07, 0xDC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x3F, 0x0F, 0x9F, 0xE3, 0xEF, 0xFC, 0xFF, 0xFF, 0xBF,
  0x87, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xFB, 0xC0, 0x3E, 0x78,
  0x0F, 0x8F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0x8F, 0x80, 0xF3,
  0xE0, 0x1E, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xF1,
  0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xE3, 0xC0,
  0x3E, 0x78, 0x07, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xC3, 0xCE, 0x7C, 0x7E, 0xEF, 0xEF,
  0xFE, 0xFE, 0xFF, 0xF1, 0xF8, 0xFF, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F,
  0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0,
  0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE,
  0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xF0, 0xF8, 0xFC,
  0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xBE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0xC0,
  0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0xF8, 0xFC, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xE0, 0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xFE, 0x0F, 0xDF, 0xFF, 0xF3, 0xEF, 0xFE,
  0x7C, 0xFF, 0x8F, 0x8F, 0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE3, 0xE3, 0xFE, 0x7C, 0xFF, 0xEF, 0x9F, 0xFF, 0xF7, 0xE0, 0xFE,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFB,
  0xE0, 0x1F, 0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0xEF, 0x8F, 0xF9, 0xF0,
  0x7E, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xF0, 0x3D, 0x80, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xE0, 0x3C, 0x78,
  0x01, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x79, 0x80,
  0x0F, 0x7C, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x3F,
  0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7E, 0x1F, 0xDF, 0xFF,
  0xF3, 0xFF, 0x7C, 0x7F, 0x9F, 0x0F, 0xC7, 0xC0, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0xFF, 0x07, 0xC3, 0xFC, 0x3F, 0x0F,
  0xF0, 0xFC, 0x3D, 0xC3, 0xF0, 0xE7, 0x0E, 0xC3, 0x9C, 0x33, 0x0E, 0x71,
  0xCE, 0x39, 0xE7, 0x38, 0xE7, 0x9C, 0xE7, 0x9E, 0x73, 0x9E, 0x39, 0xC6,
  0x78, 0xE6, 0x19, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70,
  0xEE, 0x1D, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC,
  0x01, 0xF7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x80,
  0xF9, 0xF0, 0x07, 0xDE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0x9F,
  0x00, 0xF1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0,
  0x3E, 0xF8, 0x01, 0xF0, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x03, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x9E,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x07, 0xFF, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F,
  0x00, 0x61, 0xFC, 0x07, 0x3F, 0xC0, 0xF7, 0xFE, 0x0F, 0x79, 0xF0, 0xE7,
  0x0F, 0x9E, 0xF0, 0x7F, 0xEE, 0x07, 0xFC, 0xE0, 0x3F, 0x86, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Medium40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 28, 24, 9, -28 },
  { 22, 12, 12, 24, 6, -30 },
  { 40, 22, 28, 24, 1, -28 },
  { 117, 20, 36, 24, 2, -32 },
  { 207, 24, 28, 24, 0, -28 },
  { 291, 22, 28, 24, 1, -28 },
  { 368, 4, 12, 24, 10, -30 },
  { 374, 12, 36, 24, 8, -30 },
  { 428, 12, 36, 24, 4, -30 },
  { 482, 20, 20, 24, 2, -22 },
  { 532, 20, 20, 24, 2, -22 },
  { 582, 8, 12, 24, 8, -6 },
  { 594, 12, 4, 24, 6, -14 },
  { 600, 6, 7, 24, 9, -6 },
  { 606, 18, 36, 24, 3, -30 },
  { 687, 20, 28, 24, 2, -28 },
  { 757, 21, 28, 24, 2, -28 },
  { 831, 20, 28, 24, 2, -28 },
  { 901, 19, 28, 24, 2, -28 },
  { 968, 22, 28, 24, 1, -28 },
  { 1045, 20, 28, 24, 2, -28 },
  { 1115, 20, 28, 24, 2, -28 },
  { 1185, 20, 28, 24, 2, -28 },
  { 1255, 20, 28, 24, 2, -28 },
  { 1325, 20, 28, 24, 2, -28 },
  { 1395, 6, 22, 24, 9, -21 },
  { 1412, 8, 27, 24, 8, -21 },
  { 1439, 18, 23, 24, 3, -24 },
  { 1491, 20, 12, 24, 2, -18 },
  { 1521, 18, 23, 24, 3, -24 },
  { 1573, 18, 28, 24, 3, -28 },
  { 1636, 19, 32, 24, 2, -28 },
  { 1712, 22, 28, 24, 1, -28 },
  { 1789, 19, 28, 24, 3, -28 },
  { 1856, 20, 28, 24, 2, -28 },
  { 1926, 19, 28, 24, 3, -28 },
  { 1993, 18, 28, 24, 3, -28 },
  { 2056, 18, 28, 24, 3, -28 },
  { 2119, 19, 28, 24, 2, -28 },
  { 2186, 18, 28, 24, 3, -28 },
  { 2249, 18, 28, 24, 3, -28 },
  { 2312, 18, 28, 24, 2, -28 },
  { 2375, 21, 28, 24, 3, -28 },
  { 2449, 18, 28, 24, 4, -28 },
  { 2512, 20, 28, 24, 2, -28 },
  { 2582, 18, 28, 24, 3, -28 },
  { 2645, 20, 28, 24, 2, -28 },
  { 2715, 19, 28, 24, 3, -28 },
  { 2782, 20, 35, 24, 2, -28 },
  { 2870, 19, 28, 24, 3, -28 },
  { 2937, 20, 28, 24, 2, -28 },
  { 3007, 22, 28, 24, 1, -28 },
  { 3084, 18, 28, 24, 3, -28 },
  { 3147, 22, 28, 24, 1, -28 },
  { 3224, 22, 28, 24, 1, -28 },
  { 3301, 22, 28, 24, 1, -28 },
  { 3378, 24, 28, 24, 0, -28 },
  { 3462, 20, 28, 24, 2, -28 },
  { 3532, 12, 36, 24, 8, -30 },
  { 3586, 18, 36, 24, 3, -30 },
  { 3667, 12, 36, 24, 4, -30 },
  { 3721, 22, 17, 24, 1, -28 },
  { 3768, 20, 4, 24, 2, 3 },
  { 3778, 7, 8, 24, 7, -31 },
  { 3785, 20, 21, 24, 2, -21 },
  { 3838, 19, 30, 24, 3, -30 },
  { 3910, 18, 21, 24, 3, -21 },
  { 3958, 19, 30, 24, 2, -30 },
  { 4030, 20, 21, 24, 2, -21 },
  { 4083, 19, 30, 24, 3, -30 },
  { 4155, 21, 33, 24, 2, -25 },
  { 4242, 18, 30, 24, 3, -30 },
  { 4310, 18, 31, 24, 4, -31 },
  { 4380, 14, 39, 24, 4, -31 },
  { 4449, 19, 30, 24, 4, -30 },
  { 4521, 18, 30, 24, 3, -30 },
  { 4589, 20, 21, 24, 2, -21 },
  { 4642, 18, 21, 24, 3, -21 },
  { 4690, 20, 21, 24, 2, -21 },
  { 4743, 19, 29, 24, 3, -21 },
  { 4812, 19, 29, 24, 2, -21 },
  { 4881, 19, 21, 24, 3, -21 },
  { 4931, 19, 21, 24, 2, -21 },
  { 4981, 19, 28, 24, 2, -28 },
  { 5048, 18, 21, 24, 3, -21 },
  { 5096, 20, 21, 24, 2, -21 },
  { 5149, 22, 21, 24, 1, -21 },
  { 5207, 20, 21, 24, 2, -21 },
  { 5260, 20, 29, 24, 2, -21 },
  { 5333, 18, 21, 24, 3, -21 },
  { 5381, 16, 36, 24, 4, -30 },
  { 5453, 4, 36, 24, 10, -30 },
  { 5471, 16, 36, 24, 4, -30 },
  { 5543, 20, 10, 24, 2, -17 },
};

const GFXfont IBMPlexMono_Medium40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_MEDIUM40PT7B_H_
