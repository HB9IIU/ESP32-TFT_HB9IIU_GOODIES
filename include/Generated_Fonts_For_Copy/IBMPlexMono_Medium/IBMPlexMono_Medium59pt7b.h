#ifndef _IBMPLEXMONO_MEDIUM59PT7B_H_
#define _IBMPLEXMONO_MEDIUM59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x8F, 0x80, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0xF3, 0xFF,
  0xE0, 0x7F, 0xFC, 0xFF, 0xF8, 0x3F, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x07,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF9, 0xE7, 0xFE, 0x3F, 0x87, 0x83, 0xF1, 0xFC, 0x1E, 0x07, 0x87, 0xF0,
  0x78, 0x0C, 0x1F, 0x81, 0xE0, 0x20, 0x7E, 0x07, 0x80, 0x01, 0xF8, 0x1E,
  0x00, 0x07, 0xE0, 0x78, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x7F, 0x07, 0x80,
  0x01, 0xFC, 0x1E, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x0F, 0xFD, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x79, 0xFF, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x1E,
  0x07, 0xF0, 0x00, 0x78, 0x1F, 0xC0, 0x01, 0xE0, 0x3F, 0x00, 0x07, 0x80,
  0xFC, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x78, 0x0F, 0xC6, 0x01, 0xE0, 0x7F,
  0x3C, 0x07, 0x81, 0xF9, 0xF8, 0x1E, 0x0F, 0xEF, 0xF0, 0x78, 0x7F, 0xBF,
  0xF9, 0xE7, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xF1, 0xFF, 0xE0, 0x00, 0xF8, 0xFF, 0xFC,
  0x00, 0x7C, 0x7F, 0xFF, 0x80, 0x1F, 0x1F, 0x87, 0xE0, 0x0F, 0x8F, 0xC0,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x7C, 0x3E,
  0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0xF8, 0x07, 0xC1, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC0, 0xF8, 0x3E,
  0x01, 0xF8, 0x7E, 0x1F, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x0F, 0xFF, 0xC3,
  0xE0, 0x03, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7C, 0x3F, 0xFE, 0x00, 0x3E, 0x1F, 0xFF, 0xC0,
  0x0F, 0x87, 0xFF, 0xF0, 0x07, 0xC3, 0xF0, 0x7E, 0x01, 0xF0, 0xF8, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x78, 0x1F, 0x03, 0xC0,
  0x1E, 0x07, 0xC0, 0xF0, 0x07, 0xC3, 0xE0, 0x3C, 0x01, 0xE1, 0xF8, 0x0F,
  0x80, 0x78, 0x7C, 0x03, 0xE0, 0x3E, 0x3F, 0x00, 0xF8, 0x0F, 0x8F, 0x80,
  0x3F, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0xFC, 0xFC,
  0x00, 0x3F, 0xFE, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x0C,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x3F,
  0xBF, 0x83, 0xFF, 0x3F, 0x8F, 0xC1, 0xF0, 0x3F, 0x87, 0xF0, 0xF8, 0x1F,
  0x81, 0xFC, 0x7C, 0x0F, 0xC0, 0x7F, 0x3E, 0x0F, 0xE0, 0x1F, 0x9F, 0x07,
  0xF0, 0x07, 0xEF, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0xC0,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF8,
  0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFE, 0x07, 0xDF,
  0xE0, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x07, 0xE0, 0x0C, 0xF8,
  0x0F, 0xC0, 0xF9, 0xFE, 0x1F, 0x8F, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x3E, 0x07,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x7F, 0xFC, 0x1F, 0xC1, 0xFF,
  0xF0, 0x7F, 0x07, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x7F, 0xFC,
  0x0F, 0x81, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0xFF, 0x3F,
  0x00, 0x07, 0xF8, 0xFC, 0x00, 0x3F, 0xC3, 0xF0, 0x01, 0xFE, 0x0F, 0xC0,
  0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0xE0, 0x0F, 0xC0, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x87, 0x00, 0x01,
  0xFC, 0x08, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xC0, 0x01, 0xFC,
  0x0E, 0x00, 0x07, 0xF0, 0x08, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x08, 0x00, 0x03, 0xF8, 0x30, 0x00,
  0x0F, 0xE3, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x0F,
  0xF1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC,
  0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80,
  0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x0F, 0xF0, 0x07, 0xE3, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0x07, 0xEF, 0xFF,
  0xF8, 0x7D, 0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0x00, 0x1F, 0xE7,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF1, 0x00, 0x00, 0x7F, 0x18, 0x00, 0x07, 0xF3, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFC, 0x7F, 0xC0, 0x7F,
  0xC7, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x1F, 0xFE, 0x03, 0xF9, 0xFF, 0xFC, 0x1F,
  0xDF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xC7, 0xEF, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x01,
  0xFC, 0x7F, 0x80, 0x1F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xFC, 0x7F, 0xFF,
  0xEF, 0xE3, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0xE7, 0xF0, 0x1F, 0xFE, 0x3F,
  0x80, 0x3F, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0x1F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC7, 0x80, 0x01,
  0xF8, 0x30, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x1F, 0x1F, 0xBE, 0x03, 0xFE, 0x7D, 0xF0, 0x3F, 0xF3, 0xEF,
  0x81, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0xFE, 0x0F,
  0xC0, 0x7F, 0xF0, 0x7E, 0x03, 0xFF, 0x83, 0xE0, 0x0F, 0xFC, 0x1F, 0x00,
  0x7F, 0xE0, 0xF8, 0x03, 0xFF, 0x07, 0xC0, 0x1F, 0xF8, 0x3E, 0x00, 0xFF,
  0xC1, 0xF0, 0x07, 0xFE, 0x0F, 0x80, 0x3F, 0xF0, 0x7C, 0x01, 0xFF, 0x83,
  0xE0, 0x0F, 0xFC, 0x1F, 0x00, 0x7F, 0xE0, 0xFC, 0x07, 0xFF, 0x03, 0xE0,
  0x3F, 0xFC, 0x1F, 0xE7, 0xFB, 0xE0, 0xFF, 0xF7, 0xDF, 0x03, 0xFF, 0xBE,
  0xF8, 0x0F, 0xF9, 0xF7, 0xC0, 0x3F, 0x8F, 0xBF, 0x00, 0x60, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x01,
  0xFF, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xDF,
  0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xE0,
  0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x78, 0x7E, 0x00, 0x02, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x3F, 0x80, 0x01, 0xE1,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0, 0xFC, 0x00, 0x7F,
  0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC,
  0x00, 0x7F, 0x8F, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00,
  0xFF, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xC7,
  0xF0, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0x03, 0xFF, 0x0F, 0xFF,
  0xFB, 0xF0, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0x1F, 0xFC, 0x3F,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x18, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x3F, 0xC0,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xFB, 0xF0, 0x00,
  0x3F, 0xCF, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0xC3, 0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0x80,
  0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F,
  0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xC3,
  0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xFC,
  0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x3F, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF3, 0xF8, 0x00,
  0xFF, 0xCF, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F,
  0x80, 0xFF, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xC0,
  0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x83, 0xF0, 0x00,
  0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFE,
  0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xEF, 0x81, 0xFF, 0xFF, 0x7E, 0x1F, 0x7F, 0xFB, 0xF0,
  0xFB, 0xFF, 0xCF, 0x87, 0xDF, 0xFE, 0x7E, 0x7C, 0xFF, 0xF1, 0xF3, 0xE7,
  0xFF, 0x8F, 0xBE, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE1, 0xFF, 0x8F, 0xFF,
  0x0F, 0xF8, 0x7F, 0xF8, 0x3F, 0xC3, 0xFF, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F,
  0xE0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x07, 0x81,
  0xFF, 0xE0, 0x38, 0x0F, 0xFF, 0x01, 0xC0, 0x7F, 0xF8, 0x06, 0x03, 0xFF,
  0xC0, 0x20, 0x1F, 0xFE, 0x01, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xE0, 0x1F,
  0xFE, 0xFC, 0x03, 0xFF, 0xCF, 0xC0, 0x7F, 0xF9, 0xF8, 0x0F, 0xFF, 0x3F,
  0x01, 0xFF, 0xE3, 0xF0, 0x3F, 0xFC, 0x7E, 0x07, 0xFF, 0x87, 0xC0, 0xFF,
  0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x7F, 0xF8, 0x3F,
  0x0F, 0xFF, 0x03, 0xE1, 0xFF, 0xE0, 0x7E, 0x3F, 0xFC, 0x0F, 0xC7, 0xFF,
  0x80, 0xFC, 0xFF, 0xF0, 0x1F, 0x9F, 0xFE, 0x03, 0xF3, 0xFF, 0xC0, 0x3F,
  0x7F, 0xF8, 0x07, 0xEF, 0xFF, 0x00, 0x7D, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFC, 0x00, 0xFF, 0xBF, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFB, 0xF8, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFE, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x60, 0xFE, 0x00, 0x01, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x20, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x9F,
  0x81, 0xFC, 0x07, 0xCF, 0xC0, 0xFE, 0x03, 0xE7, 0xE0, 0x7F, 0x81, 0xF3,
  0xF0, 0x3F, 0xC1, 0xF8, 0xF8, 0x1F, 0xE0, 0xFC, 0x7C, 0x1F, 0xF0, 0x7E,
  0x3E, 0x0F, 0xF8, 0x3F, 0x1F, 0x07, 0xBE, 0x1F, 0x8F, 0x83, 0xDF, 0x0F,
  0xC7, 0xC1, 0xEF, 0x87, 0xE3, 0xF1, 0xF7, 0xC3, 0xE1, 0xF8, 0xF9, 0xE1,
  0xF0, 0xFC, 0x7C, 0xF0, 0xF8, 0x7E, 0x3C, 0x7C, 0x7C, 0x3F, 0x1E, 0x3E,
  0x3E, 0x1F, 0x8F, 0x1F, 0x1F, 0x0F, 0xCF, 0x87, 0x8F, 0x87, 0xE7, 0xC3,
  0xC7, 0xC1, 0xF3, 0xE1, 0xF3, 0xE0, 0xF9, 0xE0, 0xFB, 0xF0, 0x7C, 0xF0,
  0x7D, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0x7E, 0x0F, 0xBE,
  0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3E, 0x1C, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x80, 0xF8,
  0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xE0, 0x10, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0x83,
  0xF8, 0x01, 0xFC, 0x07, 0x80, 0x07, 0xF0, 0x18, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF, 0xFC, 0xFF, 0x9F,
  0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x0F, 0xFE,
  0x07, 0xE3, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0x1F, 0xBF, 0xFF, 0xF3, 0xF7,
  0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xF7, 0xEE, 0x07,
  0xFC, 0xFD, 0xFF, 0xFF, 0x9F, 0x9F, 0xFF, 0xE3, 0xF1, 0xFF, 0xF8, 0x7E,
  0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F,
  0xE0, 0x7F, 0x87, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x07,
  0x0F, 0xE0, 0x00, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x81,
  0xF8, 0x00, 0x1C, 0x3F, 0x80, 0x07, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0xC0,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0x87, 0xF0, 0x7F,
  0xFC, 0x7F, 0x0F, 0xFF, 0xE7, 0xF1, 0xFF, 0xFF, 0x7F, 0x3F, 0xE0, 0x7F,
  0xF3, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3, 0xFE,
  0x07, 0xFF, 0x1F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xC7,
  0xF0, 0x3F, 0xF8, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x02, 0x07, 0xE0, 0x00, 0x30, 0x7F, 0x00, 0x07, 0x83,
  0xF8, 0x00, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x78, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x1F, 0xDF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x03,
  0xF8, 0x0F, 0xC3, 0xFF, 0x83, 0xF1, 0xFF, 0xF0, 0xFC, 0xFF, 0xFE, 0x3F,
  0x7F, 0xFF, 0xCF, 0xDC, 0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xDF, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x07,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x7F, 0x80,
  0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0xC3, 0xE7, 0xF8, 0x7F, 0xCF, 0x9F,
  0xF3, 0xFF, 0x3E, 0xFF, 0xCF, 0xFE, 0xFB, 0xFF, 0xFF, 0xFB, 0xF8, 0xFF,
  0x87, 0xEF, 0xC1, 0xFC, 0x0F, 0xFE, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0x80,
  0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x3F,
  0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE,
  0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80,
  0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E,
  0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0x80,
  0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x3F,
  0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x3F, 0x0F, 0xFE, 0x0F, 0xC7, 0xFF, 0xC3, 0xF3, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFF, 0x3F, 0x70, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x87, 0xFF, 0x03, 0xF1, 0xFF, 0xF8, 0x7E,
  0x7F, 0xFF, 0x8F, 0xDF, 0xFF, 0xF9, 0xFB, 0x81, 0xFF, 0x3F, 0xC0, 0x0F,
  0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xDF, 0xE0, 0x07, 0xFB, 0xF7, 0x03, 0xFE, 0x7E, 0xFF, 0xFF, 0xCF,
  0xCF, 0xFF, 0xF1, 0xF8, 0xFF, 0xFC, 0x3F, 0x0F, 0xFE, 0x07, 0xE0, 0x7F,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0x07, 0xFF,
  0xC7, 0xF0, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0xF7, 0xF3, 0xFE, 0x07, 0xFF,
  0x3F, 0xC0, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x3F, 0xE0,
  0x7F, 0xF1, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFC, 0x7F,
  0x03, 0xFF, 0x87, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0x7F, 0xFC, 0x01, 0xFB, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFE, 0x01, 0xFF, 0x1F, 0x80, 0x07, 0xC3,
  0xF8, 0x00, 0x18, 0x3F, 0x80, 0x01, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF1, 0x80, 0x00, 0x3F, 0x3E,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xBF, 0xE0, 0xFF, 0xDF, 0xFF, 0xF7, 0xE7, 0xFF, 0xF3, 0xF1,
  0xFF, 0xF9, 0xF8, 0x7F, 0xF0, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC,
  0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x03, 0xF8, 0x07, 0xDF, 0x01,
  0xFC, 0x03, 0xEF, 0x80, 0xFF, 0x01, 0xF7, 0xC0, 0x7F, 0x81, 0xFB, 0xE0,
  0x3F, 0xC0, 0xF9, 0xF0, 0x3F, 0xE0, 0x7C, 0xFC, 0x1E, 0xF0, 0x3E, 0x7E,
  0x0F, 0x78, 0x1F, 0x1F, 0x07, 0xBE, 0x0F, 0x8F, 0x83, 0xCF, 0x07, 0xC7,
  0xC1, 0xE7, 0x83, 0xE3, 0xE1, 0xE3, 0xC3, 0xE1, 0xF0, 0xF1, 0xE1, 0xF0,
  0xF8, 0x78, 0xF8, 0xF8, 0x7C, 0x3C, 0x3C, 0x7C, 0x1F, 0x1E, 0x1E, 0x3E,
  0x0F, 0x9F, 0x0F, 0x1F, 0x07, 0xCF, 0x07, 0x8F, 0x83, 0xE7, 0x83, 0xC7,
  0x81, 0xF3, 0xC1, 0xF7, 0xC0, 0xF9, 0xE0, 0x7B, 0xE0, 0x7C, 0xF0, 0x3D,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x60, 0x3F, 0xE0, 0x01, 0xF1, 0xFF, 0xC0, 0x07, 0xC7,
  0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0x00, 0xF8, 0xF8, 0xFE, 0x03, 0xE7, 0xC1,
  0xF8, 0x1F, 0x9F, 0x03, 0xF0, 0x7C, 0x7C, 0x07, 0xE3, 0xF3, 0xE0, 0x1F,
  0xFF, 0x8F, 0x80, 0x3F, 0xFE, 0x3E, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0xFF,
  0x80, 0xC0, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Medium59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 10, 42, 35, 13, -41 },
  { 54, 18, 18, 35, 9, -44 },
  { 95, 34, 41, 35, 1, -41 },
  { 270, 30, 55, 35, 3, -48 },
  { 477, 34, 43, 35, 1, -42 },
  { 660, 33, 43, 35, 1, -42 },
  { 838, 6, 18, 35, 15, -44 },
  { 852, 19, 53, 35, 11, -45 },
  { 978, 19, 53, 35, 5, -45 },
  { 1104, 31, 30, 35, 2, -32 },
  { 1221, 28, 29, 35, 4, -33 },
  { 1323, 13, 18, 35, 11, -9 },
  { 1353, 18, 6, 35, 9, -21 },
  { 1367, 10, 10, 35, 13, -9 },
  { 1380, 26, 53, 35, 5, -45 },
  { 1553, 30, 43, 35, 3, -42 },
  { 1715, 30, 41, 35, 3, -41 },
  { 1869, 29, 42, 35, 3, -42 },
  { 2022, 30, 43, 35, 2, -42 },
  { 2184, 31, 41, 35, 2, -41 },
  { 2343, 28, 42, 35, 4, -41 },
  { 2490, 29, 42, 35, 3, -41 },
  { 2643, 29, 41, 35, 3, -41 },
  { 2792, 30, 43, 35, 3, -42 },
  { 2954, 29, 42, 35, 3, -42 },
  { 3107, 10, 32, 35, 13, -31 },
  { 3147, 13, 40, 35, 11, -31 },
  { 3212, 25, 35, 35, 5, -35 },
  { 3322, 28, 18, 35, 4, -27 },
  { 3385, 25, 35, 35, 5, -35 },
  { 3495, 27, 43, 35, 4, -42 },
  { 3641, 29, 49, 35, 3, -42 },
  { 3819, 33, 41, 35, 1, -41 },
  { 3989, 27, 41, 35, 5, -41 },
  { 4128, 29, 43, 35, 3, -42 },
  { 4284, 28, 41, 35, 5, -41 },
  { 4428, 26, 41, 35, 5, -41 },
  { 4562, 27, 41, 35, 5, -41 },
  { 4701, 28, 43, 35, 3, -42 },
  { 4852, 27, 41, 35, 4, -41 },
  { 4991, 26, 41, 35, 5, -41 },
  { 5125, 26, 42, 35, 3, -41 },
  { 5262, 30, 41, 35, 5, -41 },
  { 5416, 26, 41, 35, 6, -41 },
  { 5550, 29, 41, 35, 3, -41 },
  { 5699, 27, 41, 35, 4, -41 },
  { 5838, 30, 43, 35, 3, -42 },
  { 6000, 27, 41, 35, 5, -41 },
  { 6139, 30, 52, 35, 3, -42 },
  { 6334, 28, 41, 35, 5, -41 },
  { 6478, 30, 43, 35, 2, -42 },
  { 6640, 33, 41, 35, 1, -41 },
  { 6810, 27, 42, 35, 4, -41 },
  { 6952, 33, 41, 35, 1, -41 },
  { 7122, 33, 41, 35, 1, -41 },
  { 7292, 33, 41, 35, 1, -41 },
  { 7462, 34, 41, 35, 1, -41 },
  { 7637, 30, 41, 35, 3, -41 },
  { 7791, 18, 53, 35, 12, -45 },
  { 7911, 26, 53, 35, 5, -45 },
  { 8084, 17, 53, 35, 6, -45 },
  { 8197, 31, 25, 35, 2, -41 },
  { 8294, 28, 5, 35, 4, 5 },
  { 8312, 11, 13, 35, 10, -47 },
  { 8330, 29, 32, 35, 4, -31 },
  { 8446, 27, 45, 35, 5, -44 },
  { 8598, 27, 32, 35, 4, -31 },
  { 8706, 28, 45, 35, 3, -44 },
  { 8864, 28, 32, 35, 4, -31 },
  { 8976, 28, 44, 35, 4, -44 },
  { 9130, 31, 48, 35, 3, -35 },
  { 9316, 26, 44, 35, 5, -44 },
  { 9459, 27, 44, 35, 6, -44 },
  { 9608, 22, 56, 35, 5, -44 },
  { 9762, 29, 44, 35, 5, -44 },
  { 9922, 27, 44, 35, 4, -44 },
  { 10071, 30, 31, 35, 3, -31 },
  { 10188, 26, 31, 35, 5, -31 },
  { 10289, 29, 32, 35, 3, -31 },
  { 10405, 27, 43, 35, 5, -31 },
  { 10551, 28, 43, 35, 3, -31 },
  { 10702, 29, 30, 35, 4, -30 },
  { 10811, 28, 32, 35, 3, -31 },
  { 10923, 29, 41, 35, 2, -41 },
  { 11072, 25, 31, 35, 5, -30 },
  { 11169, 30, 30, 35, 3, -30 },
  { 11282, 33, 30, 35, 1, -30 },
  { 11406, 30, 30, 35, 3, -30 },
  { 11519, 31, 42, 35, 2, -30 },
  { 11682, 26, 30, 35, 5, -30 },
  { 11780, 24, 53, 35, 6, -45 },
  { 11939, 5, 53, 35, 15, -45 },
  { 11973, 24, 53, 35, 6, -45 },
  { 12132, 30, 14, 35, 3, -25 },
};

const GFXfont IBMPlexMono_Medium59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_MEDIUM59PT7B_H_
