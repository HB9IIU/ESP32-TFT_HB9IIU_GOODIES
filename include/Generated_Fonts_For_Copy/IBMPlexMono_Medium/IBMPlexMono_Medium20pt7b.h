#ifndef _IBMPLEXMONO_MEDIUM20PT7B_H_
#define _IBMPLEXMONO_MEDIUM20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium20pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x40, 0x06, 0xF6, 0xCF, 0x3C, 0xF3, 0xCF,
  0x30, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xC8, 0x79, 0xF7, 0x9F, 0x19, 0x81,
  0x98, 0xF9, 0xEF, 0x9E, 0x13, 0x03, 0x30, 0x33, 0x03, 0x30, 0x0C, 0x03,
  0x03, 0xF1, 0xFE, 0x6D, 0xF3, 0x2E, 0xC1, 0xF0, 0x7F, 0x07, 0xE0, 0xDC,
  0x33, 0x4C, 0xFB, 0x77, 0xF8, 0xFC, 0x0C, 0x03, 0x00, 0x38, 0x37, 0xC6,
  0xC4, 0x4C, 0x4C, 0xC4, 0x87, 0xD8, 0x38, 0x00, 0x1C, 0x1B, 0xE1, 0x23,
  0x32, 0x32, 0x23, 0x63, 0xEC, 0x1C, 0x1E, 0x03, 0xF0, 0x31, 0x83, 0x00,
  0x30, 0x03, 0x80, 0x3C, 0xE7, 0xCE, 0x66, 0xCE, 0x7C, 0xE3, 0x86, 0x1C,
  0x7E, 0xC3, 0xC7, 0xFF, 0xF0, 0x1C, 0xC3, 0x18, 0x63, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x70, 0xE0, 0xC3, 0x06, 0x18, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x8C, 0x33, 0x80, 0x0C, 0x03, 0x00,
  0xC3, 0xB7, 0xFF, 0xC7, 0x81, 0xE0, 0xCC, 0x73, 0x88, 0x40, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x76,
  0xEE, 0xCC, 0xFF, 0xF0, 0x6F, 0x60, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0,
  0x1E, 0x1F, 0xE6, 0x1B, 0x87, 0xC0, 0xF3, 0x3C, 0xCF, 0x33, 0xC0, 0xF0,
  0x3E, 0x1D, 0x86, 0x7F, 0x87, 0x80, 0x1E, 0x0F, 0x87, 0x63, 0x98, 0xC6,
  0x11, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x7F, 0xDF, 0xF0,
  0x1E, 0x1F, 0xEE, 0x3B, 0x06, 0x01, 0x80, 0x60, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xFF, 0xFF, 0xF0, 0x3E, 0x1F, 0xEE, 0x39, 0x06, 0x01,
  0x80, 0xE1, 0xF0, 0x7C, 0x01, 0x80, 0x74, 0x1F, 0x86, 0x7F, 0x8F, 0x80,
  0x07, 0x03, 0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xC6, 0x31, 0x8C, 0xC3, 0x3F,
  0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60,
  0x1B, 0xC7, 0xF9, 0x87, 0x01, 0xC0, 0x34, 0x1F, 0x86, 0x7F, 0x87, 0x80,
  0x0F, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x1B, 0xCD, 0xFB, 0x87, 0xC0, 0xF0,
  0x3C, 0x0D, 0x87, 0x7F, 0x87, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0x06, 0xC3,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00,
  0x3F, 0x1F, 0xE6, 0x1B, 0x87, 0xE1, 0xD8, 0x63, 0xF0, 0xFC, 0xE1, 0xF0,
  0x3C, 0x0F, 0x87, 0x7F, 0x8F, 0xC0, 0x1E, 0x1F, 0xEE, 0x1B, 0x03, 0xC0,
  0xF0, 0x3E, 0x1D, 0xFB, 0x3D, 0x80, 0x60, 0x30, 0x1C, 0x0E, 0x0F, 0x00,
  0x6F, 0x60, 0x00, 0x06, 0xF6, 0x6F, 0x60, 0x00, 0x07, 0x6E, 0xEC, 0xC0,
  0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x03, 0x0F, 0x3C, 0xF0, 0xC0, 0x80, 0x1E, 0x3F, 0xD8, 0x7C,
  0x30, 0x18, 0x1C, 0x3C, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0,
  0x1E, 0x1F, 0xE6, 0x19, 0x03, 0xC6, 0xF3, 0xFD, 0x8F, 0x63, 0xD8, 0xF6,
  0x3C, 0xFF, 0x3B, 0x60, 0x1C, 0x03, 0xF0, 0x7C, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF8, 0x19, 0x81, 0x98, 0x19, 0x83, 0x0C, 0x3F, 0xC3, 0xFC, 0x70,
  0xE6, 0x06, 0x60, 0x6E, 0x07, 0xFE, 0x7F, 0xB0, 0xD8, 0x6C, 0x36, 0x1B,
  0xF9, 0xFE, 0xC3, 0xE0, 0xF0, 0x78, 0x7F, 0xF7, 0xF0, 0x1F, 0x0F, 0xE7,
  0x1D, 0x83, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x0D, 0xC7,
  0x3F, 0x87, 0xC0, 0xFC, 0x7F, 0xB1, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xF8, 0xEF, 0xF7, 0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x1E, 0x1F, 0xE6, 0x1B, 0x87, 0xC0, 0x30, 0x0C, 0x03, 0x1F, 0xC7,
  0xF0, 0x3E, 0x0D, 0x87, 0x7E, 0xCF, 0x30, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x70, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x3F, 0x9F, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xF0, 0x6C, 0x77, 0xF1, 0xF0, 0xC1, 0xF0, 0xCC, 0x73, 0x38,
  0xCC, 0x36, 0x0F, 0x83, 0xF0, 0xEE, 0x31, 0x8C, 0x73, 0x0C, 0xC3, 0xB0,
  0x70, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0F, 0xFF, 0xFC, 0xE1, 0xF8, 0x7F, 0x3F, 0xCF, 0xDE, 0xF7,
  0xBC, 0xCF, 0x33, 0xCC, 0xF2, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0xF0,
  0xFC, 0x3F, 0x0F, 0x63, 0xD8, 0xF6, 0x3C, 0xCF, 0x33, 0xC6, 0xF1, 0xBC,
  0x6F, 0x0F, 0xC3, 0xF0, 0xF0, 0x1E, 0x1F, 0xE6, 0x1B, 0x87, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0x86, 0x7F, 0x87, 0x80, 0xFE,
  0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x0F, 0xFE, 0xFE, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x00, 0x1E, 0x1F, 0xE6, 0x1B, 0x87, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0x86, 0x7F, 0x87, 0xC0, 0xC0, 0x30, 0x0F,
  0x81, 0xE0, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x0F, 0xFE, 0xFE,
  0x66, 0x31, 0x98, 0xEC, 0x36, 0x1C, 0x3F, 0x1F, 0xE6, 0x1F, 0x84, 0xE0,
  0x1C, 0x07, 0xF0, 0x7E, 0x01, 0xC0, 0x34, 0x0F, 0x87, 0x7F, 0x8F, 0xC0,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x76, 0x19, 0x86,
  0x7F, 0x8F, 0xC0, 0xE0, 0x76, 0x06, 0x70, 0x67, 0x0E, 0x30, 0xC3, 0x0C,
  0x39, 0xC1, 0x98, 0x19, 0x81, 0x98, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0xC0, 0x36, 0x02, 0x60, 0x66, 0x66, 0x66, 0x66, 0xF6, 0x6F, 0x66, 0xF6,
  0x69, 0x66, 0x96, 0x69, 0x67, 0x9E, 0x79, 0xE7, 0x9E, 0x60, 0x63, 0x0E,
  0x38, 0xC1, 0x98, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0x98,
  0x39, 0xC3, 0x0C, 0x70, 0xEE, 0x07, 0xE0, 0x77, 0x0E, 0x30, 0xC3, 0x9C,
  0x19, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0,
  0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x06, 0x06, 0x06, 0x03, 0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x0C, 0x07, 0x81, 0xE0, 0xCC,
  0x73, 0x98, 0x6E, 0x1F, 0x03, 0x80, 0x80, 0xFF, 0xFF, 0xF0, 0x6E, 0x33,
  0x3E, 0x1F, 0xC6, 0x38, 0x06, 0x3F, 0x9F, 0xEE, 0x1B, 0x8E, 0x7F, 0xCF,
  0x70, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0xFD, 0x87, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3F, 0xFB, 0x78, 0x1F, 0x0F, 0xE7, 0x19, 0x84, 0x60,
  0x38, 0x06, 0x11, 0xC7, 0x3F, 0x87, 0xC0, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x19, 0xED, 0xFF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1B, 0xFC, 0xF6,
  0x1E, 0x1F, 0xE6, 0x1B, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0x86, 0x7F, 0x87,
  0xC0, 0x07, 0xC3, 0xF0, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1F, 0xF7, 0xFC, 0x01, 0xC0, 0x71, 0xF1,
  0xFE, 0x61, 0x98, 0x66, 0x19, 0xFC, 0x1E, 0x18, 0x07, 0xF8, 0xFF, 0x40,
  0xF0, 0x3F, 0xFC, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x1C, 0x0E, 0x07, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE,
  0x0E, 0x1C, 0x38, 0x00, 0x1F, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x07, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xEC, 0x73, 0x30, 0xD8, 0x3E, 0x0E, 0xC3, 0x38, 0xC7, 0x30, 0xCC, 0x1C,
  0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0xD9, 0xBF, 0xFC, 0xCF, 0x33,
  0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x30, 0xDE, 0xFF, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x1E, 0x1F, 0xE6, 0x1B, 0x03, 0xC0,
  0xF0, 0x3C, 0x0D, 0x86, 0x7F, 0x87, 0x80, 0xDE, 0x7F, 0xB0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0xFF, 0x6F, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x3D,
  0xBF, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0x7F, 0x9E, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0xF3, 0xFB, 0xCE, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0xFF, 0x7F, 0x80, 0x1F, 0x1F, 0xE6, 0x09, 0x80, 0x7F, 0x0F, 0xE0, 0x1D,
  0x06, 0xFF, 0x8F, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0xFF, 0xF1,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xC3, 0xF0, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x7B, 0xC0, 0xD8, 0x66, 0x19,
  0x86, 0x33, 0x0C, 0xC3, 0x30, 0x78, 0x1E, 0x07, 0x80, 0xC6, 0x34, 0x62,
  0x67, 0x66, 0xF6, 0x6F, 0x66, 0x96, 0x69, 0x66, 0x9E, 0x39, 0xC3, 0x9C,
  0xE1, 0xDC, 0xE3, 0x30, 0x78, 0x1C, 0x07, 0x81, 0xE0, 0xCC, 0x63, 0xB8,
  0x70, 0xC0, 0xF8, 0x76, 0x19, 0x86, 0x33, 0x0C, 0xC3, 0xB0, 0x78, 0x1E,
  0x03, 0x00, 0xC0, 0x60, 0x78, 0x1C, 0x00, 0xFF, 0xFF, 0x07, 0x0E, 0x1C,
  0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x1F, 0x3F, 0x30, 0x30, 0x18, 0x08, 0x0C,
  0x0C, 0xF8, 0xF8, 0x0C, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x3F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xFC, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x30,
  0x1F, 0x1F, 0x30, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0xFC, 0xF8, 0x30, 0xDE,
  0x3C, 0xCF, 0x1E, 0xC3, 0x00,
};

const GFXglyph IBMPlexMono_Medium20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 6, 6, 12, 3, -15 },
  { 13, 12, 14, 12, 0, -14 },
  { 34, 10, 18, 12, 1, -16 },
  { 57, 12, 14, 12, 0, -14 },
  { 78, 12, 14, 12, 0, -14 },
  { 99, 2, 6, 12, 5, -15 },
  { 101, 6, 18, 12, 4, -15 },
  { 115, 6, 18, 12, 2, -15 },
  { 129, 10, 10, 12, 1, -11 },
  { 142, 10, 10, 12, 1, -11 },
  { 155, 4, 6, 12, 4, -3 },
  { 158, 6, 2, 12, 3, -7 },
  { 160, 4, 3, 12, 4, -3 },
  { 162, 8, 18, 12, 2, -15 },
  { 180, 10, 14, 12, 1, -14 },
  { 198, 10, 14, 12, 1, -14 },
  { 216, 10, 14, 12, 1, -14 },
  { 234, 10, 14, 12, 1, -14 },
  { 252, 10, 14, 12, 1, -14 },
  { 270, 10, 14, 12, 1, -14 },
  { 288, 10, 14, 12, 1, -14 },
  { 306, 10, 14, 12, 1, -14 },
  { 324, 10, 14, 12, 1, -14 },
  { 342, 10, 14, 12, 1, -14 },
  { 360, 4, 10, 12, 4, -10 },
  { 365, 4, 13, 12, 4, -10 },
  { 372, 8, 12, 12, 2, -12 },
  { 384, 10, 6, 12, 1, -9 },
  { 392, 8, 12, 12, 2, -12 },
  { 404, 9, 14, 12, 1, -14 },
  { 420, 10, 16, 12, 1, -14 },
  { 440, 12, 14, 12, 0, -14 },
  { 461, 9, 14, 12, 2, -14 },
  { 477, 10, 14, 12, 1, -14 },
  { 495, 9, 14, 12, 2, -14 },
  { 511, 8, 14, 12, 2, -14 },
  { 525, 9, 14, 12, 2, -14 },
  { 541, 10, 14, 12, 1, -14 },
  { 559, 10, 14, 12, 1, -14 },
  { 577, 8, 14, 12, 2, -14 },
  { 591, 9, 14, 12, 1, -14 },
  { 607, 10, 14, 12, 2, -14 },
  { 625, 9, 14, 12, 2, -14 },
  { 641, 10, 14, 12, 1, -14 },
  { 659, 10, 14, 12, 1, -14 },
  { 677, 10, 14, 12, 1, -14 },
  { 695, 9, 14, 12, 2, -14 },
  { 711, 10, 18, 12, 1, -14 },
  { 734, 9, 14, 12, 2, -14 },
  { 750, 10, 14, 12, 1, -14 },
  { 768, 12, 14, 12, 0, -14 },
  { 789, 10, 14, 12, 1, -14 },
  { 807, 12, 14, 12, 0, -14 },
  { 828, 12, 14, 12, 0, -14 },
  { 849, 12, 14, 12, 0, -14 },
  { 870, 12, 14, 12, 0, -14 },
  { 891, 10, 14, 12, 1, -14 },
  { 909, 6, 18, 12, 4, -15 },
  { 923, 8, 18, 12, 2, -15 },
  { 941, 6, 18, 12, 2, -15 },
  { 955, 10, 9, 12, 1, -14 },
  { 967, 10, 2, 12, 1, 2 },
  { 970, 4, 4, 12, 3, -16 },
  { 972, 10, 10, 12, 1, -10 },
  { 985, 9, 15, 12, 2, -15 },
  { 1002, 10, 10, 12, 1, -10 },
  { 1015, 9, 15, 12, 1, -15 },
  { 1032, 10, 10, 12, 1, -10 },
  { 1045, 10, 15, 12, 1, -15 },
  { 1064, 10, 16, 12, 1, -12 },
  { 1084, 8, 15, 12, 2, -15 },
  { 1099, 9, 15, 12, 2, -15 },
  { 1116, 7, 19, 12, 2, -15 },
  { 1133, 10, 15, 12, 2, -15 },
  { 1152, 10, 15, 12, 1, -15 },
  { 1171, 10, 10, 12, 1, -10 },
  { 1184, 8, 10, 12, 2, -10 },
  { 1194, 10, 10, 12, 1, -10 },
  { 1207, 9, 14, 12, 2, -10 },
  { 1223, 9, 14, 12, 1, -10 },
  { 1239, 9, 10, 12, 2, -10 },
  { 1251, 10, 10, 12, 1, -10 },
  { 1264, 10, 14, 12, 1, -14 },
  { 1282, 8, 10, 12, 2, -10 },
  { 1292, 10, 10, 12, 1, -10 },
  { 1305, 12, 10, 12, 0, -10 },
  { 1320, 10, 10, 12, 1, -10 },
  { 1333, 10, 14, 12, 1, -10 },
  { 1351, 8, 10, 12, 2, -10 },
  { 1361, 8, 18, 12, 2, -15 },
  { 1379, 2, 18, 12, 5, -15 },
  { 1384, 8, 18, 12, 2, -15 },
  { 1402, 10, 5, 12, 1, -9 },
};

const GFXfont IBMPlexMono_Medium20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_MEDIUM20PT7B_H_
