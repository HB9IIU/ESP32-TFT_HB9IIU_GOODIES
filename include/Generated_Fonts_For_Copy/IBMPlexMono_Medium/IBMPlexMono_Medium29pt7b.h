#ifndef _IBMPLEXMONO_MEDIUM29PT7B_H_
#define _IBMPLEXMONO_MEDIUM29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium29pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x31, 0x8C, 0x40, 0x00, 0x0E, 0xFF,
  0xFE, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0x80, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x71, 0xC3,
  0xF8, 0xFD, 0xFC, 0x7E, 0xFE, 0x3F, 0x07, 0x38, 0x03, 0x1C, 0x01, 0x8E,
  0x01, 0xC7, 0x0F, 0xE3, 0xF7, 0xF3, 0xFB, 0xF9, 0xFC, 0x18, 0xE0, 0x0C,
  0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x9C, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x3F, 0x01, 0xFF, 0x87, 0xFF, 0x9E, 0x67, 0xB8, 0xC6, 0x71,
  0x80, 0xE3, 0x01, 0xE6, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x80, 0xCF, 0x01, 0x8E, 0x83, 0x1D, 0x86, 0x3F, 0xCC, 0xF7, 0xFF, 0xC7,
  0xFF, 0x03, 0xF8, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x1E, 0x03, 0xBF,
  0x81, 0x9F, 0xE1, 0xCC, 0x70, 0xCE, 0x18, 0xE7, 0x0C, 0x61, 0x8E, 0x70,
  0xFF, 0x30, 0x7F, 0x38, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xCF, 0xE0, 0xE7,
  0xF8, 0x67, 0x1C, 0x73, 0x86, 0x31, 0xC3, 0x38, 0xE3, 0x98, 0x3F, 0xDC,
  0x1F, 0xDC, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x78, 0xF0,
  0x70, 0x60, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x1F, 0x3E, 0x1F,
  0x7F, 0x1F, 0xF7, 0x98, 0xE3, 0xD8, 0xE1, 0xF8, 0xE0, 0xF8, 0xE0, 0x70,
  0xF0, 0xF8, 0xFF, 0xFC, 0x7F, 0x9E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0x87, 0x07, 0x07, 0x03, 0x83, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x06, 0x38, 0x7F, 0x77, 0xFF,
  0xFF, 0x8F, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3B, 0xC0, 0xF3, 0x83, 0xC3,
  0x83, 0x07, 0x04, 0x08, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x7D, 0xE7, 0x3C, 0xF3,
  0x8E, 0x30, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE1,
  0xE7, 0x81, 0xCE, 0x03, 0xDC, 0x03, 0xF8, 0x07, 0xF3, 0x8F, 0xE7, 0x1F,
  0xCF, 0x3F, 0x9C, 0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xBC, 0x0E, 0x3C,
  0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x7F,
  0x01, 0xEE, 0x07, 0x9C, 0x1E, 0x38, 0x18, 0x70, 0x20, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xC0, 0xFF,
  0x87, 0xFF, 0x3C, 0x3E, 0xE0, 0x79, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x7F, 0xC3,
  0xFF, 0x9E, 0x1F, 0x30, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x07, 0xF0,
  0x1F, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x72, 0x01, 0xD8, 0x07,
  0xF8, 0x3D, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x77, 0x80, 0xEF, 0x03, 0x9E, 0x06, 0x3C, 0x1C, 0x78,
  0x70, 0xF0, 0xC1, 0xE3, 0x83, 0xCE, 0x07, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x19, 0xF0, 0x6F,
  0xF1, 0xFF, 0xEF, 0x07, 0x88, 0x0F, 0x00, 0x3C, 0x00, 0xF4, 0x03, 0xF8,
  0x0F, 0xF0, 0x79, 0xFF, 0xC3, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0xF0, 0xEF, 0xF3,
  0xFF, 0xEF, 0x07, 0xB8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xF0, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xC1, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x1C, 0x1E, 0x1F, 0xF8, 0x1F,
  0xC0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0x78, 0x3E, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0x70,
  0x1E, 0xF0, 0x7D, 0xFF, 0xF9, 0xFE, 0xE0, 0xF9, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xEE, 0x73, 0xEF, 0xBE, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE7, 0x3C, 0xF3, 0x8E, 0x30, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x00,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x07, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x07, 0xC0,
  0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x80, 0x00, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xFF, 0x07, 0xB0, 0x1C, 0x01, 0xE0, 0x0E,
  0x07, 0xE0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0xC0, 0xFF, 0x87,
  0xFF, 0x1E, 0x1E, 0xE0, 0x3B, 0x80, 0x6C, 0x3D, 0xF1, 0xFF, 0xC7, 0xFF,
  0x38, 0x7C, 0xE1, 0xF3, 0x87, 0xCE, 0x1F, 0x38, 0x7C, 0x7F, 0xF1, 0xFF,
  0xC3, 0xDF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0xFE,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xF0, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x70, 0x1E, 0x70, 0x1E, 0xF0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E,
  0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF,
  0x3C, 0x1E, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E, 0x70,
  0x3F, 0xC0, 0x6E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x01, 0x9C, 0x0F, 0x78, 0x78, 0xFF, 0xC1,
  0xFF, 0x03, 0xF0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x3B,
  0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0xFB, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x7F, 0xC3, 0xFF, 0x8F, 0x0F, 0x78, 0x1D, 0xC0, 0x77, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x1D, 0xC0, 0x77, 0x01,
  0xDE, 0x07, 0x7C, 0x3C, 0xFF, 0xF1, 0xFD, 0xC3, 0xE7, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x60, 0x7E, 0x07, 0xF0, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xF0, 0x1F, 0xE0,
  0x7B, 0xC1, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x38, 0x3C, 0xF0, 0x7B, 0xC0,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xCE, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x78, 0x38, 0xF0, 0x79, 0xE0, 0x7B, 0xC0, 0x77, 0x80, 0xF0, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3F, 0xC1, 0xFF,
  0x87, 0xFE, 0x1F, 0xD8, 0xFF, 0x73, 0x7D, 0xCD, 0xF3, 0x77, 0xCF, 0x9F,
  0x1E, 0x7E, 0x71, 0xF9, 0xC7, 0xE3, 0x1F, 0x88, 0x7E, 0x21, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC3, 0xF6, 0x1F, 0xB8, 0xFD, 0xC7, 0xE7, 0x3F, 0x39, 0xF9,
  0xCF, 0xC7, 0x7E, 0x3B, 0xF0, 0xDF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE1, 0xE7,
  0x81, 0xCE, 0x03, 0xDC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x03, 0xDC, 0x07, 0xBC, 0x0E, 0x3C, 0x3C,
  0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xEF,
  0xFF, 0x3F, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE1,
  0xE7, 0x81, 0xCE, 0x03, 0xDC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x03, 0xDC, 0x07, 0xBC, 0x0E, 0x7C,
  0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xEF, 0xFF, 0x3F,
  0xF0, 0xF1, 0xC3, 0xC7, 0x8F, 0x0E, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xEF,
  0x03, 0xBC, 0x0F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xF7, 0x00,
  0x8E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x07, 0xE0, 0x01, 0xE0, 0x01, 0xD0, 0x03, 0xB0, 0x0F, 0xF8, 0x3C, 0xFF,
  0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0x78,
  0x7B, 0xFF, 0x8F, 0xFC, 0x3F, 0x80, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E,
  0x70, 0x1E, 0x70, 0x1C, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x38, 0x38,
  0x3C, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE3, 0x86, 0xE3, 0xC6,
  0xE3, 0xCE, 0xE7, 0xCE, 0xE6, 0xCE, 0xE6, 0xCE, 0x66, 0xEE, 0x66, 0x6E,
  0x6E, 0x6E, 0x6E, 0x6E, 0x7C, 0x6E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x7C, 0x3C, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x1C, 0x3C, 0x3C, 0x1C, 0x78,
  0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x1C, 0x78, 0x3C, 0x38, 0x38, 0x3C,
  0x78, 0x1C, 0xF0, 0x1E, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0x8E, 0x03,
  0xC7, 0x81, 0xC1, 0xC1, 0xE0, 0xF0, 0xE0, 0x38, 0xE0, 0x1E, 0x70, 0x07,
  0x70, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x77, 0x00, 0xE7, 0x03, 0x8E, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x1C, 0xE0,
  0x39, 0xC0, 0x3F, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x67,
  0x9C, 0x73, 0x88, 0x1F, 0x80, 0xFF, 0x87, 0xFF, 0x3C, 0x3C, 0x60, 0x70,
  0x01, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0x73, 0x81, 0xCE, 0x07, 0x3C, 0x3C,
  0xFF, 0xFD, 0xFC, 0xF3, 0xE1, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x3E, 0x3B, 0xFC, 0xEF, 0xFB, 0xE1, 0xEF,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE1, 0xEE, 0xFF, 0xBB, 0xFC, 0xE3, 0xE0, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC,
  0xF0, 0xF7, 0x03, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x0C, 0xF0, 0xF3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xF9, 0xCF, 0xF7, 0x3F, 0xFD,
  0xE0, 0xF7, 0x01, 0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07,
  0x70, 0x1D, 0xE0, 0xF3, 0xFF, 0xCF, 0xF7, 0x0F, 0x9C, 0x0F, 0xC0, 0xFF,
  0x87, 0xFF, 0x1E, 0x1E, 0xE0, 0x3B, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x0F, 0x01, 0x1E, 0x1E, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF8, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x7F, 0x03, 0xFF, 0x0F, 0xFE,
  0x1C, 0x1E, 0x38, 0x1C, 0xF0, 0x38, 0xE0, 0xE1, 0xFF, 0xC1, 0xFF, 0x01,
  0xFC, 0x04, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF9, 0x80,
  0x76, 0x00, 0x7E, 0x01, 0xDF, 0xFF, 0xBF, 0xFE, 0x1F, 0xF0, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xCF, 0x1E, 0xFE, 0xFF,
  0xF7, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0x80, 0x07, 0x00, 0x7C,
  0x03, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xEF, 0xFB, 0xFC, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0xB8, 0x3C, 0xE1, 0xE3,
  0x8F, 0x0E, 0x78, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x38, 0xF0,
  0xE1, 0xE3, 0x87, 0x8E, 0x0F, 0x38, 0x1E, 0xE0, 0x3C, 0xFF, 0x07, 0xF8,
  0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xEF, 0x3D, 0xDE, 0xFF,
  0xFF, 0xFF, 0x1E, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3,
  0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3,
  0x80, 0xF3, 0xC7, 0xBF, 0xBF, 0xFD, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xE0, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x3E, 0x1E, 0xE0, 0x3B, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xBE, 0x1E, 0x7F,
  0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xE3, 0xE3, 0xBF, 0xCE, 0xFF, 0xBE, 0x1E,
  0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x03,
  0xFE, 0x1E, 0xEF, 0xFB, 0xBF, 0xCE, 0x3E, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0F, 0x9C, 0xFF, 0x73, 0xFF, 0xDE,
  0x0F, 0x70, 0x1D, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x1D, 0xC0, 0x77,
  0x01, 0xDE, 0x0F, 0x3F, 0xFC, 0xFF, 0x70, 0xF9, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF,
  0xC3, 0xA0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xC1,
  0xFF, 0x9F, 0xFE, 0xE0, 0x67, 0x00, 0x3C, 0x01, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x03, 0xD0, 0x0F, 0xE0, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x0E, 0xF0, 0xF7, 0xFB, 0x9F, 0xDC, 0x7C, 0xE0, 0xF0,
  0x0E, 0xE0, 0x3D, 0xC0, 0x71, 0xC0, 0xE3, 0x83, 0x87, 0x07, 0x07, 0x0E,
  0x0E, 0x38, 0x1C, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xC3, 0x87, 0xC3, 0xC7, 0xE3, 0xC6, 0xE3, 0xC6,
  0xE6, 0xC6, 0xE6, 0xC6, 0xE6, 0xCE, 0x66, 0x6E, 0x66, 0x6E, 0x66, 0x6E,
  0x6C, 0x6C, 0x7C, 0x6C, 0x7C, 0x6C, 0x7C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E,
  0x70, 0x78, 0xF0, 0xE0, 0xF3, 0x80, 0xEF, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0xC0, 0xE3, 0xC3, 0x83, 0x8F, 0x07,
  0xBC, 0x07, 0x80, 0xF0, 0x0E, 0xE0, 0x3D, 0xC0, 0x71, 0xC0, 0xE3, 0x83,
  0x87, 0x87, 0x07, 0x0E, 0x0E, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x3B, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF1, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x07,
  0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x00, 0x70, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xF0,
  0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x1C, 0x00, 0xFF, 0x03, 0xF0, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0x1E, 0x06, 0x7E, 0x1D, 0xFE, 0x3B, 0x9E, 0x66, 0x1F, 0xDC, 0x3F, 0x38,
  0x1C, 0x00,
};

const GFXglyph IBMPlexMono_Medium29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 9, 9, 17, 4, -21 },
  { 25, 17, 20, 17, 0, -20 },
  { 68, 15, 26, 17, 1, -23 },
  { 117, 17, 20, 17, 0, -20 },
  { 160, 16, 20, 17, 1, -20 },
  { 200, 3, 9, 17, 7, -21 },
  { 204, 9, 26, 17, 6, -22 },
  { 234, 9, 26, 17, 3, -22 },
  { 264, 15, 15, 17, 1, -16 },
  { 293, 14, 15, 17, 2, -16 },
  { 320, 6, 8, 17, 6, -4 },
  { 326, 9, 3, 17, 4, -10 },
  { 330, 5, 5, 17, 6, -5 },
  { 334, 13, 26, 17, 2, -22 },
  { 377, 15, 20, 17, 1, -20 },
  { 415, 15, 20, 17, 1, -20 },
  { 453, 14, 20, 17, 2, -20 },
  { 488, 14, 20, 17, 1, -20 },
  { 523, 15, 20, 17, 1, -20 },
  { 561, 14, 20, 17, 2, -20 },
  { 596, 14, 20, 17, 2, -20 },
  { 631, 14, 20, 17, 2, -20 },
  { 666, 15, 20, 17, 1, -20 },
  { 704, 15, 20, 17, 1, -20 },
  { 742, 5, 16, 17, 6, -16 },
  { 752, 6, 20, 17, 6, -16 },
  { 767, 13, 17, 17, 2, -17 },
  { 795, 14, 9, 17, 2, -13 },
  { 811, 13, 17, 17, 2, -17 },
  { 839, 13, 20, 17, 2, -20 },
  { 872, 14, 23, 17, 2, -20 },
  { 913, 16, 20, 17, 1, -20 },
  { 953, 14, 20, 17, 2, -20 },
  { 988, 14, 20, 17, 2, -20 },
  { 1023, 14, 20, 17, 2, -20 },
  { 1058, 13, 20, 17, 2, -20 },
  { 1091, 14, 20, 17, 2, -20 },
  { 1126, 14, 20, 17, 1, -20 },
  { 1161, 13, 20, 17, 2, -20 },
  { 1194, 13, 20, 17, 2, -20 },
  { 1227, 12, 20, 17, 2, -20 },
  { 1257, 15, 20, 17, 2, -20 },
  { 1295, 13, 20, 17, 3, -20 },
  { 1328, 14, 20, 17, 2, -20 },
  { 1363, 13, 20, 17, 2, -20 },
  { 1396, 15, 20, 17, 1, -20 },
  { 1434, 14, 20, 17, 2, -20 },
  { 1469, 15, 25, 17, 1, -20 },
  { 1516, 14, 20, 17, 2, -20 },
  { 1551, 15, 20, 17, 1, -20 },
  { 1589, 16, 20, 17, 1, -20 },
  { 1629, 13, 20, 17, 2, -20 },
  { 1662, 16, 20, 17, 1, -20 },
  { 1702, 16, 20, 17, 1, -20 },
  { 1742, 16, 20, 17, 1, -20 },
  { 1782, 17, 20, 17, 0, -20 },
  { 1825, 15, 20, 17, 1, -20 },
  { 1863, 9, 26, 17, 6, -22 },
  { 1893, 13, 26, 17, 2, -22 },
  { 1936, 8, 26, 17, 3, -22 },
  { 1962, 15, 12, 17, 1, -20 },
  { 1985, 14, 3, 17, 2, 2 },
  { 1991, 5, 6, 17, 5, -23 },
  { 1995, 14, 15, 17, 2, -15 },
  { 2022, 14, 21, 17, 2, -21 },
  { 2059, 13, 15, 17, 2, -15 },
  { 2084, 14, 21, 17, 1, -21 },
  { 2121, 14, 15, 17, 2, -15 },
  { 2148, 14, 21, 17, 2, -21 },
  { 2185, 15, 24, 17, 2, -18 },
  { 2230, 13, 21, 17, 2, -21 },
  { 2265, 13, 22, 17, 3, -22 },
  { 2301, 10, 28, 17, 3, -22 },
  { 2336, 14, 21, 17, 3, -21 },
  { 2373, 13, 21, 17, 2, -21 },
  { 2408, 15, 15, 17, 1, -15 },
  { 2437, 13, 15, 17, 2, -15 },
  { 2462, 14, 15, 17, 2, -15 },
  { 2489, 14, 21, 17, 2, -15 },
  { 2526, 14, 21, 17, 1, -15 },
  { 2563, 14, 15, 17, 2, -15 },
  { 2590, 13, 15, 17, 2, -15 },
  { 2615, 14, 20, 17, 1, -20 },
  { 2650, 13, 15, 17, 2, -15 },
  { 2675, 15, 15, 17, 1, -15 },
  { 2704, 16, 15, 17, 1, -15 },
  { 2734, 15, 15, 17, 1, -15 },
  { 2763, 15, 21, 17, 1, -15 },
  { 2803, 13, 15, 17, 2, -15 },
  { 2828, 12, 26, 17, 3, -22 },
  { 2867, 3, 26, 17, 7, -22 },
  { 2877, 12, 26, 17, 3, -22 },
  { 2916, 15, 7, 17, 1, -12 },
};

const GFXfont IBMPlexMono_Medium29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_MEDIUM29PT7B_H_
