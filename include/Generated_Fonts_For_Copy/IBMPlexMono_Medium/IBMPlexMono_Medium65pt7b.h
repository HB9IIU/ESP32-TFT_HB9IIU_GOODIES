#ifndef _IBMPLEXMONO_MEDIUM65PT7B_H_
#define _IBMPLEXMONO_MEDIUM65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium65pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x87, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFC, 0x3E, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFF,
  0xE7, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xFF, 0x01, 0xFF, 0xF9, 0xFF, 0xF8,
  0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xF8, 0x0F, 0xFF,
  0xCF, 0xFF, 0xC0, 0x7F, 0xFE, 0x7F, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF0,
  0x3F, 0xFF, 0x9F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0x87, 0xC3, 0xFC, 0x7F, 0x03,
  0xE0, 0xFC, 0x3F, 0x81, 0xF0, 0x1C, 0x3F, 0x80, 0xF8, 0x08, 0x1F, 0xC0,
  0x7C, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x03, 0xF8,
  0x0F, 0x80, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x3F,
  0xC1, 0xF0, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xC0, 0x00, 0x3E, 0x1F,
  0xF0, 0x00, 0x1F, 0x07, 0xF8, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x07, 0xC0,
  0xFE, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x00, 0xF8,
  0x1F, 0xC2, 0x00, 0x7C, 0x0F, 0xE3, 0x80, 0x3E, 0x07, 0xF3, 0xE0, 0x1F,
  0x07, 0xFB, 0xF8, 0x0F, 0x83, 0xFB, 0xFF, 0x07, 0xC3, 0xFC, 0xFF, 0xE3,
  0xEF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xC7, 0xFF, 0xE0, 0x00, 0x7E, 0x7F, 0xFF,
  0x00, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x3F, 0x3F, 0x03, 0xF0, 0x03, 0xF1,
  0xF0, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0xFC, 0x07, 0xC1, 0xF0,
  0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x3F,
  0x03, 0xE0, 0x0F, 0xC1, 0xF0, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0xF8, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x7C, 0x00,
  0x7F, 0xFF, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x3E, 0x00, 0x07, 0xFF, 0x02,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xC3, 0xFF,
  0xF0, 0x00, 0xFC, 0x3F, 0xFF, 0xC0, 0x07, 0xC1, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x81, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xF8, 0x1F,
  0x80, 0x3E, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x0F, 0x87,
  0xE0, 0x3F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC0,
  0x3F, 0x1F, 0x00, 0x3E, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0x1F, 0x9F, 0x80,
  0x07, 0xE1, 0xF8, 0xFC, 0x00, 0x3F, 0xFF, 0xCF, 0xC0, 0x00, 0xFF, 0xFC,
  0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0x7F, 0x81, 0xFF, 0x8F, 0xF3,
  0xFC, 0x0F, 0x80, 0x7F, 0x0F, 0xF0, 0xFC, 0x07, 0xF0, 0x3F, 0xC7, 0xE0,
  0x3F, 0x80, 0xFF, 0x3F, 0x01, 0xFC, 0x03, 0xF9, 0xF0, 0x0F, 0xC0, 0x0F,
  0xEF, 0x80, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x3F,
  0x80, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x3E, 0xFF, 0x01, 0xFF, 0xFF, 0xF3, 0xFC,
  0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x06, 0x00, 0x7F, 0x00, 0x30, 0xF8, 0x0F, 0xE0, 0x3E, 0x3F,
  0xE1, 0xFC, 0x3F, 0xE7, 0xFF, 0xBF, 0xBF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x8F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x7C, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81,
  0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFE, 0x07, 0xF0,
  0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xF8, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x03, 0xC0, 0x1F, 0xE0, 0x00,
  0x60, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x1F, 0xE0, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xC0, 0x01, 0xFE, 0x03, 0xC0, 0x00, 0xFF,
  0x80, 0xC0, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0x0F, 0xF0,
  0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F, 0x0F,
  0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xE0, 0x3F, 0x7F,
  0xFF, 0xF0, 0x3E, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xC0,
  0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0x01, 0xFE, 0x1C, 0x00,
  0x01, 0xFE, 0x3E, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFF, 0xC0,
  0x07, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE3, 0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0xF8,
  0x07, 0xF3, 0xFF, 0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0x83, 0xFB, 0xFF, 0xFF,
  0xE1, 0xFD, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xF0, 0x1E, 0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0x7F,
  0x03, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0x1F, 0xC0, 0x1F, 0xFF, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0x8F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFC, 0x38, 0x00, 0x0F, 0xF0,
  0x40, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3F, 0x3E,
  0x00, 0x7C, 0x3F, 0x7E, 0x01, 0xFF, 0x3F, 0x7E, 0x03, 0xFF, 0xBF, 0x7E,
  0x07, 0xFF, 0xBF, 0x7C, 0x07, 0xFF, 0xFF, 0x7C, 0x0F, 0xF0, 0xFF, 0x7C,
  0x0F, 0xC0, 0x7F, 0x7C, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0x80, 0x3F, 0xFC,
  0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC,
  0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC,
  0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0x7C,
  0x1F, 0x80, 0x3F, 0x7C, 0x0F, 0x80, 0x3F, 0x7C, 0x0F, 0xC0, 0x3F, 0x7C,
  0x0F, 0xE0, 0x7F, 0x7E, 0x0F, 0xF9, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0x7E,
  0x03, 0xFF, 0xBF, 0x7E, 0x03, 0xFF, 0x3F, 0x3E, 0x01, 0xFF, 0x3F, 0x3F,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xFC, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0x3F,
  0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF,
  0xC0, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x7F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x70, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0x7F,
  0x0F, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFC, 0x7F,
  0x01, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x20, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFE, 0x07, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0xFF, 0x9F, 0xC0, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x7F, 0xC1, 0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x0F, 0xEF, 0xFE, 0x00, 0x07,
  0xF7, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFB, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0x00,
  0x1F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03,
  0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xC3, 0xF8, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF7, 0xE0, 0x7D, 0xFF,
  0xEF, 0xC1, 0xFB, 0xFF, 0xDF, 0x83, 0xF7, 0xFF, 0x9F, 0x87, 0xCF, 0xFF,
  0x3F, 0x1F, 0x9F, 0xFE, 0x3F, 0x3E, 0x3F, 0xFC, 0x7E, 0xFC, 0x7F, 0xF8,
  0xFD, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC1,
  0xFF, 0x07, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0x07, 0xFC, 0x1F, 0xFE, 0x07,
  0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x0F, 0x80, 0xFF, 0xF0, 0x1F,
  0x01, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0xC0, 0x38, 0x07, 0xFF, 0x80, 0x70,
  0x0F, 0xFF, 0x00, 0x60, 0x1F, 0xFE, 0x00, 0x80, 0x3F, 0xFC, 0x01, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x7E, 0x00, 0x7F, 0xFB, 0xF0, 0x03, 0xFF, 0xDF, 0xC0, 0x1F, 0xFE,
  0x7E, 0x00, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0x8F, 0xC0, 0x3F, 0xFC, 0x7E,
  0x01, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0x0F, 0xC0, 0x7F, 0xF8, 0x7F, 0x03,
  0xFF, 0xC1, 0xF8, 0x1F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0x81, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0, 0x7F, 0x0F, 0xFF, 0x01,
  0xF8, 0x7F, 0xF8, 0x0F, 0xE3, 0xFF, 0xC0, 0x3F, 0x1F, 0xFE, 0x01, 0xF8,
  0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0x80, 0x3F, 0x3F, 0xFC, 0x01, 0xFD, 0xFF,
  0xE0, 0x07, 0xEF, 0xFF, 0x00, 0x3F, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x03,
  0xFE, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE,
  0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x7C, 0x1F, 0xC0, 0x00, 0x1C, 0x1F, 0xE0, 0x00, 0x04, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE1, 0x00, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xF0, 0x0F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x01, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x80, 0xFC, 0xFC, 0x0F, 0xF8, 0x1F,
  0x9F, 0x81, 0xFF, 0x03, 0xF3, 0xF0, 0x3F, 0xE0, 0x7E, 0x7E, 0x07, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFF, 0x81, 0xF9, 0xF8, 0x1F, 0xF8, 0x3F, 0x3F, 0x07,
  0xDF, 0x07, 0xE7, 0xE0, 0xFB, 0xE0, 0xFC, 0xFC, 0x1F, 0x7C, 0x1F, 0x9F,
  0x83, 0xEF, 0x83, 0xF3, 0xF0, 0x78, 0xF8, 0x7E, 0x7F, 0x1F, 0x1F, 0x0F,
  0xCF, 0xE3, 0xE3, 0xE1, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x1F, 0x8F, 0x8F,
  0x8F, 0xC3, 0xF1, 0xF1, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F, 0x3F, 0x0F, 0xCF,
  0x83, 0xE7, 0xE1, 0xF9, 0xF0, 0x7C, 0xFC, 0x3F, 0x3E, 0x0F, 0x9F, 0x87,
  0xE7, 0xC1, 0xFB, 0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xBE, 0x03, 0xEF,
  0xC3, 0xF7, 0xC0, 0x7D, 0xF8, 0x7E, 0xF8, 0x0F, 0xBF, 0x0F, 0xFF, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x01, 0xFC, 0x78,
  0x00, 0x00, 0x3C, 0x02, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0xE0, 0x3E,
  0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xE0, 0x18, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x00, 0x1F,
  0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0x0F, 0xF0, 0x08, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x7B,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0x3F, 0xFF, 0xE1,
  0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x07, 0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0x81, 0xFC, 0x7F, 0xFF, 0x83, 0xF9,
  0xFF, 0xFF, 0x87, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0x9F, 0xF8,
  0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE,
  0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xC0, 0xFF, 0xE7,
  0xF7, 0xFF, 0xFF, 0x8F, 0xE7, 0xFF, 0xFE, 0x1F, 0xC7, 0xFF, 0xF8, 0x3F,
  0x87, 0xFF, 0xE0, 0x7F, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1E, 0x1F,
  0xC0, 0x00, 0x41, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x83, 0xFC, 0x00, 0x0F, 0x0F, 0xE0, 0x00,
  0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xF0, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0xFF, 0xF3, 0xF8, 0xFF, 0xFF, 0xF7, 0xF3,
  0xFF, 0x81, 0xFF, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xCF,
  0xE0, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0xFC, 0x3F, 0x80, 0xFF, 0xF0, 0x7F,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x40, 0xFE, 0x00, 0x00, 0xC0, 0xFE, 0x00, 0x03,
  0xC1, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3E, 0x00, 0x01, 0xFF, 0x3E, 0x00, 0x00, 0x3F, 0xBE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE1, 0xFF, 0xE0, 0xFF, 0x1F, 0xFF,
  0x87, 0xF9, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xF9, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x0F,
  0xF8, 0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFE,
  0x00, 0xFE, 0x07, 0xFC, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0xFE, 0x1F, 0xF0,
  0x00, 0xFE, 0x3F, 0xE0, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F,
  0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xFC, 0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x3F, 0xC1, 0xFF, 0x3F,
  0x3F, 0xE1, 0xFF, 0x9F, 0xBF, 0xF9, 0xFF, 0xEF, 0xDF, 0xFC, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F,
  0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x01, 0xF8, 0x07,
  0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xE0, 0x3F, 0x00,
  0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xF8, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0,
  0x1F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFC,
  0x03, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF0, 0x1F,
  0x80, 0x7F, 0xF8, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0xFE, 0x03,
  0xF0, 0x0F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0,
  0x7E, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xF8,
  0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x7F, 0xF8, 0x3F, 0xC7, 0xFF, 0xE1, 0xFE,
  0x7F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFE, 0x7F, 0xBF, 0xFF, 0xF3, 0xFF, 0xC0,
  0xFF, 0xDF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFC, 0x1F, 0xFE, 0x03, 0xF8, 0x7F, 0xFE, 0x07, 0xF1, 0xFF, 0xFE, 0x0F,
  0xE7, 0xFF, 0xFE, 0x1F, 0xDF, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xFE, 0x7F,
  0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0x03, 0xFF,
  0x9F, 0xDF, 0xFF, 0xFE, 0x3F, 0x9F, 0xFF, 0xF8, 0x7F, 0x1F, 0xFF, 0xE0,
  0xFE, 0x1F, 0xFF, 0x81, 0xFC, 0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0xC3, 0xF8, 0x3F,
  0xFF, 0xC7, 0xF0, 0xFF, 0xFF, 0xCF, 0xE3, 0xFF, 0xFF, 0xDF, 0xCF, 0xFE,
  0x07, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFE,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xF3,
  0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83,
  0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xC1, 0xFC, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xC0, 0x1F, 0xDF, 0x00, 0x00, 0x3F, 0xB0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0xE0,
  0xFE, 0x00, 0x01, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x60, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0xFB, 0xFC, 0xFF, 0xFF,
  0xDF, 0xE3, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xC7, 0xF8, 0x1F, 0xFC, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8,
  0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x0F, 0xDF, 0x80,
  0x7F, 0x00, 0x7C, 0xFC, 0x03, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0xE0, 0x3F,
  0x3F, 0x01, 0xFF, 0x01, 0xF9, 0xF8, 0x0F, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F,
  0xC0, 0x7E, 0x7E, 0x03, 0xDF, 0x03, 0xF1, 0xF0, 0x1E, 0xF8, 0x1F, 0x0F,
  0xC1, 0xF7, 0xC0, 0xF8, 0x7E, 0x0F, 0x9E, 0x07, 0xC3, 0xF0, 0x78, 0xF0,
  0x7E, 0x1F, 0x83, 0xC7, 0x83, 0xF0, 0xFC, 0x1E, 0x3E, 0x1F, 0x87, 0xE0,
  0xF1, 0xF0, 0xFC, 0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x07, 0xC3, 0xC1, 0xE1, 0xF0, 0x3F, 0x1E, 0x0F, 0x0F, 0x81, 0xF8, 0xF0,
  0x7C, 0x7C, 0x0F, 0xCF, 0x83, 0xE7, 0xE0, 0x7E, 0x7C, 0x1F, 0x3F, 0x01,
  0xF3, 0xE0, 0x79, 0xF0, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0x7C, 0xF0, 0x1E,
  0x7C, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x00, 0xFF,
  0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x03, 0xFF, 0x00,
  0x07, 0xC3, 0xFF, 0xC0, 0x07, 0xE3, 0xFF, 0xF0, 0x03, 0xF1, 0xFF, 0xFC,
  0x01, 0xF1, 0xFF, 0xFF, 0x01, 0xF8, 0xFC, 0x7F, 0xC0, 0xFC, 0xFC, 0x0F,
  0xE0, 0x7E, 0x7E, 0x07, 0xFC, 0x7E, 0x3F, 0x01, 0xFF, 0xFF, 0x1F, 0x00,
  0x7F, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0x87, 0xC0,
  0x01, 0xFF, 0x80, 0x60, 0x00, 0x3F, 0x00,
};

const GFXglyph IBMPlexMono_Medium65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 11, 46, 39, 14, -45 },
  { 65, 19, 19, 39, 10, -48 },
  { 111, 37, 45, 39, 1, -45 },
  { 320, 33, 61, 39, 3, -53 },
  { 572, 37, 47, 39, 1, -46 },
  { 790, 37, 47, 39, 1, -46 },
  { 1008, 7, 19, 39, 16, -48 },
  { 1025, 21, 58, 39, 12, -49 },
  { 1178, 21, 58, 39, 6, -49 },
  { 1331, 35, 33, 39, 2, -36 },
  { 1476, 31, 32, 39, 4, -36 },
  { 1600, 14, 19, 39, 12, -10 },
  { 1634, 19, 7, 39, 10, -23 },
  { 1651, 11, 11, 39, 14, -10 },
  { 1667, 29, 58, 39, 5, -49 },
  { 1878, 33, 47, 39, 3, -46 },
  { 2072, 34, 45, 39, 3, -45 },
  { 2264, 31, 46, 39, 4, -46 },
  { 2443, 33, 47, 39, 2, -46 },
  { 2637, 35, 45, 39, 2, -45 },
  { 2834, 32, 46, 39, 4, -45 },
  { 3018, 33, 46, 39, 3, -45 },
  { 3208, 31, 45, 39, 4, -45 },
  { 3383, 33, 47, 39, 3, -46 },
  { 3577, 33, 46, 39, 3, -46 },
  { 3767, 11, 35, 39, 14, -34 },
  { 3816, 14, 43, 39, 12, -34 },
  { 3892, 27, 38, 39, 6, -39 },
  { 4021, 31, 20, 39, 4, -30 },
  { 4099, 27, 38, 39, 6, -39 },
  { 4228, 29, 47, 39, 5, -46 },
  { 4399, 32, 53, 39, 3, -46 },
  { 4611, 37, 45, 39, 1, -45 },
  { 4820, 31, 45, 39, 5, -45 },
  { 4995, 32, 47, 39, 4, -46 },
  { 5183, 31, 45, 39, 5, -45 },
  { 5358, 28, 45, 39, 6, -45 },
  { 5516, 29, 45, 39, 6, -45 },
  { 5680, 32, 47, 39, 3, -46 },
  { 5868, 29, 45, 39, 5, -45 },
  { 6032, 29, 45, 39, 5, -45 },
  { 6196, 28, 46, 39, 4, -45 },
  { 6357, 33, 45, 39, 5, -45 },
  { 6543, 28, 45, 39, 7, -45 },
  { 6701, 31, 45, 39, 4, -45 },
  { 6876, 29, 45, 39, 5, -45 },
  { 7040, 33, 47, 39, 3, -46 },
  { 7234, 31, 45, 39, 5, -45 },
  { 7409, 33, 58, 39, 3, -46 },
  { 7649, 31, 45, 39, 5, -45 },
  { 7824, 33, 47, 39, 3, -46 },
  { 8018, 35, 45, 39, 2, -45 },
  { 8215, 31, 46, 39, 4, -45 },
  { 8394, 35, 45, 39, 2, -45 },
  { 8591, 35, 45, 39, 2, -45 },
  { 8788, 37, 45, 39, 1, -45 },
  { 8997, 37, 45, 39, 1, -45 },
  { 9206, 33, 45, 39, 3, -45 },
  { 9392, 20, 58, 39, 13, -49 },
  { 9537, 29, 58, 39, 5, -49 },
  { 9748, 20, 58, 39, 6, -49 },
  { 9893, 35, 28, 39, 2, -45 },
  { 10016, 31, 6, 39, 4, 6 },
  { 10040, 12, 14, 39, 11, -52 },
  { 10061, 32, 35, 39, 4, -34 },
  { 10201, 31, 49, 39, 5, -48 },
  { 10391, 29, 35, 39, 5, -34 },
  { 10518, 31, 49, 39, 3, -48 },
  { 10708, 31, 35, 39, 4, -34 },
  { 10844, 32, 48, 39, 4, -48 },
  { 11036, 33, 53, 39, 4, -39 },
  { 11255, 29, 48, 39, 5, -48 },
  { 11429, 29, 49, 39, 7, -49 },
  { 11607, 24, 62, 39, 6, -49 },
  { 11793, 32, 48, 39, 6, -48 },
  { 11985, 29, 48, 39, 5, -48 },
  { 12159, 33, 34, 39, 3, -34 },
  { 12300, 29, 34, 39, 5, -34 },
  { 12424, 31, 35, 39, 4, -34 },
  { 12560, 31, 47, 39, 5, -34 },
  { 12743, 31, 47, 39, 3, -34 },
  { 12926, 31, 34, 39, 5, -34 },
  { 13058, 30, 35, 39, 4, -34 },
  { 13190, 31, 45, 39, 3, -45 },
  { 13365, 29, 35, 39, 5, -34 },
  { 13492, 33, 34, 39, 3, -34 },
  { 13633, 37, 34, 39, 1, -34 },
  { 13791, 33, 34, 39, 3, -34 },
  { 13932, 33, 47, 39, 3, -34 },
  { 14126, 29, 34, 39, 5, -34 },
  { 14250, 27, 58, 39, 6, -49 },
  { 14446, 7, 58, 39, 16, -49 },
  { 14497, 27, 58, 39, 6, -49 },
  { 14693, 33, 15, 39, 3, -28 },
};

const GFXfont IBMPlexMono_Medium65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_MEDIUM65PT7B_H_
