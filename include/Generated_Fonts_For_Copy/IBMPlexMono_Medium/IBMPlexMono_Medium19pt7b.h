#ifndef _IBMPLEXMONO_MEDIUM19PT7B_H_
#define _IBMPLEXMONO_MEDIUM19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium19pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0x92, 0x03, 0xFE, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x0C,
  0xC1, 0x90, 0x36, 0x04, 0xC7, 0x9E, 0xF3, 0xC6, 0x47, 0xDE, 0xF3, 0xC6,
  0x60, 0xCC, 0x19, 0x03, 0x60, 0x0C, 0x03, 0x03, 0xE1, 0xFE, 0xED, 0xB3,
  0x0E, 0xC1, 0xF0, 0x3F, 0x83, 0xE0, 0xDE, 0x33, 0xED, 0x9F, 0xE3, 0xE0,
  0x30, 0x0C, 0x00, 0x38, 0x6F, 0x8B, 0x33, 0x66, 0xCC, 0xD8, 0xF8, 0x0E,
  0x70, 0x1F, 0x1E, 0x66, 0xC4, 0x99, 0xB1, 0xFC, 0x1C, 0x1E, 0x07, 0xE0,
  0xCC, 0x10, 0x03, 0x00, 0x31, 0xCF, 0x3B, 0x74, 0xC6, 0x98, 0x71, 0x8E,
  0x3F, 0x63, 0xCE, 0xFF, 0xF0, 0x1C, 0xC6, 0x18, 0xC3, 0x0C, 0x20, 0x82,
  0x0C, 0x30, 0xC1, 0x86, 0x0C, 0x1C, 0xC1, 0x83, 0x06, 0x18, 0x20, 0xC3,
  0x0C, 0x30, 0xC2, 0x18, 0x63, 0x18, 0xC0, 0x0C, 0x03, 0x00, 0xC3, 0xB6,
  0xFF, 0xC7, 0x03, 0xE0, 0xDC, 0x63, 0x10, 0x80, 0x0C, 0x06, 0x03, 0x01,
  0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x7E, 0xEC, 0xC8, 0xFF,
  0xF0, 0xFF, 0x80, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x30, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x3E, 0x1F, 0xC6, 0x3B,
  0x06, 0xC1, 0xB3, 0x7C, 0xDF, 0x37, 0xC1, 0xB0, 0x66, 0x39, 0xFC, 0x3E,
  0x00, 0x1E, 0x0F, 0x87, 0xE3, 0xB8, 0xCE, 0x23, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE1, 0xFF, 0x7F, 0xC0, 0x3E, 0x3F, 0xB8, 0xF8, 0x30, 0x18,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x1F, 0xFF, 0xF8, 0x3E, 0x3F, 0xB8,
  0xE8, 0x30, 0x30, 0xF0, 0x7C, 0x07, 0x01, 0xC0, 0xF0, 0xEF, 0xE3, 0xE0,
  0x07, 0x03, 0xC1, 0xB0, 0x6C, 0x33, 0x18, 0xC4, 0x33, 0x0C, 0xFF, 0xFF,
  0xF0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0xBF, 0xD8, 0x0C, 0x04, 0xE2, 0xFD,
  0x8E, 0x03, 0x01, 0xA0, 0xF8, 0xEF, 0xE3, 0xE0, 0x0F, 0x0C, 0x0C, 0x0C,
  0x06, 0xE6, 0xFF, 0x8F, 0x83, 0xC1, 0xE0, 0xF8, 0xEF, 0xE3, 0xE0, 0xFF,
  0xFF, 0xF0, 0x78, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x07, 0x03,
  0x03, 0x80, 0x3E, 0x1F, 0xEE, 0x1B, 0x06, 0x61, 0x8F, 0xC7, 0xF3, 0x86,
  0xC1, 0xB0, 0x7E, 0x19, 0xFE, 0x3E, 0x00, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C,
  0x1E, 0x0F, 0x8E, 0xFF, 0x3D, 0x81, 0x81, 0x81, 0x83, 0x80, 0xFF, 0x80,
  0x07, 0xFC, 0xEE, 0xE0, 0x00, 0x07, 0xEE, 0xCC, 0x80, 0x01, 0x07, 0x1E,
  0x78, 0xE0, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x80, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x0F, 0x3C, 0x70,
  0xC0, 0x80, 0x3E, 0x3F, 0x98, 0xF8, 0x30, 0x38, 0x38, 0x70, 0x30, 0x00,
  0x00, 0x07, 0x03, 0x81, 0xC0, 0x3E, 0x3F, 0x98, 0x78, 0x3C, 0xEE, 0xFF,
  0x63, 0xB1, 0xD8, 0xEF, 0xF3, 0xB8, 0x06, 0x03, 0xF8, 0x7C, 0x0E, 0x01,
  0xE0, 0x2C, 0x0D, 0x81, 0xB0, 0x33, 0x0C, 0x61, 0x8C, 0x3F, 0xCF, 0xF9,
  0x83, 0x30, 0x7E, 0x06, 0xFC, 0xFF, 0xC3, 0xC3, 0xC3, 0xFE, 0xFE, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0x1E, 0x3F, 0x98, 0x7C, 0x3C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x70, 0xD8, 0x6F, 0xE1, 0xE0, 0xFC, 0x7F, 0x31, 0xD8,
  0x6C, 0x36, 0x1B, 0x0F, 0x86, 0xC3, 0x61, 0xB1, 0xDF, 0xCF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x3E, 0x3F, 0x98, 0xF8, 0x3C, 0x06, 0x03, 0x1F, 0x8F, 0xC1, 0xE0,
  0xD8, 0xEF, 0xF3, 0xD8, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3F, 0x3F, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xE3, 0x7F, 0x3E, 0xE1, 0xF8, 0xEE,
  0x33, 0x98, 0xEC, 0x3F, 0x0F, 0xC3, 0xF8, 0xE6, 0x38, 0xCE, 0x3B, 0x86,
  0xE1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xE1, 0xF1, 0xFC, 0xFE, 0xDD, 0xFE, 0xEF, 0x37, 0x93,
  0xC9, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xE1, 0xF8, 0xFC, 0x7A, 0x3D, 0x9E,
  0xCF, 0x37, 0x9B, 0xC5, 0xE3, 0xF1, 0xF8, 0x7C, 0x38, 0x3E, 0x1F, 0xC6,
  0x3B, 0x06, 0xC1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xB0, 0x66, 0x39, 0xFC,
  0x3E, 0x00, 0xFE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3E, 0x1F, 0xC6, 0x3B, 0x06, 0xC1, 0xB0, 0x7C, 0x1F,
  0x07, 0xC1, 0xB0, 0x66, 0x39, 0xFC, 0x3E, 0x03, 0x00, 0xC0, 0x3E, 0x07,
  0x80, 0xFE, 0x7F, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0xFD, 0xFC, 0xCC, 0x67,
  0x31, 0x98, 0xEC, 0x38, 0x3E, 0x3F, 0xF8, 0x78, 0x0E, 0x03, 0xE0, 0xFC,
  0x0F, 0x01, 0xC0, 0xF8, 0x6F, 0xF3, 0xE0, 0xFF, 0xFF, 0xFC, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0xD8, 0xEF, 0xE3, 0xE0, 0xE0, 0x6C, 0x19, 0x83, 0x38, 0x63, 0x0C, 0x63,
  0x0E, 0x60, 0xCC, 0x1B, 0x03, 0x60, 0x7C, 0x07, 0x80, 0xE0, 0xC0, 0x68,
  0x0D, 0x01, 0xB3, 0x36, 0xE6, 0xDC, 0xDA, 0x93, 0x5A, 0x6B, 0x4F, 0x29,
  0xE7, 0x3C, 0xE7, 0x1C, 0x60, 0xE6, 0x18, 0xC6, 0x0C, 0xC1, 0xF0, 0x1E,
  0x03, 0x80, 0x78, 0x1B, 0x07, 0x30, 0xC7, 0x38, 0x6E, 0x0E, 0xE0, 0x6C,
  0x18, 0xC3, 0x18, 0xC1, 0x98, 0x36, 0x03, 0xC0, 0x70, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x70,
  0x30, 0x30, 0x30, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0xC0, 0xC0, 0x40, 0x60,
  0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x06,
  0x03, 0xFF, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3F, 0xF8,
  0x1C, 0x07, 0x83, 0x60, 0xCC, 0x63, 0x18, 0x6C, 0x1B, 0x03, 0xFF, 0xFF,
  0xC0, 0x4E, 0x63, 0x3E, 0x1F, 0xCC, 0x30, 0x0C, 0x3F, 0x1F, 0xCC, 0x33,
  0x0C, 0xFD, 0xDE, 0x70, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xF7, 0xFF, 0x8F,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7F, 0xFF, 0x78, 0x1E, 0x1F, 0x98, 0x6C,
  0x0E, 0x07, 0x01, 0x84, 0xC3, 0x3F, 0x0F, 0x00, 0x01, 0x80, 0xC0, 0x60,
  0x33, 0xDB, 0xFF, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x77, 0xF9, 0xEC,
  0x1E, 0x3F, 0x98, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0xC2, 0x7F, 0x8F, 0x00,
  0x0F, 0x87, 0xC3, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x8F, 0xFF, 0xFC, 0x01, 0xC0, 0xF3, 0xE1, 0xFC, 0x63, 0x98, 0x66,
  0x31, 0xFC, 0x1E, 0x18, 0x07, 0xF8, 0xFF, 0xC0, 0xF0, 0x3F, 0xF9, 0xFC,
  0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x1C, 0x1C, 0x1C, 0x00, 0x00, 0xF8, 0xF8, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x0C, 0x1C, 0x30, 0x00, 0x1F, 0xBF, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0D, 0xFB, 0xE0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x3E, 0x33, 0x31, 0xB0, 0xF8, 0x7E, 0x33, 0x18, 0xCC,
  0x76, 0x1C, 0xFC, 0x7E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0xFB, 0xBE, 0xEC, 0xCF, 0x33, 0xCC,
  0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x30, 0xDC, 0xFE, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3E, 0x3F, 0x98, 0xF8, 0x3C, 0x1E, 0x0F,
  0x06, 0xC7, 0x7F, 0x1F, 0x00, 0xEF, 0x7F, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F,
  0x87, 0xC7, 0xFF, 0xF7, 0xB8, 0x1C, 0x0E, 0x07, 0x00, 0x3D, 0xBF, 0xF8,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC7, 0x7F, 0x9E, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0xF9, 0xFE, 0xF1, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF,
  0xBF, 0xE0, 0x3E, 0x3F, 0xD8, 0x4C, 0x07, 0xF1, 0xFC, 0x06, 0x83, 0xFF,
  0x9F, 0x00, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0xF0, 0xF8, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0D,
  0x86, 0xC7, 0x7D, 0x9E, 0xC0, 0xC1, 0xF0, 0xD8, 0x6C, 0x66, 0x31, 0x98,
  0xD8, 0x2C, 0x1C, 0x0E, 0x00, 0xC6, 0x69, 0xCD, 0x39, 0xB5, 0x36, 0xB4,
  0xD6, 0x9A, 0x53, 0xCE, 0x39, 0xC6, 0x38, 0xE1, 0x98, 0xC3, 0x70, 0xF8,
  0x1C, 0x07, 0x03, 0x60, 0xDC, 0x63, 0x30, 0x70, 0xC1, 0xF0, 0x66, 0x19,
  0x8C, 0x33, 0x0C, 0x83, 0x60, 0x78, 0x1C, 0x03, 0x01, 0xC0, 0x60, 0xF8,
  0x3C, 0x00, 0x7F, 0xBF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xC0, 0x1F, 0x3F, 0x30, 0x30, 0x18, 0x08, 0x0C, 0xF8, 0xF8, 0x0C,
  0x0C, 0x18, 0x10, 0x30, 0x30, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0xF8, 0x18, 0x18, 0x10, 0x30, 0x30, 0x3F, 0x1F, 0x30, 0x30, 0x30,
  0x18, 0x18, 0x18, 0xF8, 0xF8, 0x70, 0xDE, 0x2C, 0xDB, 0x3E, 0x87, 0x00,
};

const GFXglyph IBMPlexMono_Medium19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 6, 6, 11, 3, -14 },
  { 11, 11, 13, 11, 0, -13 },
  { 29, 10, 17, 11, 1, -15 },
  { 51, 11, 13, 11, 0, -13 },
  { 69, 11, 13, 11, 0, -13 },
  { 87, 2, 6, 11, 5, -14 },
  { 89, 6, 17, 11, 4, -14 },
  { 102, 6, 17, 11, 2, -14 },
  { 115, 10, 10, 11, 1, -10 },
  { 128, 9, 10, 11, 1, -11 },
  { 140, 4, 6, 11, 4, -3 },
  { 143, 6, 2, 11, 3, -7 },
  { 145, 3, 3, 11, 4, -3 },
  { 147, 8, 17, 11, 2, -14 },
  { 164, 10, 13, 11, 1, -13 },
  { 181, 10, 13, 11, 1, -13 },
  { 198, 9, 13, 11, 1, -13 },
  { 213, 9, 13, 11, 1, -13 },
  { 228, 10, 13, 11, 1, -13 },
  { 245, 9, 13, 11, 1, -13 },
  { 260, 9, 13, 11, 1, -13 },
  { 275, 9, 13, 11, 1, -13 },
  { 290, 10, 13, 11, 1, -13 },
  { 307, 9, 13, 11, 1, -13 },
  { 322, 3, 10, 11, 4, -10 },
  { 326, 4, 13, 11, 4, -10 },
  { 333, 8, 11, 11, 2, -11 },
  { 344, 9, 6, 11, 1, -9 },
  { 351, 8, 11, 11, 2, -11 },
  { 362, 9, 13, 11, 1, -13 },
  { 377, 9, 15, 11, 1, -13 },
  { 394, 11, 13, 11, 0, -13 },
  { 412, 8, 13, 11, 2, -13 },
  { 425, 9, 13, 11, 1, -13 },
  { 440, 9, 13, 11, 2, -13 },
  { 455, 8, 13, 11, 2, -13 },
  { 468, 8, 13, 11, 2, -13 },
  { 481, 9, 13, 11, 1, -13 },
  { 496, 9, 13, 11, 1, -13 },
  { 511, 8, 13, 11, 2, -13 },
  { 524, 8, 13, 11, 1, -13 },
  { 537, 10, 13, 11, 1, -13 },
  { 554, 8, 13, 11, 2, -13 },
  { 567, 9, 13, 11, 1, -13 },
  { 582, 9, 13, 11, 1, -13 },
  { 597, 10, 13, 11, 1, -13 },
  { 614, 8, 13, 11, 2, -13 },
  { 627, 10, 17, 11, 1, -13 },
  { 649, 9, 13, 11, 2, -13 },
  { 664, 9, 13, 11, 1, -13 },
  { 679, 11, 13, 11, 0, -13 },
  { 697, 9, 13, 11, 1, -13 },
  { 712, 11, 13, 11, 0, -13 },
  { 730, 11, 13, 11, 0, -13 },
  { 748, 11, 13, 11, 0, -13 },
  { 766, 11, 13, 11, 0, -13 },
  { 784, 9, 13, 11, 1, -13 },
  { 799, 6, 17, 11, 4, -14 },
  { 812, 8, 17, 11, 2, -14 },
  { 829, 5, 17, 11, 2, -14 },
  { 840, 10, 8, 11, 1, -13 },
  { 850, 9, 2, 11, 1, 2 },
  { 853, 4, 4, 11, 3, -15 },
  { 855, 10, 10, 11, 1, -10 },
  { 868, 9, 14, 11, 1, -14 },
  { 884, 9, 10, 11, 1, -10 },
  { 896, 9, 14, 11, 1, -14 },
  { 912, 9, 10, 11, 1, -10 },
  { 924, 9, 14, 11, 1, -14 },
  { 940, 10, 16, 11, 1, -12 },
  { 960, 8, 14, 11, 2, -14 },
  { 974, 8, 15, 11, 2, -15 },
  { 989, 7, 19, 11, 2, -15 },
  { 1006, 9, 14, 11, 2, -14 },
  { 1022, 9, 14, 11, 1, -14 },
  { 1038, 10, 10, 11, 1, -10 },
  { 1051, 8, 10, 11, 2, -10 },
  { 1061, 9, 10, 11, 1, -10 },
  { 1073, 9, 14, 11, 1, -10 },
  { 1089, 9, 14, 11, 1, -10 },
  { 1105, 10, 10, 11, 1, -10 },
  { 1118, 9, 10, 11, 1, -10 },
  { 1130, 9, 13, 11, 1, -13 },
  { 1145, 9, 10, 11, 1, -10 },
  { 1157, 9, 10, 11, 1, -10 },
  { 1169, 11, 10, 11, 0, -10 },
  { 1183, 10, 10, 11, 1, -10 },
  { 1196, 10, 14, 11, 1, -10 },
  { 1214, 9, 10, 11, 1, -10 },
  { 1226, 8, 17, 11, 2, -14 },
  { 1243, 2, 17, 11, 5, -14 },
  { 1248, 8, 17, 11, 2, -14 },
  { 1265, 10, 5, 11, 1, -8 },
};

const GFXfont IBMPlexMono_Medium19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_MEDIUM19PT7B_H_
