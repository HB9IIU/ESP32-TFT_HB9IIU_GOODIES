#ifndef _IBMPLEXMONO_MEDIUM18PT7B_H_
#define _IBMPLEXMONO_MEDIUM18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium18pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6C, 0x92, 0x03, 0xFE, 0xDE, 0xF7, 0xBD, 0x80, 0x0D, 0x81,
  0x30, 0x26, 0x0C, 0x87, 0x9E, 0xF7, 0xC6, 0xC7, 0x9E, 0xF3, 0xC6, 0x40,
  0xC8, 0x1B, 0x03, 0x60, 0x08, 0x04, 0x0F, 0x8F, 0xEE, 0x9E, 0x43, 0x20,
  0xF8, 0x3F, 0x07, 0xC2, 0x71, 0x3C, 0x9B, 0xF8, 0xF8, 0x10, 0x08, 0x00,
  0x78, 0x6F, 0x1B, 0x32, 0x66, 0xCC, 0xF0, 0xF0, 0x1E, 0xE0, 0x3E, 0x1E,
  0x46, 0xCC, 0x99, 0x33, 0xEC, 0x38, 0x1C, 0x07, 0xC1, 0xCC, 0x30, 0x03,
  0x00, 0x73, 0x8E, 0x73, 0x6C, 0xC7, 0x98, 0xE1, 0x8E, 0x3F, 0xC3, 0xCE,
  0xFF, 0xC0, 0x0C, 0x43, 0x18, 0x61, 0x04, 0x30, 0xC1, 0x04, 0x18, 0x60,
  0xC1, 0x03, 0xC3, 0x0C, 0x21, 0x8C, 0x21, 0x08, 0x46, 0x31, 0x19, 0x98,
  0x08, 0x04, 0x22, 0x3D, 0x77, 0xF0, 0xE0, 0xD8, 0xCC, 0x23, 0x00, 0x08,
  0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0x77,
  0x66, 0x6C, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x03, 0x02, 0x06, 0x06, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x3E, 0x3F,
  0xB8, 0xD8, 0x3C, 0x1E, 0x0F, 0x67, 0xBB, 0xC1, 0xE0, 0xF8, 0xCF, 0xE3,
  0xE0, 0x1C, 0x1E, 0x1F, 0x1D, 0x8C, 0xC4, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x0F, 0xF7, 0xF8, 0x3E, 0x3F, 0xB8, 0xD8, 0x60, 0x30, 0x18, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x1F, 0xFF, 0xF8, 0x3E, 0x3F, 0xB0, 0xC8, 0x60,
  0x30, 0xF0, 0x78, 0x06, 0x03, 0xC1, 0xF0, 0xCF, 0xE3, 0xC0, 0x0E, 0x07,
  0x06, 0x82, 0x43, 0x23, 0x11, 0x09, 0x84, 0xFF, 0xFF, 0xC0, 0x80, 0x40,
  0x20, 0x7F, 0x3F, 0x90, 0x08, 0x05, 0xE3, 0xF9, 0x8F, 0x03, 0x01, 0xA0,
  0xF8, 0xCF, 0xE3, 0xE0, 0x0E, 0x0C, 0x0C, 0x0C, 0x07, 0xE7, 0xFB, 0x8F,
  0x83, 0xC1, 0xE0, 0xF8, 0xCF, 0xE3, 0xE0, 0xFF, 0xFF, 0xF0, 0xD8, 0x60,
  0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x00, 0x3E, 0x3F,
  0xB8, 0xF8, 0x36, 0x31, 0xF1, 0xFD, 0xC7, 0xC1, 0xE0, 0xF8, 0xEF, 0xE3,
  0xE0, 0x3E, 0x3F, 0xB8, 0xD8, 0x3C, 0x1E, 0x0F, 0x8E, 0xFA, 0x3B, 0x01,
  0x81, 0x81, 0x83, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x77, 0x70, 0x00, 0x07,
  0x76, 0x66, 0xC0, 0x02, 0x0C, 0x73, 0xCE, 0x10, 0x38, 0x3C, 0x1C, 0x0C,
  0x08, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x81, 0x83, 0xC1, 0xE0, 0xE0,
  0xC3, 0x9E, 0xF1, 0x82, 0x00, 0x3E, 0x7F, 0x63, 0xC3, 0x03, 0x0E, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x1C, 0x18, 0x3E, 0x3F, 0x98, 0xD8, 0x3C, 0xFE,
  0xFF, 0x67, 0xB3, 0xD9, 0xEF, 0xF3, 0xF8, 0x06, 0x03, 0xF0, 0x78, 0x0E,
  0x03, 0x81, 0xA0, 0x6C, 0x1B, 0x0C, 0xC3, 0x18, 0xC6, 0x3F, 0x9F, 0xE6,
  0x0D, 0x83, 0xE0, 0xC0, 0xFE, 0x7F, 0xB0, 0xD8, 0x6C, 0x37, 0xF3, 0xFD,
  0x87, 0xC1, 0xE0, 0xF0, 0xFF, 0xEF, 0xE0, 0x1E, 0x3F, 0x98, 0xDC, 0x3C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0xD8, 0xCF, 0xE1, 0xE0, 0xFC, 0x7F,
  0xB0, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xDF, 0xEF,
  0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x3C, 0x3F, 0x98, 0xD8, 0x3C, 0x06, 0x03, 0x3F, 0x9F, 0xC1,
  0xE0, 0xF8, 0xEF, 0xB3, 0xD8, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF,
  0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x38, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x7F, 0x7F, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xE7, 0x7E, 0x3C, 0xC1, 0xB0,
  0xCC, 0x73, 0x38, 0xCC, 0x36, 0x0F, 0xC3, 0xF0, 0xE6, 0x31, 0xCC, 0x33,
  0x0E, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFE, 0xFF, 0x5E, 0xAF, 0x77,
  0x93, 0xC9, 0xE4, 0xF0, 0x78, 0x3C, 0x18, 0xE1, 0xF0, 0xFC, 0x7E, 0x3D,
  0x9E, 0xCF, 0x27, 0x9B, 0xCD, 0xE2, 0xF1, 0xF8, 0xFC, 0x38, 0x3E, 0x3F,
  0xB8, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0xCF, 0xE3,
  0xE0, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x3E, 0x3F, 0xB8, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF8, 0xCF, 0xE3, 0xE0, 0xC0, 0x20, 0x1E, 0x0F, 0x00, 0xFC, 0xFE,
  0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xDC, 0xCC, 0xC6, 0xC6, 0xC3, 0x3E,
  0x3F, 0xB8, 0xF8, 0x0C, 0x03, 0xE1, 0xFC, 0x0F, 0x01, 0xC0, 0xF0, 0xFF,
  0xE3, 0xE0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0x98, 0xCF, 0xE3, 0xE0, 0xE0, 0xD8,
  0x36, 0x0D, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xEC, 0x1B, 0x06, 0xC1, 0xA0,
  0x38, 0x0E, 0x00, 0xC0, 0x50, 0x14, 0x05, 0x3B, 0x4E, 0xDA, 0xB6, 0xAD,
  0xAB, 0x7A, 0xDE, 0xF7, 0x3D, 0xC7, 0x71, 0x80, 0x60, 0xDC, 0x63, 0x18,
  0x6C, 0x1B, 0x03, 0x80, 0xE0, 0x38, 0x1B, 0x0C, 0xC3, 0x19, 0x87, 0xE0,
  0xC0, 0xE0, 0xEC, 0x18, 0xC6, 0x18, 0xC1, 0xB0, 0x36, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0,
  0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x30, 0x1F, 0xFF, 0xF8, 0xFF, 0xE1,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xFF, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x02, 0x03, 0x03,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x1C, 0x0E,
  0x0D, 0x84, 0xC6, 0x36, 0x1B, 0x07, 0x02, 0xFF, 0xFF, 0xC0, 0x59, 0x90,
  0x3C, 0x3F, 0xB0, 0xC0, 0x67, 0xF7, 0xFB, 0x0D, 0xFF, 0x79, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0D, 0xE6, 0xFB, 0x8F, 0x83, 0xC1, 0xE0, 0xF8, 0xFB,
  0xED, 0xE0, 0x3E, 0x7F, 0x63, 0xC0, 0xC0, 0xC0, 0x63, 0x7F, 0x3E, 0x03,
  0x03, 0x03, 0x03, 0x3B, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B,
  0x3E, 0x3F, 0xB0, 0x5F, 0xFF, 0xFE, 0x03, 0x84, 0xFE, 0x3E, 0x00, 0x0F,
  0x8F, 0xC6, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1F,
  0xEF, 0xF0, 0x03, 0x81, 0xCF, 0x8F, 0xE6, 0x33, 0x19, 0xFC, 0x7C, 0x40,
  0x3F, 0x9F, 0xE8, 0x3C, 0x1F, 0xFD, 0xFC, 0x81, 0x02, 0x04, 0x09, 0xD7,
  0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0x18, 0x18, 0x00, 0x00, 0xF8,
  0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x0C, 0x30, 0x00, 0xFF,
  0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF8, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC7, 0xCC, 0xD8, 0xF0, 0xF8, 0xDC, 0xCE, 0xC6, 0xC3, 0xF8, 0xF8,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xB3,
  0x5F, 0xF6, 0x71, 0x38, 0x9C, 0x4E, 0x27, 0x13, 0x89, 0x80, 0x9D, 0x7F,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x3E, 0x3F, 0xB8, 0xD8, 0x3C, 0x1E,
  0x0F, 0x8C, 0xFE, 0x3E, 0x00, 0xDE, 0x6F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F,
  0x8F, 0xBE, 0xDE, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x3B, 0x7F, 0xE3, 0xC3,
  0xC3, 0xC3, 0xE3, 0x7F, 0x3B, 0x03, 0x03, 0x03, 0x03, 0xFB, 0xFF, 0xC7,
  0x03, 0x01, 0x80, 0xC0, 0x61, 0xFE, 0xFF, 0x00, 0x3E, 0x3F, 0x98, 0x8F,
  0x07, 0xF0, 0x79, 0x07, 0xFE, 0x3E, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x0F,
  0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF1, 0xF8, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B, 0xC1, 0xE1, 0x98, 0xCC, 0x62,
  0x61, 0xB0, 0xD8, 0x38, 0x1C, 0x00, 0xCC, 0x53, 0x94, 0xA5, 0x2B, 0x6A,
  0xDA, 0xB7, 0xBD, 0xCE, 0x31, 0x80, 0xE3, 0xB1, 0x8D, 0x83, 0x81, 0xC1,
  0xE0, 0xD8, 0xC6, 0xC3, 0x80, 0xC1, 0xE0, 0x98, 0xCC, 0x62, 0x61, 0xB0,
  0xD0, 0x38, 0x1C, 0x0C, 0x06, 0x1E, 0x0F, 0x00, 0x7F, 0x7F, 0x07, 0x0E,
  0x18, 0x30, 0x60, 0xFF, 0xFF, 0x3E, 0x7C, 0xC1, 0x81, 0x03, 0x06, 0x7C,
  0xF8, 0x30, 0x60, 0x83, 0x06, 0x0F, 0x9F, 0xFF, 0xFF, 0xF1, 0xF0, 0x60,
  0xC1, 0x04, 0x08, 0x1F, 0x3E, 0x40, 0x80, 0x81, 0x83, 0x3E, 0x78, 0x71,
  0xBC, 0xF6, 0x79, 0xE8, 0x60,
};

const GFXglyph IBMPlexMono_Medium18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -13 },
  { 10, 11, 13, 11, 0, -13 },
  { 28, 9, 17, 11, 1, -15 },
  { 48, 11, 13, 11, 0, -13 },
  { 66, 11, 13, 11, 0, -13 },
  { 84, 2, 5, 11, 4, -13 },
  { 86, 6, 16, 11, 3, -14 },
  { 98, 5, 16, 11, 2, -14 },
  { 108, 9, 9, 11, 1, -10 },
  { 119, 9, 10, 11, 1, -11 },
  { 131, 4, 6, 11, 3, -3 },
  { 134, 5, 2, 11, 3, -6 },
  { 136, 3, 3, 11, 4, -3 },
  { 138, 8, 16, 11, 1, -14 },
  { 154, 9, 13, 11, 1, -13 },
  { 169, 9, 13, 11, 1, -13 },
  { 184, 9, 13, 11, 1, -13 },
  { 199, 9, 13, 11, 1, -13 },
  { 214, 9, 13, 11, 1, -13 },
  { 229, 9, 13, 11, 1, -13 },
  { 244, 9, 13, 11, 1, -13 },
  { 259, 9, 13, 11, 1, -13 },
  { 274, 9, 13, 11, 1, -13 },
  { 289, 9, 13, 11, 1, -13 },
  { 304, 3, 10, 11, 4, -10 },
  { 308, 4, 13, 11, 3, -10 },
  { 315, 7, 11, 11, 2, -11 },
  { 325, 9, 5, 11, 1, -8 },
  { 331, 7, 11, 11, 2, -11 },
  { 341, 8, 13, 11, 1, -13 },
  { 354, 9, 15, 11, 1, -13 },
  { 371, 10, 13, 11, 0, -13 },
  { 388, 9, 13, 11, 1, -13 },
  { 403, 9, 13, 11, 1, -13 },
  { 418, 9, 13, 11, 1, -13 },
  { 433, 7, 13, 11, 2, -13 },
  { 445, 8, 13, 11, 2, -13 },
  { 458, 9, 13, 11, 1, -13 },
  { 473, 9, 13, 11, 1, -13 },
  { 488, 8, 13, 11, 1, -13 },
  { 501, 8, 13, 11, 1, -13 },
  { 514, 10, 13, 11, 1, -13 },
  { 531, 8, 13, 11, 2, -13 },
  { 544, 9, 13, 11, 1, -13 },
  { 559, 9, 13, 11, 1, -13 },
  { 574, 9, 13, 11, 1, -13 },
  { 589, 8, 13, 11, 2, -13 },
  { 602, 9, 17, 11, 1, -13 },
  { 622, 8, 13, 11, 2, -13 },
  { 635, 9, 13, 11, 1, -13 },
  { 650, 10, 13, 11, 0, -13 },
  { 667, 9, 13, 11, 1, -13 },
  { 682, 10, 13, 11, 0, -13 },
  { 699, 10, 13, 11, 0, -13 },
  { 716, 10, 13, 11, 0, -13 },
  { 733, 11, 13, 11, 0, -13 },
  { 751, 9, 13, 11, 1, -13 },
  { 766, 5, 16, 11, 4, -14 },
  { 776, 8, 16, 11, 1, -14 },
  { 792, 5, 16, 11, 2, -14 },
  { 802, 9, 8, 11, 1, -13 },
  { 811, 9, 2, 11, 1, 1 },
  { 814, 3, 4, 11, 3, -14 },
  { 816, 9, 9, 11, 1, -9 },
  { 827, 9, 13, 11, 1, -13 },
  { 842, 8, 9, 11, 1, -9 },
  { 851, 8, 13, 11, 1, -13 },
  { 864, 9, 9, 11, 1, -9 },
  { 875, 9, 13, 11, 1, -13 },
  { 890, 9, 15, 11, 1, -11 },
  { 907, 7, 13, 11, 2, -13 },
  { 919, 8, 13, 11, 2, -13 },
  { 932, 6, 17, 11, 2, -13 },
  { 945, 8, 13, 11, 2, -13 },
  { 958, 8, 13, 11, 1, -13 },
  { 971, 9, 9, 11, 1, -9 },
  { 982, 7, 9, 11, 2, -9 },
  { 990, 9, 9, 11, 1, -9 },
  { 1001, 9, 13, 11, 1, -9 },
  { 1016, 8, 13, 11, 1, -9 },
  { 1029, 9, 9, 11, 1, -9 },
  { 1040, 9, 9, 11, 1, -9 },
  { 1051, 9, 13, 11, 1, -13 },
  { 1066, 8, 9, 11, 1, -9 },
  { 1075, 9, 9, 11, 1, -9 },
  { 1086, 10, 9, 11, 0, -9 },
  { 1098, 9, 9, 11, 1, -9 },
  { 1109, 9, 13, 11, 1, -9 },
  { 1124, 8, 9, 11, 1, -9 },
  { 1133, 7, 16, 11, 2, -14 },
  { 1147, 1, 16, 11, 5, -14 },
  { 1149, 7, 16, 11, 2, -14 },
  { 1163, 9, 5, 11, 1, -8 },
};

const GFXfont IBMPlexMono_Medium18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_MEDIUM18PT7B_H_
