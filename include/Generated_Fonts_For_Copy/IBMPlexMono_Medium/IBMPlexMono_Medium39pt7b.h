#ifndef _IBMPLEXMONO_MEDIUM39PT7B_H_
#define _IBMPLEXMONO_MEDIUM39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0xF1, 0xC3,
  0x87, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0xFF, 0xFE, 0xFD,
  0xF0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x00, 0x70, 0xF0, 0x01, 0xE1,
  0xC0, 0x03, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFC,
  0xFF, 0x0F, 0xF8, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00,
  0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0xFF, 0x87, 0xF9, 0xFF, 0x0F, 0xF3, 0xFE,
  0x1F, 0xE0, 0x3C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3,
  0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7E, 0x77, 0xE7,
  0x87, 0x1C, 0x78, 0x70, 0x87, 0x87, 0x00, 0x78, 0x70, 0x07, 0xC7, 0x00,
  0x7E, 0x70, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x73, 0xE0, 0x07, 0x1F, 0x00, 0x70, 0xF2, 0x07,
  0x0F, 0x60, 0x71, 0xFF, 0x87, 0x1E, 0xFE, 0x77, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x7F, 0xC0, 0x38, 0xFF,
  0x80, 0xF3, 0xC7, 0x81, 0xC7, 0x07, 0x07, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0xF0, 0x70, 0x71, 0xC0, 0xE0, 0xE7, 0x81, 0xE3, 0xCE,
  0x01, 0xFF, 0x20, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFE, 0x03, 0xCE, 0x3C, 0x07, 0x38, 0x3C, 0x1E, 0x70, 0x38,
  0x38, 0xE0, 0x70, 0xF1, 0xC0, 0xE3, 0xC3, 0x81, 0xC7, 0x07, 0x07, 0x9E,
  0x07, 0x0E, 0x38, 0x0F, 0xFC, 0xF0, 0x0F, 0xF3, 0xC0, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0x87, 0xC0, 0x3E, 0x0F,
  0x00, 0xF0, 0x10, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x7F,
  0x07, 0xE3, 0xDE, 0x1F, 0x9E, 0x7C, 0x70, 0xF8, 0xF9, 0xC3, 0xC1, 0xE7,
  0x0F, 0x03, 0xDC, 0x3C, 0x07, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F,
  0x80, 0xFC, 0x1F, 0x06, 0xF8, 0x7F, 0xF9, 0xF0, 0xFF, 0xC3, 0xE0, 0xFC,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x20,
  0x3C, 0x09, 0xE1, 0xE3, 0xCF, 0xEF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0x3C, 0x00, 0xF1, 0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x1E, 0x01, 0x80, 0x60,
  0x08, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C,
  0x1C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xFF, 0xFF,
  0xF7, 0xEF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7E, 0x0F, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xEF,
  0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x0E, 0x1F,
  0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x0E, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0,
  0x3C, 0x3E, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0x78, 0x03, 0xE7, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0x80, 0x70, 0x78,
  0x02, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF0, 0x0F,
  0xBE, 0x01, 0xF1, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x3F, 0x07, 0xE3, 0xC0, 0x3E, 0x18, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF1, 0x00, 0x1F, 0x38, 0x01, 0xF7, 0xC0, 0x3F, 0xFE, 0x07,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x01,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE3, 0xF0,
  0x3C, 0xFF, 0x87, 0xBF, 0xF8, 0xFC, 0x1F, 0x9F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x88, 0x00, 0xF3, 0x00, 0x3E,
  0xF0, 0x07, 0xFF, 0x83, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF3, 0xF0, 0x3C, 0xFF, 0x87, 0xBF, 0xF9, 0xFC, 0x1F,
  0xBF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xDF, 0x00, 0xF1, 0xF0, 0x7E,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xE0, 0xFC, 0x7C,
  0x03, 0xC7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0xC0, 0x3C, 0x3E, 0x0F, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF0,
  0x3E, 0x0F, 0xC7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xE0,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x3C, 0xF0, 0x07, 0xBE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x1B, 0xCF, 0xFF, 0xF8, 0xFF, 0xDF, 0x07,
  0xE3, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFB, 0xF7, 0xC0, 0x3E, 0x1F, 0x9F,
  0xCF, 0xE3, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0,
  0x78, 0x38, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x3F, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1E, 0x60, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x03, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0x9E,
  0x00, 0x7B, 0x80, 0x0F, 0x70, 0x7C, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8,
  0xF0, 0xFF, 0x1C, 0x1F, 0xE3, 0x81, 0xFC, 0x70, 0x3F, 0x9E, 0x07, 0xF3,
  0xC0, 0xFE, 0x38, 0x1F, 0xC7, 0x03, 0xF8, 0xE0, 0x7F, 0x1E, 0x1F, 0xE3,
  0xFD, 0xDC, 0x3F, 0xBB, 0x83, 0xE7, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xDE,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x1F, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x0F, 0x1E, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x00,
  0x07, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8,
  0x1F, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01,
  0xEF, 0x80, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0x80, 0xFB,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0x8F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE3, 0xF0, 0x7C, 0x7C, 0x07, 0xDF, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0xE7, 0xC0, 0x1E, 0x7C, 0x07, 0xCF, 0xC1, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0x3E, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x01,
  0xEF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x03,
  0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F,
  0x3E, 0x07, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC,
  0xF8, 0x0F, 0x9F, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF7,
  0x80, 0x1E, 0xF8, 0x07, 0xDF, 0x00, 0xF9, 0xF8, 0x6F, 0x1F, 0xFD, 0xE1,
  0xFF, 0x3C, 0x1F, 0x87, 0x80, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE7, 0x00, 0xFF, 0x80,
  0x7B, 0xC0, 0x7D, 0xF8, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x07, 0xFE, 0x01,
  0xFC, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0xF8,
  0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8,
  0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0xF7, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0x80, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8,
  0x3E, 0x0F, 0x03, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F,
  0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xB8, 0xFF, 0xF7, 0x9D, 0xFE, 0x77, 0xBF, 0xCF, 0xE7, 0xF9, 0xFC,
  0xFF, 0x1F, 0x9F, 0xE3, 0xE3, 0xFC, 0x3C, 0x7F, 0x87, 0x0F, 0xF0, 0xE1,
  0xFE, 0x0C, 0x3F, 0xC1, 0x07, 0xF8, 0x20, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0x80, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF7, 0x83, 0xFD, 0xE0, 0xFF,
  0x38, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC3,
  0x8F, 0xF0, 0xF3, 0xFC, 0x3C, 0xFF, 0x07, 0xBF, 0xC1, 0xEF, 0xF0, 0x7B,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x7E, 0x0F, 0xC7, 0xC0, 0x7C, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF8,
  0x01, 0xEF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x7C, 0x3E, 0x0F, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFC,
  0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x0F, 0xC7,
  0xC0, 0x7C, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x80,
  0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x7C, 0x07, 0xC3, 0xE0, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x80, 0xFD, 0xF0, 0x0F,
  0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F,
  0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xC0,
  0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xE1,
  0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0x9F, 0x00, 0xFB,
  0xE0, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE7, 0xE0, 0x7E, 0xF8, 0x03, 0x9E, 0x00, 0x23, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xA0, 0x00, 0xF6, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x81, 0xFB, 0xFF, 0xFE,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xBE, 0x03, 0xE7, 0xC1, 0xF9, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xDE, 0x00, 0x3E, 0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0x1E, 0x00, 0xF8,
  0xF0, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3E, 0x1E, 0x01,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xEE, 0x1F, 0x0F, 0x70, 0xF8, 0x7B, 0x87, 0xC3, 0xDC, 0x3F, 0x1E,
  0xF1, 0xF8, 0xF7, 0x9D, 0xC7, 0xBC, 0xEE, 0x39, 0xE7, 0x71, 0xCF, 0x39,
  0xCE, 0x79, 0xCE, 0x73, 0xCE, 0x73, 0x9E, 0xE3, 0x9C, 0xF7, 0x1D, 0xE7,
  0xB8, 0xFF, 0x1D, 0xC3, 0xF8, 0xEE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07,
  0xF1, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0xF8,
  0x78, 0x01, 0xE3, 0xE0, 0x07, 0xCF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x78, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x07, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x07,
  0x8F, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80,
  0x1E, 0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x1E, 0x07, 0x80,
  0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xFE,
  0x00, 0x0E, 0x10, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x31, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x84, 0x07, 0xF8,
  0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xC1, 0xF0, 0x38, 0x0F, 0x81, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7F, 0xF8, 0x3F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7C, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F,
  0x80, 0x78, 0x7C, 0x1F, 0x87, 0xFF, 0x3F, 0x3F, 0xF3, 0xF0, 0xFC, 0x1F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x3E, 0x0F, 0x3F,
  0xE3, 0xDF, 0xFC, 0xF4, 0x1F, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xBD, 0x07, 0xEF, 0x7F,
  0xF3, 0xCF, 0xF8, 0xF0, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xF8, 0x3E, 0x7C, 0x07, 0x9E, 0x00, 0x8F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x31, 0xF0, 0x1E, 0x3E, 0x0F, 0xC7, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC1,
  0xF8, 0xF1, 0xFF, 0x3C, 0xFF, 0xEF, 0x7E, 0x0F, 0xDF, 0x01, 0xF7, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F, 0x7C, 0x07, 0xDF,
  0x83, 0xF3, 0xFF, 0xBC, 0x7F, 0xCF, 0x07, 0xE3, 0xC0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E,
  0x00, 0x7B, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x41, 0xE0, 0x1E, 0x3F,
  0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x3F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x78, 0x7C,
  0x07, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0x83,
  0xE0, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x7C, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xE1,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x78, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8, 0x0F, 0x8F, 0x81, 0xF0,
  0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x87,
  0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8,
  0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE7, 0x87, 0xCE, 0xFC, 0xFE, 0xEF, 0xEF, 0xEF, 0x1F, 0x1E, 0xF0,
  0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE,
  0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F,
  0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0,
  0xFE, 0x0F, 0x0F, 0xF8, 0xF8, 0x7D, 0xFF, 0x3F, 0xFF, 0xDF, 0xC3, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x3C, 0xF0, 0x07,
  0x9E, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xE0, 0x1E,
  0x3E, 0x0F, 0x83, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xF0, 0xF8,
  0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xD0, 0x7E, 0xF8, 0x07, 0xBE, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0xF4, 0x1F,
  0xBD, 0xFF, 0xCF, 0x3F, 0xE3, 0xC3, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD, 0xF8, 0x3F, 0x7C, 0x07,
  0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x3D, 0xF0,
  0x1F, 0x7E, 0x0F, 0xCF, 0xFE, 0xF1, 0xFF, 0x3C, 0x1F, 0x8F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0x83,
  0xEF, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F,
  0x03, 0xE3, 0xC0, 0x18, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC8, 0x00, 0xFB, 0xC0, 0x1E, 0xFE, 0x07, 0xCF, 0xFF, 0xF0, 0x7F,
  0xFC, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x7C, 0x17, 0xBF, 0xFB, 0xCF,
  0xF9, 0xE1, 0xF0, 0xF0, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x78, 0x03, 0xE7,
  0x80, 0x3C, 0x7C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0x79, 0xE0, 0x07, 0x9C, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xE0, 0x78, 0x3F, 0xC3, 0xE0, 0xEF,
  0x0F, 0x83, 0xBC, 0x3E, 0x0E, 0xF0, 0xFC, 0x39, 0xC3, 0x71, 0xE7, 0x0D,
  0xC7, 0x9C, 0x77, 0x1E, 0x71, 0xCC, 0x71, 0xE7, 0x39, 0xC7, 0x9C, 0xE7,
  0x1E, 0x63, 0x9C, 0x3B, 0x8E, 0x70, 0xEE, 0x39, 0xC3, 0xB8, 0x6F, 0x0E,
  0xE1, 0xF8, 0x3B, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC1,
  0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x3C, 0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1F,
  0x0F, 0x00, 0xF9, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7B, 0xE0,
  0x0F, 0x1F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x83, 0xC0, 0x7C, 0x78, 0x03,
  0xEF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x3C, 0x7C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00,
  0x79, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xE0, 0x03, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0xFF,
  0x03, 0xFF, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0x00,
  0xE3, 0xF8, 0x0F, 0x3F, 0xC0, 0xE7, 0x9E, 0x0E, 0x70, 0xF1, 0xEF, 0x0F,
  0x1C, 0xE0, 0x7F, 0xCE, 0x03, 0xF8, 0xE0, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_Medium39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 27, 23, 8, -27 },
  { 25, 12, 12, 23, 6, -29 },
  { 43, 23, 27, 23, 0, -27 },
  { 121, 20, 35, 23, 2, -31 },
  { 209, 23, 27, 23, 0, -27 },
  { 287, 22, 27, 23, 1, -27 },
  { 362, 4, 12, 23, 10, -29 },
  { 368, 13, 35, 23, 7, -30 },
  { 425, 12, 35, 23, 4, -30 },
  { 478, 21, 20, 23, 1, -21 },
  { 531, 19, 19, 23, 2, -21 },
  { 577, 9, 12, 23, 7, -6 },
  { 591, 12, 4, 23, 6, -14 },
  { 597, 7, 6, 23, 8, -6 },
  { 603, 17, 35, 23, 3, -30 },
  { 678, 20, 27, 23, 2, -27 },
  { 746, 20, 27, 23, 2, -27 },
  { 814, 19, 27, 23, 2, -27 },
  { 879, 20, 27, 23, 1, -27 },
  { 947, 21, 27, 23, 1, -27 },
  { 1018, 19, 27, 23, 2, -27 },
  { 1083, 19, 27, 23, 2, -27 },
  { 1148, 19, 27, 23, 2, -27 },
  { 1213, 20, 27, 23, 2, -27 },
  { 1281, 19, 27, 23, 2, -27 },
  { 1346, 7, 21, 23, 8, -21 },
  { 1365, 9, 27, 23, 7, -21 },
  { 1396, 17, 23, 23, 3, -23 },
  { 1445, 19, 12, 23, 2, -18 },
  { 1474, 17, 23, 23, 3, -23 },
  { 1523, 17, 27, 23, 3, -27 },
  { 1581, 19, 31, 23, 2, -27 },
  { 1655, 22, 27, 23, 1, -27 },
  { 1730, 18, 27, 23, 3, -27 },
  { 1791, 19, 27, 23, 2, -27 },
  { 1856, 19, 27, 23, 3, -27 },
  { 1921, 17, 27, 23, 3, -27 },
  { 1979, 18, 27, 23, 3, -27 },
  { 2040, 19, 27, 23, 2, -27 },
  { 2105, 18, 27, 23, 3, -27 },
  { 2166, 17, 27, 23, 3, -27 },
  { 2224, 17, 27, 23, 2, -27 },
  { 2282, 20, 27, 23, 3, -27 },
  { 2350, 17, 27, 23, 4, -27 },
  { 2408, 19, 27, 23, 2, -27 },
  { 2473, 18, 27, 23, 3, -27 },
  { 2534, 20, 27, 23, 2, -27 },
  { 2602, 18, 27, 23, 3, -27 },
  { 2663, 20, 33, 23, 2, -27 },
  { 2746, 19, 27, 23, 3, -27 },
  { 2811, 19, 27, 23, 2, -27 },
  { 2876, 21, 27, 23, 1, -27 },
  { 2947, 18, 27, 23, 3, -27 },
  { 3008, 21, 27, 23, 1, -27 },
  { 3079, 21, 27, 23, 1, -27 },
  { 3150, 22, 27, 23, 1, -27 },
  { 3225, 23, 27, 23, 0, -27 },
  { 3303, 20, 27, 23, 2, -27 },
  { 3371, 12, 35, 23, 8, -30 },
  { 3424, 17, 35, 23, 3, -30 },
  { 3499, 11, 35, 23, 4, -30 },
  { 3548, 21, 17, 23, 1, -27 },
  { 3593, 19, 4, 23, 2, 3 },
  { 3603, 7, 8, 23, 7, -31 },
  { 3610, 20, 20, 23, 2, -20 },
  { 3660, 18, 29, 23, 3, -29 },
  { 3726, 18, 20, 23, 3, -20 },
  { 3771, 18, 29, 23, 2, -29 },
  { 3837, 19, 20, 23, 2, -20 },
  { 3885, 18, 29, 23, 3, -29 },
  { 3951, 20, 31, 23, 2, -23 },
  { 4029, 17, 29, 23, 3, -29 },
  { 4091, 17, 29, 23, 4, -29 },
  { 4153, 14, 37, 23, 4, -29 },
  { 4218, 20, 29, 23, 3, -29 },
  { 4291, 18, 29, 23, 3, -29 },
  { 4357, 20, 20, 23, 2, -20 },
  { 4407, 17, 20, 23, 3, -20 },
  { 4450, 19, 20, 23, 2, -20 },
  { 4498, 18, 28, 23, 3, -20 },
  { 4561, 18, 28, 23, 2, -20 },
  { 4624, 19, 20, 23, 3, -20 },
  { 4672, 19, 20, 23, 2, -20 },
  { 4720, 19, 27, 23, 2, -27 },
  { 4785, 17, 20, 23, 3, -20 },
  { 4828, 20, 20, 23, 2, -20 },
  { 4878, 22, 20, 23, 1, -20 },
  { 4933, 20, 20, 23, 2, -20 },
  { 4983, 20, 28, 23, 2, -20 },
  { 5053, 17, 20, 23, 3, -20 },
  { 5096, 16, 35, 23, 4, -30 },
  { 5166, 4, 35, 23, 10, -30 },
  { 5184, 16, 35, 23, 4, -30 },
  { 5254, 20, 9, 23, 2, -16 },
};

const GFXfont IBMPlexMono_Medium39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_MEDIUM39PT7B_H_
