#ifndef _IBMPLEXMONO_MEDIUM10PT7B_H_
#define _IBMPLEXMONO_MEDIUM10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0x3C, 0xFC, 0x28, 0xAE, 0xCC, 0xDD, 0x45, 0x00, 0x11, 0xE6,
  0x98, 0x78, 0xB6, 0xFE, 0x10, 0x6E, 0xAB, 0x1E, 0x15, 0xD9, 0x80, 0x71,
  0x44, 0x1B, 0x9A, 0x66, 0xC0, 0xFC, 0x6A, 0x49, 0x22, 0x60, 0xC8, 0x92,
  0x4A, 0xC0, 0x22, 0xA7, 0xCC, 0x48, 0x44, 0xF4, 0x40, 0xE8, 0xF0, 0xF0,
  0x11, 0x22, 0x44, 0x48, 0x80, 0x79, 0x2C, 0xFF, 0xCD, 0x27, 0x80, 0x31,
  0x4D, 0x04, 0x10, 0x47, 0xC0, 0xF9, 0x13, 0x68, 0xF0, 0x7A, 0x42, 0x60,
  0xA7, 0xE0, 0x18, 0xA2, 0x92, 0x4B, 0xF0, 0x80, 0xF8, 0xF9, 0x19, 0xF0,
  0x76, 0x3D, 0x29, 0xCB, 0xC0, 0xF9, 0x12, 0x26, 0x40, 0x79, 0x24, 0x8C,
  0x4B, 0x37, 0x80, 0x7A, 0x53, 0x97, 0x8D, 0xC0, 0xF0, 0xF0, 0xF0, 0xE8,
  0x12, 0xCC, 0x21, 0xF0, 0xF0, 0x84, 0x33, 0x48, 0xF9, 0x16, 0x06, 0x60,
  0xF9, 0xBD, 0xDF, 0x87, 0x30, 0xC3, 0x12, 0x79, 0x28, 0xC0, 0xF9, 0x9E,
  0x99, 0xF0, 0x79, 0x88, 0x89, 0x70, 0xF4, 0xA5, 0x39, 0x4B, 0xC0, 0xF8,
  0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x7A, 0x51, 0xB4, 0xA5, 0xE0,
  0x99, 0x9F, 0x99, 0x90, 0xF6, 0x66, 0x66, 0xF0, 0xF1, 0x11, 0x19, 0xE0,
  0x9D, 0xA9, 0xCA, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0x9D, 0xFF, 0xD9,
  0x90, 0x9D, 0xDD, 0xBB, 0x90, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x80, 0xF4,
  0xA7, 0xE8, 0x42, 0x00, 0x79, 0x24, 0xB3, 0xCD, 0x27, 0x84, 0x18, 0xF4,
  0xA7, 0xEA, 0x4A, 0x60, 0x7A, 0x50, 0xF0, 0xA7, 0xE0, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x00, 0x99, 0x99, 0x99, 0xF0, 0xCD, 0x24, 0x92, 0x30, 0xC3,
  0x00, 0x86, 0x1B, 0x6D, 0x79, 0xE4, 0x80, 0xCD, 0x23, 0x0C, 0x31, 0x2C,
  0xC0, 0xCD, 0x23, 0x0C, 0x30, 0xC3, 0x00, 0x78, 0x21, 0x0C, 0x21, 0x0F,
  0xC0, 0xF2, 0x49, 0x24, 0xE0, 0x88, 0x44, 0x42, 0x21, 0x10, 0xE4, 0x92,
  0x49, 0xE0, 0x30, 0xC4, 0xB3, 0xF0, 0xB0, 0xE4, 0xBD, 0x2F, 0x80, 0x88,
  0xF9, 0x99, 0xF0, 0x79, 0x89, 0x70, 0x11, 0xF9, 0x99, 0xF0, 0xF9, 0xF9,
  0xF0, 0x36, 0xF6, 0x66, 0xF0, 0x1F, 0xA5, 0xE8, 0x7A, 0x3E, 0x88, 0xF9,
  0x99, 0x90, 0x20, 0x38, 0x42, 0x13, 0xE0, 0x30, 0xE2, 0x22, 0x22, 0xE0,
  0x84, 0x27, 0x4E, 0x5A, 0x60, 0xE6, 0x66, 0x66, 0xF0, 0xAB, 0xDA, 0x69,
  0xA4, 0xF9, 0x99, 0x90, 0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9,
  0x99, 0xF1, 0x10, 0xDB, 0x10, 0x8F, 0x00, 0xF8, 0xF9, 0xF0, 0x21, 0x3E,
  0x42, 0x10, 0xE0, 0x99, 0x99, 0xF0, 0xCD, 0x24, 0x8C, 0x30, 0xB6, 0xDB,
  0x9E, 0x48, 0x48, 0xC3, 0x0C, 0xCC, 0xCD, 0x24, 0x8C, 0x30, 0x86, 0x00,
  0xF3, 0x6C, 0xF0, 0x74, 0x42, 0xC2, 0x44, 0x70, 0xFF, 0x80, 0xE2, 0x44,
  0x34, 0x42, 0xE0, 0x6E, 0x60,
};

const GFXglyph IBMPlexMono_Medium10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 2, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 6, 9, 6, 0, -8 },
  { 17, 6, 7, 6, 0, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 2, 3, 6, 2, -7 },
  { 30, 3, 9, 6, 2, -8 },
  { 34, 3, 9, 6, 1, -8 },
  { 38, 6, 5, 6, 0, -5 },
  { 42, 4, 5, 6, 1, -6 },
  { 45, 2, 3, 6, 2, -2 },
  { 46, 4, 1, 6, 1, -4 },
  { 47, 2, 2, 6, 2, -2 },
  { 48, 4, 9, 6, 1, -8 },
  { 53, 6, 7, 6, 0, -7 },
  { 59, 6, 7, 6, 0, -7 },
  { 65, 4, 7, 6, 1, -7 },
  { 69, 5, 7, 6, 0, -7 },
  { 74, 6, 7, 6, 0, -7 },
  { 80, 4, 7, 6, 1, -7 },
  { 84, 5, 7, 6, 1, -7 },
  { 89, 4, 7, 6, 1, -7 },
  { 93, 6, 7, 6, 0, -7 },
  { 99, 5, 7, 6, 0, -7 },
  { 104, 2, 6, 6, 2, -6 },
  { 106, 2, 7, 6, 2, -6 },
  { 108, 4, 6, 6, 1, -6 },
  { 111, 4, 3, 6, 1, -5 },
  { 113, 4, 6, 6, 1, -6 },
  { 116, 4, 7, 6, 1, -7 },
  { 120, 4, 8, 6, 1, -7 },
  { 124, 6, 7, 6, 0, -7 },
  { 130, 4, 7, 6, 1, -7 },
  { 134, 4, 7, 6, 1, -7 },
  { 138, 5, 7, 6, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 5, 7, 6, 0, -7 },
  { 156, 4, 7, 6, 1, -7 },
  { 160, 4, 7, 6, 1, -7 },
  { 164, 4, 7, 6, 1, -7 },
  { 168, 5, 7, 6, 1, -7 },
  { 173, 4, 7, 6, 1, -7 },
  { 177, 4, 7, 6, 1, -7 },
  { 181, 4, 7, 6, 1, -7 },
  { 185, 6, 7, 6, 0, -7 },
  { 191, 5, 7, 6, 1, -7 },
  { 196, 6, 9, 6, 0, -7 },
  { 203, 5, 7, 6, 1, -7 },
  { 208, 5, 7, 6, 0, -7 },
  { 213, 6, 7, 6, 0, -7 },
  { 219, 4, 7, 6, 1, -7 },
  { 223, 6, 7, 6, 0, -7 },
  { 229, 6, 7, 6, 0, -7 },
  { 235, 6, 7, 6, 0, -7 },
  { 241, 6, 7, 6, 0, -7 },
  { 247, 6, 7, 6, 0, -7 },
  { 253, 3, 9, 6, 2, -8 },
  { 257, 4, 9, 6, 1, -8 },
  { 262, 3, 9, 6, 1, -8 },
  { 266, 6, 4, 6, 0, -7 },
  { 269, 4, 1, 6, 1, 1 },
  { 270, 2, 2, 6, 2, -8 },
  { 271, 5, 5, 6, 1, -5 },
  { 275, 4, 7, 6, 1, -7 },
  { 279, 4, 5, 6, 1, -5 },
  { 282, 4, 7, 6, 1, -7 },
  { 286, 4, 5, 6, 1, -5 },
  { 289, 4, 7, 6, 1, -7 },
  { 293, 5, 8, 6, 1, -6 },
  { 298, 4, 7, 6, 1, -7 },
  { 302, 5, 7, 6, 1, -7 },
  { 307, 4, 9, 6, 1, -7 },
  { 312, 5, 7, 6, 1, -7 },
  { 317, 4, 7, 6, 1, -7 },
  { 321, 6, 5, 6, 0, -5 },
  { 325, 4, 5, 6, 1, -5 },
  { 328, 4, 5, 6, 1, -5 },
  { 331, 4, 7, 6, 1, -5 },
  { 335, 4, 7, 6, 1, -5 },
  { 339, 5, 5, 6, 1, -5 },
  { 343, 4, 5, 6, 1, -5 },
  { 346, 5, 7, 6, 0, -7 },
  { 351, 4, 5, 6, 1, -5 },
  { 354, 6, 5, 6, 0, -5 },
  { 358, 6, 5, 6, 0, -5 },
  { 362, 6, 5, 6, 0, -5 },
  { 366, 6, 7, 6, 0, -5 },
  { 372, 4, 5, 6, 1, -5 },
  { 375, 4, 9, 6, 1, -8 },
  { 380, 1, 9, 6, 3, -8 },
  { 382, 4, 9, 6, 1, -8 },
  { 387, 6, 2, 6, 0, -4 },
};

const GFXfont IBMPlexMono_Medium10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_MEDIUM10PT7B_H_
