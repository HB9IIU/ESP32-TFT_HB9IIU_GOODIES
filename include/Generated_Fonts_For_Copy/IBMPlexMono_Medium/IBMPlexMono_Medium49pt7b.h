#ifndef _IBMPLEXMONO_MEDIUM49PT7B_H_
#define _IBMPLEXMONO_MEDIUM49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00,
  0x0F, 0x87, 0xC0, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xF0,
  0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0xFF, 0xE1, 0xFF, 0xCF, 0xFE, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF,
  0xCF, 0xFC, 0x1F, 0xFC, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xE7,
  0x9F, 0xE7, 0xE3, 0xC3, 0xE7, 0xE1, 0xE0, 0xE3, 0xF0, 0xF0, 0x21, 0xF0,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7E, 0x1E, 0x00, 0x3F, 0x0F, 0x00, 0x0F,
  0xC7, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0x8F, 0xE0, 0x03, 0xC3, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0,
  0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1F, 0x18, 0x1E, 0x0F, 0x9E, 0x0F,
  0x0F, 0xDF, 0x87, 0x87, 0xFF, 0xF3, 0xCF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0x3F, 0xF8,
  0x01, 0xE7, 0xFF, 0x80, 0x3E, 0xF8, 0x7C, 0x03, 0xCF, 0x03, 0xC0, 0x7C,
  0xF0, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0xF8, 0xF0, 0x1E, 0x0F, 0x0F, 0x01,
  0xE1, 0xF0, 0xF0, 0x1E, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C,
  0x0F, 0x87, 0xC7, 0x80, 0x7F, 0xF8, 0x78, 0x03, 0xFF, 0x8F, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF8, 0x01, 0xF1, 0xFF, 0xC0, 0x3E, 0x3F, 0xFC, 0x03, 0xC7, 0xC3, 0xE0,
  0x7C, 0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xF8, 0x78, 0x0F, 0x0F, 0x07,
  0x80, 0xF1, 0xF0, 0x78, 0x0F, 0x1E, 0x07, 0x80, 0xF3, 0xE0, 0x78, 0x1E,
  0x3C, 0x07, 0x81, 0xE7, 0xC0, 0x7C, 0x3E, 0x78, 0x03, 0xFF, 0xCF, 0x80,
  0x1F, 0xFC, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFE,
  0x1F, 0xF8, 0x1F, 0xE3, 0xF7, 0xC1, 0xFE, 0x3E, 0x7E, 0x1E, 0x07, 0xC3,
  0xF1, 0xE0, 0x7C, 0x1F, 0x9E, 0x0F, 0x80, 0xF9, 0xE0, 0xF8, 0x07, 0xDE,
  0x0F, 0x80, 0x7F, 0xC0, 0xF8, 0x03, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x01, 0xBF, 0x07, 0xF0, 0x79,
  0xF0, 0x3F, 0xFF, 0x1F, 0x81, 0xFF, 0xF0, 0xFC, 0x0F, 0xFE, 0x07, 0xE0,
  0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0xF8, 0x0C, 0x7E,
  0x3E, 0x1F, 0xBF, 0xEF, 0xBF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x87, 0xC0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x3C, 0x1F, 0xFC, 0x3F, 0x0F, 0xFE, 0x1F, 0x87, 0xFF,
  0x0F, 0xC3, 0xFF, 0x87, 0xE1, 0xFF, 0xC1, 0xE0, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03,
  0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFB, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0xFE, 0x3E, 0x00, 0x7F, 0x0F,
  0x80, 0x3F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xE0, 0x3E, 0x00, 0x10,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x7F, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xF8,
  0x00, 0x7C, 0x38, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0x81, 0xFE, 0x7E, 0x00, 0xFE, 0x1C, 0x00, 0x7E, 0x08, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x10, 0x00, 0x3F, 0x38, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x7C, 0xFF, 0xE0,
  0x7D, 0xFF, 0xF0, 0x7D, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x7E, 0x00, 0xFE,
  0x0C, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x10, 0x00, 0x3F, 0x38, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x7C, 0x7F, 0xE0, 0xFD, 0xFF, 0xF8,
  0xFD, 0xFF, 0xFC, 0xFB, 0x81, 0xFC, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFC, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xE3, 0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xF8,
  0x1F, 0xC3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFC,
  0x7F, 0x81, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF1, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x9F, 0xE0, 0x6F,
  0x87, 0xFF, 0xF7, 0xC1, 0xFF, 0xF7, 0xE0, 0x7F, 0xF3, 0xF0, 0x0F, 0xE1,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB,
  0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x8F, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x1F, 0x00,
  0x1F, 0x07, 0xF0, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0x8F, 0xE0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFE, 0x0F, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC,
  0x00, 0x7C, 0x20, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3E, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x3C, 0x7F, 0x81, 0xFE,
  0xFF, 0x07, 0xFD, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x0F, 0xF8, 0x7C, 0x0F,
  0xF0, 0xF0, 0x1F, 0xE1, 0xE0, 0x3F, 0xC3, 0xC0, 0x7F, 0x87, 0x80, 0xFF,
  0x0F, 0x01, 0xFE, 0x1E, 0x03, 0xFC, 0x3C, 0x07, 0xF8, 0x78, 0x0F, 0xF0,
  0xF0, 0x1F, 0xE1, 0xF0, 0x3F, 0xC3, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFD, 0xFF, 0x07, 0xFB, 0xDE, 0x07, 0xE7, 0xBC, 0x02, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x80,
  0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3F, 0x00,
  0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFC, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x00, 0x7F, 0x3E, 0x00, 0x7E,
  0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE3, 0xE0, 0x07, 0xE7, 0xC0,
  0x07, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xEF, 0x80, 0x1F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFC,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1C,
  0x7C, 0x00, 0x20, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x20,
  0x7C, 0x00, 0x1C, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E,
  0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x00, 0xFF, 0x3E,
  0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7,
  0xC0, 0x0F, 0xCF, 0x80, 0x7F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFE, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x1C, 0x7E, 0x00,
  0x20, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80,
  0x7F, 0x1F, 0xC0, 0xDF, 0x0F, 0xFF, 0xDF, 0x07, 0xFF, 0x9F, 0x03, 0xFF,
  0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x3F,
  0xBF, 0x83, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00,
  0x3F, 0x1F, 0x00, 0x3F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0,
  0x1F, 0x81, 0xF0, 0x1F, 0xC0, 0xF8, 0x1F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E,
  0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xE0, 0x07, 0xC7, 0xE0, 0x03,
  0xE7, 0xE0, 0x01, 0xF7, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xEF, 0xC0, 0x1F, 0xE7, 0xE0, 0x0F, 0xF1, 0xF8, 0x07, 0xF0, 0xFC,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0xC7, 0xC0,
  0x07, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xF7, 0xC3, 0xDF,
  0xF3, 0xC3, 0xDF, 0xF3, 0xE7, 0x9F, 0xFB, 0xE7, 0x9F, 0xF9, 0xEF, 0x9F,
  0xF9, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0xFE, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x38, 0x1F,
  0xF8, 0x38, 0x1F, 0xF8, 0x18, 0x1F, 0xF8, 0x10, 0x1F, 0xF8, 0x10, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xF7, 0xC0, 0x7F, 0xDF, 0x01, 0xFF, 0x3E, 0x07, 0xFC, 0xF8, 0x1F,
  0xF1, 0xE0, 0x7F, 0xC7, 0xC1, 0xFF, 0x1F, 0x07, 0xFC, 0x3E, 0x1F, 0xF0,
  0xF8, 0x7F, 0xC3, 0xE1, 0xFF, 0x07, 0xC7, 0xFC, 0x1F, 0x1F, 0xF0, 0x3C,
  0x7F, 0xC0, 0xF9, 0xFF, 0x03, 0xE7, 0xFC, 0x07, 0xDF, 0xF0, 0x1F, 0x7F,
  0xC0, 0x3D, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7F,
  0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0x80, 0x3F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0x7E, 0x00, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFE, 0x0F, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFE, 0x07, 0xFC, 0xFC, 0x00, 0xF8, 0xFC,
  0x00, 0x18, 0x7E, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xCC, 0x00,
  0x07, 0xE6, 0x00, 0x03, 0xF7, 0x80, 0x01, 0xF7, 0xF0, 0x01, 0xFB, 0xFE,
  0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7C, 0x00,
  0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F,
  0xCF, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F,
  0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xF0,
  0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x1F, 0x7C, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x7D, 0xF0,
  0x7E, 0x0F, 0x3E, 0x1F, 0xC1, 0xE7, 0xC3, 0xF8, 0x3C, 0xF8, 0x7F, 0x87,
  0x9F, 0x0E, 0xF0, 0xF3, 0xE1, 0xDE, 0x1E, 0x7C, 0x7B, 0xC7, 0xCF, 0x8F,
  0x78, 0xF8, 0xF1, 0xE7, 0x1F, 0x1E, 0x3C, 0xF3, 0xE3, 0xC7, 0x1E, 0x7C,
  0x79, 0xE3, 0xCF, 0x8F, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0x3C, 0x3E, 0xF0,
  0xF7, 0x87, 0xDE, 0x1E, 0xF0, 0xFB, 0x83, 0xDE, 0x1F, 0xF0, 0x7B, 0xC3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x7E, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0x83, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF9, 0xF0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3F, 0x10, 0x00,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x3E, 0x3F, 0x07, 0xC3, 0xE0, 0xF8,
  0x3C, 0x1F, 0x07, 0x81, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7E, 0x07, 0xF0, 0x7C, 0x01, 0xF8, 0x18,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E,
  0x07, 0xFF, 0x7F, 0xFE, 0x7F, 0x3F, 0xFE, 0x7F, 0x1F, 0xFC, 0x1F, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x07, 0xC7, 0xFE,
  0x0F, 0x9F, 0xFE, 0x1F, 0x7F, 0xFE, 0x3E, 0xC0, 0xFE, 0x7F, 0x00, 0xFC,
  0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x3F, 0x7F, 0x00, 0xFC, 0xFB, 0x03,
  0xF9, 0xF7, 0xFF, 0xE3, 0xE7, 0xFF, 0xC7, 0xC7, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0x83, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x1F, 0x00, 0x10, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x08, 0x7C, 0x00, 0x71, 0xF8,
  0x03, 0xF3, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x3F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x3F, 0xC1,
  0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0xC1, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF,
  0x3F, 0x07, 0xFE, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x1F,
  0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x87, 0xE0, 0x03, 0x87, 0xE0, 0x0F, 0x8F, 0xE0,
  0x7F, 0x8F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x1F,
  0xDF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0x07, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0x7C, 0x01, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x3E, 0x3F, 0xF0,
  0xF9, 0xFF, 0xE3, 0xEF, 0xFF, 0xCF, 0xB0, 0x7F, 0xBF, 0x80, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07,
  0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7E,
  0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x7D, 0xFC,
  0x7F, 0xBE, 0xFF, 0x3F, 0xDF, 0xFF, 0xBF, 0xFF, 0xC7, 0xD0, 0xFF, 0xC1,
  0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xFC,
  0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xFF, 0x07, 0xC0, 0xFF, 0x83, 0xE0, 0x7F,
  0xC1, 0xF0, 0x3F, 0xE0, 0xF8, 0x1F, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07,
  0xFC, 0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xFF, 0x07, 0xC0, 0xFF, 0x83, 0xE0,
  0x7F, 0xC1, 0xF0, 0x3F, 0xE0, 0xF8, 0x1F, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E,
  0x07, 0xFC, 0x1F, 0x03, 0xC0, 0x00, 0x3F, 0x03, 0xE3, 0xFF, 0x0F, 0x9F,
  0xFE, 0x3E, 0xFF, 0xFC, 0xFB, 0x07, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x3E, 0x00, 0xFC, 0x7E,
  0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F,
  0x83, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x01, 0xF1, 0xFF, 0x83, 0xE7, 0xFF, 0x87, 0xDF,
  0xFF, 0x8F, 0xB0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0xC0, 0x0F, 0xDF, 0xC0, 0x3F, 0x3E, 0xC0, 0xFE, 0x7D, 0xFF, 0xF8, 0xF9,
  0xFF, 0xF1, 0xF1, 0xFF, 0x83, 0xE0, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x3F, 0xC1,
  0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0xC1, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF,
  0x3F, 0x07, 0xFE, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0x7F,
  0xE0, 0x7E, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F,
  0xC7, 0xC0, 0x0F, 0x1F, 0x80, 0x04, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x80, 0x01, 0xF3, 0x80, 0x07, 0xEF, 0x80,
  0x0F, 0xBF, 0xC0, 0x7F, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x83, 0x7D, 0xFF, 0xFB, 0xE7, 0xFF,
  0x9F, 0x1F, 0xF8, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x1F, 0x01, 0xFF, 0x03, 0xF0, 0x3F, 0xE0, 0x7E, 0x07,
  0xFC, 0x0F, 0xC0, 0xF7, 0x83, 0xF8, 0x1E, 0xF0, 0x7F, 0x07, 0xDE, 0x0E,
  0xF0, 0xFB, 0xC1, 0xDE, 0x1E, 0x7C, 0x3B, 0xC3, 0xCF, 0x8F, 0x38, 0x79,
  0xF1, 0xE7, 0x0F, 0x1E, 0x38, 0xE1, 0xE3, 0xC7, 0x1E, 0x3C, 0x78, 0xE3,
  0xCF, 0x8F, 0x1C, 0x79, 0xE1, 0xE7, 0x87, 0x3C, 0x3C, 0xF0, 0xE7, 0x87,
  0xDC, 0x1E, 0xF0, 0x7B, 0x83, 0xDE, 0x0F, 0x70, 0x7B, 0xC1, 0xEE, 0x07,
  0x78, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x07, 0xE7, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xE3, 0xE0,
  0x03, 0xF1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F,
  0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0x07, 0xF8, 0x03, 0xC7,
  0xFE, 0x01, 0xE7, 0xFF, 0x81, 0xF3, 0xC7, 0xE0, 0xF3, 0xE1, 0xF0, 0x79,
  0xE0, 0x7C, 0x7C, 0xF0, 0x1F, 0xFC, 0xF8, 0x0F, 0xFC, 0x78, 0x03, 0xFE,
  0x0C, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Medium49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 34, 29, 11, -34 },
  { 35, 15, 15, 29, 7, -36 },
  { 64, 28, 34, 29, 1, -34 },
  { 183, 25, 46, 29, 2, -40 },
  { 327, 28, 36, 29, 1, -35 },
  { 453, 28, 36, 29, 1, -35 },
  { 579, 5, 15, 29, 12, -36 },
  { 589, 16, 44, 29, 9, -37 },
  { 677, 16, 44, 29, 4, -37 },
  { 765, 26, 25, 29, 2, -27 },
  { 847, 23, 24, 29, 3, -27 },
  { 916, 11, 14, 29, 9, -7 },
  { 936, 15, 5, 29, 7, -17 },
  { 946, 9, 8, 29, 10, -8 },
  { 955, 21, 44, 29, 4, -37 },
  { 1071, 25, 36, 29, 2, -35 },
  { 1184, 26, 34, 29, 2, -34 },
  { 1295, 24, 35, 29, 3, -35 },
  { 1400, 24, 36, 29, 2, -35 },
  { 1508, 27, 34, 29, 1, -34 },
  { 1623, 24, 35, 29, 3, -34 },
  { 1728, 24, 35, 29, 3, -34 },
  { 1833, 23, 34, 29, 3, -34 },
  { 1931, 25, 36, 29, 2, -35 },
  { 2044, 25, 35, 29, 2, -35 },
  { 2154, 9, 26, 29, 10, -26 },
  { 2184, 11, 33, 29, 9, -26 },
  { 2230, 21, 29, 29, 4, -29 },
  { 2307, 23, 14, 29, 3, -22 },
  { 2348, 21, 29, 29, 4, -29 },
  { 2425, 22, 35, 29, 3, -35 },
  { 2522, 23, 40, 29, 3, -35 },
  { 2637, 27, 34, 29, 1, -34 },
  { 2752, 23, 34, 29, 4, -34 },
  { 2850, 24, 36, 29, 3, -35 },
  { 2958, 23, 34, 29, 4, -34 },
  { 3056, 22, 34, 29, 4, -34 },
  { 3150, 22, 34, 29, 4, -34 },
  { 3244, 24, 36, 29, 2, -35 },
  { 3352, 22, 34, 29, 4, -34 },
  { 3446, 21, 34, 29, 4, -34 },
  { 3536, 21, 35, 29, 3, -34 },
  { 3628, 25, 34, 29, 4, -34 },
  { 3735, 21, 34, 29, 5, -34 },
  { 3825, 24, 34, 29, 3, -34 },
  { 3927, 22, 34, 29, 4, -34 },
  { 4021, 25, 36, 29, 2, -35 },
  { 4134, 23, 34, 29, 4, -34 },
  { 4232, 25, 43, 29, 2, -35 },
  { 4367, 23, 34, 29, 4, -34 },
  { 4465, 25, 36, 29, 2, -35 },
  { 4578, 27, 34, 29, 1, -34 },
  { 4693, 23, 35, 29, 3, -34 },
  { 4794, 27, 34, 29, 1, -34 },
  { 4909, 27, 34, 29, 1, -34 },
  { 5024, 28, 34, 29, 1, -34 },
  { 5143, 28, 34, 29, 1, -34 },
  { 5262, 25, 34, 29, 2, -34 },
  { 5369, 15, 44, 29, 10, -37 },
  { 5452, 21, 44, 29, 4, -37 },
  { 5568, 14, 44, 29, 5, -37 },
  { 5645, 26, 21, 29, 2, -34 },
  { 5714, 23, 5, 29, 3, 4 },
  { 5729, 9, 10, 29, 8, -38 },
  { 5741, 24, 27, 29, 3, -26 },
  { 5822, 23, 37, 29, 4, -36 },
  { 5929, 22, 27, 29, 4, -26 },
  { 6004, 24, 37, 29, 2, -36 },
  { 6115, 23, 27, 29, 3, -26 },
  { 6193, 24, 36, 29, 3, -36 },
  { 6301, 25, 39, 29, 3, -29 },
  { 6423, 22, 36, 29, 4, -36 },
  { 6522, 22, 37, 29, 5, -37 },
  { 6624, 17, 47, 29, 5, -37 },
  { 6724, 24, 36, 29, 4, -36 },
  { 6832, 22, 36, 29, 4, -36 },
  { 6931, 25, 26, 29, 2, -26 },
  { 7013, 22, 26, 29, 4, -26 },
  { 7085, 24, 27, 29, 3, -26 },
  { 7166, 23, 36, 29, 4, -26 },
  { 7270, 24, 36, 29, 2, -26 },
  { 7378, 23, 25, 29, 4, -25 },
  { 7450, 23, 27, 29, 3, -26 },
  { 7528, 24, 34, 29, 2, -34 },
  { 7630, 21, 26, 29, 4, -25 },
  { 7699, 25, 25, 29, 2, -25 },
  { 7778, 27, 25, 29, 1, -25 },
  { 7863, 25, 25, 29, 2, -25 },
  { 7942, 25, 35, 29, 2, -25 },
  { 8052, 22, 25, 29, 4, -25 },
  { 8121, 20, 44, 29, 5, -37 },
  { 8231, 5, 44, 29, 12, -37 },
  { 8259, 20, 44, 29, 5, -37 },
  { 8369, 25, 11, 29, 2, -20 },
};

const GFXfont IBMPlexMono_Medium49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_MEDIUM49PT7B_H_
