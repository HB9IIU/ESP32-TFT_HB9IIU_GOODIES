#ifndef _IBMPLEXMONO_MEDIUM21PT7B_H_
#define _IBMPLEXMONO_MEDIUM21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xB2, 0x48, 0x0F, 0xF8, 0xCF, 0x3C, 0xF3, 0xCF, 0x30,
  0x06, 0x60, 0xCC, 0x0C, 0xC0, 0xCC, 0x7C, 0xF7, 0xCF, 0x19, 0x81, 0x98,
  0x19, 0x8F, 0x9F, 0xF9, 0xF1, 0x98, 0x13, 0x03, 0x30, 0x33, 0x00, 0x04,
  0x00, 0x80, 0x7C, 0x3F, 0xE6, 0x4F, 0xC9, 0x39, 0x03, 0x20, 0x7E, 0x07,
  0xF0, 0x1F, 0x02, 0x70, 0x46, 0x89, 0xF9, 0x33, 0xFE, 0x3F, 0x00, 0x80,
  0x10, 0x00, 0x38, 0x37, 0xC3, 0xC6, 0x6C, 0x64, 0xC6, 0xCC, 0x78, 0x7C,
  0x03, 0x9E, 0x03, 0xF1, 0xB3, 0x1B, 0x13, 0x31, 0x23, 0x36, 0x3F, 0xC1,
  0xE0, 0x0F, 0x03, 0xF8, 0x31, 0x83, 0x00, 0x30, 0x03, 0x80, 0x18, 0x73,
  0xC7, 0x7E, 0x46, 0x7C, 0xE3, 0xCE, 0x1C, 0x61, 0xC7, 0xF6, 0x3E, 0x70,
  0xFF, 0xF0, 0x0E, 0x30, 0xC1, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x0C, 0x18, 0x10, 0x30, 0x30, 0x38, 0xE0, 0x60, 0xC0, 0xC0, 0xC1,
  0x83, 0x06, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C, 0x30, 0x63, 0x80,
  0x0C, 0x01, 0x80, 0x30, 0x66, 0x6F, 0xFE, 0x7E, 0x07, 0x80, 0xD8, 0x33,
  0x8E, 0x30, 0x84, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x77, 0x6E, 0xCC, 0xFF, 0xF0, 0x7F, 0x70,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06,
  0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x00, 0x1F, 0x07,
  0xF1, 0xC7, 0x70, 0x6E, 0x0D, 0x81, 0xF3, 0x3E, 0x77, 0xCC, 0xF8, 0x1F,
  0x83, 0x70, 0x67, 0x1C, 0x7F, 0x07, 0xC0, 0x1E, 0x07, 0xC1, 0xD8, 0x3B,
  0x0E, 0x60, 0x8C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0xFF, 0xDF, 0xF8, 0x1F, 0x1F, 0xE6, 0x1F, 0x87, 0x01, 0xC0, 0x70,
  0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x3F, 0xFF, 0xFC, 0x1F,
  0x1F, 0xEE, 0x1D, 0x07, 0x01, 0xC0, 0x61, 0xF0, 0x7C, 0x01, 0xC0, 0x30,
  0x0D, 0x03, 0xE1, 0xDF, 0xE3, 0xF0, 0x07, 0x80, 0xF0, 0x36, 0x06, 0xC1,
  0x98, 0x63, 0x0C, 0x63, 0x0C, 0x61, 0x98, 0x33, 0xFF, 0xFF, 0xF0, 0x18,
  0x03, 0x00, 0x60, 0x7F, 0xDF, 0xF6, 0x01, 0x80, 0x60, 0x1B, 0xC7, 0xF9,
  0x87, 0x00, 0xC0, 0x30, 0x0D, 0x03, 0xE1, 0xDF, 0xE1, 0xF0, 0x07, 0x81,
  0x80, 0x60, 0x18, 0x07, 0x00, 0xDE, 0x1F, 0xE7, 0x8E, 0xE0, 0xDC, 0x1F,
  0x83, 0xF0, 0x67, 0x1C, 0x7F, 0x07, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0x07,
  0xC1, 0x80, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0x80, 0x1F, 0x0F, 0xF1, 0x87, 0x70, 0x66, 0x0C, 0xC3, 0x8F, 0xC1,
  0xFC, 0x61, 0xDC, 0x1B, 0x03, 0xF0, 0x7E, 0x1C, 0xFF, 0x87, 0xC0, 0x1F,
  0x1F, 0xE7, 0x1F, 0x83, 0xC0, 0xF0, 0x3E, 0x0F, 0xC7, 0x7F, 0xCF, 0x30,
  0x18, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0x7F, 0x70, 0x00, 0x00, 0x7F, 0x70,
  0x7F, 0x70, 0x00, 0x00, 0x77, 0x6E, 0xCC, 0x00, 0x81, 0xC3, 0xC7, 0x87,
  0x07, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x10, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x70, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x0E, 0x1E, 0x3C, 0x78, 0x38, 0x10, 0x00, 0x1F, 0x0F, 0xE7, 0x1F,
  0x87, 0x01, 0xC0, 0x70, 0x38, 0x3C, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x07, 0x81, 0xC0, 0x1F, 0x0F, 0xE6, 0x1D, 0x83, 0xC7, 0xF3, 0xFC, 0xCF,
  0x23, 0xC8, 0xF2, 0x3C, 0xCF, 0x3F, 0xC7, 0xD8, 0x07, 0x00, 0xFC, 0x1F,
  0x00, 0x07, 0x00, 0xF0, 0x0F, 0x80, 0xD8, 0x1D, 0x81, 0x98, 0x19, 0xC1,
  0x8C, 0x38, 0xC3, 0xFE, 0x3F, 0xE7, 0x06, 0x70, 0x66, 0x07, 0xE0, 0x30,
  0xFE, 0x3F, 0xCC, 0x3B, 0x06, 0xC1, 0xB0, 0xEF, 0xE3, 0xFC, 0xC3, 0xB0,
  0x6C, 0x1F, 0x06, 0xC3, 0xBF, 0xEF, 0xE0, 0x1F, 0x07, 0xF1, 0xC7, 0x30,
  0x66, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x77,
  0x1C, 0x7F, 0x07, 0xC0, 0xFE, 0x3F, 0xCC, 0x3B, 0x06, 0xC1, 0xB0, 0x6C,
  0x1F, 0x07, 0xC1, 0xF0, 0x6C, 0x1B, 0x06, 0xC3, 0xBF, 0xCF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFF,
  0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0x0F, 0xE7,
  0x1D, 0x83, 0xE0, 0x38, 0x0C, 0x03, 0x1F, 0xC7, 0xF8, 0x3E, 0x0F, 0x83,
  0x71, 0xDF, 0xB1, 0xEC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0xFF, 0xFF, 0xC6,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87,
  0xFF, 0xFE, 0x3F, 0x9F, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x7C, 0x36, 0x3B, 0xF8, 0xF8, 0xC1, 0xF0, 0xEC, 0x33, 0x1C,
  0xCE, 0x37, 0x0D, 0x83, 0xF0, 0xEE, 0x39, 0x8C, 0x73, 0x0C, 0xC3, 0xB0,
  0x7C, 0x1C, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xE0, 0xFC, 0x7F, 0x1F, 0xCF,
  0xDB, 0xF6, 0xBC, 0xEF, 0x3B, 0xCC, 0xF1, 0x3C, 0x8F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0C, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1E, 0xCF, 0x67, 0xB3, 0xCD,
  0xE6, 0xF3, 0x78, 0xFC, 0x7E, 0x1F, 0x0E, 0x1F, 0x07, 0xF1, 0xC7, 0x70,
  0x6E, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0x70, 0x67,
  0x1C, 0x7F, 0x07, 0xC0, 0xFF, 0x3F, 0xEC, 0x1B, 0x06, 0xC1, 0xF0, 0x6C,
  0x1B, 0xFE, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F,
  0x07, 0xF1, 0xC7, 0x70, 0x6E, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x83, 0x70, 0x67, 0x1C, 0x7F, 0x07, 0xC0, 0x60, 0x0C, 0x00, 0xF8,
  0x1F, 0x00, 0xFF, 0x3F, 0xEC, 0x1B, 0x06, 0xC1, 0xF0, 0x6C, 0x1B, 0xFE,
  0xFE, 0x33, 0x8C, 0x63, 0x1C, 0xC3, 0x30, 0xEC, 0x1C, 0x1F, 0x0F, 0xF9,
  0x83, 0x70, 0x4E, 0x00, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xC0, 0x18, 0x03,
  0xA0, 0x6E, 0x1C, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x36, 0x0D, 0x83, 0x71, 0xDF, 0xE1, 0xF0, 0xC0, 0x78,
  0x1F, 0x83, 0x70, 0x66, 0x1C, 0xC3, 0x9C, 0x61, 0x8C, 0x33, 0x86, 0x60,
  0xEC, 0x0D, 0x81, 0xF0, 0x3C, 0x03, 0x80, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0xE7, 0x9C, 0xF3, 0x9E, 0xD3, 0xDA, 0x5B, 0x6B, 0x6F, 0x69, 0xED,
  0x3D, 0xE3, 0x9C, 0x70, 0x70, 0x73, 0x06, 0x38, 0xE1, 0x8C, 0x1D, 0x80,
  0xF8, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xD8, 0x19, 0xC3, 0x8C, 0x30, 0xE7,
  0x06, 0xE0, 0x70, 0xE0, 0x37, 0x07, 0x30, 0x63, 0x8E, 0x18, 0xC1, 0xD8,
  0x0D, 0x80, 0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xFF, 0xF8, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01,
  0x80, 0x60, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x0E, 0x03, 0xC0, 0x6C, 0x19, 0x83, 0x18,
  0xC3, 0x18, 0x36, 0x06, 0xC0, 0x60, 0xFF, 0xFF, 0xF0, 0xDD, 0x90, 0x1E,
  0x0F, 0xF1, 0x8E, 0x00, 0xC0, 0x18, 0x7F, 0x1F, 0xE7, 0x0C, 0xE1, 0x8F,
  0xFC, 0xF3, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0x8F, 0xF3,
  0x8E, 0xC1, 0xB0, 0x6C, 0x1F, 0x06, 0xC1, 0xB8, 0xEF, 0xF3, 0x78, 0x3E,
  0x3F, 0xB8, 0xF8, 0x4C, 0x06, 0x03, 0x01, 0x82, 0xE3, 0xBF, 0x8F, 0x80,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF, 0x37, 0xED, 0x87, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xD8, 0x77, 0xEC, 0xF3, 0x1F, 0x0F, 0xE6, 0x1D,
  0x83, 0xFF, 0xFF, 0xFE, 0x01, 0x82, 0x70, 0xCF, 0xE1, 0xF0, 0x07, 0xE1,
  0xFC, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x1F, 0xF3, 0xFE, 0x00, 0xE0, 0x3C, 0x7C,
  0x1F, 0xC6, 0x1C, 0xC3, 0x98, 0x63, 0xFC, 0x3F, 0x04, 0x01, 0x80, 0x3F,
  0xE3, 0xFF, 0x80, 0xF8, 0x1F, 0xFE, 0x3F, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x73, 0x7D, 0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x0C, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x06, 0x0F,
  0x06, 0x00, 0x00, 0xFE, 0xFE, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0xFE, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFC, 0x73, 0x38, 0xDC, 0x3E, 0x0F, 0xC3, 0xB8, 0xC7, 0x30, 0xCC,
  0x3B, 0x07, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC3, 0xFF, 0xFF, 0xD9, 0xDF, 0xFB, 0x3B,
  0xE6, 0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x8F, 0x31, 0x80,
  0xCE, 0x6F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x60, 0x1F, 0x0F, 0xE7, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x71,
  0xCF, 0xE1, 0xF0, 0xDE, 0x3F, 0xCE, 0x3B, 0x06, 0xC1, 0xB0, 0x7C, 0x1B,
  0x06, 0xE3, 0xBF, 0xCD, 0xE3, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x3C, 0xDF,
  0xB6, 0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0x61, 0xDF, 0xB3, 0xCC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0xF9, 0xFE, 0xF3, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x3F, 0xEF, 0xF8, 0x1F, 0x1F, 0xF6, 0x09, 0x80,
  0x7E, 0x0F, 0xE0, 0x7C, 0x03, 0x61, 0xFF, 0xE3, 0xF0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0xFF, 0xFF, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x07, 0xF0, 0xFC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xE3, 0xFE, 0xDE, 0x60, 0xE0, 0xEC, 0x19, 0x83, 0x30, 0xC3, 0x18,
  0x63, 0x0C, 0xC0, 0xD8, 0x1B, 0x03, 0xC0, 0x38, 0x00, 0xC7, 0x36, 0x73,
  0x67, 0x36, 0x53, 0x6D, 0x36, 0xD2, 0x6D, 0xA6, 0x9E, 0x29, 0xE3, 0x8E,
  0x38, 0xE0, 0xE0, 0xCE, 0x30, 0xCE, 0x0D, 0x81, 0xE0, 0x1C, 0x07, 0x81,
  0xD8, 0x33, 0x8C, 0x3B, 0x83, 0x80, 0xC0, 0xFC, 0x19, 0x83, 0x38, 0xC3,
  0x18, 0x67, 0x0E, 0xC0, 0xD8, 0x1E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x18, 0xF8, 0x7C, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xC7, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7E, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0xC0, 0x60, 0x1F, 0x8F, 0xCE, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x18, 0x0C, 0x7E, 0x3E, 0x00, 0x38, 0x6F, 0x8B, 0x3B, 0x63, 0xEC, 0x38,
};

const GFXglyph IBMPlexMono_Medium21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 6, 6, 13, 3, -16 },
  { 12, 12, 15, 13, 0, -15 },
  { 35, 11, 19, 13, 1, -17 },
  { 62, 12, 15, 13, 0, -15 },
  { 85, 12, 15, 13, 0, -15 },
  { 108, 2, 6, 13, 5, -16 },
  { 110, 7, 19, 13, 4, -16 },
  { 127, 7, 19, 13, 2, -16 },
  { 144, 11, 11, 13, 1, -12 },
  { 160, 10, 10, 13, 1, -11 },
  { 173, 4, 6, 13, 4, -3 },
  { 176, 6, 2, 13, 3, -7 },
  { 178, 4, 3, 13, 4, -3 },
  { 180, 9, 19, 13, 2, -16 },
  { 202, 11, 15, 13, 1, -15 },
  { 223, 11, 15, 13, 1, -15 },
  { 244, 10, 15, 13, 1, -15 },
  { 263, 10, 15, 13, 1, -15 },
  { 282, 11, 15, 13, 1, -15 },
  { 303, 10, 15, 13, 1, -15 },
  { 322, 11, 15, 13, 1, -15 },
  { 343, 10, 15, 13, 1, -15 },
  { 362, 11, 15, 13, 1, -15 },
  { 383, 10, 15, 13, 1, -15 },
  { 402, 4, 11, 13, 4, -11 },
  { 408, 4, 14, 13, 4, -11 },
  { 415, 9, 12, 13, 2, -12 },
  { 429, 10, 7, 13, 1, -10 },
  { 438, 9, 12, 13, 2, -12 },
  { 452, 10, 15, 13, 1, -15 },
  { 471, 10, 17, 13, 1, -15 },
  { 493, 12, 15, 13, 0, -15 },
  { 516, 10, 15, 13, 2, -15 },
  { 535, 11, 15, 13, 1, -15 },
  { 556, 10, 15, 13, 2, -15 },
  { 575, 9, 15, 13, 2, -15 },
  { 592, 9, 15, 13, 2, -15 },
  { 609, 10, 15, 13, 1, -15 },
  { 628, 9, 15, 13, 2, -15 },
  { 645, 9, 15, 13, 2, -15 },
  { 662, 9, 15, 13, 1, -15 },
  { 679, 10, 15, 13, 2, -15 },
  { 698, 9, 15, 13, 2, -15 },
  { 715, 10, 15, 13, 1, -15 },
  { 734, 9, 15, 13, 2, -15 },
  { 751, 11, 15, 13, 1, -15 },
  { 772, 10, 15, 13, 2, -15 },
  { 791, 11, 19, 13, 1, -15 },
  { 818, 10, 15, 13, 2, -15 },
  { 837, 11, 15, 13, 1, -15 },
  { 858, 11, 15, 13, 1, -15 },
  { 879, 10, 15, 13, 1, -15 },
  { 898, 11, 15, 13, 1, -15 },
  { 919, 11, 15, 13, 1, -15 },
  { 940, 12, 15, 13, 0, -15 },
  { 963, 12, 15, 13, 0, -15 },
  { 986, 11, 15, 13, 1, -15 },
  { 1007, 7, 19, 13, 4, -16 },
  { 1024, 9, 19, 13, 2, -16 },
  { 1046, 6, 19, 13, 2, -16 },
  { 1061, 11, 9, 13, 1, -15 },
  { 1074, 10, 2, 13, 1, 2 },
  { 1077, 3, 4, 13, 4, -16 },
  { 1079, 11, 11, 13, 1, -11 },
  { 1095, 10, 16, 13, 2, -16 },
  { 1115, 9, 11, 13, 2, -11 },
  { 1128, 10, 16, 13, 1, -16 },
  { 1148, 10, 11, 13, 1, -11 },
  { 1162, 11, 16, 13, 1, -16 },
  { 1184, 11, 17, 13, 1, -13 },
  { 1208, 9, 16, 13, 2, -16 },
  { 1226, 10, 16, 13, 2, -16 },
  { 1246, 8, 20, 13, 2, -16 },
  { 1266, 10, 16, 13, 2, -16 },
  { 1286, 9, 16, 13, 2, -16 },
  { 1304, 11, 11, 13, 1, -11 },
  { 1320, 9, 11, 13, 2, -11 },
  { 1333, 10, 11, 13, 1, -11 },
  { 1347, 10, 15, 13, 2, -11 },
  { 1366, 10, 15, 13, 1, -11 },
  { 1385, 10, 11, 13, 2, -11 },
  { 1399, 10, 11, 13, 1, -11 },
  { 1413, 10, 15, 13, 1, -15 },
  { 1432, 9, 11, 13, 2, -11 },
  { 1445, 11, 11, 13, 1, -11 },
  { 1461, 12, 11, 13, 0, -11 },
  { 1478, 11, 11, 13, 1, -11 },
  { 1494, 11, 15, 13, 1, -11 },
  { 1515, 9, 11, 13, 2, -11 },
  { 1528, 9, 19, 13, 2, -16 },
  { 1550, 2, 19, 13, 5, -16 },
  { 1555, 9, 19, 13, 2, -16 },
  { 1577, 11, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_Medium21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_MEDIUM21PT7B_H_
