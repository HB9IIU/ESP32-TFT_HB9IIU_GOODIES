#ifndef _IBMPLEXMONO_MEDIUM53PT7B_H_
#define _IBMPLEXMONO_MEDIUM53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium53pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xC0, 0xE0, 0x30, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF9, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xF9, 0xF0, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x03, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF, 0x07,
  0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0x83, 0xFF,
  0xC0, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0,
  0xFF, 0xF3, 0xFF, 0x83, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xCF,
  0x3F, 0xE3, 0xF8, 0xF0, 0xFC, 0x3F, 0x0F, 0x03, 0x83, 0xE0, 0xF0, 0x10,
  0x3E, 0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x3F, 0xEF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF3,
  0xFE, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x10, 0x0F,
  0x03, 0xE1, 0x80, 0xF0, 0x3E, 0x3C, 0x0F, 0x07, 0xE7, 0xF0, 0xF0, 0xFE,
  0xFF, 0xCF, 0x3F, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xF3, 0xFF,
  0xC0, 0x07, 0x9F, 0xFF, 0x00, 0x3E, 0x7C, 0x3E, 0x00, 0xF3, 0xE0, 0x78,
  0x07, 0xCF, 0x01, 0xF0, 0x1E, 0x3C, 0x07, 0xC0, 0xF8, 0xF0, 0x0F, 0x03,
  0xC3, 0xC0, 0x3C, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x3C, 0x07, 0xC3, 0xE0,
  0xF0, 0x1F, 0x1F, 0x03, 0xE0, 0x78, 0x7C, 0x07, 0xC3, 0xE3, 0xE0, 0x1F,
  0xFF, 0x0F, 0x80, 0x3F, 0xFC, 0x7C, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0x00, 0x7C, 0x7F, 0xFE, 0x01, 0xE1, 0xF0,
  0xF8, 0x0F, 0x8F, 0x81, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xF0, 0xF0, 0x0F,
  0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x0F, 0x00, 0xF1, 0xF0, 0x3C, 0x03, 0xC7,
  0xC0, 0xF0, 0x0F, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x0F, 0x81, 0xE7, 0xC0,
  0x1F, 0x0F, 0x9F, 0x00, 0x7F, 0xFE, 0xF8, 0x00, 0xFF, 0xF3, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0x00,
  0x1F, 0x80, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x83, 0xFF, 0x81, 0xFE, 0x1F, 0xFE, 0x07,
  0xF8, 0xFE, 0xFC, 0x1F, 0xE7, 0xE3, 0xF8, 0x78, 0x1F, 0x87, 0xF1, 0xE0,
  0x7C, 0x0F, 0xCF, 0x83, 0xF0, 0x1F, 0xBE, 0x0F, 0xC0, 0x3F, 0xF0, 0x3F,
  0x00, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0x81, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x1F, 0xFF, 0x83,
  0xF8, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x04, 0x01, 0xF0, 0x04, 0x78, 0x1F, 0x01,
  0xE7, 0xF1, 0xF0, 0xFE, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x01, 0xC0,
  0x01, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0xFF,
  0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x0F, 0x07, 0xFF, 0x83, 0xF0, 0xFF, 0xF0, 0x7E, 0x1F,
  0xFE, 0x0F, 0xC3, 0xFF, 0xC1, 0xF8, 0x7F, 0xF8, 0x3F, 0x0F, 0xFF, 0x03,
  0xC1, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7C, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xC0,
  0x7E, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xE0,
  0x7F, 0x87, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x0F,
  0x00, 0x0F, 0xE0, 0x80, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xE7, 0xF0, 0x03, 0xF8, 0x78, 0x00, 0x7E,
  0x0C, 0x00, 0x1F, 0xC1, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC2, 0x00, 0x03, 0xF3,
  0x80, 0x01, 0xFD, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x3F,
  0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x7E,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE1, 0xFC, 0x00, 0xF8, 0xFF, 0xE0, 0x3E, 0xFF, 0xFC, 0x0F, 0x3F,
  0xFF, 0x83, 0xDF, 0xFF, 0xF0, 0xFF, 0x03, 0xFE, 0x7F, 0x00, 0x3F, 0x87,
  0x80, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x08, 0x00,
  0x1F, 0xC7, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xFC, 0x00, 0xFE, 0x7F,
  0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0xFF, 0xE0, 0x7E,
  0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0x8F, 0xDF, 0xFF, 0xF3, 0xFF, 0x03, 0xFE,
  0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xE0, 0x07, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x07,
  0xE0, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0x0F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x80, 0x1F, 0xC7, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xFC,
  0x0F, 0xFC, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xDF, 0x87, 0xFF, 0xF7, 0xE0,
  0x7F, 0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xF9, 0xFF, 0x3F, 0xE7, 0xFE,
  0xFF, 0xDF, 0xF1, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xCF,
  0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xCF, 0xF0, 0x7F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x70, 0x00, 0xFC, 0x20, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF8, 0xFC,
  0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xEF, 0x00, 0xF8, 0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0xBF,
  0xE0, 0xFF, 0xDF, 0xF0, 0xFC, 0x3F, 0xF8, 0x7C, 0x0F, 0xFC, 0x3E, 0x03,
  0xFE, 0x1E, 0x01, 0xFF, 0x0F, 0x00, 0xFF, 0x87, 0x80, 0x7F, 0xC3, 0xC0,
  0x3F, 0xE1, 0xE0, 0x1F, 0xF0, 0xF0, 0x0F, 0xF8, 0x78, 0x07, 0xFC, 0x3C,
  0x03, 0xFE, 0x1F, 0x01, 0xFF, 0x0F, 0x80, 0xFF, 0x87, 0xC0, 0xFF, 0xC1,
  0xFD, 0xFF, 0xE0, 0xFF, 0xDF, 0xF0, 0x3F, 0xEF, 0x78, 0x0F, 0xE7, 0xBE,
  0x00, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xE0, 0x0F, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE7, 0xE0,
  0x07, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xFE, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0x41, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x1F,
  0x80, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x87, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xE0, 0x1F, 0xE3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x07, 0xF8,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xE1, 0xFC, 0x03,
  0xF8, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xF0,
  0x00, 0x41, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xF7, 0xE0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFF, 0x7E, 0x00, 0x07, 0xDF,
  0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF8, 0x1D, 0xF0, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0x9F, 0x07,
  0xFF, 0xC7, 0xC0, 0x7F, 0xE1, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF3,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0x7E, 0x7F,
  0x83, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB,
  0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F,
  0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFD,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFD, 0xF8, 0x01, 0xFF, 0x3F, 0x80, 0x3F, 0xE3, 0xF8, 0x07, 0xF8,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFB,
  0xE0, 0xF7, 0xFE, 0xF8, 0x7D, 0xFF, 0xBE, 0x1E, 0x7F, 0xE7, 0xCF, 0x9F,
  0xF9, 0xF3, 0xE7, 0xFE, 0x3E, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE,
  0x1F, 0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0xE1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0,
  0xFC, 0x1F, 0xF8, 0x3E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F,
  0xE0, 0x30, 0x1F, 0xF8, 0x0C, 0x07, 0xFE, 0x03, 0x01, 0xFF, 0x80, 0x80,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFB, 0xE0, 0x1F, 0xFB, 0xE0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF9, 0xF0,
  0x1F, 0xF9, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3F, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8, 0x0F,
  0x9F, 0xF8, 0x0F, 0x9F, 0xF8, 0x0F, 0xDF, 0xF8, 0x07, 0xDF, 0xF8, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xE0, 0x07, 0xFB, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x3F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x7F, 0xCF, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0x3C, 0x3F, 0x00, 0x03, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x20, 0x00, 0x0F, 0xCE, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x7E, 0xFF, 0x00, 0x1F, 0xCF, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFE, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x7E,
  0x07, 0xDF, 0x03, 0xF0, 0x3E, 0xF8, 0x1F, 0x81, 0xF7, 0xC1, 0xFE, 0x0F,
  0xBE, 0x0F, 0xF0, 0x7D, 0xF0, 0x7F, 0x83, 0xCF, 0x83, 0xFC, 0x3E, 0x3E,
  0x1F, 0xE1, 0xF1, 0xF1, 0xEF, 0x8F, 0x8F, 0x8F, 0x3C, 0x7C, 0x7C, 0x79,
  0xE3, 0xE3, 0xE3, 0xCF, 0x1F, 0x1F, 0x1E, 0x78, 0xF8, 0xF9, 0xE3, 0xC7,
  0xC7, 0xCF, 0x1F, 0x3E, 0x3E, 0x78, 0x79, 0xF1, 0xF3, 0xC3, 0xCF, 0x8F,
  0x9E, 0x1E, 0x7C, 0x7D, 0xF0, 0xF3, 0xE3, 0xEF, 0x07, 0xDE, 0x1F, 0x78,
  0x1E, 0xF0, 0x7B, 0xC0, 0xF7, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x3C,
  0x08, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x1F, 0x0F,
  0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x20, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0xE0,
  0x03, 0xF0, 0x08, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x1D, 0xFF, 0x7F, 0xFF, 0xBF, 0xE7,
  0xFF, 0xE3, 0xFC, 0xFF, 0xFC, 0x7F, 0x87, 0xFF, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x83, 0xF8, 0x0F, 0xC7, 0xFF, 0x07, 0xE7, 0xFF, 0xC3, 0xF7, 0xFF, 0xF1,
  0xFB, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0x3F, 0xBF, 0x80, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x80, 0x3F, 0xBF,
  0xE0, 0x7F, 0x9F, 0xBF, 0xFF, 0xCF, 0xDF, 0xFF, 0xC7, 0xE7, 0xFF, 0xC3,
  0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC0, 0xFE,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x3D, 0x7E, 0x00, 0x10, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x7E, 0x00, 0x1E,
  0x3F, 0x00, 0x3F, 0x3F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x7F,
  0xE1, 0xF8, 0x7F, 0xFC, 0xFC, 0x7F, 0xFE, 0x7E, 0x7F, 0xFF, 0xBF, 0x7F,
  0xC1, 0xFF, 0xBF, 0x80, 0x3F, 0xDF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xF0, 0x3F, 0xE7, 0xFF,
  0xFB, 0xF1, 0xFF, 0xF9, 0xF8, 0x7F, 0xFC, 0xFC, 0x1F, 0xF8, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x1F, 0xC0,
  0x03, 0x83, 0xF8, 0x01, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x1F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x3C, 0x00, 0x0F, 0xEF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFC,
  0xFF, 0xFC, 0xFD, 0xFF, 0xFC, 0xFD, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xBE, 0x00, 0x3F, 0x8F, 0x80, 0x1F, 0xC3, 0xE0,
  0x0F, 0xE0, 0xF8, 0x07, 0xF0, 0x3E, 0x03, 0xF8, 0x0F, 0x81, 0xFC, 0x03,
  0xE0, 0xFE, 0x00, 0xF8, 0x7F, 0x00, 0x3E, 0x3F, 0x80, 0x0F, 0x9F, 0xC0,
  0x03, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFB,
  0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3E, 0x03, 0xF8, 0x0F,
  0x80, 0x7E, 0x03, 0xE0, 0x1F, 0xC0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0x7F,
  0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF8, 0xF8, 0x00, 0x7F, 0x3E, 0x00,
  0x0F, 0xEF, 0x80, 0x03, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x1F, 0x1F, 0x3F, 0x87, 0xFB, 0xE7, 0xF9, 0xFF,
  0x7D, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0x07,
  0xE0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F,
  0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E,
  0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF,
  0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0,
  0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8,
  0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x3F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFC, 0xFF,
  0xFC, 0xFD, 0xFF, 0xFC, 0xFD, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xE3, 0xF0, 0x03, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x7E, 0x3F, 0xF8, 0x3F, 0x3F, 0xFE, 0x1F, 0xBF, 0xFF,
  0x8F, 0xDF, 0xFF, 0xE7, 0xFC, 0x0F, 0xF3, 0xFC, 0x01, 0xFD, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xFC, 0x01, 0xFD,
  0xFF, 0x03, 0xFC, 0xFD, 0xFF, 0xFE, 0x7E, 0xFF, 0xFE, 0x3F, 0x3F, 0xFE,
  0x1F, 0x8F, 0xFE, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xC3, 0xFF, 0xE7, 0xE3,
  0xFF, 0xF3, 0xF3, 0xFF, 0xFD, 0xFB, 0xFE, 0x0F, 0xFD, 0xFC, 0x01, 0xFE,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xFC,
  0x01, 0xFE, 0xFF, 0x81, 0xFF, 0x3F, 0xFF, 0xDF, 0x8F, 0xFF, 0xCF, 0xC3,
  0xFF, 0xE7, 0xE0, 0xFF, 0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xC0, 0x7E, 0xE0, 0x00,
  0x1F, 0xB0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9,
  0xFC, 0x03, 0xF8, 0xFC, 0x00, 0x78, 0x7C, 0x00, 0x08, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF1, 0x00,
  0x01, 0xF9, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0xE0, 0xFF, 0xBF, 0xFF,
  0xDF, 0x3F, 0xFF, 0xBE, 0x3F, 0xFE, 0x7C, 0x3F, 0xF8, 0xF8, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01,
  0xFF, 0x80, 0xFC, 0x07, 0x9E, 0x03, 0xF0, 0x1E, 0x7C, 0x1F, 0xE0, 0xF9,
  0xF0, 0x7F, 0x83, 0xE7, 0xC1, 0xFE, 0x0F, 0x9F, 0x07, 0x78, 0x3E, 0x7C,
  0x1C, 0xE0, 0xF9, 0xF0, 0x73, 0x83, 0xC3, 0xC3, 0xCF, 0x0F, 0x0F, 0x0F,
  0x3C, 0x3C, 0x3C, 0x3C, 0xF0, 0xF0, 0xF8, 0xE3, 0xC7, 0xC3, 0xE3, 0x87,
  0x1F, 0x0F, 0x9E, 0x1E, 0x7C, 0x3E, 0x78, 0x79, 0xE0, 0x79, 0xE1, 0xE7,
  0x81, 0xE7, 0x87, 0x9E, 0x07, 0x9C, 0x0E, 0x78, 0x1E, 0x70, 0x39, 0xE0,
  0x7B, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0xCF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F,
  0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0xFF,
  0x00, 0x3C, 0x3F, 0xF0, 0x07, 0x8F, 0xFF, 0x01, 0xF3, 0xFF, 0xE0, 0x3E,
  0x7C, 0x7E, 0x07, 0x8F, 0x07, 0xE1, 0xF3, 0xE0, 0x7E, 0x3E, 0x7C, 0x0F,
  0xFF, 0x8F, 0x00, 0xFF, 0xF1, 0xE0, 0x0F, 0xFC, 0x7C, 0x00, 0xFF, 0x03,
  0x80, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Medium53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 9, 38, 32, 11, -37 },
  { 44, 16, 16, 32, 8, -39 },
  { 76, 30, 37, 32, 1, -37 },
  { 215, 28, 49, 32, 2, -43 },
  { 387, 30, 39, 32, 1, -38 },
  { 534, 30, 39, 32, 1, -38 },
  { 681, 6, 16, 32, 13, -39 },
  { 693, 17, 47, 32, 10, -40 },
  { 793, 17, 47, 32, 5, -40 },
  { 893, 28, 27, 32, 2, -29 },
  { 988, 26, 27, 32, 3, -30 },
  { 1076, 11, 16, 32, 10, -8 },
  { 1098, 16, 5, 32, 8, -19 },
  { 1108, 10, 9, 32, 11, -8 },
  { 1120, 23, 47, 32, 4, -40 },
  { 1256, 27, 39, 32, 2, -38 },
  { 1388, 28, 37, 32, 2, -37 },
  { 1518, 26, 38, 32, 3, -38 },
  { 1642, 26, 39, 32, 2, -38 },
  { 1769, 28, 37, 32, 2, -37 },
  { 1899, 26, 38, 32, 3, -37 },
  { 2023, 26, 38, 32, 3, -37 },
  { 2147, 26, 37, 32, 3, -37 },
  { 2268, 27, 39, 32, 2, -38 },
  { 2400, 26, 38, 32, 3, -38 },
  { 2524, 10, 29, 32, 11, -28 },
  { 2561, 11, 36, 32, 10, -28 },
  { 2611, 23, 31, 32, 4, -32 },
  { 2701, 26, 16, 32, 3, -24 },
  { 2753, 23, 31, 32, 4, -32 },
  { 2843, 23, 39, 32, 4, -38 },
  { 2956, 25, 44, 32, 3, -38 },
  { 3094, 30, 37, 32, 1, -37 },
  { 3233, 25, 37, 32, 4, -37 },
  { 3349, 26, 39, 32, 3, -38 },
  { 3476, 25, 37, 32, 4, -37 },
  { 3592, 23, 37, 32, 5, -37 },
  { 3699, 23, 37, 32, 5, -37 },
  { 3806, 26, 39, 32, 2, -38 },
  { 3933, 24, 37, 32, 4, -37 },
  { 4044, 24, 37, 32, 4, -37 },
  { 4155, 23, 38, 32, 3, -37 },
  { 4265, 27, 37, 32, 4, -37 },
  { 4390, 23, 37, 32, 6, -37 },
  { 4497, 26, 37, 32, 3, -37 },
  { 4618, 24, 37, 32, 4, -37 },
  { 4729, 27, 39, 32, 2, -38 },
  { 4861, 25, 37, 32, 4, -37 },
  { 4977, 27, 47, 32, 2, -38 },
  { 5136, 26, 37, 32, 4, -37 },
  { 5257, 27, 39, 32, 2, -38 },
  { 5389, 29, 37, 32, 1, -37 },
  { 5524, 24, 38, 32, 4, -37 },
  { 5638, 29, 37, 32, 1, -37 },
  { 5773, 29, 37, 32, 1, -37 },
  { 5908, 30, 37, 32, 1, -37 },
  { 6047, 30, 37, 32, 1, -37 },
  { 6186, 26, 37, 32, 3, -37 },
  { 6307, 16, 47, 32, 11, -40 },
  { 6401, 23, 47, 32, 4, -40 },
  { 6537, 16, 47, 32, 5, -40 },
  { 6631, 28, 23, 32, 2, -37 },
  { 6712, 26, 5, 32, 3, 4 },
  { 6729, 10, 11, 32, 9, -42 },
  { 6743, 27, 29, 32, 3, -28 },
  { 6841, 25, 40, 32, 4, -39 },
  { 6966, 24, 29, 32, 4, -28 },
  { 7053, 25, 40, 32, 3, -39 },
  { 7178, 26, 29, 32, 3, -28 },
  { 7273, 25, 39, 32, 4, -39 },
  { 7395, 27, 43, 32, 3, -32 },
  { 7541, 24, 39, 32, 4, -39 },
  { 7658, 24, 39, 32, 5, -39 },
  { 7775, 19, 50, 32, 5, -39 },
  { 7894, 26, 39, 32, 5, -39 },
  { 8021, 24, 39, 32, 4, -39 },
  { 8138, 27, 28, 32, 2, -28 },
  { 8233, 24, 28, 32, 4, -28 },
  { 8317, 26, 29, 32, 3, -28 },
  { 8412, 25, 39, 32, 4, -28 },
  { 8534, 25, 39, 32, 3, -28 },
  { 8656, 26, 27, 32, 4, -27 },
  { 8744, 25, 29, 32, 3, -28 },
  { 8835, 26, 37, 32, 2, -37 },
  { 8956, 23, 28, 32, 4, -27 },
  { 9037, 26, 27, 32, 3, -27 },
  { 9125, 30, 27, 32, 1, -27 },
  { 9227, 27, 27, 32, 2, -27 },
  { 9319, 28, 38, 32, 2, -27 },
  { 9452, 24, 27, 32, 4, -27 },
  { 9533, 22, 47, 32, 5, -40 },
  { 9663, 5, 47, 32, 13, -40 },
  { 9693, 22, 47, 32, 5, -40 },
  { 9823, 27, 13, 32, 2, -23 },
};

const GFXfont IBMPlexMono_Medium53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_MEDIUM53PT7B_H_
