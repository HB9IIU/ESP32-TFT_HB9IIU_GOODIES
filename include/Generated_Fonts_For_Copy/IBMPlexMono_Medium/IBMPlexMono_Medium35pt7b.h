#ifndef _IBMPLEXMONO_MEDIUM35PT7B_H_
#define _IBMPLEXMONO_MEDIUM35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x73, 0x9C, 0xE7, 0x10, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3C, 0x00, 0xE3, 0xC0, 0x0F, 0x1C, 0x00,
  0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C,
  0x07, 0xF8, 0xFF, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0xC0, 0xE3, 0xC0, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x03, 0xFC, 0x3F, 0x9F, 0xE1, 0xFC,
  0xFF, 0x1F, 0xE0, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xF3, 0x3E, 0x3C, 0x61, 0x8F, 0x0C, 0x21, 0xE1, 0x80, 0x3C,
  0x30, 0x03, 0xC6, 0x00, 0x7C, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0x8F, 0x00, 0x30, 0xE0, 0x06, 0x1E, 0x00,
  0xC3, 0xCC, 0x18, 0x73, 0xC3, 0x1E, 0xFE, 0x67, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x79, 0xFE, 0x03, 0x9F, 0xF0, 0x38, 0xE3, 0xC1, 0xC7,
  0x0E, 0x1C, 0x30, 0x71, 0xE1, 0x83, 0x8E, 0x0E, 0x1C, 0xF0, 0x71, 0xE7,
  0x03, 0xFE, 0x70, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xF0, 0x0E, 0x7F, 0xC0, 0xE7, 0x8E, 0x0F, 0x38, 0x70, 0x71, 0xC1,
  0x87, 0x8E, 0x0C, 0x38, 0x70, 0xE3, 0x83, 0xC7, 0x1C, 0x0F, 0xF9, 0xC0,
  0x7F, 0x9E, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1E,
  0x1E, 0x03, 0xC1, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x1F, 0x8F, 0xC3, 0xF3, 0xFC, 0x7E, 0xF7,
  0x8E, 0x3C, 0x79, 0xC7, 0x87, 0xB8, 0xE0, 0x7F, 0x1C, 0x07, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x8F, 0x83, 0xF8, 0xFF, 0xEF, 0x0F, 0xF8, 0xF0, 0x7C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0xF0, 0x3C, 0x07, 0x01, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x07, 0xC0, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC1, 0xC1, 0x9F,
  0x39, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0x78, 0x0C,
  0x06, 0x01, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x7E, 0xF9, 0xF3, 0xC7, 0x9F, 0x3C, 0x78,
  0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0xFB, 0xFF, 0xF7, 0xCF,
  0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF7,
  0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0xE3, 0xFC, 0xF9,
  0xFE, 0x7C, 0xFF, 0x3E, 0x7F, 0x8E, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B,
  0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0x60, 0xF0,
  0x10, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x87, 0xCF, 0x81, 0xF7, 0x80, 0x78, 0x80,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7E, 0x38, 0x07,
  0x84, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF3, 0x00, 0x7D, 0xE0, 0x1E, 0xFC, 0x1F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xE0, 0x03, 0x9C, 0x00, 0xF3, 0x80,
  0x3C, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x78, 0x38, 0x0E, 0x07, 0x03,
  0xC0, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0xFC, 0x1C, 0xFF, 0x0E, 0xFF, 0xE7, 0xC1, 0xF3, 0xC0, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xCC, 0x01, 0xEE, 0x01, 0xEF, 0xC1,
  0xF3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0xFC, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF,
  0x01, 0xF7, 0xC1, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0x7B, 0x80,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF7,
  0x80, 0x3F, 0xC0, 0x1E, 0xE0, 0x0E, 0x78, 0x0F, 0x1E, 0x0F, 0x07, 0xFF,
  0x00, 0xFE, 0x03, 0xFF, 0xE3, 0xE0, 0xFB, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0xC1, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83,
  0xEF, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x03, 0xEF, 0x83, 0xF7, 0xFF, 0x79, 0xFF, 0xBC, 0x3F, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0xFB, 0xFF, 0xF7, 0xCF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x7F, 0xFE, 0xF9, 0xF0,
  0x7C, 0xFB, 0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xBE, 0x7C, 0xF1, 0xE7, 0xCF, 0x1E, 0x38, 0x70, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x01, 0xF0, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x01, 0xF0,
  0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x03, 0xC0,
  0x07, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C,
  0x1F, 0x78, 0x0F, 0xF0, 0x0F, 0x10, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x3E, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87,
  0x83, 0xE7, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x0F, 0xC1, 0xE7, 0xE1, 0xFB,
  0xF1, 0xFF, 0xF8, 0xF1, 0xFC, 0x70, 0x7E, 0x38, 0x3F, 0x1C, 0x1F, 0x8E,
  0x0F, 0xC7, 0x07, 0xE3, 0x83, 0xF1, 0xC3, 0xF8, 0xFF, 0xFC, 0x3F, 0x7E,
  0x0F, 0x3B, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x38, 0xE0,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x38, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x38, 0x1E, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x00, 0xF1,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE7, 0xC0,
  0xFB, 0xC0, 0x3D, 0xE0, 0x19, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0x1E, 0x01, 0xEF, 0x81, 0xF3, 0xE1, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0,
  0x7C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x7C, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0x83, 0xE7, 0x80,
  0xF3, 0xC0, 0x7F, 0xC0, 0x19, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x01, 0xF7, 0xC1, 0xF9, 0xFF,
  0xBC, 0x7F, 0x9E, 0x1F, 0x8F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x20, 0x3F, 0xC0, 0x7F, 0xC0,
  0xF7, 0xC3, 0xCF, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0xF0, 0x0F, 0xBC, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x0F, 0x03,
  0xC7, 0x80, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0x78, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x1F,
  0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xFB,
  0xC0, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x71, 0xDF,
  0xB8, 0xEF, 0xDE, 0x77, 0xE7, 0x73, 0xF3, 0xB9, 0xF8, 0xF8, 0xFC, 0x7C,
  0x7E, 0x3E, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC1, 0x07, 0xE0, 0x83, 0xF0,
  0x41, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xC1, 0xFB, 0x83, 0xF7, 0x87, 0xEF, 0x0F, 0xCE, 0x1F, 0x9E, 0x3F, 0x1C,
  0x7E, 0x38, 0xFC, 0x79, 0xF8, 0x73, 0xF0, 0xF7, 0xE1, 0xEF, 0xC1, 0xDF,
  0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF7, 0x80, 0x7B,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x03, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0,
  0x0F, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80,
  0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0xBC, 0x07, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0x83,
  0xC7, 0x81, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1F, 0x1E, 0x07,
  0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1F, 0x03, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xF8, 0xF8, 0x1F, 0x3C, 0x03, 0x9E, 0x00, 0x47, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF3, 0x00, 0x3D, 0xE0, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF,
  0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0x38, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x0F, 0xE0, 0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x3C, 0xF8, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0x9C, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x7C, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xEE, 0x3E, 0x39,
  0xC6, 0xC7, 0x38, 0xDC, 0xE7, 0x3B, 0x9C, 0xE7, 0x73, 0x9C, 0xEE, 0x73,
  0x98, 0xCE, 0x73, 0x1D, 0xCE, 0xE3, 0xB9, 0xDC, 0x77, 0x3F, 0x8E, 0xE7,
  0xF1, 0xFC, 0xFC, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0xF8, 0x01, 0xEF,
  0x00, 0x78, 0xF0, 0x1F, 0x1F, 0x03, 0xC1, 0xE0, 0xF0, 0x3E, 0x1E, 0x03,
  0xC7, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x3C, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0xF0,
  0x0F, 0x9E, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0x8F,
  0x00, 0x78, 0x7C, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x3C, 0x1E,
  0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01,
  0xDC, 0x00, 0x7B, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0x70, 0x70, 0x1E,
  0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xE0,
  0x03, 0xCC, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x73,
  0xC7, 0x8E, 0x3C, 0x70, 0x80, 0x07, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xC1,
  0xE0, 0xF8, 0x30, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x83, 0xE1, 0xFF, 0xBF, 0x3F, 0xEF, 0xC7, 0xE1, 0xF0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0xF7, 0xFC,
  0xF1, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xFF, 0x81, 0xDE,
  0x01, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x9F, 0x01, 0xDF, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x8F, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F, 0x7F, 0xFF,
  0x3F, 0xEF, 0x0F, 0x8F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0x83,
  0xE7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x43, 0xC0, 0x30, 0xF0, 0x3C,
  0x7F, 0xFE, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xC1, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xE1, 0xF0, 0x78, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0x9C, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF,
  0xFF, 0xE7, 0xFF, 0xF0, 0x3F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF1, 0xF1, 0xEF,
  0xF3, 0xDF, 0xF7, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xFF, 0xDF, 0xFC,
  0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0xF8, 0x1F, 0x3C,
  0x1F, 0x1E, 0x1F, 0x0F, 0x1F, 0x07, 0x9F, 0x03, 0xDF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7E, 0xF0, 0x3E, 0x7C, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x83,
  0xE3, 0xC0, 0xF9, 0xE0, 0x3C, 0xF0, 0x0F, 0x78, 0x07, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7,
  0x0F, 0x77, 0xCF, 0xFF, 0xFF, 0xFE, 0x7C, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F,
  0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38,
  0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0,
  0xE1, 0xC0, 0xF1, 0xF1, 0xEF, 0xF3, 0xDF, 0xF7, 0xC1, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF7, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x79, 0xF0, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0xF7,
  0xFC, 0xF1, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x8F, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F, 0x7F,
  0xFF, 0x3F, 0xEF, 0x0F, 0x8F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xE1, 0xEC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x07, 0xF0,
  0x1F, 0xFE, 0x3F, 0xFF, 0x7C, 0x0E, 0x78, 0x04, 0x78, 0x00, 0x7C, 0x00,
  0x3F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07,
  0x60, 0x07, 0xF8, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xBF, 0xFF, 0x3F, 0xDE, 0x3F, 0x3C, 0xF0,
  0x07, 0xF8, 0x03, 0xDC, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x70,
  0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xC7,
  0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xE0, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7E,
  0x1B, 0x0F, 0xE3, 0x61, 0xDC, 0x6E, 0x73, 0x9D, 0xCE, 0x73, 0xB9, 0xCE,
  0x63, 0x39, 0xCC, 0x67, 0x39, 0x8C, 0xE7, 0x71, 0xDC, 0x7E, 0x3B, 0x0F,
  0xC7, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x07, 0xBC,
  0x07, 0x8F, 0x07, 0x87, 0xC3, 0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xF7,
  0x80, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x3E, 0x78, 0x0F, 0x78, 0x03, 0xC0,
  0xF8, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x38, 0x0E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x0F, 0x0E, 0x01, 0xE3, 0xC0,
  0x1C, 0x70, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x3F, 0xF0, 0x7F, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0x07, 0xFE, 0x1F, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x1E, 0x01,
  0x9F, 0x81, 0xDF, 0xE0, 0xEE, 0x78, 0x7E, 0x1E, 0x77, 0x07, 0xFB, 0x81,
  0xF9, 0x80, 0x78,
};

const GFXglyph IBMPlexMono_Medium35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 24, 21, 8, -24 },
  { 16, 11, 10, 21, 5, -26 },
  { 30, 21, 24, 21, 0, -24 },
  { 93, 19, 32, 21, 1, -28 },
  { 169, 21, 24, 21, 0, -24 },
  { 232, 19, 24, 21, 1, -24 },
  { 289, 3, 10, 21, 9, -26 },
  { 293, 11, 32, 21, 7, -27 },
  { 337, 11, 32, 21, 3, -27 },
  { 381, 19, 18, 21, 1, -19 },
  { 424, 17, 17, 21, 2, -19 },
  { 461, 7, 10, 21, 7, -5 },
  { 470, 11, 3, 21, 5, -12 },
  { 475, 7, 6, 21, 7, -6 },
  { 481, 15, 32, 21, 3, -27 },
  { 541, 17, 24, 21, 2, -24 },
  { 592, 18, 24, 21, 2, -24 },
  { 646, 17, 24, 21, 2, -24 },
  { 697, 18, 24, 21, 1, -24 },
  { 751, 19, 24, 21, 1, -24 },
  { 808, 17, 24, 21, 2, -24 },
  { 859, 17, 24, 21, 2, -24 },
  { 910, 17, 24, 21, 2, -24 },
  { 961, 17, 24, 21, 2, -24 },
  { 1012, 17, 24, 21, 2, -24 },
  { 1063, 7, 19, 21, 7, -19 },
  { 1080, 7, 24, 21, 7, -19 },
  { 1101, 15, 21, 21, 3, -21 },
  { 1141, 17, 11, 21, 2, -16 },
  { 1165, 15, 21, 21, 3, -21 },
  { 1205, 16, 24, 21, 2, -24 },
  { 1253, 17, 28, 21, 2, -24 },
  { 1313, 19, 24, 21, 1, -24 },
  { 1370, 16, 24, 21, 3, -24 },
  { 1418, 17, 24, 21, 2, -24 },
  { 1469, 16, 24, 21, 3, -24 },
  { 1517, 15, 24, 21, 3, -24 },
  { 1562, 16, 24, 21, 3, -24 },
  { 1610, 17, 24, 21, 2, -24 },
  { 1661, 15, 24, 21, 3, -24 },
  { 1706, 15, 24, 21, 3, -24 },
  { 1751, 15, 24, 21, 2, -24 },
  { 1796, 18, 24, 21, 3, -24 },
  { 1850, 15, 24, 21, 4, -24 },
  { 1895, 17, 24, 21, 2, -24 },
  { 1946, 15, 24, 21, 3, -24 },
  { 1991, 17, 24, 21, 2, -24 },
  { 2042, 16, 24, 21, 3, -24 },
  { 2090, 17, 30, 21, 2, -24 },
  { 2154, 17, 24, 21, 3, -24 },
  { 2205, 18, 24, 21, 1, -24 },
  { 2259, 19, 24, 21, 1, -24 },
  { 2316, 17, 24, 21, 2, -24 },
  { 2367, 19, 24, 21, 1, -24 },
  { 2424, 19, 24, 21, 1, -24 },
  { 2481, 19, 24, 21, 1, -24 },
  { 2538, 21, 24, 21, 0, -24 },
  { 2601, 17, 24, 21, 2, -24 },
  { 2652, 11, 32, 21, 7, -27 },
  { 2696, 15, 32, 21, 3, -27 },
  { 2756, 11, 32, 21, 3, -27 },
  { 2800, 19, 15, 21, 1, -24 },
  { 2836, 17, 3, 21, 2, 3 },
  { 2843, 6, 7, 21, 6, -27 },
  { 2849, 18, 18, 21, 2, -18 },
  { 2890, 16, 26, 21, 3, -26 },
  { 2942, 15, 18, 21, 3, -18 },
  { 2976, 16, 26, 21, 2, -26 },
  { 3028, 17, 18, 21, 2, -18 },
  { 3067, 17, 26, 21, 2, -26 },
  { 3123, 18, 28, 21, 2, -21 },
  { 3186, 15, 26, 21, 3, -26 },
  { 3235, 15, 26, 21, 4, -26 },
  { 3284, 13, 33, 21, 3, -26 },
  { 3338, 17, 26, 21, 3, -26 },
  { 3394, 15, 26, 21, 3, -26 },
  { 3443, 17, 18, 21, 2, -18 },
  { 3482, 15, 18, 21, 3, -18 },
  { 3516, 17, 18, 21, 2, -18 },
  { 3555, 16, 25, 21, 3, -18 },
  { 3605, 16, 25, 21, 2, -18 },
  { 3655, 17, 18, 21, 3, -18 },
  { 3694, 16, 18, 21, 2, -18 },
  { 3730, 17, 24, 21, 1, -24 },
  { 3781, 15, 18, 21, 3, -18 },
  { 3815, 17, 18, 21, 2, -18 },
  { 3854, 19, 18, 21, 1, -18 },
  { 3897, 17, 18, 21, 2, -18 },
  { 3936, 19, 25, 21, 1, -18 },
  { 3996, 15, 18, 21, 3, -18 },
  { 4030, 15, 32, 21, 3, -27 },
  { 4090, 3, 32, 21, 9, -27 },
  { 4102, 15, 32, 21, 3, -27 },
  { 4162, 17, 8, 21, 2, -15 },
};

const GFXfont IBMPlexMono_Medium35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_MEDIUM35PT7B_H_
