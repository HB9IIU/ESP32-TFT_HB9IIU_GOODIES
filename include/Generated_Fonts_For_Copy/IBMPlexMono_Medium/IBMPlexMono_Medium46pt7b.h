#ifndef _IBMPLEXMONO_MEDIUM46PT7B_H_
#define _IBMPLEXMONO_MEDIUM46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF0, 0x1F, 0xFC, 0x3F, 0xF7, 0xFF, 0x0F, 0xFD, 0xFF, 0x83,
  0xFF, 0x7F, 0xE0, 0xFF, 0xC0, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x03,
  0xFF, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF, 0x3F, 0xF0, 0xFF, 0xCF, 0xF8, 0x3F,
  0xF0, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x9C, 0xFE,
  0x3E, 0x1C, 0x3C, 0x7C, 0x1C, 0x18, 0x7C, 0x1C, 0x10, 0x7C, 0x1C, 0x00,
  0x7C, 0x1C, 0x00, 0x7C, 0x1C, 0x00, 0x7C, 0x1C, 0x00, 0x3E, 0x1C, 0x00,
  0x3F, 0x9C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1D, 0xFE, 0x00, 0x1C, 0x7E,
  0x00, 0x1C, 0x3E, 0x00, 0x1C, 0x1F, 0x00, 0x1C, 0x1F, 0x00, 0x1C, 0x1F,
  0x00, 0x1C, 0x1F, 0x10, 0x1C, 0x1E, 0x38, 0x1C, 0x3E, 0xFC, 0x1C, 0x7E,
  0xFF, 0x1C, 0xFC, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x3C, 0xFF, 0xE0, 0x0F, 0x1F, 0xFE, 0x01, 0xE7, 0xC3, 0xC0, 0x78, 0xF0,
  0x78, 0x0F, 0x1E, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x78, 0x78, 0x1E, 0x1E,
  0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0xC3,
  0xC7, 0x80, 0x7F, 0xF8, 0xF0, 0x0F, 0xFE, 0x3C, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xF8,
  0xFF, 0xC0, 0x1E, 0x3F, 0xFC, 0x07, 0xCF, 0x87, 0x80, 0xF1, 0xE0, 0x78,
  0x3E, 0x3C, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E,
  0x07, 0x8F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1E, 0x78, 0x0F, 0x87, 0x8F,
  0x00, 0xFF, 0xF3, 0xC0, 0x0F, 0xFC, 0x78, 0x00, 0xFF, 0x10, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x18, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x87, 0xFE, 0x0F, 0xE3,
  0xEF, 0x83, 0xF9, 0xF1, 0xF0, 0xF0, 0x7C, 0x3E, 0x3C, 0x3E, 0x0F, 0xCE,
  0x0F, 0x81, 0xF3, 0x83, 0xE0, 0x3F, 0xE0, 0xF8, 0x07, 0xF8, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xFC, 0x1F,
  0xC1, 0xDF, 0x83, 0xFF, 0xE3, 0xF0, 0xFF, 0xF8, 0x7C, 0x0F, 0xFC, 0x0F,
  0x80, 0xFC, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x40, 0x3C, 0x02, 0x78, 0x3C, 0x1E, 0xFF, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xC7, 0xC0,
  0x0F, 0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x00, 0xE0,
  0x02, 0x00, 0x40, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8,
  0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x3C, 0x3E, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F,
  0xF8, 0x7E, 0x3F, 0xF8, 0x3C, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x83, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xDF, 0x00, 0x1F, 0x9F, 0x00, 0x3F, 0x1F, 0x00, 0x7E, 0x1F, 0x00,
  0xFC, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x38, 0x1F, 0x00, 0x10, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xF8, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x18,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0,
  0x3F, 0x87, 0xC0, 0x3F, 0x07, 0x00, 0x3F, 0x04, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0xC0, 0x01, 0xF3, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0xE0,
  0x7F, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x7F, 0x01, 0xE3, 0xFF, 0x07, 0x9F, 0xFE, 0x1E, 0xFF,
  0xFC, 0x7F, 0x07, 0xF9, 0xF0, 0x07, 0xE0, 0x80, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0xC0, 0x03, 0xF7, 0x80, 0x0F, 0xBF, 0x00, 0x7E, 0xFF, 0x07,
  0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE1,
  0xF8, 0x07, 0xCF, 0xFC, 0x1F, 0x3F, 0xFC, 0x3E, 0xFF, 0xFC, 0x7F, 0x81,
  0xFC, 0xFE, 0x01, 0xFB, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE1, 0xF8, 0x1F, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x7E, 0xF0, 0x01, 0xF3,
  0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0x83, 0xF0, 0x3E, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFE, 0x07, 0xE3, 0xF0, 0x03,
  0xE7, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7,
  0xE0, 0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x9F, 0x80,
  0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x7F, 0x3F, 0x81, 0xBE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF0,
  0x7F, 0xF3, 0xE0, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x3E, 0x3F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F,
  0x0F, 0x87, 0x83, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F,
  0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xEF, 0x00, 0x3F, 0x08, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xF8, 0x1F, 0x83, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x1E, 0x3D, 0xE0, 0xFE, 0x7B, 0xC1, 0xFE,
  0xF7, 0x87, 0xFF, 0xEF, 0x0F, 0x8F, 0xDE, 0x3E, 0x0F, 0xFC, 0x78, 0x0F,
  0xF8, 0xF0, 0x1F, 0xF1, 0xE0, 0x3F, 0xE3, 0xC0, 0x7F, 0xC7, 0x80, 0xFF,
  0x8F, 0x01, 0xFF, 0x1E, 0x03, 0xFE, 0x3C, 0x07, 0xBC, 0x7C, 0x0F, 0x78,
  0x78, 0x3E, 0xF0, 0xFF, 0xFD, 0xE1, 0xFF, 0x7B, 0xC1, 0xFE, 0xF7, 0x81,
  0xF9, 0xE7, 0x80, 0x80, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80,
  0x7E, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x03,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3E,
  0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0x83, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0x7C, 0x00,
  0x73, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xC7,
  0xC0, 0x07, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0xF8, 0x7E, 0x0F, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFE, 0x7C,
  0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x1F, 0xCF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF8, 0xFC, 0x03, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x31, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xDF, 0x00, 0x0F,
  0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3F,
  0x00, 0xFC, 0x7F, 0x06, 0xF1, 0xFF, 0xFB, 0xC3, 0xFF, 0xCF, 0x07, 0xFE,
  0x3C, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x08, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0x7E, 0x0F,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0x80,
  0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F,
  0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80,
  0x1F, 0x7E, 0x00, 0x3E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFD, 0xF8, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x9F, 0x00,
  0x1F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFD, 0xE1,
  0xEF, 0xF7, 0x87, 0xBF, 0xDF, 0x3C, 0xFF, 0x3C, 0xF3, 0xFC, 0xFF, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0x1F, 0xC7, 0xFC, 0x3F, 0x1F, 0xF0,
  0xF8, 0x7F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1C, 0x1F, 0xF0, 0x30,
  0x7F, 0xC0, 0x81, 0xFF, 0x02, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFB, 0xC0, 0x7F, 0xDF, 0x03, 0xFE, 0xF8, 0x1F,
  0xF3, 0xC0, 0xFF, 0x9F, 0x07, 0xFC, 0x78, 0x3F, 0xE3, 0xC1, 0xFF, 0x1F,
  0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xE3, 0xFE, 0x1F, 0x1F, 0xF0, 0x78, 0xFF,
  0x83, 0xE7, 0xFC, 0x0F, 0x3F, 0xE0, 0x7D, 0xFF, 0x03, 0xEF, 0xF8, 0x0F,
  0x7F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x83,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF,
  0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xE7, 0xE0,
  0x0F, 0x9F, 0x80, 0x06, 0x3E, 0x00, 0x08, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0xC0,
  0x00, 0xFB, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0xE0, 0x3F, 0x9F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x3E, 0xFC, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x3F,
  0x07, 0xBC, 0x1F, 0x87, 0xDE, 0x0F, 0xC3, 0xEF, 0x07, 0xE1, 0xF7, 0x87,
  0xF0, 0xFB, 0xC3, 0xF8, 0x7D, 0xF1, 0xDE, 0x3C, 0xF8, 0xEF, 0x1E, 0x7C,
  0x77, 0x8F, 0x3E, 0x79, 0xC7, 0x9F, 0x3C, 0xE3, 0xC7, 0x9E, 0x79, 0xE3,
  0xCE, 0x3C, 0xF1, 0xE7, 0x1E, 0x78, 0xF3, 0x87, 0x3C, 0x7B, 0xC3, 0x9E,
  0x3D, 0xE1, 0xEF, 0x1E, 0xF0, 0xFF, 0x8F, 0x70, 0x7F, 0xC7, 0xF8, 0x3F,
  0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xC0,
  0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xC7, 0xC0,
  0x07, 0xC7, 0xC0, 0x07, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x70, 0x00, 0x1E,
  0x10, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x10, 0x38, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x04,
  0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xE0, 0xFE, 0x1F, 0x00, 0x7C, 0x04, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0xFF,
  0xEF, 0xFF, 0xBF, 0xDF, 0xFF, 0x3F, 0x9F, 0xFC, 0x3F, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x1F, 0x81, 0xF3, 0xFF, 0x0F, 0xBF, 0xFC, 0x7D, 0xFF,
  0xF3, 0xF8, 0x1F, 0xDF, 0x80, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0x7E, 0x01, 0xFB, 0xF8, 0x1F, 0xDF, 0x7F, 0xFC,
  0xFB, 0xFF, 0xC7, 0xCF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xF8, 0x3F, 0x1F, 0x00, 0x7D,
  0xF8, 0x03, 0x8F, 0x80, 0x10, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x02, 0x1F, 0x80, 0x1C, 0x7E, 0x01,
  0xF3, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xC1, 0xFF, 0x1F, 0x1F,
  0xFE, 0x7C, 0x7F, 0xFD, 0xF3, 0xF8, 0x3F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFD, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0x7D, 0xF8, 0x03,
  0xF3, 0xF8, 0x3F, 0xC7, 0xFF, 0xDF, 0x1F, 0xFE, 0x7C, 0x3F, 0xF1, 0xF0,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x01, 0x07, 0xC0, 0x06, 0x1F, 0x80, 0x3C, 0x3F, 0x03,
  0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xD8,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x07, 0xF0,
  0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0x80, 0x07, 0xEE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x7E, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xBF, 0xFE, 0xFE,
  0x0F, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x07, 0xF7, 0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F,
  0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xF1,
  0xF8, 0x03, 0xE7, 0xE0, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFC,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xE0, 0xF8, 0xF3, 0xF1, 0xFC,
  0xF7, 0xFB, 0xFE, 0xF7, 0xFB, 0xFE, 0xF8, 0x7E, 0x3E, 0xF8, 0x7C, 0x1E,
  0xF0, 0x3C, 0x1E, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F,
  0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F,
  0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F,
  0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F,
  0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF8, 0x7E, 0x0F, 0x9F, 0xF8, 0xFB,
  0xFF, 0xCF, 0xBF, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF1, 0xF8, 0x07, 0xE7, 0xC0,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x80,
  0x7E, 0x3F, 0x07, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0xF8, 0x7E, 0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xF1, 0xF7,
  0xFF, 0xCF, 0xE0, 0x7F, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xE0, 0x7F, 0x7D, 0xFF,
  0xF3, 0xEF, 0xFF, 0x1F, 0x3F, 0xF0, 0xF8, 0x7E, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x1F, 0xF1, 0xF1,
  0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0x83, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80,
  0x3F, 0x3F, 0x83, 0xFC, 0x7F, 0xFD, 0xF1, 0xFF, 0xE7, 0xC3, 0xFF, 0x1F,
  0x03, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF,
  0xF0, 0x1F, 0x60, 0x00, 0x3E, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF0, 0x1F, 0x3E,
  0x00, 0x31, 0xF0, 0x01, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xCC, 0x00, 0x3E,
  0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x0D,
  0xF7, 0xFF, 0xDF, 0x3F, 0xF9, 0xF1, 0xFF, 0x1F, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x78, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xF0, 0x3E, 0x03, 0xFC,
  0x0F, 0xC1, 0xFF, 0x03, 0xF0, 0x7B, 0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07,
  0x9E, 0x1F, 0xC1, 0xE7, 0x87, 0x70, 0x79, 0xE1, 0xDE, 0x1E, 0x78, 0x73,
  0x87, 0x9E, 0x1C, 0xE3, 0xC7, 0x87, 0x38, 0xF0, 0xF3, 0xCE, 0x3C, 0x3C,
  0xE3, 0xCF, 0x0F, 0x38, 0xF3, 0xC3, 0xCE, 0x1C, 0xF0, 0xF3, 0x87, 0x3C,
  0x3C, 0xE1, 0xCE, 0x0F, 0x78, 0x73, 0x83, 0xDC, 0x1F, 0xE0, 0x77, 0x07,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xE7, 0xC0, 0x03,
  0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xEF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F, 0x83, 0xF0, 0x1F,
  0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xC7, 0xC0, 0x03,
  0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x7E, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x0C, 0x1F,
  0xE0, 0x0F, 0x1F, 0xF0, 0x1E, 0x3F, 0xF8, 0x1E, 0x3C, 0xFC, 0x1E, 0x78,
  0x7C, 0x3C, 0x78, 0x3E, 0x3C, 0x70, 0x1F, 0xFC, 0xF0, 0x0F, 0xF8, 0xF0,
  0x07, 0xF0, 0x70, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_Medium46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 32, 28, 10, -32 },
  { 33, 14, 14, 28, 7, -34 },
  { 58, 26, 32, 28, 1, -32 },
  { 162, 24, 44, 28, 2, -38 },
  { 294, 27, 34, 28, 0, -33 },
  { 409, 26, 34, 28, 1, -33 },
  { 520, 5, 14, 28, 11, -34 },
  { 529, 14, 41, 28, 9, -35 },
  { 601, 15, 41, 28, 4, -35 },
  { 678, 24, 23, 28, 2, -25 },
  { 747, 22, 22, 28, 3, -25 },
  { 808, 9, 14, 28, 9, -7 },
  { 824, 14, 4, 28, 7, -17 },
  { 831, 8, 8, 28, 10, -7 },
  { 839, 20, 41, 28, 4, -35 },
  { 942, 24, 34, 28, 2, -33 },
  { 1044, 24, 32, 28, 2, -32 },
  { 1140, 23, 33, 28, 2, -33 },
  { 1235, 23, 34, 28, 2, -33 },
  { 1333, 25, 32, 28, 1, -32 },
  { 1433, 22, 33, 28, 3, -32 },
  { 1524, 23, 33, 28, 2, -32 },
  { 1619, 22, 32, 28, 3, -32 },
  { 1707, 23, 34, 28, 2, -33 },
  { 1805, 23, 33, 28, 2, -33 },
  { 1900, 8, 25, 28, 10, -24 },
  { 1925, 9, 31, 28, 9, -24 },
  { 1960, 20, 27, 28, 4, -28 },
  { 2028, 22, 14, 28, 3, -21 },
  { 2067, 20, 27, 28, 4, -28 },
  { 2135, 21, 33, 28, 3, -33 },
  { 2222, 23, 38, 28, 2, -33 },
  { 2332, 26, 32, 28, 1, -32 },
  { 2436, 21, 32, 28, 4, -32 },
  { 2520, 22, 34, 28, 3, -33 },
  { 2614, 21, 32, 28, 4, -32 },
  { 2698, 20, 32, 28, 4, -32 },
  { 2778, 21, 32, 28, 4, -32 },
  { 2862, 22, 34, 28, 2, -33 },
  { 2956, 21, 32, 28, 3, -32 },
  { 3040, 20, 32, 28, 4, -32 },
  { 3120, 20, 33, 28, 3, -32 },
  { 3203, 23, 32, 28, 4, -32 },
  { 3295, 20, 32, 28, 5, -32 },
  { 3375, 22, 32, 28, 3, -32 },
  { 3463, 21, 32, 28, 3, -32 },
  { 3547, 24, 34, 28, 2, -33 },
  { 3649, 21, 32, 28, 4, -32 },
  { 3733, 24, 41, 28, 2, -33 },
  { 3856, 22, 32, 28, 4, -32 },
  { 3944, 23, 34, 28, 2, -33 },
  { 4042, 25, 32, 28, 1, -32 },
  { 4142, 21, 33, 28, 3, -32 },
  { 4229, 25, 32, 28, 1, -32 },
  { 4329, 25, 32, 28, 1, -32 },
  { 4429, 26, 32, 28, 1, -32 },
  { 4533, 26, 32, 28, 1, -32 },
  { 4637, 23, 32, 28, 2, -32 },
  { 4729, 13, 41, 28, 10, -35 },
  { 4796, 20, 41, 28, 4, -35 },
  { 4899, 14, 41, 28, 4, -35 },
  { 4971, 24, 20, 28, 2, -32 },
  { 5031, 22, 4, 28, 3, 4 },
  { 5042, 8, 10, 28, 8, -37 },
  { 5052, 23, 25, 28, 3, -24 },
  { 5124, 21, 35, 28, 4, -34 },
  { 5216, 21, 25, 28, 3, -24 },
  { 5282, 22, 35, 28, 2, -34 },
  { 5379, 22, 25, 28, 3, -24 },
  { 5448, 22, 34, 28, 3, -34 },
  { 5542, 23, 38, 28, 3, -28 },
  { 5652, 20, 34, 28, 4, -34 },
  { 5737, 20, 34, 28, 5, -34 },
  { 5822, 17, 43, 28, 4, -34 },
  { 5914, 23, 34, 28, 4, -34 },
  { 6012, 21, 34, 28, 3, -34 },
  { 6102, 24, 24, 28, 2, -24 },
  { 6174, 20, 24, 28, 4, -24 },
  { 6234, 22, 25, 28, 3, -24 },
  { 6303, 21, 33, 28, 4, -24 },
  { 6390, 22, 33, 28, 2, -24 },
  { 6481, 23, 24, 28, 3, -24 },
  { 6550, 21, 25, 28, 3, -24 },
  { 6616, 22, 32, 28, 2, -32 },
  { 6704, 20, 25, 28, 4, -24 },
  { 6767, 23, 24, 28, 2, -24 },
  { 6836, 26, 24, 28, 1, -24 },
  { 6914, 24, 24, 28, 2, -24 },
  { 6986, 24, 33, 28, 2, -24 },
  { 7085, 20, 24, 28, 4, -24 },
  { 7145, 18, 41, 28, 5, -35 },
  { 7238, 4, 41, 28, 12, -35 },
  { 7259, 18, 41, 28, 5, -35 },
  { 7352, 24, 11, 28, 2, -19 },
};

const GFXfont IBMPlexMono_Medium46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_MEDIUM46PT7B_H_
