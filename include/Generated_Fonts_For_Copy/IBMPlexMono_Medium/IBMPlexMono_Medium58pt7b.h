#ifndef _IBMPLEXMONO_MEDIUM58PT7B_H_
#define _IBMPLEXMONO_MEDIUM58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium58pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xF0, 0x7F, 0xFC, 0xFF,
  0xF8, 0x3F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x80,
  0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x01,
  0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF8, 0x3F, 0xFE, 0x7F, 0xFC, 0x1F, 0xFF,
  0x3F, 0xFC, 0x0F, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0xF3, 0xFF, 0x1F, 0xC3, 0xC3, 0xF8, 0xFE,
  0x0F, 0x03, 0xC3, 0xF0, 0x3C, 0x06, 0x0F, 0xC0, 0xF0, 0x00, 0x3F, 0x03,
  0xC0, 0x00, 0xFC, 0x0F, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x3F, 0x83, 0xC0, 0x00, 0xFF, 0x0F, 0x00, 0x01, 0xFE, 0x3C, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0xF0, 0xFF, 0x00, 0x03,
  0xC1, 0xFC, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0xF0,
  0x3F, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x0F, 0x03, 0xF0, 0x80, 0x3C, 0x0F,
  0xC7, 0x00, 0xF0, 0x3F, 0x3F, 0x03, 0xC1, 0xFD, 0xFE, 0x0F, 0x0F, 0xEF,
  0xFE, 0x3C, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xCF, 0xFF, 0x80, 0x07, 0xC7, 0xFF, 0xE0,
  0x03, 0xE7, 0xFF, 0xF0, 0x03, 0xE3, 0xF0, 0xFC, 0x01, 0xF3, 0xE0, 0x3E,
  0x01, 0xF1, 0xF0, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0x80, 0xF8, 0x7C, 0x03,
  0xC0, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0xF0, 0x7E, 0x0F, 0x80,
  0x78, 0x3E, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xFC,
  0x3F, 0x1F, 0x00, 0x7F, 0xFF, 0x0F, 0x80, 0x1F, 0xFF, 0x8F, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0xFC, 0x7F, 0xFE, 0x00, 0x7C, 0x7F, 0xFF, 0x80, 0x7E, 0x3F, 0x0F,
  0xC0, 0x3E, 0x1F, 0x03, 0xE0, 0x3F, 0x0F, 0x00, 0xF8, 0x1F, 0x0F, 0x80,
  0x7C, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x81, 0xF0,
  0x0F, 0x87, 0xC0, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x03, 0xE3, 0xE0, 0x1F,
  0x03, 0xE3, 0xE0, 0x0F, 0xC3, 0xF3, 0xF0, 0x07, 0xFF, 0xF9, 0xF0, 0x01,
  0xFF, 0xF9, 0xF8, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x3C, 0x00,
  0x0F, 0xC0, 0x08, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFE,
  0x07, 0xFC, 0x7F, 0x3F, 0x83, 0xFE, 0x3F, 0x0F, 0xE1, 0xF0, 0x3F, 0x03,
  0xF0, 0xF8, 0x1F, 0x81, 0xFC, 0x78, 0x0F, 0xC0, 0x7F, 0x7C, 0x0F, 0xC0,
  0x1F, 0xFE, 0x07, 0xE0, 0x07, 0xFF, 0x03, 0xF0, 0x01, 0xFF, 0x01, 0xF8,
  0x00, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xFC, 0x0F, 0x3F, 0x81,
  0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0x81, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x20, 0x07, 0xC0, 0x18, 0xF8, 0x0F, 0x81, 0xF1, 0xFE, 0x1F, 0x1F,
  0xF3, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x41, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0x7F, 0xCF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x07, 0xF0, 0x7F, 0xF8, 0x3F, 0x83,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0x81, 0xF0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x81, 0xFE,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0xE0, 0x1F,
  0xC0, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x7F, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFE, 0x00, 0x7F, 0x83, 0xE0, 0x01,
  0xFE, 0x0E, 0x00, 0x07, 0xF0, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE1, 0x00, 0x00, 0x7F, 0x0C, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x3F, 0xDF,
  0x80, 0x01, 0xFD, 0xFF, 0x00, 0x1F, 0xE7, 0xFE, 0x03, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x3E, 0x1F, 0xFE, 0x01, 0xF1, 0xFF, 0xF8, 0x0F, 0x9F, 0xFF,
  0xE0, 0x7D, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x0F, 0xC1, 0x80, 0x00, 0xFE,
  0x1E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xF8, 0xFF,
  0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x1F, 0xFE, 0x03, 0xF9,
  0xFF, 0xFC, 0x1F, 0x9F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x8F, 0xFE, 0x03,
  0xFE, 0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFD,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xFE, 0x03, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC,
  0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xFC,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xDF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x03, 0xBF, 0x1F,
  0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0xDF, 0xC1, 0xFF, 0xFC, 0xFE, 0x03, 0xFF,
  0xC7, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0xCF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xF7, 0xFC, 0xFC, 0x0F, 0x83, 0xFE, 0x3F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xE7, 0xF0, 0x03, 0xF9, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x1F, 0xCF, 0x00, 0x07, 0xF0, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFE, 0x03,
  0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x01,
  0xF1, 0xF7, 0xC0, 0x7F, 0x9F, 0x7C, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x7F, 0xF8, 0x3F, 0x01, 0xFF, 0x83,
  0xE0, 0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x3E, 0x01,
  0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8,
  0x3E, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0x83, 0xE0,
  0x1F, 0xF8, 0x3F, 0x03, 0xFF, 0x81, 0xFC, 0xFF, 0x7C, 0x1F, 0xFF, 0xF7,
  0xC0, 0xFF, 0xDF, 0x7C, 0x0F, 0xF9, 0xF7, 0xC0, 0x7F, 0x9F, 0x7C, 0x00,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x01, 0xFE, 0x3F, 0x00, 0x1F,
  0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0xFE, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x01, 0xFE, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x70, 0xFE, 0x00, 0x04, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x08, 0x07, 0xE0, 0x00, 0x38,
  0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xF8, 0x03, 0xFE, 0x3F, 0x00, 0x1F,
  0xC7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xFB, 0xF0,
  0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xE3, 0xF0, 0x07, 0xFC, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0x87, 0xE0, 0x00,
  0x40, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7F,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF3, 0xFC, 0x01,
  0xFF, 0x1F, 0xF0, 0x3B, 0xF1, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xF3, 0xF0,
  0x7F, 0xFE, 0x3F, 0x01, 0xFF, 0xC3, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x60, 0x01, 0xFF, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x7F, 0x8F, 0xC0,
  0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xFC, 0x1F, 0x80, 0x3F,
  0xC0, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x01,
  0xF8, 0x1F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0x7E, 0x1F, 0xE0, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x07, 0xE7, 0xF8,
  0x00, 0x3F, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFC, 0x00, 0xFF,
  0x8F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x87, 0xE0, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x7E, 0x00,
  0x07, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xEF,
  0x83, 0xEF, 0xFF, 0x7C, 0x1F, 0x7F, 0xFB, 0xF1, 0xF3, 0xFF, 0xCF, 0x8F,
  0x9F, 0xFE, 0x7E, 0x7C, 0xFF, 0xF1, 0xF7, 0xC7, 0xFF, 0x8F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xE1, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0x7F, 0xF8,
  0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF0, 0x3E,
  0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x07, 0x01, 0xFF, 0xE0, 0x38, 0x0F,
  0xFF, 0x01, 0x80, 0x7F, 0xF8, 0x04, 0x03, 0xFF, 0xC0, 0x20, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xF7, 0xE0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0xCF, 0x80, 0x7F, 0xF9,
  0xF8, 0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0xE3, 0xF0, 0x3F, 0xFC, 0x7E, 0x07,
  0xFF, 0x87, 0xC0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC1,
  0xF0, 0x7F, 0xF8, 0x3F, 0x0F, 0xFF, 0x07, 0xE1, 0xFF, 0xE0, 0x7E, 0x3F,
  0xFC, 0x0F, 0xC7, 0xFF, 0x80, 0xF8, 0xFF, 0xF0, 0x1F, 0x9F, 0xFE, 0x03,
  0xF3, 0xFF, 0xC0, 0x3F, 0x7F, 0xF8, 0x07, 0xEF, 0xFF, 0x00, 0x7D, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xBF,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB,
  0xF0, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x1F,
  0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F,
  0xCF, 0xC0, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F,
  0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x78, 0x3F, 0x80, 0x00, 0xC0,
  0xFE, 0x00, 0x02, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x18, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x3F, 0xBF, 0xE0, 0x01, 0xFC, 0x7F, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x0F,
  0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x3E, 0x7E,
  0x07, 0xF0, 0x3E, 0x7E, 0x0F, 0xF8, 0x3E, 0x3E, 0x0F, 0xF8, 0x3E, 0x3E,
  0x0F, 0xF8, 0x3E, 0x3E, 0x0F, 0x78, 0x3E, 0x3E, 0x0F, 0x78, 0x3E, 0x3E,
  0x1F, 0x7C, 0x3E, 0x3E, 0x1F, 0x7C, 0x3E, 0x3E, 0x1E, 0x7C, 0x7E, 0x3F,
  0x1E, 0x3C, 0x7E, 0x3F, 0x1E, 0x3C, 0x7E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3F,
  0x3E, 0x3E, 0x7E, 0x3F, 0x3E, 0x3E, 0x7C, 0x3F, 0x3C, 0x3E, 0x7C, 0x1F,
  0x3C, 0x1E, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x9E, 0x00, 0x00, 0x3C, 0x08, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x07, 0x83, 0xF8,
  0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFC,
  0x00, 0xFE, 0x03, 0x80, 0x07, 0xF0, 0x0C, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F,
  0xE0, 0x3B, 0xFE, 0x7F, 0xFF, 0xDF, 0xF3, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF,
  0xC3, 0xFC, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x7F, 0xF0, 0x3F, 0x1F, 0xFF, 0x07,
  0xE7, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x1F, 0xF8, 0x1F, 0xF3, 0xFC, 0x01,
  0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xE0,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xF0, 0x3F, 0xE7, 0xEF, 0xFF, 0xF8,
  0xFC, 0xFF, 0xFE, 0x1F, 0x8F, 0xFF, 0x83, 0xF0, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x07, 0xF1, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x06, 0x0F, 0xE0, 0x01, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x01, 0xF8, 0x00, 0x38, 0x3F,
  0x80, 0x0F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x07, 0xFF,
  0x0F, 0xC3, 0xFF, 0xF1, 0xF8, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0xF7, 0xE7,
  0xFC, 0x0E, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xF8,
  0x1D, 0xF8, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xE7, 0xE1, 0xFF, 0xF8, 0xFC,
  0x0F, 0xFE, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0x03, 0xF0, 0x00, 0x18, 0x3F, 0x80, 0x03, 0xC1, 0xFC,
  0x00, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xCF,
  0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0xE0, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x07, 0xE1, 0xFF, 0xC3, 0xF1,
  0xFF, 0xF1, 0xF9, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0x7E, 0xE0, 0xFF, 0xBF,
  0xC0, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x0F,
  0xF0, 0xFC, 0x00, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x01,
  0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0x00, 0x7E, 0x0F, 0xF0, 0x03, 0xF0,
  0xFF, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0xFC, 0xFF, 0x00, 0x07, 0xEF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x7E, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x7F, 0xBF,
  0x00, 0x01, 0xFE, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x0F, 0xC7, 0xCF, 0xF0, 0xFF,
  0x3E, 0xFF, 0xCF, 0xFD, 0xF7, 0xFE, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0xF8, 0x0F,
  0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01,
  0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF,
  0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03,
  0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0,
  0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF,
  0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80,
  0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0xE0, 0x7E, 0x1F, 0xFC, 0x3F, 0x1F, 0xFF, 0x1F, 0x9F, 0xFF, 0xCF, 0xDF,
  0xFF, 0xF7, 0xEE, 0x0F, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x87,
  0xFF, 0x03, 0xF1, 0xFF, 0xF0, 0x7E, 0x7F, 0xFF, 0x0F, 0xDF, 0xFF, 0xF1,
  0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFF,
  0x03, 0xFE, 0x7E, 0xFF, 0xFF, 0x8F, 0xCF, 0xFF, 0xE1, 0xF8, 0xFF, 0xF8,
  0x3F, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0xFC, 0x3F, 0xFF, 0x1F, 0x8F, 0xFF, 0xF3, 0xF1, 0xFF,
  0xFF, 0x7E, 0x7F, 0xC0, 0xEF, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x03,
  0xFC, 0xFF, 0x81, 0xDF, 0x8F, 0xFF, 0xFB, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F,
  0xFF, 0x8F, 0xC0, 0xFF, 0xE1, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x0F, 0xEF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0x80, 0x07, 0xC3, 0xF8, 0x00, 0x38,
  0x3F, 0x00, 0x01, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF1, 0x80, 0x00, 0x7F, 0x3C, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0xFE, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0xEF, 0xDF, 0xFF,
  0xF7, 0xE7, 0xFF, 0xF3, 0xF1, 0xFF, 0xF1, 0xF8, 0x7F, 0xF0, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0x9F,
  0x01, 0xFC, 0x07, 0xCF, 0x80, 0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x01, 0xF3,
  0xE0, 0x7F, 0xC0, 0xF9, 0xF0, 0x3F, 0xE0, 0x7C, 0xF8, 0x1E, 0xF0, 0x3E,
  0x7E, 0x0F, 0x78, 0x3E, 0x3F, 0x07, 0xBC, 0x1F, 0x0F, 0x83, 0xDE, 0x0F,
  0x87, 0xC3, 0xCF, 0x87, 0xC3, 0xE1, 0xE3, 0xC3, 0xE1, 0xF0, 0xF1, 0xE1,
  0xF0, 0xF8, 0x78, 0xF0, 0xF8, 0x7C, 0x3C, 0x78, 0x7C, 0x3E, 0x3C, 0x3E,
  0x3C, 0x0F, 0x9E, 0x0F, 0x3E, 0x07, 0xCF, 0x07, 0x9F, 0x03, 0xE7, 0x83,
  0xCF, 0x81, 0xF3, 0xC1, 0xE7, 0xC0, 0xF9, 0xE0, 0xF3, 0xE0, 0x7D, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x07, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x7F, 0xC0, 0x07, 0xC7, 0xFF, 0x00,
  0x3E, 0x7F, 0xFC, 0x01, 0xF3, 0xFF, 0xF0, 0x1F, 0x3F, 0x1F, 0xC0, 0xF9,
  0xF0, 0x7F, 0x07, 0xCF, 0x81, 0xFC, 0x7C, 0xF8, 0x07, 0xFF, 0xE7, 0xC0,
  0x1F, 0xFE, 0x3E, 0x00, 0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0x03, 0x00, 0x07,
  0xE0, 0x00,
};

const GFXglyph IBMPlexMono_Medium58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 41, 35, 13, -40 },
  { 48, 17, 17, 35, 9, -43 },
  { 85, 33, 40, 35, 1, -40 },
  { 250, 30, 54, 35, 2, -47 },
  { 453, 33, 42, 35, 1, -41 },
  { 627, 33, 42, 35, 1, -41 },
  { 801, 6, 17, 35, 14, -43 },
  { 814, 19, 52, 35, 11, -44 },
  { 938, 19, 52, 35, 5, -44 },
  { 1062, 31, 29, 35, 2, -32 },
  { 1175, 27, 29, 35, 4, -32 },
  { 1273, 12, 17, 35, 11, -9 },
  { 1299, 17, 6, 35, 9, -21 },
  { 1312, 10, 10, 35, 12, -9 },
  { 1325, 25, 52, 35, 5, -44 },
  { 1488, 29, 42, 35, 3, -41 },
  { 1641, 30, 40, 35, 3, -40 },
  { 1791, 29, 41, 35, 3, -41 },
  { 1940, 29, 42, 35, 2, -41 },
  { 2093, 31, 40, 35, 2, -40 },
  { 2248, 29, 41, 35, 3, -40 },
  { 2397, 29, 41, 35, 3, -40 },
  { 2546, 28, 40, 35, 3, -40 },
  { 2686, 29, 42, 35, 3, -41 },
  { 2839, 29, 41, 35, 3, -41 },
  { 2988, 10, 32, 35, 12, -31 },
  { 3028, 12, 39, 35, 11, -31 },
  { 3087, 25, 34, 35, 5, -35 },
  { 3194, 27, 17, 35, 4, -26 },
  { 3252, 25, 34, 35, 5, -35 },
  { 3359, 26, 42, 35, 4, -41 },
  { 3496, 28, 48, 35, 3, -41 },
  { 3664, 33, 40, 35, 1, -40 },
  { 3829, 27, 40, 35, 5, -40 },
  { 3964, 29, 42, 35, 3, -41 },
  { 4117, 27, 40, 35, 5, -40 },
  { 4252, 25, 40, 35, 5, -40 },
  { 4377, 26, 40, 35, 5, -40 },
  { 4507, 28, 42, 35, 3, -41 },
  { 4654, 27, 40, 35, 4, -40 },
  { 4789, 25, 40, 35, 5, -40 },
  { 4914, 26, 41, 35, 3, -40 },
  { 5048, 29, 40, 35, 5, -40 },
  { 5193, 25, 40, 35, 6, -40 },
  { 5318, 29, 40, 35, 3, -40 },
  { 5463, 27, 40, 35, 4, -40 },
  { 5598, 29, 42, 35, 3, -41 },
  { 5751, 27, 40, 35, 5, -40 },
  { 5886, 29, 51, 35, 3, -41 },
  { 6071, 27, 40, 35, 5, -40 },
  { 6206, 30, 42, 35, 2, -41 },
  { 6364, 32, 40, 35, 1, -40 },
  { 6524, 27, 41, 35, 4, -40 },
  { 6663, 32, 40, 35, 1, -40 },
  { 6823, 32, 40, 35, 1, -40 },
  { 6983, 33, 40, 35, 1, -40 },
  { 7148, 33, 40, 35, 1, -40 },
  { 7313, 29, 40, 35, 3, -40 },
  { 7458, 17, 52, 35, 12, -44 },
  { 7569, 25, 52, 35, 5, -44 },
  { 7732, 18, 52, 35, 5, -44 },
  { 7849, 31, 25, 35, 2, -40 },
  { 7946, 28, 5, 35, 3, 5 },
  { 7964, 11, 12, 35, 10, -46 },
  { 7981, 29, 32, 35, 3, -31 },
  { 8097, 27, 44, 35, 5, -43 },
  { 8246, 27, 32, 35, 4, -31 },
  { 8354, 27, 44, 35, 3, -43 },
  { 8503, 28, 32, 35, 3, -31 },
  { 8615, 28, 43, 35, 4, -43 },
  { 8766, 30, 47, 35, 3, -35 },
  { 8943, 25, 43, 35, 5, -43 },
  { 9078, 26, 43, 35, 6, -43 },
  { 9218, 21, 55, 35, 5, -43 },
  { 9363, 29, 43, 35, 5, -43 },
  { 9519, 27, 43, 35, 4, -43 },
  { 9665, 29, 31, 35, 3, -31 },
  { 9778, 25, 31, 35, 5, -31 },
  { 9875, 29, 32, 35, 3, -31 },
  { 9991, 27, 43, 35, 5, -31 },
  { 10137, 27, 43, 35, 3, -31 },
  { 10283, 28, 30, 35, 4, -30 },
  { 10388, 28, 32, 35, 3, -31 },
  { 10500, 29, 40, 35, 2, -40 },
  { 10645, 25, 31, 35, 5, -30 },
  { 10742, 29, 30, 35, 3, -30 },
  { 10851, 33, 30, 35, 1, -30 },
  { 10975, 29, 30, 35, 3, -30 },
  { 11084, 31, 42, 35, 2, -30 },
  { 11247, 26, 30, 35, 4, -30 },
  { 11345, 23, 52, 35, 6, -44 },
  { 11495, 5, 52, 35, 15, -44 },
  { 11528, 23, 52, 35, 6, -44 },
  { 11678, 29, 13, 35, 3, -24 },
};

const GFXfont IBMPlexMono_Medium58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_MEDIUM58PT7B_H_
