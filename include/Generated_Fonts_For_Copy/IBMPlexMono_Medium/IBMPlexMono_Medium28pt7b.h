#ifndef _IBMPLEXMONO_MEDIUM28PT7B_H_
#define _IBMPLEXMONO_MEDIUM28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium28pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x08, 0x40, 0x00, 0x0E, 0xFF,
  0xFE, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x03,
  0x9C, 0x03, 0x9C, 0x03, 0x1C, 0x03, 0x18, 0x07, 0x18, 0x07, 0x18, 0x7F,
  0x3F, 0x7E, 0x3F, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0xFE,
  0x7E, 0xFC, 0x7E, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x1C,
  0xE0, 0x18, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x7F, 0x01, 0xFF,
  0x87, 0xFF, 0x9E, 0x6F, 0x38, 0xC4, 0x71, 0x80, 0xE3, 0x01, 0xE6, 0x01,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xCE, 0x01, 0x8E, 0x83,
  0x1D, 0x86, 0x7F, 0xCD, 0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x03, 0x7F, 0x07, 0x63, 0x86, 0x63, 0x8E,
  0xE1, 0x8C, 0xE1, 0x9C, 0x63, 0x98, 0x63, 0xB8, 0x7F, 0x30, 0x1E, 0x00,
  0x00, 0x3C, 0x0E, 0x7E, 0x0C, 0xE7, 0x1C, 0xC3, 0x1C, 0xC3, 0x38, 0xC3,
  0x38, 0xC3, 0x30, 0xE7, 0x70, 0x7E, 0xE0, 0x3C, 0x0F, 0x80, 0x3F, 0xC0,
  0xE3, 0x83, 0x82, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x3D, 0xF8, 0xFF, 0x39, 0xCE, 0x3B, 0x9C, 0x3E, 0x38, 0x3C,
  0x70, 0x78, 0xE0, 0xF9, 0xE3, 0x71, 0xFE, 0x71, 0xF0, 0x70, 0xFF, 0xFF,
  0xFF, 0x03, 0x83, 0x03, 0x83, 0x83, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x30,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E,
  0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07,
  0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x06, 0x38, 0xDF, 0xFF, 0x9F, 0xFF, 0x87, 0xF0, 0x07, 0xC0,
  0x1F, 0xC0, 0x7B, 0x80, 0xE3, 0x83, 0x83, 0x82, 0x04, 0x00, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0xF7, 0x9E,
  0x71, 0xC6, 0x38, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x03, 0xCE, 0x03,
  0xBC, 0x07, 0x70, 0x0E, 0xE3, 0x9D, 0xC7, 0x3F, 0x8E, 0x7F, 0x1C, 0xFE,
  0x01, 0xDE, 0x03, 0x9C, 0x07, 0x38, 0x1E, 0x78, 0x78, 0x7F, 0xF0, 0x7F,
  0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xEE, 0x07, 0x9C,
  0x1E, 0x38, 0x18, 0x70, 0x20, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xE1, 0xEE,
  0x07, 0x20, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x30, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x07, 0xF0, 0x1F, 0x00, 0x7F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x76, 0x01, 0xD8, 0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x03,
  0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x00, 0xCE,
  0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0, 0xE1, 0xC3, 0x83, 0x8E,
  0x07, 0x1C, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE7, 0xC7, 0x7F, 0xBC, 0x3C, 0x40, 0x70, 0x03,
  0x80, 0x1D, 0x00, 0xFC, 0x07, 0xF0, 0x7B, 0xFF, 0x8F, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x73, 0xE1, 0xDF, 0xE7, 0x87, 0xFC, 0x07, 0xF0, 0x1D, 0xC0,
  0x77, 0x01, 0xDC, 0x07, 0x70, 0x1C, 0xE0, 0xE1, 0xFF, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0x60, 0x3B, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0x0F, 0xE0, 0xFF, 0xC3,
  0x87, 0x9C, 0x0F, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x38, 0x78,
  0x3F, 0x81, 0xFF, 0x1E, 0x0E, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0x70, 0x1D, 0xE0, 0xF3, 0xFF, 0x83, 0xF8, 0x0F, 0xC0, 0x7F, 0xC3, 0x87,
  0x9C, 0x0E, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xE1,
  0xF3, 0xFD, 0xC3, 0xEF, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00,
  0x1D, 0xFF, 0xFD, 0xC0, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x3D, 0xE7, 0x9C, 0x71, 0x8E, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0,
  0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x70, 0x1F, 0x07,
  0xC1, 0xF8, 0x7E, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x0F, 0x83, 0xFE, 0x7F,
  0xFF, 0x0F, 0xE0, 0x72, 0x07, 0x00, 0x70, 0x0F, 0x0F, 0xE0, 0xF8, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x8C, 0x06, 0x70, 0x1D, 0x80,
  0x76, 0x1C, 0xD8, 0xFB, 0x67, 0x1F, 0x9C, 0x3E, 0x70, 0xF9, 0xC3, 0xE7,
  0x0F, 0x9C, 0x36, 0x71, 0xD8, 0xFB, 0x61, 0xED, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0xE1, 0xE1, 0xC1, 0xC3, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0x38,
  0x0E, 0x70, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x70, 0xFF, 0xC7, 0xFF,
  0x3F, 0xFD, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x0E, 0xFF, 0xC7,
  0xFF, 0x38, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0xFF, 0xBF, 0xFD, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0,
  0xFF, 0x03, 0xF0, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xFE, 0x07, 0x78, 0x7B, 0xFF, 0x8F,
  0xF8, 0x1F, 0x80, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F,
  0x1E, 0x78, 0x3D, 0xC0, 0x67, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x1F, 0xFC, 0x7F, 0xF0, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x78, 0x3C,
  0xF1, 0xF1, 0xFD, 0xC3, 0xE7, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x60, 0x7E, 0x0F, 0xF0,
  0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0x38, 0x3C,
  0xE1, 0xE3, 0x8F, 0x0E, 0x38, 0x39, 0xE0, 0xEF, 0x03, 0xFC, 0x0F, 0xF8,
  0x3E, 0xF0, 0xF1, 0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x3C, 0xE0, 0x73, 0x80,
  0xEE, 0x03, 0xF8, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xF1, 0xFD, 0x8D, 0xEC, 0x6F, 0x77, 0xF9, 0xB7, 0xCF,
  0xBE, 0x79, 0xF1, 0xCF, 0x8E, 0x7C, 0x63, 0xE1, 0x1F, 0x08, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x70, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xB0, 0xFD, 0xC7, 0xEE, 0x3F, 0x39, 0xF9,
  0xCF, 0xC6, 0x7E, 0x3B, 0xF1, 0xDF, 0x86, 0xFC, 0x3F, 0xE1, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7,
  0x03, 0xCE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xDE, 0x03, 0x9C, 0x07, 0x38, 0x1E, 0x78, 0x78,
  0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0xC0,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0x8E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x03,
  0xCE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xDE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38, 0x70,
  0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFE, 0x00, 0xFC,
  0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03,
  0xB8, 0x0E, 0xE0, 0x7B, 0xFF, 0xCF, 0xFC, 0x38, 0xF0, 0xE1, 0xC3, 0x87,
  0x8E, 0x0E, 0x38, 0x38, 0xE0, 0x73, 0x81, 0xCE, 0x03, 0xB8, 0x0F, 0x0F,
  0xE0, 0x7F, 0xE3, 0xFF, 0xDE, 0x0F, 0x70, 0x19, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x1C, 0x00, 0x74,
  0x01, 0xD8, 0x07, 0xF8, 0x3D, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xF0, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xE0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9E, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x78, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x71, 0xF8, 0xE3,
  0xF3, 0xC7, 0xE7, 0xCF, 0xCD, 0x9B, 0x9B, 0x33, 0x36, 0x66, 0xEC, 0xCD,
  0x9D, 0x9B, 0x1B, 0x36, 0x3E, 0x6C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3,
  0xE0, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7, 0x03, 0x8E,
  0x03, 0xB8, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xEE, 0x03, 0xDE, 0x07, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0xE0, 0x7B, 0xC0,
  0x77, 0x00, 0xF0, 0xF0, 0x07, 0x78, 0x0F, 0x38, 0x0E, 0x3C, 0x1E, 0x1C,
  0x1C, 0x1E, 0x3C, 0x0E, 0x38, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x30, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x07, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x77, 0x01, 0xCE, 0x03, 0x8E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x70, 0x38, 0xE0, 0x3B, 0x80, 0x7B, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x27, 0x1C, 0xE3, 0x88, 0x1F, 0x81, 0xFF, 0x8F, 0x0E, 0x10,
  0x1C, 0x00, 0x70, 0x01, 0xC3, 0xFF, 0x1F, 0xFC, 0xE0, 0x73, 0x81, 0xCE,
  0x07, 0x38, 0x3C, 0x7F, 0xFC, 0xF8, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x78, 0xEF, 0xF7, 0x43, 0xBC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81,
  0xFA, 0x1D, 0xDF, 0xEE, 0x3C, 0x00, 0x0F, 0xC1, 0xFF, 0x9E, 0x1C, 0xE0,
  0x5E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x0C,
  0xF0, 0xF3, 0xFF, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0xC7, 0x3F, 0xDD, 0xE1, 0x77, 0x03,
  0xDC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x1D, 0xC0,
  0xF7, 0x85, 0xCF, 0xF7, 0x0F, 0x1C, 0x0F, 0x81, 0xFF, 0x1E, 0x3D, 0xC0,
  0xEE, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x38, 0x08,
  0xF0, 0xF3, 0xFF, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0xC1, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x01, 0xF1, 0xFC, 0x0F, 0xF8, 0x70,
  0xF1, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0x70, 0x71, 0xC3, 0x83, 0xFE, 0x0F,
  0xE0, 0x60, 0x01, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x7F, 0xFF, 0x80, 0x7C,
  0x01, 0xF8, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x78, 0xEF, 0xE7, 0x47, 0xBC,
  0x1D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xBF, 0xEF, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x1F, 0xF0, 0xF3, 0xC7, 0x8F, 0x3C, 0x3D, 0xE0, 0xFF, 0x03, 0xFE,
  0x0F, 0xB8, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF, 0x07, 0x3C, 0x1E, 0xF0,
  0x3C, 0xFF, 0x07, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0x80,
  0xEE, 0x39, 0xDE, 0xFB, 0xCE, 0x77, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8,
  0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38,
  0xFC, 0x71, 0xC0, 0xE3, 0xC7, 0x7F, 0x3A, 0x3D, 0xE0, 0xEE, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1C, 0x0F, 0x81, 0xFF, 0x1C, 0x3D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1E, 0xE1, 0xE3, 0xFE, 0x0F,
  0xC0, 0xE3, 0xC7, 0x7F, 0xBA, 0x1D, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xD0, 0xEE, 0xFF, 0x71, 0xE3,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0F, 0x1C,
  0xFF, 0x77, 0x85, 0xDC, 0x0F, 0x70, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1D, 0xC0, 0x77, 0x03, 0xDE, 0x17, 0x3F, 0xDC, 0x3C, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFE, 0x3F, 0xFB,
  0xF0, 0xEF, 0xC3, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xC1,
  0xFF, 0x9C, 0x1F, 0xE0, 0x4F, 0x00, 0x3C, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x78, 0x01, 0xD0, 0x0F, 0xE0, 0xE7, 0xFF, 0x0F, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x77, 0x0F, 0x7F, 0x71, 0xE7, 0xF0, 0x1D, 0xC0, 0x77, 0x01, 0xCE, 0x0E,
  0x38, 0x38, 0xE0, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x3B, 0x80, 0xEE,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x3F,
  0x36, 0x7E, 0x6C, 0xFC, 0xD9, 0xB9, 0xB3, 0x33, 0x66, 0x6C, 0xCC, 0xD8,
  0xD9, 0xB1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x0F, 0x00, 0xF0, 0x1C, 0x70,
  0x70, 0xF1, 0xC0, 0xF3, 0x80, 0xEE, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1D, 0xC0, 0x73, 0xC1, 0xC3, 0xC7, 0x83, 0x9E, 0x03, 0xC0,
  0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0x71, 0xC1, 0xC3, 0x83, 0x87, 0x06, 0x07,
  0x1C, 0x0E, 0x38, 0x0C, 0xE0, 0x1D, 0xC0, 0x3B, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xE3, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x60, 0x1C, 0x7F, 0x0F, 0xC0, 0x0E, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x00,
  0x70, 0x07, 0xF0, 0xFE, 0x38, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC7, 0xF0, 0xFE, 0x00, 0x1C, 0x0E, 0x7E,
  0x19, 0xCC, 0x33, 0x1C, 0xEE, 0x1F, 0x9C, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_Medium28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 9, 8, 17, 4, -21 },
  { 23, 16, 20, 17, 0, -20 },
  { 63, 15, 26, 17, 1, -23 },
  { 112, 16, 20, 17, 0, -20 },
  { 152, 15, 20, 17, 1, -20 },
  { 190, 3, 8, 17, 7, -21 },
  { 193, 9, 25, 17, 5, -21 },
  { 222, 8, 25, 17, 3, -21 },
  { 247, 15, 14, 17, 1, -15 },
  { 274, 13, 14, 17, 2, -16 },
  { 297, 6, 8, 17, 5, -4 },
  { 303, 9, 3, 17, 4, -10 },
  { 307, 5, 5, 17, 6, -5 },
  { 311, 12, 25, 17, 2, -21 },
  { 349, 15, 20, 17, 1, -20 },
  { 387, 15, 20, 17, 1, -20 },
  { 425, 13, 20, 17, 2, -20 },
  { 458, 14, 20, 17, 1, -20 },
  { 493, 15, 20, 17, 1, -20 },
  { 531, 13, 20, 17, 2, -20 },
  { 564, 14, 20, 17, 1, -20 },
  { 599, 13, 20, 17, 2, -20 },
  { 632, 14, 20, 17, 1, -20 },
  { 667, 14, 20, 17, 1, -20 },
  { 702, 5, 15, 17, 6, -15 },
  { 712, 6, 19, 17, 5, -15 },
  { 727, 12, 16, 17, 2, -17 },
  { 751, 13, 8, 17, 2, -13 },
  { 764, 12, 16, 17, 2, -17 },
  { 788, 12, 20, 17, 2, -20 },
  { 818, 14, 23, 17, 1, -20 },
  { 859, 15, 20, 17, 1, -20 },
  { 897, 13, 20, 17, 2, -20 },
  { 930, 13, 20, 17, 2, -20 },
  { 963, 13, 20, 17, 2, -20 },
  { 996, 13, 20, 17, 2, -20 },
  { 1029, 13, 20, 17, 2, -20 },
  { 1062, 14, 20, 17, 1, -20 },
  { 1097, 13, 20, 17, 2, -20 },
  { 1130, 13, 20, 17, 2, -20 },
  { 1163, 12, 20, 17, 2, -20 },
  { 1193, 14, 20, 17, 2, -20 },
  { 1228, 12, 20, 17, 3, -20 },
  { 1258, 13, 20, 17, 2, -20 },
  { 1291, 13, 20, 17, 2, -20 },
  { 1324, 15, 20, 17, 1, -20 },
  { 1362, 13, 20, 17, 2, -20 },
  { 1395, 15, 24, 17, 1, -20 },
  { 1440, 14, 20, 17, 2, -20 },
  { 1475, 14, 20, 17, 1, -20 },
  { 1510, 15, 20, 17, 1, -20 },
  { 1548, 13, 20, 17, 2, -20 },
  { 1581, 15, 20, 17, 1, -20 },
  { 1619, 15, 20, 17, 1, -20 },
  { 1657, 15, 20, 17, 1, -20 },
  { 1695, 16, 20, 17, 0, -20 },
  { 1735, 14, 20, 17, 1, -20 },
  { 1770, 8, 25, 17, 6, -21 },
  { 1795, 12, 25, 17, 2, -21 },
  { 1833, 8, 25, 17, 3, -21 },
  { 1858, 15, 12, 17, 1, -20 },
  { 1881, 13, 3, 17, 2, 2 },
  { 1886, 5, 6, 17, 5, -22 },
  { 1890, 14, 14, 17, 2, -14 },
  { 1915, 13, 21, 17, 2, -21 },
  { 1950, 13, 14, 17, 2, -14 },
  { 1973, 14, 21, 17, 1, -21 },
  { 2010, 13, 14, 17, 2, -14 },
  { 2033, 13, 21, 17, 2, -21 },
  { 2068, 14, 22, 17, 2, -16 },
  { 2107, 13, 21, 17, 2, -21 },
  { 2142, 12, 21, 17, 3, -21 },
  { 2174, 10, 27, 17, 3, -21 },
  { 2208, 14, 21, 17, 2, -21 },
  { 2245, 13, 21, 17, 2, -21 },
  { 2280, 15, 14, 17, 1, -14 },
  { 2307, 13, 14, 17, 2, -14 },
  { 2330, 13, 14, 17, 2, -14 },
  { 2353, 13, 20, 17, 2, -14 },
  { 2386, 14, 20, 17, 1, -14 },
  { 2421, 14, 14, 17, 2, -14 },
  { 2446, 13, 14, 17, 2, -14 },
  { 2469, 14, 20, 17, 1, -20 },
  { 2504, 12, 14, 17, 2, -14 },
  { 2525, 14, 14, 17, 1, -14 },
  { 2550, 15, 14, 17, 1, -14 },
  { 2577, 15, 14, 17, 1, -14 },
  { 2604, 15, 20, 17, 1, -14 },
  { 2642, 13, 14, 17, 2, -14 },
  { 2665, 11, 25, 17, 3, -21 },
  { 2700, 3, 25, 17, 7, -21 },
  { 2710, 11, 25, 17, 3, -21 },
  { 2745, 15, 6, 17, 1, -12 },
};

const GFXfont IBMPlexMono_Medium28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_MEDIUM28PT7B_H_
