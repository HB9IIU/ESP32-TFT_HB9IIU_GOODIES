#ifndef _IBMPLEXMONO_MEDIUM45PT7B_H_
#define _IBMPLEXMONO_MEDIUM45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x80, 0x00, 0x00, 0x00, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x3F, 0xF0, 0x7F, 0xDF, 0xF8,
  0x3F, 0xEF, 0xFC, 0x3F, 0xF7, 0xFE, 0x1F, 0xF8, 0x0F, 0x0F, 0x00, 0x0F,
  0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x3F,
  0xF0, 0xFF, 0xDF, 0xF8, 0x7F, 0xEF, 0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0xF8,
  0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7E, 0x7B, 0xFC, 0xF8, 0xF1, 0xF3,
  0xE1, 0xE0, 0x87, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3C, 0xFC, 0x00, 0x78, 0xFC, 0x00, 0xF0, 0xF8, 0x01, 0xE1,
  0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0xC4, 0x0F, 0x0F, 0xBC, 0x1E, 0x1F,
  0xFC, 0x3C, 0x7D, 0xFE, 0x7B, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x7C, 0xFF, 0xE0, 0x0F, 0x1F, 0xFC, 0x03, 0xC7, 0xC7, 0xC0,
  0x78, 0xF0, 0x78, 0x1E, 0x1C, 0x07, 0x03, 0xC3, 0x80, 0xE0, 0xF0, 0x70,
  0x1C, 0x1E, 0x0E, 0x03, 0x87, 0x81, 0xE0, 0xF0, 0xF0, 0x3E, 0x3E, 0x3C,
  0x03, 0xFF, 0x87, 0x80, 0x7F, 0xF1, 0xE0, 0x07, 0xFC, 0x3C, 0x00, 0x3E,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC7, 0xFC,
  0x00, 0xF1, 0xFF, 0xC0, 0x3C, 0x3F, 0xF8, 0x07, 0x8F, 0x8F, 0x81, 0xE1,
  0xE0, 0xF0, 0x3C, 0x38, 0x0E, 0x0F, 0x07, 0x01, 0xC1, 0xE0, 0xE0, 0x38,
  0x78, 0x1C, 0x07, 0x0F, 0x03, 0xC1, 0xE3, 0xC0, 0x7C, 0x7C, 0x78, 0x0F,
  0xFF, 0x1E, 0x00, 0xFF, 0xE3, 0xC0, 0x0F, 0xF8, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x06, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0x1F, 0xF0, 0x7F, 0x9F, 0xFC, 0x3F, 0xDF, 0xBF, 0x1F, 0xEF,
  0x8F, 0x8F, 0x0F, 0x83, 0xE7, 0x87, 0xC0, 0xFB, 0xC3, 0xE0, 0x7F, 0xE1,
  0xF0, 0x1F, 0xE0, 0xF8, 0x07, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x80, 0x7F, 0x07, 0xE0, 0xF7, 0xC3, 0xFF, 0xF3, 0xF0, 0xFF, 0xF8,
  0xFC, 0x3F, 0xF8, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x10, 0x1F, 0x01, 0x3C, 0x3E, 0x1E,
  0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x07,
  0xEF, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3,
  0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8,
  0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x07, 0x07, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F,
  0xF0, 0xF8, 0x7F, 0xE0, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0,
  0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0x80, 0xFC, 0x1F, 0x00,
  0xF0, 0x3E, 0x00, 0xC0, 0x7C, 0x01, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0x08, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F,
  0x07, 0xF0, 0xF0, 0x07, 0xE1, 0x80, 0x0F, 0x82, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0xC0, 0x03, 0xF7,
  0x80, 0x0F, 0xFF, 0x00, 0x7E, 0xFF, 0x03, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1F, 0x00,
  0x3C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x7E, 0x01, 0xE7, 0xFF, 0x07, 0xBF,
  0xFE, 0x1E, 0xFF, 0xFC, 0x7F, 0x07, 0xF1, 0xF0, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x30, 0x00, 0xF9, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x81,
  0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE3,
  0xF8, 0x0F, 0x9F, 0xFC, 0x1F, 0x7F, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x83,
  0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x03, 0xF7, 0x80, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x8F, 0xC0, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x7E, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFC, 0x07,
  0xE3, 0xF0, 0x07, 0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB,
  0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x3F,
  0x3F, 0xC1, 0xFE, 0x3F, 0xFF, 0x7C, 0x3F, 0xFC, 0xF8, 0x3F, 0xF3, 0xF0,
  0x1F, 0xC7, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x3E, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8,
  0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0x07, 0xE7, 0xC0, 0x3F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x10, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x81, 0xF8,
  0xF8, 0x03, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0,
  0x7C, 0xF7, 0x83, 0xFB, 0xDE, 0x1F, 0xFF, 0x78, 0x7F, 0xFD, 0xC3, 0xE1,
  0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF,
  0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F,
  0x03, 0xDC, 0x3E, 0x0F, 0x78, 0x7F, 0xFD, 0xE1, 0xFF, 0xF7, 0x83, 0xFB,
  0xDE, 0x07, 0xCF, 0x78, 0x04, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0x80, 0xFE, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x7C, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xC0, 0x3F, 0x3E, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x01, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0x83, 0xF0, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x00,
  0x1F, 0x7C, 0x00, 0x63, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x61,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x83, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x81, 0xFC, 0x7C,
  0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x03, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF8, 0xFC, 0x07,
  0xE3, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x61, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x83, 0xFC, 0x7F, 0xFD, 0xF0, 0xFF, 0xF7, 0xC1, 0xFF, 0x9F,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBF, 0x07, 0xE7, 0xFF, 0xFC,
  0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0xF8, 0x00, 0xFD, 0xF0, 0x03,
  0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xF8,
  0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03,
  0xE3, 0xF0, 0x07, 0xCF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0xF8, 0x03, 0xF9,
  0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0xBE, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xF7, 0x8F, 0x7F, 0xBC, 0x7B, 0xFC, 0xF3, 0x9F, 0xE7, 0xBC, 0xFF, 0x3F,
  0xE7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F,
  0x87, 0xC3, 0xFC, 0x1C, 0x1F, 0xE0, 0xE0, 0xFF, 0x02, 0x07, 0xF8, 0x10,
  0x3F, 0xC0, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFB, 0xC0,
  0xFF, 0xDE, 0x07, 0xFE, 0xF8, 0x3F, 0xF3, 0xC1, 0xFF, 0x9F, 0x0F, 0xFC,
  0xF8, 0x7F, 0xE3, 0xC3, 0xFF, 0x1F, 0x1F, 0xF8, 0x78, 0xFF, 0xC3, 0xE7,
  0xFE, 0x1F, 0x3F, 0xF0, 0x79, 0xFF, 0x83, 0xEF, 0xFC, 0x0F, 0x7F, 0xE0,
  0x7B, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8,
  0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x1F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0x07, 0xC0,
  0x3F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xDF,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xF8,
  0x07, 0xE1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0x80, 0x7F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x03, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE3, 0xF8, 0x1F, 0xC7, 0xC0, 0x0F, 0x1F, 0x80, 0x0C, 0x3E, 0x00, 0x10,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x60, 0x00, 0xF9, 0xE0, 0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xF0, 0x3F,
  0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0x78, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xFE, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0xC0, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0xF0, 0x7C, 0x1E, 0x78, 0x3E, 0x0F, 0x3C, 0x1F, 0x87, 0x9E, 0x1F, 0xC3,
  0xCF, 0x0F, 0xE1, 0xE7, 0x87, 0xF0, 0xF3, 0xC3, 0xB8, 0x79, 0xE1, 0xDC,
  0x3C, 0xF9, 0xEF, 0x1E, 0x7C, 0xF7, 0x8F, 0x3E, 0x71, 0xCF, 0x9F, 0x38,
  0xE7, 0xC7, 0x9C, 0x73, 0xC3, 0xCE, 0x3D, 0xE1, 0xEF, 0x1E, 0xF0, 0xF7,
  0x8F, 0x78, 0x7B, 0x83, 0xBC, 0x3D, 0xC1, 0xDE, 0x1E, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x03,
  0xE0, 0x0F, 0x83, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x1F, 0x80,
  0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0xC0, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x10, 0x30, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x04, 0x03, 0xFC,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7C, 0x0F, 0xC3,
  0xE0, 0x1F, 0x83, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x0D, 0xFF, 0xFF, 0xF7, 0xF7, 0xFF,
  0x8F, 0xCF, 0xFC, 0x1F, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x83, 0xF0, 0x3C, 0x7F, 0xE1,
  0xE7, 0xFF, 0x8F, 0x7F, 0xFE, 0x7B, 0x07, 0xF3, 0xF0, 0x0F, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0xC0, 0x3F, 0x7B,
  0x07, 0xF3, 0xDF, 0xFF, 0x9E, 0x7F, 0xF8, 0xF1, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF8, 0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x03, 0x0F, 0x80, 0x10, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x04,
  0x1F, 0x00, 0x38, 0x7C, 0x01, 0xF3, 0xF8, 0x3F, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x83, 0xC3, 0xFF, 0x1E,
  0x3F, 0xFC, 0xF3, 0xFF, 0xF7, 0x9F, 0xC1, 0xBD, 0xF8, 0x07, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x9F,
  0xC1, 0xBC, 0xFF, 0xFD, 0xE3, 0xFF, 0xCF, 0x0F, 0xFC, 0x78, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF0, 0x7E, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x02,
  0x1F, 0x00, 0x18, 0xFC, 0x01, 0xE3, 0xF0, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xEF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0x83,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x1F, 0x83, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF1, 0xC0, 0x03, 0xE7, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0xFD, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x0F,
  0xC3, 0xE7, 0xFC, 0x7D, 0xFF, 0xCF, 0xBF, 0xFD, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x1F, 0xBE, 0x00, 0xFC, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3E,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xE7, 0xC0, 0x3F, 0x1F,
  0x80, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0,
  0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8,
  0x00, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0xF1, 0xE7, 0xE3, 0xFB, 0xDF,
  0xEF, 0xF7, 0xBF, 0xFF, 0xFF, 0x8F, 0xE3, 0xFE, 0x0F, 0x87, 0xFC, 0x1F,
  0x07, 0xF8, 0x3E, 0x0F, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0,
  0x7F, 0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07,
  0xF8, 0x3E, 0x0F, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x7F,
  0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8,
  0x3E, 0x0F, 0x00, 0x7E, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xEF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8,
  0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1, 0xF8, 0x3F, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x07, 0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0x60, 0xFE,
  0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x7D, 0xF8, 0x07, 0xEF, 0x60, 0xFE, 0x7B, 0xFF, 0xF3, 0xCF, 0xFF, 0x1E,
  0x3F, 0xF0, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE3, 0xC7, 0xFF, 0x9E, 0x7F, 0xFE,
  0xF3, 0xF8, 0x37, 0xBF, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0,
  0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x03, 0xF3, 0xF8, 0x37, 0x9F, 0xFF, 0xBC,
  0x7F, 0xF9, 0xE1, 0xFF, 0x8F, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF9, 0xFF, 0x01, 0xE6, 0x00, 0x07, 0xA0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xF0, 0x3F, 0x3E, 0x00,
  0x71, 0xF0, 0x01, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xCC, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0xE0, 0x3F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xF7, 0xFF, 0xBE, 0x7F, 0xF7, 0xC7, 0xFC, 0xF8,
  0x7E, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x78, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xE3, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x3E, 0x07,
  0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xE0, 0xF7, 0x87, 0xF0,
  0x73, 0xC3, 0xB8, 0x79, 0xE1, 0xDC, 0x3C, 0xF0, 0xEE, 0x1E, 0x78, 0x77,
  0x8F, 0x3C, 0x7B, 0xC7, 0x9E, 0x38, 0xE3, 0xC7, 0x1C, 0x71, 0xC3, 0xCE,
  0x38, 0xE1, 0xE7, 0x1C, 0xF0, 0xF3, 0x8F, 0x78, 0x7B, 0xC3, 0xBC, 0x3D,
  0xC1, 0xDE, 0x1E, 0xE0, 0xEF, 0x0F, 0x70, 0x77, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x3E, 0x01,
  0xF8, 0xFC, 0x01, 0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0xBF, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x01,
  0xF3, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF8, 0x00, 0xF1, 0xE0, 0x01,
  0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0x07, 0x80, 0x1C, 0x3F, 0xC0, 0x3C, 0x7F, 0xC0, 0x79, 0xFF, 0x80, 0xE7,
  0xCF, 0x83, 0xCF, 0x0F, 0x87, 0x9E, 0x0F, 0x9F, 0x38, 0x0F, 0xFC, 0xF0,
  0x1F, 0xF1, 0xE0, 0x1F, 0xE1, 0xC0, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_Medium45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 31, 27, 10, -31 },
  { 29, 13, 13, 27, 7, -33 },
  { 51, 25, 31, 27, 1, -31 },
  { 148, 23, 43, 27, 2, -37 },
  { 272, 27, 33, 27, 0, -32 },
  { 384, 25, 33, 27, 1, -32 },
  { 488, 5, 13, 27, 11, -33 },
  { 497, 14, 40, 27, 9, -34 },
  { 567, 14, 40, 27, 4, -34 },
  { 637, 23, 23, 27, 2, -25 },
  { 704, 21, 22, 27, 3, -25 },
  { 762, 9, 14, 27, 9, -7 },
  { 778, 13, 4, 27, 7, -16 },
  { 785, 7, 7, 27, 10, -7 },
  { 792, 19, 40, 27, 4, -34 },
  { 887, 23, 33, 27, 2, -32 },
  { 982, 23, 31, 27, 2, -31 },
  { 1072, 23, 32, 27, 2, -32 },
  { 1164, 22, 33, 27, 2, -32 },
  { 1255, 25, 31, 27, 1, -31 },
  { 1352, 22, 32, 27, 3, -31 },
  { 1440, 23, 32, 27, 2, -31 },
  { 1532, 21, 31, 27, 3, -31 },
  { 1614, 23, 33, 27, 2, -32 },
  { 1709, 23, 32, 27, 2, -32 },
  { 1801, 7, 24, 27, 10, -24 },
  { 1822, 9, 31, 27, 9, -24 },
  { 1857, 19, 26, 27, 4, -27 },
  { 1919, 21, 14, 27, 3, -21 },
  { 1956, 19, 26, 27, 4, -27 },
  { 2018, 20, 32, 27, 3, -32 },
  { 2098, 22, 37, 27, 2, -32 },
  { 2200, 25, 31, 27, 1, -31 },
  { 2297, 21, 31, 27, 4, -31 },
  { 2379, 22, 33, 27, 3, -32 },
  { 2470, 21, 31, 27, 4, -31 },
  { 2552, 20, 31, 27, 4, -31 },
  { 2630, 20, 31, 27, 4, -31 },
  { 2708, 22, 33, 27, 2, -32 },
  { 2799, 21, 31, 27, 3, -31 },
  { 2881, 19, 31, 27, 4, -31 },
  { 2955, 19, 32, 27, 3, -31 },
  { 3031, 23, 31, 27, 4, -31 },
  { 3121, 19, 31, 27, 5, -31 },
  { 3195, 21, 31, 27, 3, -31 },
  { 3277, 21, 31, 27, 3, -31 },
  { 3359, 23, 33, 27, 2, -32 },
  { 3454, 21, 31, 27, 4, -31 },
  { 3536, 23, 40, 27, 2, -32 },
  { 3651, 21, 31, 27, 4, -31 },
  { 3733, 23, 33, 27, 2, -32 },
  { 3828, 25, 31, 27, 1, -31 },
  { 3925, 21, 32, 27, 3, -31 },
  { 4009, 25, 31, 27, 1, -31 },
  { 4106, 25, 31, 27, 1, -31 },
  { 4203, 25, 31, 27, 1, -31 },
  { 4300, 25, 31, 27, 1, -31 },
  { 4397, 23, 31, 27, 2, -31 },
  { 4487, 14, 40, 27, 9, -34 },
  { 4557, 19, 40, 27, 4, -34 },
  { 4652, 14, 40, 27, 4, -34 },
  { 4722, 23, 19, 27, 2, -31 },
  { 4777, 21, 4, 27, 3, 4 },
  { 4788, 8, 10, 27, 8, -36 },
  { 4798, 22, 25, 27, 3, -24 },
  { 4867, 21, 34, 27, 4, -33 },
  { 4957, 21, 25, 27, 3, -24 },
  { 5023, 21, 34, 27, 2, -33 },
  { 5113, 21, 25, 27, 3, -24 },
  { 5179, 22, 33, 27, 3, -33 },
  { 5270, 23, 37, 27, 3, -27 },
  { 5377, 19, 33, 27, 4, -33 },
  { 5456, 20, 33, 27, 5, -33 },
  { 5539, 16, 42, 27, 4, -33 },
  { 5623, 22, 33, 27, 4, -33 },
  { 5714, 21, 33, 27, 3, -33 },
  { 5801, 23, 24, 27, 2, -24 },
  { 5870, 19, 24, 27, 4, -24 },
  { 5927, 23, 25, 27, 2, -24 },
  { 5999, 21, 33, 27, 4, -24 },
  { 6086, 21, 33, 27, 2, -24 },
  { 6173, 22, 23, 27, 3, -23 },
  { 6237, 21, 25, 27, 3, -24 },
  { 6303, 22, 31, 27, 2, -31 },
  { 6389, 19, 24, 27, 4, -23 },
  { 6446, 23, 23, 27, 2, -23 },
  { 6513, 25, 23, 27, 1, -23 },
  { 6585, 23, 23, 27, 2, -23 },
  { 6652, 23, 32, 27, 2, -23 },
  { 6744, 21, 23, 27, 3, -23 },
  { 6805, 19, 40, 27, 4, -34 },
  { 6900, 5, 40, 27, 11, -34 },
  { 6925, 19, 40, 27, 4, -34 },
  { 7020, 23, 11, 27, 2, -19 },
};

const GFXfont IBMPlexMono_Medium45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_MEDIUM45PT7B_H_
