#ifndef _IBMPLEXMONO_MEDIUM36PT7B_H_
#define _IBMPLEXMONO_MEDIUM36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium36pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x30, 0xC3,
  0x0C, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1C,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x07, 0xF8, 0xFF, 0x3F, 0xC7, 0xF9,
  0xFE, 0x3F, 0xC0, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7,
  0x80, 0x1E, 0x3C, 0x1F, 0xF1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0x81,
  0xC7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xF9, 0xF3, 0x3F,
  0x78, 0xC3, 0xBC, 0x30, 0x8F, 0x0C, 0x03, 0xC3, 0x00, 0x78, 0xC0, 0x1F,
  0x30, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x0C,
  0xF8, 0x03, 0x0F, 0x00, 0xC3, 0xC0, 0x30, 0xF0, 0x0C, 0x3D, 0x83, 0x0F,
  0xF0, 0xC7, 0xFF, 0x33, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x39,
  0xFE, 0x03, 0x9F, 0xF8, 0x1C, 0xE1, 0xC1, 0xC7, 0x0E, 0x1E, 0x38, 0x70,
  0xE1, 0xC3, 0x8F, 0x0E, 0x1C, 0x70, 0x70, 0xE7, 0x03, 0x87, 0x38, 0x1F,
  0xFA, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xC0, 0x73, 0x8F, 0x07, 0x38, 0x38, 0x39, 0xC1, 0xC3, 0x8E, 0x0E, 0x3C,
  0x70, 0x71, 0xC3, 0x83, 0x9E, 0x0E, 0x3C, 0xE0, 0x7F, 0xCE, 0x01, 0xFC,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xE3,
  0xE0, 0x3C, 0x1C, 0x03, 0xC1, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x3F, 0x83, 0xE7,
  0xFC, 0x3E, 0x79, 0xE3, 0x8F, 0x0F, 0x38, 0xF0, 0x7B, 0x0F, 0x07, 0xF0,
  0xF0, 0x3F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x83, 0x78, 0x7F, 0xF3,
  0xC3, 0xFE, 0x3E, 0x0F, 0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xC1, 0xE0, 0x9F, 0x3C,
  0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0x3C, 0x03, 0xC7, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x80, 0x80, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x3E, 0xFD, 0xF3, 0xE7, 0x8F, 0x1C, 0x78, 0xF1,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x7C,
  0x78, 0x0F, 0x9E, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x70, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x70, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x79, 0xE0, 0x1E,
  0x78, 0x0F, 0x8F, 0x87, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xF0, 0x1F,
  0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0x60, 0xF0, 0x10, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xE3, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0xF0, 0xF8, 0x3E, 0x78, 0x07, 0x84, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0xC0, 0x0F, 0x78, 0x07, 0xFF, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0E, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x8F,
  0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1E,
  0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x7E, 0x07, 0x3F, 0xE1, 0xDF, 0xFC, 0x7C, 0x1F, 0x9E, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0xC0, 0x1E,
  0x78, 0x0F, 0xBF, 0x07, 0xC7, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x3E, 0x07, 0xBF,
  0xE3, 0xDF, 0xFC, 0xF4, 0x1F, 0xBE, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7D, 0xC0, 0x1E, 0x78, 0x07, 0x8F,
  0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3D,
  0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x7E,
  0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x79, 0xC0, 0x1E, 0x78, 0x07, 0x8F,
  0x07, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFE, 0x1F, 0x07, 0xCF, 0x80,
  0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xF8, 0x07, 0x9F, 0x07, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x0F, 0xBC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0x7C, 0x1F, 0x8F, 0xFD, 0xE1, 0xFE, 0x78, 0x3F, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80,
  0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xBF, 0x7C, 0xF9, 0xE3, 0xC7, 0x1E, 0x3C, 0x70, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F,
  0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xE0, 0x1F, 0x20, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE7, 0x80, 0x7B, 0x80, 0x1D, 0xC0, 0x0F,
  0xE0, 0xE7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xF1, 0xFC, 0x70, 0x7E, 0x38,
  0x3F, 0x1C, 0x1F, 0x8E, 0x0F, 0xC7, 0x07, 0xE3, 0x83, 0xF1, 0xC1, 0xF8,
  0xF0, 0xFC, 0x3F, 0xFE, 0x1F, 0xFB, 0x87, 0xDD, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xBC, 0x00,
  0x7B, 0xC0, 0x07, 0x9C, 0x00, 0x79, 0xE0, 0x07, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3C, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07, 0xCF, 0x01,
  0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C,
  0x0F, 0x9F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80,
  0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x3C, 0x07, 0x9E, 0x01, 0xF7, 0x80, 0x31,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x31, 0xE0, 0x1F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E,
  0x07, 0xCF, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x01, 0xE7, 0x81, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE7,
  0x80, 0xFB, 0xC0, 0x3F, 0xC0, 0x19, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0xFB,
  0xF0, 0xFC, 0xFF, 0xFE, 0x3F, 0xEF, 0x07, 0xC7, 0x80, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x10, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xE0, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x01, 0xF3, 0xC0, 0xF8,
  0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C,
  0xF0, 0x0F, 0x7C, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xCF,
  0x03, 0xE3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF8,
  0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xC0,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFE, 0xF3, 0xBF, 0x9C, 0xEF, 0xF7, 0x7B, 0xFD, 0xFC, 0xFF, 0x3F, 0x3F,
  0xCF, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1C, 0x3F, 0xC3, 0x0F, 0xF0,
  0x83, 0xFC, 0x20, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xEE, 0x0F, 0xEF, 0x0F,
  0xEF, 0x0F, 0xE7, 0x0F, 0xE7, 0x8F, 0xE3, 0x8F, 0xE3, 0xCF, 0xE3, 0xCF,
  0xE1, 0xCF, 0xE1, 0xEF, 0xE0, 0xEF, 0xE0, 0xEF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0x03, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x0F, 0x9E, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x8F, 0x87, 0xC3,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x0F,
  0x1E, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x79, 0xE0, 0x1E, 0x78, 0x0F,
  0x8F, 0x87, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x03,
  0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x3C, 0x3C, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0x1F, 0x03, 0xE3, 0xC0, 0x18, 0xF8, 0x02, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x98, 0x01, 0xF7, 0x80, 0x3D, 0xFC, 0x1F, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0xF3, 0xE0, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x07,
  0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x03, 0xC7, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07,
  0x9C, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0xF0, 0xEF, 0x0F,
  0x0E, 0x71, 0xF0, 0xE7, 0x1F, 0x8E, 0x71, 0xF8, 0xE7, 0x1B, 0x8E, 0x71,
  0xB9, 0xE7, 0x3B, 0x9E, 0x73, 0x99, 0xE7, 0x39, 0xDE, 0x73, 0x9D, 0xE7,
  0xB1, 0xDC, 0x7F, 0x1D, 0xC7, 0xF0, 0xDC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0xC0, 0xF8, 0x01, 0xF7, 0xC0,
  0x3E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF0, 0x0F,
  0x1F, 0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0x9E, 0x00, 0xF1, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF8, 0x3E, 0x07,
  0x83, 0xC0, 0x7C, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0x7B, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x7C, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3E,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x3C,
  0x03, 0xC7, 0x80, 0x70, 0x78, 0x1E, 0x0F, 0x03, 0x80, 0xF0, 0xF0, 0x1E,
  0x1C, 0x01, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xFC, 0x00, 0x31, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0xE3, 0xE3, 0xC3, 0xC3,
  0x87, 0x84, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xE1, 0xE0, 0xF8, 0x30,
  0x1F, 0x08, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3,
  0xE0, 0xFC, 0x7F, 0xEF, 0xCF, 0xF9, 0xF1, 0xF8, 0x3C, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF1, 0xF0, 0x7B, 0xFE, 0x3D, 0xFF, 0x9F, 0x87, 0xEF, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xF8, 0x7E,
  0xF7, 0xFE, 0x7B, 0xFE, 0x3C, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x7C, 0x1E, 0x78, 0x0F, 0xF0, 0x08, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x04, 0x78,
  0x0E, 0x7C, 0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x0F, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD, 0xEF, 0x83, 0xF7, 0x80,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3E, 0xF8, 0x3F,
  0x3F, 0xF7, 0x8F, 0xF3, 0xC3, 0xF1, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0x83, 0xE7, 0x80, 0x7B, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x11, 0xE0, 0x1C, 0x7C, 0x1F, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0x07, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x83, 0xC1, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9C, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01,
  0xDF, 0x00, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF1, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE, 0xFC, 0x3E, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xEF, 0xFE, 0x7F, 0xF3, 0xFE, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x03, 0xE3, 0xC1, 0xF0, 0xF0, 0xF8, 0x3C,
  0x7C, 0x0F, 0x3E, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF,
  0x03, 0xE3, 0xC0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0x78,
  0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0x7C, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0x0F, 0x3B, 0xE7, 0xEF, 0xFD, 0xFF, 0xCF, 0x8F, 0xE1, 0xE3,
  0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E,
  0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87,
  0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1C, 0xF1, 0xF0, 0xF3, 0xFC,
  0xF7, 0xFE, 0xFC, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xF0, 0x7C, 0x78, 0x0F, 0x9E, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1E, 0xF0, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF8, 0xF8, 0x7C, 0x3F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0x00, 0xF1, 0xF0, 0x7B, 0xFE, 0x3D, 0xFF, 0x9F,
  0x87, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0,
  0x3D, 0xF8, 0x7E, 0xF7, 0xFE, 0x7B, 0xFE, 0x3C, 0x7C, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD, 0xEF, 0x83, 0xF7, 0x80, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3E, 0xF8, 0x3F, 0x3F,
  0xF7, 0x8F, 0xF3, 0xC3, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xEF, 0xE0, 0xF4, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0x81, 0xF7, 0x80,
  0x23, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x79, 0x00, 0x3D, 0xC0, 0x1F, 0xF8, 0x1F,
  0x7F, 0xFF, 0x1F, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x2F,
  0x7F, 0xEF, 0x3F, 0xCF, 0x1F, 0x8F, 0xF0, 0x03, 0xFC, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x38,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x38, 0xF0, 0x0F, 0x3C, 0x03,
  0xCE, 0x00, 0x77, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x1F, 0x0E, 0xF1,
  0xF8, 0xEF, 0x1B, 0x8E, 0x71, 0xB8, 0xE7, 0x19, 0x8E, 0x73, 0x98, 0xE7,
  0x39, 0x8E, 0x73, 0x9D, 0xC7, 0x31, 0xDC, 0x73, 0x1D, 0xC3, 0xB0, 0xDC,
  0x3F, 0x0D, 0xC3, 0xF0, 0xDC, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F,
  0x80, 0xF8, 0x07, 0xDF, 0x03, 0xE3, 0xC0, 0xF0, 0xF8, 0x78, 0x1F, 0x3C,
  0x03, 0xCF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x78, 0x03, 0xCF, 0x01, 0xE3, 0xE0, 0xF0,
  0x7C, 0x7C, 0x0F, 0x1E, 0x03, 0xEF, 0x00, 0x7C, 0xF8, 0x01, 0xEF, 0x00,
  0x3D, 0xE0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x1C, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xC0, 0x07, 0x78, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x0F, 0xF8, 0x3F, 0x00, 0xFF, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F,
  0x07, 0xFC, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC3, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC0, 0x1E, 0x01, 0xCF, 0xE0, 0x77, 0xFC, 0x3D, 0xCF,
  0x0E, 0xE1, 0xE3, 0xB8, 0x3F, 0xCE, 0x07, 0xF3, 0x80, 0xF0,
};

const GFXglyph IBMPlexMono_Medium36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 25, 22, 8, -25 },
  { 20, 11, 11, 22, 5, -27 },
  { 36, 21, 25, 22, 0, -25 },
  { 102, 18, 33, 22, 2, -29 },
  { 177, 21, 25, 22, 0, -25 },
  { 243, 20, 25, 22, 1, -25 },
  { 306, 4, 11, 22, 9, -27 },
  { 312, 11, 32, 22, 7, -27 },
  { 356, 12, 32, 22, 3, -27 },
  { 404, 19, 18, 22, 1, -20 },
  { 447, 17, 17, 22, 2, -19 },
  { 484, 7, 10, 22, 7, -5 },
  { 493, 11, 3, 22, 5, -12 },
  { 498, 6, 6, 22, 8, -6 },
  { 503, 16, 32, 22, 3, -27 },
  { 567, 18, 25, 22, 2, -25 },
  { 624, 18, 25, 22, 2, -25 },
  { 681, 18, 25, 22, 2, -25 },
  { 738, 18, 25, 22, 1, -25 },
  { 795, 19, 25, 22, 1, -25 },
  { 855, 18, 25, 22, 2, -25 },
  { 912, 18, 25, 22, 2, -25 },
  { 969, 17, 25, 22, 2, -25 },
  { 1023, 18, 25, 22, 2, -25 },
  { 1080, 18, 25, 22, 2, -25 },
  { 1137, 6, 19, 22, 8, -19 },
  { 1152, 7, 24, 22, 7, -19 },
  { 1173, 16, 21, 22, 3, -21 },
  { 1215, 17, 10, 22, 2, -16 },
  { 1237, 16, 21, 22, 3, -21 },
  { 1279, 16, 25, 22, 3, -25 },
  { 1329, 17, 29, 22, 2, -25 },
  { 1391, 20, 25, 22, 1, -25 },
  { 1454, 17, 25, 22, 3, -25 },
  { 1508, 18, 25, 22, 2, -25 },
  { 1565, 17, 25, 22, 3, -25 },
  { 1619, 16, 25, 22, 3, -25 },
  { 1669, 16, 25, 22, 3, -25 },
  { 1719, 17, 25, 22, 2, -25 },
  { 1773, 16, 25, 22, 3, -25 },
  { 1823, 16, 25, 22, 3, -25 },
  { 1873, 16, 25, 22, 2, -25 },
  { 1923, 18, 25, 22, 3, -25 },
  { 1980, 15, 25, 22, 4, -25 },
  { 2027, 18, 25, 22, 2, -25 },
  { 2084, 16, 25, 22, 3, -25 },
  { 2134, 18, 25, 22, 2, -25 },
  { 2191, 17, 25, 22, 3, -25 },
  { 2245, 18, 31, 22, 2, -25 },
  { 2315, 17, 25, 22, 3, -25 },
  { 2369, 19, 25, 22, 1, -25 },
  { 2429, 20, 25, 22, 1, -25 },
  { 2492, 17, 25, 22, 2, -25 },
  { 2546, 20, 25, 22, 1, -25 },
  { 2609, 20, 25, 22, 1, -25 },
  { 2672, 20, 25, 22, 1, -25 },
  { 2735, 21, 25, 22, 0, -25 },
  { 2801, 18, 25, 22, 2, -25 },
  { 2858, 11, 32, 22, 7, -27 },
  { 2902, 16, 32, 22, 3, -27 },
  { 2966, 11, 32, 22, 3, -27 },
  { 3010, 19, 16, 22, 1, -25 },
  { 3048, 17, 3, 22, 2, 3 },
  { 3055, 7, 8, 22, 6, -29 },
  { 3062, 18, 19, 22, 2, -19 },
  { 3105, 17, 27, 22, 3, -27 },
  { 3163, 16, 19, 22, 3, -19 },
  { 3201, 17, 27, 22, 2, -27 },
  { 3259, 17, 19, 22, 2, -19 },
  { 3300, 18, 27, 22, 2, -27 },
  { 3361, 19, 29, 22, 2, -22 },
  { 3430, 16, 27, 22, 3, -27 },
  { 3484, 16, 27, 22, 4, -27 },
  { 3538, 13, 34, 22, 3, -27 },
  { 3594, 18, 27, 22, 3, -27 },
  { 3655, 16, 27, 22, 3, -27 },
  { 3709, 18, 19, 22, 2, -19 },
  { 3752, 16, 19, 22, 3, -19 },
  { 3790, 18, 19, 22, 2, -19 },
  { 3833, 17, 26, 22, 3, -19 },
  { 3889, 17, 26, 22, 2, -19 },
  { 3945, 17, 19, 22, 3, -19 },
  { 3986, 17, 19, 22, 2, -19 },
  { 4027, 18, 25, 22, 1, -25 },
  { 4084, 16, 19, 22, 3, -19 },
  { 4122, 18, 19, 22, 2, -19 },
  { 4165, 20, 19, 22, 1, -19 },
  { 4213, 18, 19, 22, 2, -19 },
  { 4256, 19, 26, 22, 1, -19 },
  { 4318, 16, 19, 22, 3, -19 },
  { 4356, 14, 32, 22, 4, -27 },
  { 4412, 3, 32, 22, 9, -27 },
  { 4424, 14, 32, 22, 4, -27 },
  { 4480, 18, 8, 22, 2, -15 },
};

const GFXfont IBMPlexMono_Medium36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_MEDIUM36PT7B_H_
