#ifndef _IBMPLEXMONO_MEDIUM50PT7B_H_
#define _IBMPLEXMONO_MEDIUM50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x3C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x07, 0xFF, 0x87, 0xFF, 0x7F, 0xF0,
  0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF,
  0xEF, 0xFE, 0x1F, 0xFE, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0xF8, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE3, 0xF8, 0xE7, 0xF8, 0xFC, 0x38, 0x7C, 0x7E, 0x0E,
  0x06, 0x1F, 0x83, 0x81, 0x07, 0xE0, 0xE0, 0x01, 0xF8, 0x38, 0x00, 0x7E,
  0x0E, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xF8, 0xE0, 0x00, 0xFF, 0xB8, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xE3, 0xF8, 0x00,
  0x38, 0x3F, 0x00, 0x0E, 0x0F, 0xC0, 0x03, 0x81, 0xF0, 0x00, 0xE0, 0x7C,
  0x40, 0x38, 0x1F, 0x18, 0x0E, 0x0F, 0xCF, 0x03, 0x83, 0xF7, 0xE0, 0xE1,
  0xFB, 0xFE, 0x39, 0xFE, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0x3F, 0xF8, 0x01, 0xF7,
  0xFF, 0xC0, 0x1E, 0xF8, 0x7C, 0x03, 0xEF, 0x83, 0xE0, 0x3C, 0xF0, 0x1E,
  0x07, 0xCF, 0x01, 0xE0, 0x78, 0xF0, 0x1E, 0x0F, 0x8F, 0x01, 0xE0, 0xF0,
  0xF0, 0x1E, 0x1F, 0x0F, 0x01, 0xE1, 0xE0, 0xF0, 0x3E, 0x3E, 0x0F, 0x87,
  0xC3, 0xC0, 0x7F, 0xFC, 0x7C, 0x03, 0xFF, 0x87, 0x80, 0x1F, 0xF0, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0xFF, 0x80, 0x1E, 0x1F, 0xFC, 0x03, 0xE3, 0xFF, 0xE0, 0x3C, 0x3E,
  0x1E, 0x07, 0xC7, 0xC1, 0xF0, 0x78, 0x78, 0x0F, 0x0F, 0x87, 0x80, 0xF0,
  0xF0, 0x78, 0x0F, 0x1F, 0x07, 0x80, 0xF1, 0xE0, 0x78, 0x0F, 0x3E, 0x07,
  0x80, 0xF3, 0xC0, 0x7C, 0x0F, 0x7C, 0x03, 0xE1, 0xE7, 0x80, 0x3F, 0xFE,
  0xF8, 0x01, 0xFF, 0xCF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x60, 0x01,
  0xF0, 0x08, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0xFE, 0x0F, 0xF8, 0x0F, 0xE1, 0xFF, 0xC1, 0xFE, 0x3F, 0x7E, 0x1F,
  0xE7, 0xE3, 0xF1, 0xF0, 0x7C, 0x1F, 0x1F, 0x07, 0xC0, 0xF9, 0xE0, 0xFC,
  0x0F, 0xDE, 0x0F, 0x80, 0x7F, 0xE0, 0xF8, 0x03, 0xFE, 0x0F, 0x80, 0x1F,
  0xC0, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x1F, 0xF0, 0x7F, 0x07, 0x9F, 0x83, 0xFF, 0xF8, 0xFC, 0x1F, 0xFF,
  0x07, 0xE0, 0xFF, 0xE0, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0x80, 0x78,
  0x06, 0x7C, 0x1E, 0x0F, 0xBF, 0xE7, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE3, 0xF8,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07,
  0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x1E, 0x0F, 0xFF,
  0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F,
  0xFF, 0x07, 0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFB, 0xF0,
  0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x3F, 0xC3,
  0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xF0, 0x3F, 0x00, 0x18, 0x0F, 0xC0, 0x04,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xF8,
  0x00, 0x7E, 0x38, 0x00, 0x7E, 0x08, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFC, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x38, 0x00, 0x7E,
  0x0C, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE2,
  0x00, 0x03, 0xF3, 0x80, 0x03, 0xFB, 0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFC,
  0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x07, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x7C, 0x7F, 0xF0, 0x7C, 0xFF, 0xF8, 0x7D, 0xFF, 0xFC,
  0x7F, 0x81, 0xFE, 0x7E, 0x00, 0x7E, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x10, 0x00, 0x3F, 0x38, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0xF8, 0xFF, 0xE0, 0xFC, 0xFF, 0xF8, 0x7E,
  0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xE7, 0xC0, 0x03,
  0xF3, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F,
  0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7E, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x3F, 0x9F, 0xE0, 0x7F, 0xC7, 0xFF, 0xF7, 0xE1, 0xFF, 0xF3, 0xF0,
  0x7F, 0xF1, 0xF0, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F, 0x87, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x3F, 0x87,
  0xF1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x30, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x0F,
  0x9F, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0xEF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7C,
  0x3F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF0,
  0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0,
  0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x1F, 0xF0, 0x78,
  0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F,
  0x8F, 0x78, 0x06, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xE0, 0x0F, 0xEF, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFE,
  0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1E,
  0x7C, 0x00, 0x10, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x10, 0x7E, 0x00, 0x1E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x3F,
  0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFC, 0x07, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x5F, 0x80, 0x04, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0xFE, 0x3F, 0x00, 0xFF, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0xEF, 0xC1, 0xFF,
  0xE7, 0xE0, 0x7F, 0xE3, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF1, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xF0, 0x7F, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80,
  0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01,
  0xFB, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xF7, 0xE0, 0x0F, 0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFB, 0xC3, 0xDF, 0xFB, 0xE3,
  0xDF, 0xFB, 0xE7, 0xDF, 0xF9, 0xE7, 0x9F, 0xF9, 0xF7, 0x9F, 0xF8, 0xFF,
  0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x18,
  0x1F, 0xF8, 0x18, 0x1F, 0xF8, 0x18, 0x1F, 0xF8, 0x10, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xBE, 0x07, 0xFE, 0xF8, 0x1F, 0xF9, 0xF0,
  0x7F, 0xE7, 0xC1, 0xFF, 0x9F, 0x07, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F,
  0xE1, 0xE1, 0xFF, 0x87, 0xC7, 0xFE, 0x1F, 0x1F, 0xF8, 0x3E, 0x7F, 0xE0,
  0xF9, 0xFF, 0x83, 0xE7, 0xFE, 0x07, 0xDF, 0xF8, 0x1F, 0x7F, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9,
  0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFC,
  0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1,
  0xFE, 0x03, 0xFC, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x1C, 0x7E, 0x00, 0x04,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE2, 0x00, 0x01, 0xF3,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFE,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x1E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83,
  0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x3F, 0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C,
  0x3F, 0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C, 0x39, 0xC3, 0xE7, 0xC3, 0x9E,
  0x3E, 0x3C, 0x79, 0xE3, 0xC3, 0xC7, 0x9E, 0x3C, 0x3C, 0x79, 0xE3, 0xC3,
  0xC7, 0x9E, 0x3C, 0x3E, 0x70, 0xF3, 0xC3, 0xEF, 0x0F, 0x3C, 0x3E, 0xF0,
  0xF7, 0xC3, 0xEF, 0x0F, 0x7C, 0x3E, 0xF0, 0xF7, 0xC3, 0xEF, 0x0F, 0x7C,
  0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7D, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0x38, 0x00, 0x07, 0x04, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x1C,
  0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xE0, 0x0F, 0xC0, 0x60, 0x03, 0xE0, 0x20, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE1, 0xF8, 0x1D, 0xFE, 0xFF,
  0xFE, 0xFF, 0x3F, 0xFE, 0x3F, 0x8F, 0xFE, 0x0F, 0xC1, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x0F, 0x87,
  0xFE, 0x1F, 0x3F, 0xFE, 0x3E, 0x7F, 0xFE, 0x7D, 0xC1, 0xFC, 0xFE, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF7,
  0x07, 0xF3, 0xE7, 0xFF, 0xE7, 0xCF, 0xFF, 0x8F, 0x87, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x3F, 0x81, 0xF8, 0xFC, 0x03, 0xF7, 0xE0, 0x07, 0x1F, 0x00, 0x10,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x08, 0x7E, 0x00, 0x78,
  0xFC, 0x03, 0xF3, 0xF8, 0x1F, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0xC1, 0xF0, 0xFF, 0xC3, 0xE3, 0xFF, 0xE7, 0xCF, 0xFF, 0xCF,
  0xBF, 0xC1, 0xDF, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0xFE, 0xFF, 0x07, 0x7C, 0xFF, 0xFC, 0xF8, 0xFF, 0xF9,
  0xF0, 0xFF, 0xC3, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x10, 0x7E, 0x00, 0x1C, 0x3F, 0x00,
  0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x60, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0xFE, 0x00, 0x3F, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0xFF, 0xC3, 0xF7, 0xFF, 0xCF,
  0xDF, 0xFF, 0x3F, 0xE0, 0xFE, 0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xEF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0x00, 0x7F,
  0x9F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x03,
  0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0xF0, 0x3E, 0x3E, 0x7E,
  0x1F, 0xCF, 0xBF, 0xCF, 0xFB, 0xFF, 0xF7, 0xFE, 0xFC, 0x3F, 0x8F, 0xBE,
  0x0F, 0xC1, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F, 0xF8, 0x1E, 0x07,
  0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F, 0xF8, 0x1E,
  0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F, 0xF8,
  0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F,
  0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78,
  0x1F, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xF0, 0xFC, 0x3F, 0x03, 0xF3,
  0xFF, 0x0F, 0xDF, 0xFF, 0x3F, 0x7F, 0xFC, 0xFF, 0x83, 0xFB, 0xF8, 0x07,
  0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xF8, 0x3F, 0x81, 0xF0, 0xFF, 0xC3, 0xE7,
  0xFF, 0xC7, 0xCF, 0xFF, 0xCF, 0xB8, 0x3F, 0x9F, 0xC0, 0x1F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBE, 0xE0, 0xFE, 0x7C,
  0xFF, 0xFC, 0xF9, 0xFF, 0xF1, 0xF0, 0xFF, 0xC3, 0xE0, 0xFE, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x3E, 0x1F, 0xF8, 0x7C, 0x7F, 0xFC, 0xF9, 0xFF, 0xF9,
  0xF7, 0xF8, 0x3B, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0xE0, 0xEF, 0x9F, 0xFF, 0x9F, 0x1F, 0xFF,
  0x3E, 0x1F, 0xF8, 0x7C, 0x0F, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFF, 0x01, 0xF3, 0xFF,
  0x01, 0xF7, 0x00, 0x01, 0xF4, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x06, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x80, 0x01,
  0xF3, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x7F, 0xCF, 0xFF, 0xBF,
  0x3F, 0xFE, 0xFC, 0x3F, 0xF3, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xE7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xF0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x1F,
  0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F,
  0x78, 0x1F, 0xC1, 0xE7, 0x83, 0xFC, 0x1E, 0x78, 0x3F, 0xC1, 0xE7, 0xC3,
  0xDC, 0x1E, 0x7C, 0x39, 0xC1, 0xE7, 0xC3, 0x9C, 0x3E, 0x7C, 0x39, 0xE3,
  0xE3, 0xC7, 0x9E, 0x3C, 0x3C, 0x79, 0xE3, 0xC3, 0xC7, 0x0E, 0x3C, 0x3C,
  0x70, 0xE3, 0xC3, 0xC7, 0x0E, 0x3C, 0x3E, 0x70, 0xF3, 0xC3, 0xEF, 0x0F,
  0x3C, 0x1E, 0xF0, 0xF7, 0x81, 0xEE, 0x07, 0x78, 0x1E, 0xE0, 0x77, 0x81,
  0xEE, 0x07, 0x78, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3E,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xC0,
  0xFC, 0x03, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x03, 0x03, 0xFC, 0x01, 0xF1, 0xFF, 0x80, 0x78, 0xFF, 0xF0,
  0x1E, 0x3E, 0x7E, 0x07, 0x9F, 0x0F, 0xC3, 0xE7, 0x81, 0xF9, 0xF1, 0xE0,
  0x3F, 0xFC, 0x78, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0x03, 0x00, 0x1F, 0x80,
};

const GFXglyph IBMPlexMono_Medium50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 8, 36, 30, 11, -35 },
  { 37, 14, 15, 30, 8, -37 },
  { 64, 28, 35, 30, 1, -35 },
  { 187, 26, 46, 30, 2, -40 },
  { 337, 28, 37, 30, 1, -36 },
  { 467, 28, 37, 30, 1, -36 },
  { 597, 6, 15, 30, 12, -37 },
  { 609, 15, 45, 30, 10, -38 },
  { 694, 15, 45, 30, 5, -38 },
  { 779, 26, 25, 30, 2, -27 },
  { 861, 24, 24, 30, 3, -27 },
  { 933, 11, 15, 30, 9, -8 },
  { 954, 16, 5, 30, 7, -18 },
  { 964, 8, 8, 30, 11, -8 },
  { 972, 22, 45, 30, 4, -38 },
  { 1096, 26, 37, 30, 2, -36 },
  { 1217, 26, 35, 30, 2, -35 },
  { 1331, 24, 36, 30, 3, -36 },
  { 1439, 25, 37, 30, 2, -36 },
  { 1555, 27, 35, 30, 1, -35 },
  { 1674, 24, 36, 30, 3, -35 },
  { 1782, 25, 36, 30, 3, -35 },
  { 1895, 24, 35, 30, 3, -35 },
  { 2000, 26, 37, 30, 2, -36 },
  { 2121, 25, 36, 30, 2, -36 },
  { 2234, 8, 27, 30, 11, -27 },
  { 2261, 11, 34, 30, 9, -27 },
  { 2308, 22, 29, 30, 4, -30 },
  { 2388, 24, 15, 30, 3, -23 },
  { 2433, 22, 29, 30, 4, -30 },
  { 2513, 23, 37, 30, 3, -36 },
  { 2620, 24, 42, 30, 3, -36 },
  { 2746, 28, 35, 30, 1, -35 },
  { 2869, 23, 35, 30, 4, -35 },
  { 2970, 24, 37, 30, 3, -36 },
  { 3081, 24, 35, 30, 4, -35 },
  { 3186, 22, 35, 30, 4, -35 },
  { 3283, 23, 35, 30, 4, -35 },
  { 3384, 25, 37, 30, 2, -36 },
  { 3500, 22, 35, 30, 4, -35 },
  { 3597, 22, 35, 30, 4, -35 },
  { 3694, 22, 36, 30, 3, -35 },
  { 3793, 25, 35, 30, 4, -35 },
  { 3903, 22, 35, 30, 5, -35 },
  { 4000, 24, 35, 30, 3, -35 },
  { 4105, 22, 35, 30, 4, -35 },
  { 4202, 26, 37, 30, 2, -36 },
  { 4323, 24, 35, 30, 4, -35 },
  { 4428, 26, 44, 30, 2, -36 },
  { 4571, 24, 35, 30, 4, -35 },
  { 4676, 25, 37, 30, 2, -36 },
  { 4792, 28, 35, 30, 1, -35 },
  { 4915, 24, 36, 30, 3, -35 },
  { 5023, 28, 35, 30, 1, -35 },
  { 5146, 28, 35, 30, 1, -35 },
  { 5269, 28, 35, 30, 1, -35 },
  { 5392, 28, 35, 30, 1, -35 },
  { 5515, 26, 35, 30, 2, -35 },
  { 5629, 15, 45, 30, 10, -38 },
  { 5714, 22, 45, 30, 4, -38 },
  { 5838, 15, 45, 30, 5, -38 },
  { 5923, 26, 22, 30, 2, -35 },
  { 5995, 24, 5, 30, 3, 4 },
  { 6010, 9, 11, 30, 9, -40 },
  { 6023, 25, 27, 30, 3, -26 },
  { 6108, 23, 38, 30, 4, -37 },
  { 6218, 22, 27, 30, 4, -26 },
  { 6293, 23, 38, 30, 3, -37 },
  { 6403, 24, 27, 30, 3, -26 },
  { 6484, 24, 37, 30, 3, -37 },
  { 6595, 26, 41, 30, 3, -30 },
  { 6729, 22, 37, 30, 4, -37 },
  { 6831, 23, 38, 30, 5, -38 },
  { 6941, 18, 48, 30, 5, -38 },
  { 7049, 25, 37, 30, 4, -37 },
  { 7165, 22, 37, 30, 4, -37 },
  { 7267, 26, 26, 30, 2, -26 },
  { 7352, 22, 26, 30, 4, -26 },
  { 7424, 24, 27, 30, 3, -26 },
  { 7505, 23, 36, 30, 4, -26 },
  { 7609, 23, 36, 30, 3, -26 },
  { 7713, 24, 26, 30, 4, -26 },
  { 7791, 23, 27, 30, 3, -26 },
  { 7869, 24, 35, 30, 2, -35 },
  { 7974, 22, 27, 30, 4, -26 },
  { 8049, 26, 26, 30, 2, -26 },
  { 8134, 28, 26, 30, 1, -26 },
  { 8225, 26, 26, 30, 2, -26 },
  { 8310, 26, 36, 30, 2, -26 },
  { 8427, 22, 26, 30, 4, -26 },
  { 8499, 20, 45, 30, 5, -38 },
  { 8612, 4, 45, 30, 13, -38 },
  { 8635, 20, 45, 30, 5, -38 },
  { 8748, 26, 11, 30, 2, -21 },
};

const GFXfont IBMPlexMono_Medium50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_MEDIUM50PT7B_H_
