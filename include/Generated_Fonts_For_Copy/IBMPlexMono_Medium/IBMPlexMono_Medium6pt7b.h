#ifndef _IBMPLEXMONO_MEDIUM6PT7B_H_
#define _IBMPLEXMONO_MEDIUM6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6F, 0xAC, 0x5D, 0x3E, 0x80, 0xFE, 0xEF, 0xE8, 0xEF,
  0x80, 0x6A, 0x90, 0xFC, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x25,
  0x25, 0x00, 0xF7, 0xB0, 0xC9, 0x30, 0xE5, 0x70, 0xE5, 0xF0, 0x3E, 0xB0,
  0xEE, 0xF0, 0x7E, 0xB0, 0xE5, 0x20, 0xF7, 0xF0, 0xF5, 0xA0, 0xA0, 0xB0,
  0x69, 0xFC, 0xA6, 0xE5, 0x20, 0xFF, 0xE6, 0x55, 0xD0, 0xF7, 0xF0, 0xF2,
  0x30, 0xF6, 0xF0, 0xEF, 0xEE, 0xF2, 0xB0, 0xB7, 0xD0, 0xE9, 0x70, 0x64,
  0xF0, 0xAC, 0xAB, 0xAB, 0xBF, 0xD0, 0xFF, 0xD0, 0xF6, 0xB0, 0xF7, 0x40,
  0xF6, 0xB6, 0xF7, 0xD0, 0xE8, 0xF0, 0xE9, 0x20, 0xB6, 0xB0, 0xB5, 0xA0,
  0xBF, 0xD0, 0xA9, 0xD0, 0xB6, 0x44, 0xE9, 0x70, 0xEA, 0xB0, 0x91, 0x22,
  0x40, 0xFC, 0x74, 0xE0, 0xC0, 0xEF, 0x80, 0x9E, 0xF0, 0xF1, 0x80, 0x3E,
  0xB0, 0xFD, 0x80, 0x7D, 0x70, 0x3E, 0xAE, 0x9E, 0xD0, 0x8A, 0xC0, 0x9D,
  0x70, 0xBB, 0xC9, 0x70, 0xFF, 0x80, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0,
  0xF5, 0x90, 0xEB, 0x80, 0xEF, 0x80, 0x5D, 0x30, 0xB5, 0x80, 0xB5, 0x00,
  0xFE, 0x80, 0xAA, 0x80, 0xAD, 0x60, 0x6B, 0x80, 0x6A, 0xB0, 0xFC, 0xAB,
  0xA0, 0x9C,
};

const GFXglyph IBMPlexMono_Medium6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 3, 3, 4, 0, -3 },
  { 18, 3, 3, 4, 0, -3 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 3, 6, 4, 0, -5 },
  { 26, 3, 4, 4, 0, -4 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 3, 4, 4, 0, -4 },
  { 40, 3, 4, 4, 0, -4 },
  { 42, 3, 4, 4, 0, -4 },
  { 44, 3, 4, 4, 0, -4 },
  { 46, 1, 3, 4, 1, -3 },
  { 47, 1, 4, 4, 1, -3 },
  { 48, 2, 4, 4, 1, -4 },
  { 49, 3, 2, 4, 0, -3 },
  { 50, 2, 4, 4, 1, -4 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 3, 5, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 3, 4, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 2, 4, 4, 1, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 5, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 0, -4 },
  { 94, 3, 4, 4, 0, -4 },
  { 96, 3, 4, 4, 0, -4 },
  { 98, 3, 4, 4, 0, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 3, 4, 4, 0, -4 },
  { 104, 2, 6, 4, 1, -5 },
  { 106, 3, 6, 4, 0, -5 },
  { 109, 1, 6, 4, 1, -5 },
  { 110, 3, 2, 4, 0, -4 },
  { 111, 3, 1, 4, 0, 0 },
  { 112, 1, 2, 4, 1, -5 },
  { 113, 3, 3, 4, 0, -3 },
  { 115, 3, 4, 4, 0, -4 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 3, 4, 4, 0, -4 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 4, 4, 0, -4 },
  { 125, 3, 5, 4, 0, -4 },
  { 127, 3, 4, 4, 0, -4 },
  { 129, 2, 5, 4, 1, -5 },
  { 131, 2, 6, 4, 1, -5 },
  { 133, 2, 4, 4, 1, -4 },
  { 134, 3, 4, 4, 0, -4 },
  { 136, 3, 3, 4, 0, -3 },
  { 138, 3, 3, 4, 0, -3 },
  { 140, 3, 3, 4, 0, -3 },
  { 142, 3, 4, 4, 0, -3 },
  { 144, 3, 4, 4, 0, -3 },
  { 146, 3, 3, 4, 0, -3 },
  { 148, 3, 3, 4, 0, -3 },
  { 150, 3, 4, 4, 0, -4 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 3, 3, 4, 0, -3 },
  { 158, 3, 3, 4, 0, -3 },
  { 160, 3, 4, 4, 0, -3 },
  { 162, 3, 3, 4, 0, -3 },
  { 164, 2, 6, 4, 1, -5 },
  { 166, 1, 6, 4, 1, -5 },
  { 167, 2, 6, 4, 1, -5 },
  { 169, 3, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_Medium6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_MEDIUM6PT7B_H_
