#ifndef _IBMPLEXMONO_MEDIUM67PT7B_H_
#define _IBMPLEXMONO_MEDIUM67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium67pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0xE7,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F, 0xE1,
  0xF8, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xCF, 0xFF, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0xFF, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F,
  0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x7C, 0xFF, 0xF3, 0xFE,
  0x1F, 0x07, 0xF8, 0xFF, 0x07, 0xC0, 0xFC, 0x3F, 0x81, 0xF0, 0x1E, 0x0F,
  0xE0, 0x7C, 0x03, 0x07, 0xF8, 0x1F, 0x00, 0x01, 0xFE, 0x07, 0xC0, 0x00,
  0x7F, 0x81, 0xF0, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x03, 0xF8, 0x1F, 0x00,
  0x00, 0xFE, 0x07, 0xC0, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x0F, 0xFC, 0x7C,
  0x00, 0x01, 0xFF, 0xDF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0x7F, 0xF8, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0x01, 0xF0, 0x3F,
  0xC0, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x07, 0xC0,
  0x7F, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x1F,
  0x01, 0xFC, 0x20, 0x07, 0xC0, 0x7F, 0x1C, 0x01, 0xF0, 0x1F, 0xCF, 0x80,
  0x7C, 0x0F, 0xF7, 0xF8, 0x1F, 0x07, 0xFB, 0xFF, 0x07, 0xC3, 0xFE, 0x7F,
  0xF9, 0xF3, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF1, 0xFF, 0xF8, 0x00,
  0x0F, 0xCF, 0xFF, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0xE0, 0x01, 0xF9, 0xFC,
  0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xC0, 0x3F, 0x0F, 0xC0,
  0x1F, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x1F,
  0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x3F, 0x00,
  0x7C, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC3, 0xF0,
  0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0xFF,
  0xC1, 0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC1, 0xFF, 0xF8,
  0x00, 0x7E, 0x0F, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0xFF, 0xC0, 0x0F, 0xC1,
  0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0x1F, 0x07, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0xF8, 0x01, 0xF0,
  0xFE, 0x03, 0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0x80, 0x1F, 0x1F, 0xC0, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x03, 0xF3, 0xF8, 0x01, 0xF8, 0x1F, 0x8F,
  0xC0, 0x07, 0xF0, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0xF1, 0xF8, 0x00, 0x3F,
  0xFF, 0xCF, 0xE0, 0x00, 0x7F, 0xFE, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0x87, 0xF1, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xFC, 0x3F, 0x00, 0xFE, 0x0F,
  0xF0, 0xFC, 0x07, 0xF0, 0x1F, 0xE3, 0xF0, 0x1F, 0xC0, 0x3F, 0xCF, 0xC0,
  0x7F, 0x00, 0x7F, 0xBE, 0x03, 0xFC, 0x00, 0xFE, 0xF8, 0x0F, 0xE0, 0x03,
  0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0x03, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xFE,
  0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x7E, 0x00, 0x11,
  0xE0, 0x0F, 0xC0, 0x1E, 0x3F, 0x81, 0xF8, 0x1F, 0xEF, 0xFE, 0x3F, 0x1F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x87,
  0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7,
  0xFE, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF,
  0x07, 0xF8, 0x1F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x81, 0xFF,
  0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0x80, 0x3F, 0xC0, 0x00, 0xE0, 0x07, 0xF8, 0x00, 0x08, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0x80, 0x07,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xC0, 0x00,
  0x3F, 0xC0, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0x80, 0x00, 0xFF, 0x01,
  0x80, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x60, 0x00, 0x03, 0xFC, 0x70, 0x00, 0x03, 0xFC, 0xFC,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x1F,
  0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x0F, 0xC3, 0xFF, 0xE0, 0x07, 0xE3, 0xFF, 0xFC, 0x03,
  0xF3, 0xFF, 0xFF, 0x01, 0xFB, 0xFF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF, 0xF0,
  0x7F, 0xE0, 0x3F, 0xFC, 0x3F, 0xC0, 0x07, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0xC0, 0x00, 0x0F, 0xF0, 0xF0, 0x00,
  0x07, 0xF8, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0xC0,
  0x07, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE1, 0xFF,
  0xE0, 0x0F, 0xF3, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xFF, 0x03, 0xFB, 0xFF,
  0xFF, 0xC3, 0xFD, 0xFF, 0xFF, 0xF1, 0xFD, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0,
  0x03, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x03,
  0xFC, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xFC, 0x0F, 0xBF,
  0x87, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xF7, 0xF8, 0x1F, 0xFF, 0xF9,
  0xFC, 0x03, 0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0x87, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE1, 0xF8, 0x0F, 0xC0, 0xFF, 0xC3,
  0xFF, 0x1F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0,
  0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x03,
  0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0xFF, 0x04, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0xFC, 0xF8, 0x01, 0xF8, 0x7E, 0xFC, 0x01, 0xFF, 0x3F, 0x7E, 0x01, 0xFF,
  0xDF, 0xBF, 0x01, 0xFF, 0xEF, 0xDF, 0x81, 0xFF, 0xFF, 0xEF, 0xC0, 0xFE,
  0x0F, 0xF7, 0xE0, 0x7E, 0x03, 0xFB, 0xF0, 0x7E, 0x00, 0xFD, 0xF8, 0x3F,
  0x00, 0x7E, 0xFC, 0x1F, 0x80, 0x3F, 0x7E, 0x0F, 0xC0, 0x1F, 0xFF, 0x07,
  0xE0, 0x0F, 0xFF, 0x83, 0xF0, 0x07, 0xFF, 0xC1, 0xF8, 0x03, 0xFF, 0xE0,
  0xFC, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0xFD, 0xF8, 0x3F, 0x00, 0x7E, 0xFC,
  0x1F, 0x80, 0x3F, 0x7E, 0x0F, 0xC0, 0x1F, 0xBF, 0x07, 0xE0, 0x0F, 0xDF,
  0x83, 0xF0, 0x07, 0xEF, 0xC1, 0xF8, 0x03, 0xF7, 0xE0, 0x7E, 0x03, 0xFB,
  0xF0, 0x3F, 0xC7, 0xFD, 0xF8, 0x1F, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xBF,
  0x7E, 0x01, 0xFF, 0x9F, 0x9F, 0x80, 0x7F, 0x8F, 0xCF, 0xC0, 0x0F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xE0,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0x80, 0x0F, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE,
  0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0xC7, 0xF0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x03,
  0xFE, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0x83, 0xFC,
  0x00, 0x02, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x07, 0xF8, 0x00,
  0x03, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x02, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x01, 0xEF, 0xE1, 0xFF, 0xFF,
  0xE7, 0xF0, 0x7F, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xF1, 0xFC, 0x07, 0xFF,
  0xF0, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x04, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x03,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xE1,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFD, 0xF8, 0x0F, 0xBF, 0xFD, 0xF8, 0x1F, 0xBF, 0xFC, 0xFC,
  0x1F, 0xBF, 0xFC, 0xFC, 0x1F, 0x3F, 0xFC, 0xFC, 0x3F, 0x3F, 0xFC, 0x7E,
  0x3F, 0x3F, 0xFC, 0x7E, 0x3E, 0x3F, 0xFC, 0x7E, 0x7E, 0x3F, 0xFC, 0x3F,
  0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xC0, 0x3F, 0xFC, 0x03,
  0xC0, 0x3F, 0xFC, 0x01, 0x80, 0x3F, 0xFC, 0x01, 0x80, 0x3F, 0xFC, 0x00,
  0x80, 0x3F, 0xFC, 0x01, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x7F, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xCF,
  0xE0, 0x0F, 0xFF, 0x1F, 0x80, 0x3F, 0xFC, 0x7F, 0x00, 0xFF, 0xF0, 0xFC,
  0x03, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x0F, 0xE0, 0x3F, 0xFC, 0x1F, 0x80,
  0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F,
  0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x1F, 0x83, 0xFF, 0xC0, 0x7F, 0x0F, 0xFF,
  0x01, 0xFC, 0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xC0,
  0x3F, 0x8F, 0xFF, 0x00, 0x7E, 0x3F, 0xFC, 0x01, 0xFC, 0xFF, 0xF0, 0x03,
  0xF3, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x07, 0xFE, 0x7F,
  0x00, 0x03, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xDF, 0xC0, 0x03, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0xFE,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFE, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x07, 0x03, 0xF8, 0x00,
  0x00, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC2, 0x00, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x07,
  0xF8, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x7F, 0xC7, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0xFD, 0xFC, 0x07, 0xF8,
  0x0F, 0xE7, 0xE0, 0x3F, 0xC0, 0x7F, 0x3F, 0x01, 0xFE, 0x03, 0xF9, 0xF8,
  0x0F, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0xC0, 0xFC, 0x7E, 0x07, 0xFE, 0x07,
  0xE3, 0xF0, 0x3F, 0xF0, 0x3F, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0xFC, 0x0F,
  0xFE, 0x0F, 0xC7, 0xE0, 0x7D, 0xF0, 0x7E, 0x3F, 0x83, 0xCF, 0x83, 0xF1,
  0xFC, 0x3E, 0x7C, 0x1F, 0x8F, 0xE1, 0xF3, 0xE0, 0xFC, 0x7F, 0x0F, 0x9F,
  0x07, 0xE3, 0xF8, 0x7C, 0xFC, 0x3F, 0x0F, 0xC3, 0xE3, 0xE1, 0xF8, 0x7E,
  0x3E, 0x1F, 0x1F, 0xC3, 0xF1, 0xF0, 0xF8, 0xFE, 0x1F, 0x8F, 0x87, 0xC7,
  0xE0, 0xFC, 0x7C, 0x3F, 0x3F, 0x07, 0xE3, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xCF, 0xC1, 0xF9, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0x81, 0xF3, 0xF0,
  0x7E, 0x7C, 0x0F, 0x9F, 0x83, 0xF3, 0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0x03,
  0xF7, 0xE0, 0xFF, 0xF8, 0x0F, 0xBF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFE, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF1,
  0xE0, 0x00, 0x00, 0x78, 0x04, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xF8,
  0x1F, 0xC1, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x40, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x07, 0xF8, 0x06, 0x00, 0x03,
  0xFC, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF,
  0x8F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x1F, 0xFF,
  0xC0, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF,
  0xF8, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xF0, 0x1F,
  0xF8, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF,
  0xE0, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x07, 0x87, 0xF8, 0x00, 0x08, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x81, 0xFE,
  0x00, 0x03, 0x87, 0xF8, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x7F, 0x3F, 0xE0,
  0x03, 0xFC, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xF0, 0x7F,
  0x03, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0xFE, 0x7F,
  0x1F, 0xFF, 0xFF, 0x7F, 0x1F, 0xFC, 0x0F, 0x7F, 0x3F, 0xF0, 0x03, 0xFF,
  0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF,
  0x1F, 0xFC, 0x0F, 0x7F, 0x1F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFE, 0x7F,
  0x07, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xF0, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC,
  0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x20,
  0x3F, 0x80, 0x00, 0x70, 0x3F, 0xC0, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x7F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x0F, 0xFE, 0x07, 0xF1, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0xF1, 0xFC,
  0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xFE, 0x7F, 0xF0, 0x1F, 0xFB, 0xFE, 0x00,
  0x7F, 0xDF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x07, 0xFC, 0x3F,
  0x80, 0x07, 0xFC, 0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xE0, 0x07, 0xFC, 0x07,
  0xF0, 0x07, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x00,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F, 0x87, 0xFC, 0x00,
  0x1F, 0xC7, 0xFC, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x07, 0xF7, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00,
  0x1F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFE, 0x0F, 0xE0,
  0x00, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x1F, 0xE0, 0xFF, 0xCF, 0xCF, 0xFC, 0x3F, 0xF3, 0xF3, 0xFF, 0x9F,
  0xFE, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0x7F, 0xFB, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC,
  0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0xFC, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0xF0, 0x3F, 0x8F, 0xFF, 0xE1,
  0xFC, 0xFF, 0xFF, 0x8F, 0xE7, 0xFF, 0xFE, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF,
  0x80, 0xFF, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x1F, 0xFF,
  0xC0, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF,
  0xF8, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xF0, 0x1F,
  0xF8, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF,
  0xE0, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xF8,
  0x7F, 0x07, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0xFF,
  0x7F, 0x1F, 0xFC, 0x0F, 0x7F, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xFC, 0x0F,
  0x7F, 0x1F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xFC,
  0x7F, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFC, 0x01, 0xFE, 0xF8, 0x00, 0x00, 0xFF, 0x60, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0xC0, 0x00,
  0x70, 0x7F, 0x00, 0x00, 0x40, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x10, 0x00, 0x01, 0xFC, 0x70, 0x00, 0x03, 0xF9, 0xF0,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF,
  0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xC7, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xF3, 0xFC, 0x3F, 0xFF,
  0x8F, 0xF0, 0x3F, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x80, 0x7E, 0x7E, 0x01, 0xFF,
  0x01, 0xF9, 0xF8, 0x07, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xF0, 0x1F, 0x9F,
  0x80, 0xFF, 0xC0, 0x7E, 0x3F, 0x03, 0xEF, 0x01, 0xF8, 0xFC, 0x0F, 0xBC,
  0x07, 0xE3, 0xF0, 0x3C, 0xF8, 0x1F, 0x0F, 0xC0, 0xF3, 0xE0, 0x7C, 0x3F,
  0x07, 0xCF, 0x83, 0xF0, 0xFC, 0x1F, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x78,
  0x3F, 0x0F, 0xC1, 0xF1, 0xF0, 0xFC, 0x1F, 0x07, 0x87, 0xC3, 0xF0, 0x7E,
  0x1E, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x7C, 0x3E, 0x07, 0xE3, 0xE1, 0xF0,
  0xF8, 0x1F, 0x8F, 0x83, 0xC7, 0xE0, 0x7E, 0x3C, 0x0F, 0x9F, 0x81, 0xF8,
  0xF0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x0F, 0x9F, 0x03, 0xE7,
  0xE0, 0x3F, 0x7C, 0x0F, 0x9F, 0x00, 0xFD, 0xF0, 0x1E, 0x7C, 0x03, 0xF7,
  0x80, 0x7D, 0xF0, 0x0F, 0xDE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x00,
  0xFF, 0x80, 0x01, 0xF0, 0x7F, 0xF0, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x3F,
  0x1F, 0xFF, 0xC0, 0x0F, 0xC7, 0xFF, 0xF8, 0x03, 0xE3, 0xF8, 0xFF, 0x01,
  0xF8, 0xFC, 0x1F, 0xC0, 0x7E, 0x7E, 0x03, 0xF8, 0x3F, 0x1F, 0x80, 0x7F,
  0x1F, 0xC7, 0xE0, 0x1F, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x00,
  0x7F, 0xFC, 0x3F, 0x00, 0x0F, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x60,
  0x00, 0x1F, 0x80,
};

const GFXglyph IBMPlexMono_Medium67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 12, 48, 40, 14, -47 },
  { 73, 20, 20, 40, 10, -50 },
  { 123, 38, 47, 40, 1, -47 },
  { 347, 34, 62, 40, 3, -54 },
  { 611, 38, 49, 40, 1, -48 },
  { 844, 38, 49, 40, 1, -48 },
  { 1077, 6, 20, 40, 17, -50 },
  { 1092, 21, 60, 40, 13, -51 },
  { 1250, 21, 60, 40, 6, -51 },
  { 1408, 35, 34, 40, 3, -37 },
  { 1557, 32, 32, 40, 4, -36 },
  { 1685, 14, 20, 40, 13, -10 },
  { 1720, 20, 7, 40, 10, -24 },
  { 1738, 12, 11, 40, 14, -10 },
  { 1755, 29, 60, 40, 6, -51 },
  { 1973, 34, 49, 40, 3, -48 },
  { 2182, 35, 47, 40, 3, -47 },
  { 2388, 33, 48, 40, 4, -48 },
  { 2586, 33, 49, 40, 3, -48 },
  { 2789, 36, 47, 40, 2, -47 },
  { 3001, 33, 48, 40, 4, -47 },
  { 3199, 33, 48, 40, 4, -47 },
  { 3397, 32, 47, 40, 4, -47 },
  { 3585, 34, 49, 40, 3, -48 },
  { 3794, 34, 48, 40, 3, -48 },
  { 3998, 12, 36, 40, 14, -35 },
  { 4052, 14, 45, 40, 13, -35 },
  { 4131, 29, 39, 40, 6, -40 },
  { 4273, 32, 21, 40, 4, -31 },
  { 4357, 29, 39, 40, 6, -40 },
  { 4499, 30, 49, 40, 5, -48 },
  { 4683, 33, 56, 40, 3, -48 },
  { 4914, 38, 47, 40, 1, -47 },
  { 5138, 31, 47, 40, 6, -47 },
  { 5321, 33, 49, 40, 4, -48 },
  { 5524, 32, 47, 40, 5, -47 },
  { 5712, 29, 47, 40, 6, -47 },
  { 5883, 30, 47, 40, 6, -47 },
  { 6060, 33, 49, 40, 3, -48 },
  { 6263, 30, 47, 40, 5, -47 },
  { 6440, 30, 47, 40, 5, -47 },
  { 6617, 29, 48, 40, 4, -47 },
  { 6791, 34, 47, 40, 5, -47 },
  { 6991, 29, 47, 40, 7, -47 },
  { 7162, 32, 47, 40, 4, -47 },
  { 7350, 30, 47, 40, 5, -47 },
  { 7527, 34, 49, 40, 3, -48 },
  { 7736, 31, 47, 40, 6, -47 },
  { 7919, 34, 61, 40, 3, -48 },
  { 8179, 32, 47, 40, 6, -47 },
  { 8367, 34, 49, 40, 3, -48 },
  { 8576, 37, 47, 40, 2, -47 },
  { 8794, 31, 48, 40, 5, -47 },
  { 8980, 37, 47, 40, 2, -47 },
  { 9198, 37, 47, 40, 2, -47 },
  { 9416, 38, 47, 40, 1, -47 },
  { 9640, 38, 47, 40, 1, -47 },
  { 9864, 34, 47, 40, 3, -47 },
  { 10064, 20, 60, 40, 14, -51 },
  { 10214, 29, 60, 40, 6, -51 },
  { 10432, 20, 60, 40, 6, -51 },
  { 10582, 36, 29, 40, 2, -47 },
  { 10713, 32, 6, 40, 4, 6 },
  { 10737, 13, 14, 40, 11, -53 },
  { 10760, 33, 36, 40, 4, -35 },
  { 10909, 32, 51, 40, 5, -50 },
  { 11113, 30, 36, 40, 5, -35 },
  { 11248, 32, 51, 40, 3, -50 },
  { 11452, 32, 36, 40, 4, -35 },
  { 11596, 32, 50, 40, 5, -50 },
  { 11796, 34, 54, 40, 4, -40 },
  { 12026, 29, 50, 40, 6, -50 },
  { 12208, 30, 50, 40, 7, -50 },
  { 12396, 24, 63, 40, 6, -50 },
  { 12585, 33, 50, 40, 6, -50 },
  { 12792, 30, 50, 40, 5, -50 },
  { 12980, 34, 35, 40, 3, -35 },
  { 13129, 29, 35, 40, 6, -35 },
  { 13256, 33, 36, 40, 4, -35 },
  { 13405, 32, 48, 40, 5, -35 },
  { 13597, 32, 48, 40, 3, -35 },
  { 13789, 33, 35, 40, 5, -35 },
  { 13934, 31, 36, 40, 4, -35 },
  { 14074, 32, 47, 40, 3, -47 },
  { 14262, 30, 36, 40, 5, -35 },
  { 14397, 34, 35, 40, 3, -35 },
  { 14546, 38, 35, 40, 1, -35 },
  { 14713, 34, 35, 40, 3, -35 },
  { 14862, 35, 48, 40, 3, -35 },
  { 15072, 30, 35, 40, 5, -35 },
  { 15204, 27, 60, 40, 7, -51 },
  { 15407, 6, 60, 40, 17, -51 },
  { 15452, 27, 60, 40, 7, -51 },
  { 15655, 34, 16, 40, 3, -28 },
};

const GFXfont IBMPlexMono_Medium67pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium67pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium67pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _IBMPLEXMONO_MEDIUM67PT7B_H_
