#ifndef _IBMPLEXMONO_MEDIUM37PT7B_H_
#define _IBMPLEXMONO_MEDIUM37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium37pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xC3,
  0x0C, 0x30, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0x80, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x3F,
  0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0xC0, 0xF1, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x3F, 0xE3, 0xFC, 0xFF, 0x8F, 0xF3,
  0xFE, 0x3F, 0xC0, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7F,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xE7, 0x3E, 0x78, 0xE3, 0x8F, 0x1C,
  0x23, 0xC3, 0x80, 0x78, 0x70, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1F, 0xB8,
  0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x73,
  0xE0, 0x0E, 0x3C, 0x01, 0xC3, 0xC0, 0x38, 0x78, 0x07, 0x0F, 0x60, 0xE3,
  0xDE, 0x1C, 0x7B, 0xF3, 0xBF, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x3C, 0xFF, 0x00, 0xE7, 0xFE, 0x07, 0x1E, 0x38, 0x1C, 0x70, 0x70, 0xE1,
  0xC1, 0xC3, 0x87, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x73, 0x81, 0xE3,
  0x9E, 0x07, 0xFE, 0x70, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x00, 0xF7, 0xFE, 0x07, 0x9C, 0x38, 0x1C, 0x70, 0xE0,
  0xF3, 0x81, 0xC3, 0x8E, 0x07, 0x1E, 0x38, 0x1C, 0x70, 0x70, 0xE3, 0xC1,
  0xC3, 0x8E, 0x07, 0xFE, 0x78, 0x0F, 0xF3, 0xC0, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3C, 0x3C, 0x03, 0xC0, 0xE0, 0x1E,
  0x04, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x3F, 0x1F, 0xE1, 0xF9, 0xE7,
  0x8F, 0xCE, 0x3E, 0x70, 0xF0, 0xF3, 0x87, 0x83, 0xDC, 0x3C, 0x0F, 0xE1,
  0xE0, 0x3E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0xC1, 0xF0, 0xFF, 0x0F, 0xFE,
  0x7C, 0x3F, 0xE1, 0xE0, 0x7E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x06, 0x0F, 0x06, 0x7C, 0xF1, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x79, 0xE0, 0x0F, 0x8F, 0x00, 0xF0, 0xF8, 0x1E, 0x07, 0x80,
  0xE0, 0x30, 0x04, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0x3E, 0x3E, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x0F, 0x87, 0xC0, 0x78, 0xF0,
  0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC7,
  0x8F, 0x78, 0xF1, 0xFF, 0x1E, 0x3F, 0xE3, 0xC7, 0xFC, 0x78, 0xFF, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xE7, 0x80,
  0x78, 0xF8, 0x0F, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xBC, 0x03, 0xE7,
  0x80, 0xF8, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC0, 0x70, 0x78, 0x04, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xF0, 0x7C,
  0xF8, 0x0F, 0xBC, 0x01, 0xE3, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x07, 0xC7,
  0xC0, 0x7C, 0x30, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x98,
  0x01, 0xF3, 0x00, 0x3E, 0xF0, 0x0F, 0xBF, 0x83, 0xF1, 0xFF, 0xFC, 0x1F,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0,
  0x03, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF8, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x8F, 0x81, 0xEF, 0xF8,
  0x7F, 0xFF, 0x1F, 0x87, 0xE7, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x80, 0x0F, 0x30, 0x07, 0xDE, 0x01, 0xEF, 0xC1,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x8F, 0xC1, 0xEF, 0xF8, 0xFF,
  0xFF, 0xBD, 0x83, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xE3, 0xE0, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xF1, 0xF0, 0x3E, 0x78, 0x07, 0x9E, 0x01, 0xF7, 0x80, 0x3D, 0xE0, 0x0F,
  0x78, 0x07, 0x9E, 0x01, 0xE3, 0xE0, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x07,
  0xFF, 0xC7, 0xC0, 0xF9, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xF7, 0xC0, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1,
  0xF8, 0x7C, 0x78, 0x07, 0xBE, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x7E, 0x0B, 0xCF, 0xFE,
  0xF1, 0xFF, 0x7C, 0x1F, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0x3C, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E,
  0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x07, 0xE0, 0x3F, 0xF8, 0x7F, 0xFE, 0xFC, 0x3E, 0xF0, 0x1F, 0xF0,
  0x0F, 0x20, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xF8, 0x3C, 0x38, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3D, 0xC1, 0xE7, 0xF0,
  0xFD, 0xF8, 0x7F, 0x7E, 0x1C, 0x3F, 0x8F, 0x07, 0xE3, 0x81, 0xF8, 0xE0,
  0x7E, 0x38, 0x1F, 0x8E, 0x07, 0xE3, 0x81, 0xF8, 0xE0, 0x7E, 0x3C, 0x1F,
  0x87, 0x0F, 0xE1, 0xFD, 0xFC, 0x7F, 0x77, 0x0F, 0x9D, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x9F, 0x00, 0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0x9F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0xF3, 0xC0, 0x7D, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7D, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFC, 0x3E, 0x3C, 0x07, 0xDF, 0x00, 0xF7, 0x80, 0x39, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x0E, 0x7C, 0x03, 0xCF, 0x01, 0xF3, 0xF0, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E,
  0x07, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xF7, 0x80, 0xFB, 0xC0, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x7E, 0x7C, 0x07,
  0x9E, 0x01, 0xF7, 0x80, 0x33, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0x78, 0x07,
  0xDF, 0x01, 0xF3, 0xE0, 0xFC, 0xFF, 0xEF, 0x1F, 0xF3, 0xC1, 0xF0, 0xF0,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x10, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE,
  0x1F, 0xF8, 0x07, 0xE0, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x3E, 0x78,
  0x0F, 0x8F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0xC0, 0xF1,
  0xF0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0x3C, 0x07, 0xE7, 0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x78, 0x1F, 0x0F, 0x01, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0xDE, 0x00, 0x7C, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xF1, 0xDF, 0xDC, 0xF7, 0xF7, 0x39, 0xFD, 0xEE, 0x7F, 0x3F, 0x3F, 0xCF,
  0xCF, 0xF1, 0xF3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC3, 0x0F, 0xF0, 0xC3,
  0xFC, 0x10, 0xFF, 0x08, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xB8, 0x1F,
  0xDE, 0x0F, 0xE7, 0x07, 0xF3, 0xC3, 0xF9, 0xE1, 0xFC, 0x70, 0xFE, 0x3C,
  0x7F, 0x1E, 0x3F, 0x87, 0x1F, 0xC3, 0xCF, 0xE0, 0xE7, 0xF0, 0x7B, 0xF8,
  0x3D, 0xFC, 0x0E, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC,
  0x1F, 0x0F, 0x87, 0xC0, 0x78, 0xF0, 0x0F, 0x3E, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0x7C, 0x01, 0xE7, 0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x87, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F,
  0xFF, 0xDE, 0x03, 0xEF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xEF, 0xFF, 0xF7, 0xFF,
  0xF3, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x0F,
  0x87, 0xC0, 0x78, 0xF0, 0x0F, 0x3E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F,
  0x7C, 0x01, 0xE7, 0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x87, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xC0, 0x7C, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x7C, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0x03, 0xC3, 0xC0, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0xBC, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F,
  0xFF, 0x1F, 0x83, 0xF3, 0xC0, 0x1C, 0x78, 0x01, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF3, 0x00, 0x1E, 0xF0, 0x07, 0xFF, 0x81,
  0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0x79,
  0xF0, 0x7C, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03,
  0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x70, 0xF8,
  0xF7, 0x1F, 0x8F, 0x71, 0xF8, 0xF7, 0x1F, 0x8E, 0x71, 0xD8, 0xE7, 0x19,
  0xCE, 0x71, 0x9C, 0xE7, 0x39, 0xCE, 0x7B, 0x9C, 0xE7, 0xB9, 0xCE, 0x7B,
  0x8E, 0xE7, 0xB0, 0xEE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xE3,
  0xF0, 0xFE, 0x3F, 0x07, 0xE3, 0xE0, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F,
  0x0F, 0x00, 0xF8, 0x7C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0x3E,
  0x3C, 0x00, 0xF3, 0xE0, 0x07, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFE, 0x00, 0x3C, 0xF8, 0x03, 0xC3, 0xC0, 0x1E, 0x1F, 0x01,
  0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x78, 0x01,
  0xF7, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE3, 0xC0, 0x0F,
  0x0F, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x03,
  0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0x9E, 0x00, 0x79, 0xE0,
  0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xF3, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0xE3, 0xE3, 0xC3,
  0xC3, 0xC3, 0x86, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3E, 0x0F,
  0x83, 0x00, 0xF0, 0x40, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3E, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xC3, 0xC1, 0xB8, 0x7F, 0xF7, 0xE7, 0xFC, 0xFC, 0x3E, 0x0F,
  0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF1, 0xF8, 0x79, 0xFE, 0x3D, 0xFF,
  0x9F, 0x83, 0xEF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xF8, 0x3E, 0xF7, 0xFE, 0x79, 0xFE, 0x3C, 0x7E, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF7, 0x80, 0x23,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x21, 0xE0, 0x3C, 0xF8, 0x3F, 0x3F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xC7, 0x8F,
  0xF3, 0xCF, 0xFD, 0xEF, 0xC3, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x3D, 0xE0, 0x1E, 0xFC, 0x3F, 0x3F, 0xF7, 0x8F, 0xFB, 0xC1,
  0xF1, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x78,
  0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xC7, 0xC0, 0x38,
  0xF8, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x81, 0xFA, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x87, 0xC3,
  0xE0, 0x7C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x07, 0x83,
  0xE1, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0x9C,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC0, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF8, 0xF3, 0xFC,
  0xF7, 0xFE, 0xF4, 0x3F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x9F, 0xFE,
  0x7F, 0xF1, 0xFF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0xFC, 0x07, 0xCF, 0x03, 0xE3, 0xC1, 0xF0, 0xF0, 0xF8, 0x3C, 0x7C, 0x0F,
  0x3E, 0x03, 0xDF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xDF, 0x03, 0xE3,
  0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F,
  0xBC, 0x01, 0xEF, 0x00, 0x7C, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0x87, 0x9D, 0xF9, 0xFB, 0xFF, 0x7F, 0x78, 0xE9, 0xEE, 0x1E, 0x1D, 0xC3,
  0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xE1, 0xE1, 0xFC, 0x3C, 0x3F, 0x87,
  0x87, 0xF0, 0xF0, 0xFE, 0x1E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F,
  0x0F, 0xE1, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0x80, 0xF1, 0xF8, 0xF3,
  0xFC, 0xF7, 0xFE, 0xF4, 0x3F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF8, 0x7C, 0x78, 0x07, 0x9E, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x78, 0xF8, 0x7C, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xF1, 0xF8, 0x79, 0xFE, 0x3D, 0xFF,
  0x9F, 0x83, 0xEF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xF8, 0x3E, 0xF7, 0xFE, 0x79, 0xFE, 0x3C, 0x7E, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD, 0xEF, 0xC3, 0xF7, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3D, 0xE0, 0x1E, 0xFC, 0x3F,
  0x3F, 0xF7, 0x8F, 0xFB, 0xC1, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFC, 0x1E, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xF8,
  0xF0, 0x3E, 0x78, 0x03, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x88, 0x00,
  0xF7, 0x00, 0x7B, 0xF0, 0x3E, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C, 0x3F, 0x7F, 0xEF,
  0x3F, 0xCF, 0x0F, 0x8F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0,
  0x1E, 0x78, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0E,
  0x07, 0x87, 0x80, 0xE1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x01, 0xCF, 0x00,
  0x7B, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xE0,
  0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF8, 0x7F, 0x0F, 0x87, 0xF1, 0xF8, 0x7F,
  0x1F, 0x87, 0x71, 0xD8, 0xF7, 0x19, 0x8E, 0x71, 0x9C, 0xE7, 0x19, 0xCE,
  0x73, 0x9C, 0xE7, 0xB8, 0xCE, 0x7B, 0x8C, 0xE3, 0xB0, 0xEE, 0x3B, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8,
  0x03, 0xCF, 0x80, 0xF0, 0xF0, 0x3C, 0x1F, 0x0F, 0x81, 0xF1, 0xE0, 0x1E,
  0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1E, 0x7C, 0x07, 0x87, 0x81, 0xE0,
  0xF8, 0x3C, 0x0F, 0x8F, 0x00, 0xF3, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF7,
  0x80, 0x1E, 0x7C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x38,
  0x1E, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8E,
  0x00, 0x79, 0xE0, 0x03, 0x9E, 0x00, 0x3D, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xC0, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x80, 0x1F, 0x01, 0xC7, 0xF0, 0x3D, 0xFF, 0x07, 0x38, 0xF0, 0xEF, 0x1F,
  0x39, 0xC1, 0xFF, 0x38, 0x1F, 0xC7, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Medium37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 11, 11, 22, 6, -27 },
  { 37, 22, 26, 22, 0, -26 },
  { 109, 19, 34, 22, 2, -30 },
  { 190, 22, 26, 22, 0, -26 },
  { 262, 21, 26, 22, 1, -26 },
  { 331, 4, 11, 22, 9, -27 },
  { 337, 12, 33, 22, 7, -28 },
  { 387, 12, 33, 22, 3, -28 },
  { 437, 20, 19, 22, 1, -20 },
  { 485, 18, 17, 22, 2, -20 },
  { 524, 8, 11, 22, 7, -6 },
  { 535, 11, 3, 22, 6, -12 },
  { 540, 6, 6, 22, 8, -6 },
  { 545, 16, 33, 22, 3, -28 },
  { 611, 19, 26, 22, 2, -26 },
  { 673, 19, 26, 22, 2, -26 },
  { 735, 18, 26, 22, 2, -26 },
  { 794, 19, 26, 22, 1, -26 },
  { 856, 20, 26, 22, 1, -26 },
  { 921, 18, 26, 22, 2, -26 },
  { 980, 18, 26, 22, 2, -26 },
  { 1039, 18, 26, 22, 2, -26 },
  { 1098, 18, 26, 22, 2, -26 },
  { 1157, 18, 26, 22, 2, -26 },
  { 1216, 6, 20, 22, 8, -20 },
  { 1231, 8, 25, 22, 7, -20 },
  { 1256, 16, 22, 22, 3, -22 },
  { 1300, 18, 11, 22, 2, -17 },
  { 1325, 16, 22, 22, 3, -22 },
  { 1369, 16, 26, 22, 3, -26 },
  { 1421, 18, 30, 22, 2, -26 },
  { 1489, 21, 26, 22, 1, -26 },
  { 1558, 17, 26, 22, 3, -26 },
  { 1614, 18, 26, 22, 2, -26 },
  { 1673, 17, 26, 22, 3, -26 },
  { 1729, 16, 26, 22, 3, -26 },
  { 1781, 17, 26, 22, 3, -26 },
  { 1837, 18, 26, 22, 2, -26 },
  { 1896, 17, 26, 22, 3, -26 },
  { 1952, 16, 26, 22, 3, -26 },
  { 2004, 16, 26, 22, 2, -26 },
  { 2056, 19, 26, 22, 3, -26 },
  { 2118, 16, 26, 22, 4, -26 },
  { 2170, 18, 26, 22, 2, -26 },
  { 2229, 17, 26, 22, 3, -26 },
  { 2285, 19, 26, 22, 2, -26 },
  { 2347, 17, 26, 22, 3, -26 },
  { 2403, 19, 32, 22, 2, -26 },
  { 2479, 18, 26, 22, 3, -26 },
  { 2538, 19, 26, 22, 1, -26 },
  { 2600, 20, 26, 22, 1, -26 },
  { 2665, 17, 26, 22, 3, -26 },
  { 2721, 20, 26, 22, 1, -26 },
  { 2786, 20, 26, 22, 1, -26 },
  { 2851, 21, 26, 22, 1, -26 },
  { 2920, 22, 26, 22, 0, -26 },
  { 2992, 18, 26, 22, 2, -26 },
  { 3051, 11, 33, 22, 8, -28 },
  { 3097, 16, 33, 22, 3, -28 },
  { 3163, 12, 33, 22, 3, -28 },
  { 3213, 20, 16, 22, 1, -26 },
  { 3253, 18, 3, 22, 2, 3 },
  { 3260, 7, 8, 22, 6, -29 },
  { 3267, 19, 19, 22, 2, -19 },
  { 3313, 17, 27, 22, 3, -27 },
  { 3371, 17, 19, 22, 3, -19 },
  { 3412, 17, 27, 22, 2, -27 },
  { 3470, 18, 19, 22, 2, -19 },
  { 3513, 17, 27, 22, 3, -27 },
  { 3571, 19, 29, 22, 2, -22 },
  { 3640, 16, 27, 22, 3, -27 },
  { 3694, 16, 27, 22, 4, -27 },
  { 3748, 14, 34, 22, 3, -27 },
  { 3808, 18, 27, 22, 3, -27 },
  { 3869, 16, 27, 22, 3, -27 },
  { 3923, 19, 19, 22, 2, -19 },
  { 3969, 16, 19, 22, 3, -19 },
  { 4007, 18, 19, 22, 2, -19 },
  { 4050, 17, 26, 22, 3, -19 },
  { 4106, 17, 26, 22, 2, -19 },
  { 4162, 18, 19, 22, 3, -19 },
  { 4205, 18, 19, 22, 2, -19 },
  { 4248, 19, 26, 22, 1, -26 },
  { 4310, 16, 19, 22, 3, -19 },
  { 4348, 18, 19, 22, 2, -19 },
  { 4391, 20, 19, 22, 1, -19 },
  { 4439, 19, 19, 22, 2, -19 },
  { 4485, 20, 26, 22, 1, -19 },
  { 4550, 16, 19, 22, 3, -19 },
  { 4588, 15, 33, 22, 4, -28 },
  { 4650, 4, 33, 22, 9, -28 },
  { 4667, 15, 33, 22, 4, -28 },
  { 4729, 19, 8, 22, 2, -15 },
};

const GFXfont IBMPlexMono_Medium37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_MEDIUM37PT7B_H_
