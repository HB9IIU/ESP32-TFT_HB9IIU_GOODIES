#ifndef _IBMPLEXMONO_MEDIUM47PT7B_H_
#define _IBMPLEXMONO_MEDIUM47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium47pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x01, 0xFF, 0xC3, 0xFF,
  0xBF, 0xF8, 0x7F, 0xF7, 0xFF, 0x0F, 0xFE, 0xFF, 0xC1, 0xFF, 0xC0, 0x78,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x07, 0x80, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0x87,
  0xFF, 0x3F, 0xF0, 0xFF, 0xE0, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0x9C, 0xFF, 0x3E, 0x1C, 0x3E,
  0x7E, 0x1C, 0x1C, 0x7C, 0x1C, 0x10, 0x7C, 0x1C, 0x00, 0x7C, 0x1C, 0x00,
  0x7C, 0x1C, 0x00, 0x7E, 0x1C, 0x00, 0x3E, 0x1C, 0x00, 0x3F, 0x9C, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1C, 0xFE, 0x00, 0x1C, 0x3F, 0x00, 0x1C, 0x1F,
  0x00, 0x1C, 0x1F, 0x00, 0x1C, 0x1F, 0x00, 0x1C, 0x1F, 0x00, 0x1C, 0x1F,
  0x10, 0x1C, 0x1F, 0x38, 0x1C, 0x3F, 0xFC, 0x1C, 0x3E, 0xFF, 0x9C, 0xFE,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xE7, 0xFC, 0x00, 0x79, 0xFF, 0xC0,
  0x1E, 0x3F, 0xFC, 0x03, 0xCF, 0x87, 0x80, 0xF1, 0xE0, 0x78, 0x1E, 0x3C,
  0x0F, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0xF0, 0x3C, 0x3E, 0x1E, 0x07, 0x87,
  0x83, 0xC0, 0xF1, 0xF0, 0x78, 0x1E, 0x3C, 0x0F, 0x87, 0x8F, 0x80, 0xFF,
  0xF1, 0xE0, 0x1F, 0xFC, 0x7C, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xF1, 0xFF, 0xC0, 0x3C,
  0x7F, 0xF8, 0x07, 0x8F, 0x0F, 0x81, 0xE3, 0xE0, 0xF0, 0x3C, 0x78, 0x1E,
  0x0F, 0x0F, 0x01, 0xC3, 0xE1, 0xE0, 0x3C, 0x78, 0x3C, 0x07, 0x1F, 0x07,
  0x81, 0xE3, 0xC0, 0x78, 0x3C, 0xF8, 0x0F, 0x0F, 0x9E, 0x01, 0xFF, 0xE7,
  0xC0, 0x1F, 0xFC, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0x83, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x0C, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFE, 0x0F, 0xF3, 0xFF, 0xC3, 0xFD,
  0xF9, 0xF8, 0xF0, 0x7C, 0x3E, 0x3C, 0x3E, 0x07, 0xCF, 0x0F, 0x80, 0xFB,
  0xC3, 0xE0, 0x3F, 0xF0, 0xF8, 0x07, 0xF8, 0x3E, 0x00, 0xFE, 0x0F, 0x80,
  0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7C, 0x03, 0xFC, 0x1F, 0xC1, 0xDF, 0x83,
  0xFF, 0xF3, 0xF0, 0xFF, 0xF8, 0x7E, 0x0F, 0xFC, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x80, 0x3C, 0x02, 0x70, 0x3C, 0x0E, 0xFE, 0x3C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0x00, 0xF8, 0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xCF, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07,
  0x83, 0xE0, 0xF8, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC1, 0xF8, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x81,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x0E, 0x07, 0xE0, 0x02,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x1F,
  0x80, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x30, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0x87, 0xC0,
  0x1F, 0x87, 0x00, 0x3F, 0x04, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0xC0,
  0x01, 0xFB, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0xE0, 0x7F, 0x9F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1E,
  0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x87, 0xE0, 0x1E, 0x3F, 0xF0, 0x3C, 0xFF, 0xF8, 0x7B, 0xFF, 0xF8, 0xFE,
  0x07, 0xF1, 0xF8, 0x07, 0xF0, 0x40, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0xC0, 0x01, 0xF3, 0xC0, 0x07, 0xEF, 0xC0, 0x1F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x7E, 0x7F, 0xF0, 0x7E, 0xFF, 0xF8,
  0x7D, 0xFF, 0xFC, 0x7D, 0x81, 0xFC, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x1F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3E, 0xF0, 0x01, 0xFB, 0xC0, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x81, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x81, 0xFE, 0x3F, 0xFF,
  0xBE, 0x1F, 0xFF, 0x3E, 0x07, 0xFE, 0x7E, 0x01, 0xF8, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x1F,
  0x0F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E,
  0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7,
  0xF0, 0x7F, 0x3F, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0x08, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F,
  0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x1F, 0x3D, 0xE0, 0x7F, 0x7B,
  0xC1, 0xFF, 0xF7, 0x87, 0xFF, 0xEF, 0x0F, 0x87, 0xDE, 0x1E, 0x07, 0xFC,
  0x7C, 0x0F, 0xF8, 0xF8, 0x1F, 0xF1, 0xE0, 0x3F, 0xE3, 0xC0, 0x7F, 0xC7,
  0x80, 0xFF, 0x8F, 0x01, 0xFF, 0x1E, 0x03, 0xDE, 0x3E, 0x07, 0xBC, 0x3C,
  0x0F, 0x78, 0x78, 0x3E, 0xF0, 0xFF, 0xFD, 0xE0, 0xFF, 0xFB, 0xC1, 0xFE,
  0xF7, 0xC1, 0xF9, 0xE7, 0x80, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x07, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0x3E, 0x00,
  0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8,
  0x03, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC1, 0xF8, 0x3F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3F,
  0x7C, 0x00, 0x38, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x71, 0xF0, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x7F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x0F, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x1F,
  0x9F, 0x00, 0x3F, 0x7E, 0x00, 0x38, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xFF, 0xEF, 0x87, 0xFF, 0x9F,
  0x07, 0xFE, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03,
  0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F,
  0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xFB, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0x3F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F,
  0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFB,
  0xC1, 0xFF, 0xF7, 0x87, 0xBF, 0xEF, 0x8F, 0x7F, 0xCF, 0x3C, 0xFF, 0x9F,
  0x79, 0xFF, 0x1E, 0xF3, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0x8F, 0xF8, 0x7E,
  0x1F, 0xF0, 0xFC, 0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xE0, 0xFF, 0x83, 0xC1,
  0xFF, 0x03, 0x03, 0xFE, 0x06, 0x07, 0xFC, 0x0C, 0x0F, 0xF8, 0x10, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3E, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFB, 0xC0, 0x7F, 0xEF, 0x81, 0xFF, 0x9E, 0x07, 0xFE, 0x7C, 0x1F, 0xF9,
  0xF0, 0x7F, 0xE3, 0xC1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0x78,
  0x7F, 0xE1, 0xF1, 0xFF, 0x83, 0xC7, 0xFE, 0x0F, 0x9F, 0xF8, 0x3E, 0x7F,
  0xE0, 0x79, 0xFF, 0x81, 0xF7, 0xFE, 0x07, 0xDF, 0xF8, 0x0F, 0x7F, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xF8, 0x03, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xF8, 0x03, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x00, 0x3C, 0x7E, 0x00, 0x18, 0x7E, 0x00, 0x10, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x30, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFF,
  0x81, 0xFC, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0,
  0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF8, 0xFC, 0x0F,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8, 0x00,
  0x3E, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xE0,
  0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07,
  0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0x78, 0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE7, 0x83, 0xF0, 0x79,
  0xE0, 0xFC, 0x1E, 0x7C, 0x3F, 0x87, 0x9F, 0x0F, 0xE1, 0xE7, 0xC7, 0xF8,
  0x79, 0xF1, 0xEE, 0x1E, 0x7C, 0x73, 0x87, 0x9F, 0x1C, 0xF3, 0xE7, 0xC7,
  0x3C, 0xF8, 0xF3, 0xCF, 0x3E, 0x3C, 0xF3, 0xCF, 0x8F, 0x3C, 0x73, 0xE3,
  0xCE, 0x1E, 0xF0, 0xF3, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x83, 0xBC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F,
  0x83, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x83,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x30, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x3C, 0x3F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x7E, 0x0F, 0x00, 0x7E,
  0x04, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0xC1, 0xDF, 0xDF, 0xFF,
  0xBF, 0xBF, 0xFE, 0x7F, 0x1F, 0xF8, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x87, 0xF0, 0x3E, 0x3F, 0xE0, 0xF9, 0xFF, 0xE3, 0xEF, 0xFF,
  0x8F, 0xF0, 0x7F, 0x3F, 0x00, 0xFE, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF,
  0xC1, 0xFC, 0xFB, 0xFF, 0xE3, 0xE7, 0xFF, 0x8F, 0x8F, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x07, 0x1F, 0x00, 0x10, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x02, 0x0F, 0x80, 0x1C, 0x3F, 0x00, 0xFC, 0x7E,
  0x07, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x87, 0xC1, 0xFF, 0x1F, 0x0F, 0xFF,
  0x7C, 0x7F, 0xFD, 0xF3, 0xF8, 0x3F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF8, 0x01, 0xF3,
  0xF0, 0x0F, 0xCF, 0xE0, 0xFF, 0x1F, 0xFF, 0x7C, 0x3F, 0xFD, 0xF0, 0x7F,
  0xE7, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF0, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9E,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x02, 0x1F, 0x00, 0x1C, 0x3E,
  0x00, 0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x38, 0x00, 0x3E,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF, 0xCF,
  0xBF, 0xFE, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xEF,
  0x80, 0x1F, 0x9F, 0x00, 0xFE, 0x3E, 0x03, 0xF8, 0x7C, 0x0F, 0xE0, 0xF8,
  0x3F, 0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xCF, 0xC0, 0x0F, 0xBF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xBF, 0x00, 0xFE, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xFC,
  0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF9,
  0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x78, 0xF3, 0xF9, 0xFE, 0xF7, 0xF9, 0xFE, 0xF7,
  0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x00, 0x7E, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF,
  0xCF, 0xBF, 0xFE, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x03, 0xE3, 0xFE, 0x0F, 0x9F, 0xFE, 0x3E, 0xFF, 0xF8, 0xFF, 0x07,
  0xF3, 0xF0, 0x0F, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xFC, 0x1F, 0xCF,
  0xBF, 0xFE, 0x3E, 0x7F, 0xF8, 0xF8, 0xFF, 0x83, 0xE1, 0xF8, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF1, 0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0xDF, 0x3F, 0x83, 0xFC, 0xFC,
  0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0xFC, 0xFE, 0x0F, 0xF1, 0xFF, 0xF7,
  0xC3, 0xFF, 0xDF, 0x07, 0xFE, 0x7C, 0x07, 0xE1, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0x03, 0xEE, 0x00, 0x0F, 0xA0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x3F, 0x01, 0xF9, 0xF8, 0x01, 0xC7, 0xC0, 0x02, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF2, 0x00, 0x07, 0xCC, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xFC,
  0x0F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0x7E, 0x0F, 0xF7, 0xFF, 0xDF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xE0,
  0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0xF0, 0x1F, 0x03, 0xFC, 0x0F, 0xC0, 0xFF, 0x83, 0xF0,
  0x3F, 0xE0, 0xFC, 0x0F, 0x78, 0x3F, 0x03, 0xDE, 0x0F, 0xE1, 0xE7, 0x83,
  0xB8, 0x79, 0xE1, 0xEE, 0x1E, 0x78, 0x73, 0x87, 0x9E, 0x1C, 0xE1, 0xE7,
  0xC7, 0x3C, 0x78, 0xF1, 0xCF, 0x1E, 0x3C, 0xF1, 0xC7, 0x8F, 0x38, 0x73,
  0xC3, 0xCE, 0x1C, 0xF0, 0xF3, 0x87, 0x3C, 0x3C, 0xE1, 0xEF, 0x0F, 0x38,
  0x7B, 0xC1, 0xDE, 0x0E, 0xF0, 0x7F, 0x03, 0xBC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0xC1, 0xF0,
  0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xE7, 0xE0,
  0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0,
  0x01, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x0E, 0x0F,
  0xE0, 0x0F, 0x1F, 0xF0, 0x0F, 0x3F, 0xF8, 0x0F, 0x3C, 0x7C, 0x1E, 0x78,
  0x3E, 0x1E, 0x78, 0x3F, 0x3E, 0x78, 0x1F, 0xFC, 0xF0, 0x0F, 0xF8, 0xF0,
  0x07, 0xF8, 0x70, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_Medium47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 33, 28, 10, -33 },
  { 34, 14, 14, 28, 7, -35 },
  { 59, 27, 33, 28, 1, -33 },
  { 171, 24, 44, 28, 2, -38 },
  { 303, 27, 34, 28, 1, -33 },
  { 418, 26, 34, 28, 1, -33 },
  { 529, 4, 14, 28, 12, -35 },
  { 536, 15, 42, 28, 9, -36 },
  { 615, 15, 42, 28, 4, -36 },
  { 694, 24, 24, 28, 2, -26 },
  { 766, 22, 22, 28, 3, -25 },
  { 827, 10, 14, 28, 9, -7 },
  { 845, 14, 5, 28, 7, -17 },
  { 854, 8, 8, 28, 10, -7 },
  { 862, 20, 42, 28, 4, -36 },
  { 967, 24, 34, 28, 2, -33 },
  { 1069, 25, 33, 28, 2, -33 },
  { 1173, 23, 33, 28, 3, -33 },
  { 1268, 23, 34, 28, 2, -33 },
  { 1366, 26, 33, 28, 1, -33 },
  { 1474, 23, 34, 28, 3, -33 },
  { 1572, 24, 34, 28, 2, -33 },
  { 1674, 22, 33, 28, 3, -33 },
  { 1765, 24, 34, 28, 2, -33 },
  { 1867, 24, 33, 28, 2, -33 },
  { 1966, 8, 25, 28, 10, -24 },
  { 1991, 10, 31, 28, 9, -24 },
  { 2030, 20, 28, 28, 4, -28 },
  { 2100, 22, 14, 28, 3, -21 },
  { 2139, 20, 28, 28, 4, -28 },
  { 2209, 21, 33, 28, 3, -33 },
  { 2296, 23, 38, 28, 2, -33 },
  { 2406, 26, 33, 28, 1, -33 },
  { 2514, 22, 33, 28, 4, -33 },
  { 2605, 23, 34, 28, 3, -33 },
  { 2703, 22, 33, 28, 4, -33 },
  { 2794, 21, 33, 28, 4, -33 },
  { 2881, 21, 33, 28, 4, -33 },
  { 2968, 23, 34, 28, 2, -33 },
  { 3066, 22, 33, 28, 3, -33 },
  { 3157, 20, 33, 28, 4, -33 },
  { 3240, 20, 34, 28, 3, -33 },
  { 3325, 24, 33, 28, 4, -33 },
  { 3424, 20, 33, 28, 5, -33 },
  { 3507, 23, 33, 28, 3, -33 },
  { 3602, 22, 33, 28, 3, -33 },
  { 3693, 24, 34, 28, 2, -33 },
  { 3795, 22, 33, 28, 4, -33 },
  { 3886, 24, 41, 28, 2, -33 },
  { 4009, 22, 33, 28, 4, -33 },
  { 4100, 24, 34, 28, 2, -33 },
  { 4202, 26, 33, 28, 1, -33 },
  { 4310, 22, 34, 28, 3, -33 },
  { 4404, 26, 33, 28, 1, -33 },
  { 4512, 26, 33, 28, 1, -33 },
  { 4620, 26, 33, 28, 1, -33 },
  { 4728, 27, 33, 28, 1, -33 },
  { 4840, 24, 33, 28, 2, -33 },
  { 4939, 14, 42, 28, 10, -36 },
  { 5013, 20, 42, 28, 4, -36 },
  { 5118, 14, 42, 28, 4, -36 },
  { 5192, 24, 20, 28, 2, -33 },
  { 5252, 22, 4, 28, 3, 4 },
  { 5263, 9, 10, 28, 8, -37 },
  { 5275, 23, 26, 28, 3, -25 },
  { 5350, 22, 36, 28, 4, -35 },
  { 5449, 22, 26, 28, 3, -25 },
  { 5521, 22, 36, 28, 2, -35 },
  { 5620, 22, 26, 28, 3, -25 },
  { 5692, 23, 35, 28, 3, -35 },
  { 5793, 24, 38, 28, 3, -28 },
  { 5907, 20, 35, 28, 4, -35 },
  { 5995, 21, 35, 28, 5, -35 },
  { 6087, 17, 44, 28, 4, -35 },
  { 6181, 23, 35, 28, 4, -35 },
  { 6282, 21, 35, 28, 4, -35 },
  { 6374, 24, 25, 28, 2, -25 },
  { 6449, 20, 25, 28, 4, -25 },
  { 6512, 23, 26, 28, 3, -25 },
  { 6587, 22, 34, 28, 4, -25 },
  { 6681, 22, 34, 28, 2, -25 },
  { 6775, 22, 24, 28, 4, -24 },
  { 6841, 22, 26, 28, 3, -25 },
  { 6913, 23, 33, 28, 2, -33 },
  { 7008, 20, 25, 28, 4, -24 },
  { 7071, 24, 24, 28, 2, -24 },
  { 7143, 26, 24, 28, 1, -24 },
  { 7221, 24, 24, 28, 2, -24 },
  { 7293, 24, 33, 28, 2, -24 },
  { 7392, 21, 24, 28, 4, -24 },
  { 7455, 19, 42, 28, 5, -36 },
  { 7555, 4, 42, 28, 12, -36 },
  { 7576, 19, 42, 28, 5, -36 },
  { 7676, 24, 11, 28, 2, -20 },
};

const GFXfont IBMPlexMono_Medium47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_MEDIUM47PT7B_H_
