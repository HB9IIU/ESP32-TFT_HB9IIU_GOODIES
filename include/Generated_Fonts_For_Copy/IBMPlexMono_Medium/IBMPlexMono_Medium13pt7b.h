#ifndef _IBMPLEXMONO_MEDIUM13PT7B_H_
#define _IBMPLEXMONO_MEDIUM13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA3, 0xC0, 0x99, 0x99, 0x16, 0x14, 0x34, 0x67, 0x24, 0xEE,
  0x28, 0x28, 0x68, 0x31, 0xED, 0x64, 0xD1, 0xE1, 0x45, 0x95, 0xE3, 0x00,
  0x63, 0x96, 0x94, 0x98, 0x6E, 0x0A, 0x29, 0x4A, 0xCE, 0x38, 0x4C, 0x40,
  0x60, 0x76, 0xDC, 0xCC, 0xCC, 0x73, 0xFF, 0x19, 0x10, 0x84, 0x23, 0x08,
  0x42, 0x08, 0x30, 0xC2, 0x31, 0x11, 0x11, 0x13, 0x2C, 0x18, 0x31, 0xFD,
  0xE3, 0x84, 0x92, 0x00, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x6D, 0x60,
  0xF0, 0xF0, 0x0C, 0x20, 0x84, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x30, 0x7B,
  0x38, 0x6D, 0xB6, 0x18, 0x73, 0x78, 0x71, 0x49, 0x04, 0x10, 0x41, 0x04,
  0xFC, 0x7A, 0x30, 0xC3, 0x18, 0xC6, 0x30, 0xFC, 0x3C, 0x8C, 0x18, 0x21,
  0x80, 0xC1, 0xA3, 0xFC, 0x0C, 0x38, 0x51, 0x26, 0x48, 0xBF, 0x82, 0x04,
  0xFE, 0x08, 0x2E, 0xCC, 0x10, 0x63, 0x78, 0x39, 0x84, 0x2E, 0xCE, 0x18,
  0x73, 0x78, 0xFE, 0x38, 0x82, 0x18, 0x43, 0x08, 0x60, 0x7B, 0x38, 0xF3,
  0x72, 0x38, 0x63, 0x78, 0x7B, 0x38, 0x61, 0xCD, 0xF0, 0x86, 0x60, 0xF0,
  0x3C, 0x6C, 0x00, 0xDA, 0xC0, 0x04, 0x77, 0x30, 0xC1, 0xC1, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0x83, 0x03, 0x0C, 0xCE, 0x20, 0x7B, 0x30, 0xC2, 0x30,
  0x80, 0x0C, 0x30, 0x7B, 0x38, 0x6F, 0xA6, 0x9A, 0x6F, 0xC1, 0xE0, 0x18,
  0x38, 0x2C, 0x24, 0x24, 0x7E, 0x46, 0x42, 0xC3, 0xFB, 0x3C, 0xF3, 0xFB,
  0x3C, 0x73, 0xF8, 0x7B, 0x38, 0x20, 0x82, 0x08, 0x33, 0x78, 0xFB, 0x3C,
  0x71, 0xC7, 0x1C, 0x73, 0xF8, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xFC,
  0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC0, 0x7B, 0x38, 0x20, 0x9E, 0x18,
  0x77, 0x74, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8C, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0xFC, 0x78, 0x42, 0x10, 0x84, 0x31, 0x70, 0x8F, 0x12,
  0x65, 0x8F, 0x1B, 0x26, 0x46, 0x86, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xFC, 0xCF, 0x3D, 0xED, 0xB6, 0x9A, 0x61, 0x84, 0xC7, 0x1E, 0x69, 0xB6,
  0x59, 0x67, 0x8C, 0x7B, 0x38, 0x61, 0x86, 0x18, 0x73, 0x78, 0xFB, 0x3C,
  0x73, 0xFB, 0x0C, 0x30, 0xC0, 0x7B, 0x38, 0x61, 0x86, 0x18, 0x73, 0x78,
  0xC1, 0xC0, 0xFB, 0x3C, 0x73, 0xFB, 0x4D, 0xB3, 0xCC, 0x3C, 0xC5, 0x03,
  0x03, 0xC0, 0xC0, 0xA3, 0xBC, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0x78, 0xC2, 0x85, 0x9B, 0x22,
  0x44, 0x8F, 0x1C, 0x18, 0xC3, 0x85, 0x6A, 0xD5, 0xAB, 0x5A, 0xB3, 0x66,
  0xC2, 0x66, 0x2C, 0x18, 0x18, 0x38, 0x2C, 0x66, 0xC3, 0xC3, 0x66, 0x24,
  0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFC, 0x31, 0x84, 0x31, 0x84, 0x30,
  0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC1, 0x04, 0x18, 0x20, 0x83,
  0x04, 0x10, 0x20, 0x83, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x18, 0x70,
  0x93, 0x24, 0x38, 0x80, 0xFC, 0x59, 0x80, 0x7A, 0x20, 0x9E, 0x8A, 0x2F,
  0xC0, 0x82, 0x08, 0x2E, 0xCE, 0x18, 0x61, 0xCE, 0xE0, 0x7B, 0x38, 0x20,
  0x83, 0x37, 0x80, 0x0C, 0x30, 0xDF, 0xCE, 0x38, 0xE3, 0xCD, 0xF0, 0x7B,
  0x38, 0x7F, 0x83, 0x37, 0x80, 0x1C, 0xC3, 0x3F, 0x30, 0xC3, 0x0C, 0x33,
  0xF0, 0x0D, 0xEC, 0xB3, 0xC9, 0xE8, 0x3F, 0x86, 0x1F, 0xC0, 0xC3, 0x0C,
  0x3E, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x30, 0xC0, 0x3C, 0x10, 0x41, 0x04,
  0x13, 0xF0, 0x18, 0xC1, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0x00, 0xC1,
  0x83, 0x06, 0x6D, 0x9E, 0x3C, 0x6C, 0xC9, 0x8C, 0xF0, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x33, 0xF0, 0xEE, 0xDB, 0x6D, 0xB6, 0xDB, 0x40, 0xFB, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0x7B, 0x38, 0x61, 0x87, 0x37, 0x80, 0xBB, 0x38,
  0x61, 0x87, 0x3B, 0xA0, 0x82, 0x00, 0x7F, 0x38, 0xE3, 0x8F, 0x37, 0xC3,
  0x0C, 0x30, 0xEC, 0xC2, 0x08, 0x20, 0x8F, 0xC0, 0x7B, 0x3C, 0x1E, 0x0E,
  0x37, 0x80, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x3C, 0x8E, 0x38, 0xE3,
  0x8F, 0x37, 0xC0, 0x87, 0x3C, 0x92, 0x58, 0xC3, 0x00, 0xDB, 0xDA, 0x5A,
  0x5A, 0x6A, 0x66, 0x66, 0xCD, 0x27, 0x0C, 0x71, 0x28, 0xC0, 0xC2, 0xCD,
  0x91, 0x23, 0xC3, 0x06, 0x08, 0x10, 0xE0, 0xFC, 0x21, 0x8C, 0x63, 0x0F,
  0xC0, 0x3C, 0x82, 0x04, 0x13, 0x81, 0x04, 0x30, 0x82, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x41, 0x08, 0x20, 0x72, 0x08, 0x30, 0x41, 0x3C, 0xE6, 0xD9,
  0x80,
};

const GFXglyph IBMPlexMono_Medium13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 11, 8, 1, -10 },
  { 24, 8, 9, 8, 0, -9 },
  { 33, 8, 9, 8, 0, -9 },
  { 42, 2, 4, 8, 3, -10 },
  { 43, 5, 12, 8, 2, -10 },
  { 51, 4, 12, 8, 1, -10 },
  { 57, 7, 7, 8, 0, -7 },
  { 64, 6, 7, 8, 1, -7 },
  { 70, 3, 4, 8, 2, -2 },
  { 72, 4, 1, 8, 2, -4 },
  { 73, 2, 2, 8, 3, -2 },
  { 74, 6, 12, 8, 1, -10 },
  { 83, 6, 9, 8, 1, -9 },
  { 90, 6, 9, 8, 1, -9 },
  { 97, 6, 9, 8, 1, -9 },
  { 104, 7, 9, 8, 0, -9 },
  { 112, 7, 9, 8, 0, -9 },
  { 120, 6, 9, 8, 1, -9 },
  { 127, 6, 9, 8, 1, -9 },
  { 134, 6, 9, 8, 1, -9 },
  { 141, 6, 9, 8, 1, -9 },
  { 148, 6, 9, 8, 1, -9 },
  { 155, 2, 7, 8, 3, -7 },
  { 157, 3, 9, 8, 2, -7 },
  { 161, 6, 8, 8, 1, -8 },
  { 167, 6, 4, 8, 1, -6 },
  { 170, 6, 8, 8, 1, -8 },
  { 176, 6, 9, 8, 1, -9 },
  { 183, 6, 10, 8, 1, -9 },
  { 191, 8, 9, 8, 0, -9 },
  { 200, 6, 9, 8, 1, -9 },
  { 207, 6, 9, 8, 1, -9 },
  { 214, 6, 9, 8, 1, -9 },
  { 221, 6, 9, 8, 1, -9 },
  { 228, 6, 9, 8, 1, -9 },
  { 235, 6, 9, 8, 1, -9 },
  { 242, 6, 9, 8, 1, -9 },
  { 249, 6, 9, 8, 1, -9 },
  { 256, 5, 9, 8, 1, -9 },
  { 262, 7, 9, 8, 1, -9 },
  { 270, 6, 9, 8, 1, -9 },
  { 277, 6, 9, 8, 1, -9 },
  { 284, 6, 9, 8, 1, -9 },
  { 291, 6, 9, 8, 1, -9 },
  { 298, 6, 9, 8, 1, -9 },
  { 305, 6, 11, 8, 1, -9 },
  { 314, 6, 9, 8, 1, -9 },
  { 321, 7, 9, 8, 0, -9 },
  { 329, 7, 9, 8, 0, -9 },
  { 337, 6, 9, 8, 1, -9 },
  { 344, 7, 9, 8, 0, -9 },
  { 352, 7, 9, 8, 0, -9 },
  { 360, 8, 9, 8, 0, -9 },
  { 369, 8, 9, 8, 0, -9 },
  { 378, 6, 9, 8, 1, -9 },
  { 385, 4, 12, 8, 3, -10 },
  { 391, 6, 12, 8, 1, -10 },
  { 400, 4, 12, 8, 1, -10 },
  { 406, 7, 6, 8, 0, -9 },
  { 412, 6, 1, 8, 1, 1 },
  { 413, 3, 3, 8, 2, -11 },
  { 415, 6, 7, 8, 1, -7 },
  { 421, 6, 10, 8, 1, -10 },
  { 429, 6, 7, 8, 1, -7 },
  { 435, 6, 10, 8, 1, -10 },
  { 443, 6, 7, 8, 1, -7 },
  { 449, 6, 10, 8, 1, -10 },
  { 457, 6, 11, 8, 1, -8 },
  { 466, 6, 10, 8, 1, -10 },
  { 474, 6, 10, 8, 1, -10 },
  { 482, 5, 13, 8, 1, -10 },
  { 491, 7, 10, 8, 1, -10 },
  { 500, 6, 10, 8, 1, -10 },
  { 508, 6, 7, 8, 1, -7 },
  { 514, 6, 7, 8, 1, -7 },
  { 520, 6, 7, 8, 1, -7 },
  { 526, 6, 10, 8, 1, -7 },
  { 534, 6, 10, 8, 1, -7 },
  { 542, 6, 7, 8, 1, -7 },
  { 548, 6, 7, 8, 1, -7 },
  { 554, 6, 9, 8, 1, -9 },
  { 561, 6, 7, 8, 1, -7 },
  { 567, 6, 7, 8, 1, -7 },
  { 573, 8, 7, 8, 0, -7 },
  { 580, 6, 7, 8, 1, -7 },
  { 586, 7, 10, 8, 0, -7 },
  { 595, 6, 7, 8, 1, -7 },
  { 601, 6, 12, 8, 1, -10 },
  { 610, 2, 12, 8, 3, -10 },
  { 613, 6, 12, 8, 1, -10 },
  { 622, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_Medium13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_MEDIUM13PT7B_H_
