#ifndef _IBMPLEXMONO_MEDIUM15PT7B_H_
#define _IBMPLEXMONO_MEDIUM15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium15pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x90, 0xFC, 0xDE, 0xF7, 0xB0, 0x1B, 0x09, 0x04, 0x8E,
  0x73, 0x61, 0xB3, 0x9C, 0x48, 0x24, 0x36, 0x00, 0x10, 0x21, 0xF6, 0xBD,
  0x1A, 0x1E, 0x0F, 0x12, 0x27, 0x5B, 0xE1, 0x02, 0x00, 0x71, 0xEC, 0xA2,
  0x9B, 0xC7, 0x00, 0x38, 0xF6, 0x51, 0x4D, 0xE3, 0x80, 0x3C, 0x33, 0x18,
  0x0C, 0x03, 0x03, 0xDF, 0x29, 0x8C, 0x46, 0x3C, 0xC0, 0xF0, 0x39, 0x11,
  0x88, 0x42, 0x10, 0x86, 0x10, 0x43, 0x80, 0xE1, 0x04, 0x30, 0x84, 0x21,
  0x08, 0xC4, 0x4E, 0x00, 0x10, 0x22, 0x4F, 0xF3, 0x8D, 0x91, 0x24, 0x10,
  0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x7B, 0x40, 0xF8, 0xFC, 0x06, 0x08,
  0x30, 0x40, 0x83, 0x04, 0x18, 0x20, 0x41, 0x82, 0x0C, 0x00, 0x7D, 0x8F,
  0x1C, 0x19, 0x32, 0x60, 0xE3, 0xC6, 0xF8, 0x38, 0xF3, 0x64, 0xC1, 0x83,
  0x06, 0x0C, 0x19, 0xFC, 0x7D, 0x8E, 0x18, 0x30, 0x41, 0x84, 0x30, 0xC1,
  0xFC, 0x7D, 0x8C, 0x18, 0x23, 0x80, 0xC1, 0x83, 0xC6, 0xF0, 0x0E, 0x07,
  0x07, 0x82, 0xC2, 0x63, 0x31, 0x19, 0xFF, 0x06, 0x03, 0x00, 0x7E, 0x83,
  0x06, 0x0F, 0xD8, 0xC1, 0x83, 0xC6, 0xF8, 0x1C, 0x61, 0x86, 0x0F, 0xD8,
  0xF1, 0xE3, 0xC6, 0xF8, 0xFF, 0x0E, 0x18, 0x60, 0xC3, 0x06, 0x08, 0x30,
  0x60, 0x7D, 0x8F, 0x1E, 0x33, 0x98, 0xE0, 0xC1, 0xC6, 0xF8, 0x7D, 0x8F,
  0x1E, 0x3C, 0x6F, 0xC1, 0x86, 0x18, 0xE0, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1E, 0xD0, 0x02, 0x1C, 0xE3, 0x0C, 0x0C, 0x0E, 0x07, 0x02, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x81, 0xC0, 0xE0, 0x60, 0x61, 0x8E, 0x70, 0x80, 0x79,
  0x8A, 0x18, 0x31, 0xC7, 0x0C, 0x00, 0x30, 0x60, 0x3C, 0x8E, 0x0C, 0xDB,
  0x76, 0x6C, 0xD9, 0x9F, 0x81, 0x01, 0xE0, 0x1C, 0x0E, 0x05, 0x06, 0xC3,
  0x61, 0x11, 0xFC, 0xC6, 0x41, 0x60, 0xC0, 0xFD, 0x8F, 0x1E, 0x3F, 0x98,
  0xF1, 0xE3, 0xC7, 0xF8, 0x3C, 0x8F, 0x16, 0x0C, 0x18, 0x30, 0x62, 0x46,
  0x78, 0xF9, 0x8B, 0x1E, 0x1C, 0x38, 0x70, 0xE3, 0xC5, 0xF0, 0xFF, 0x83,
  0x06, 0x0F, 0xF8, 0x30, 0x60, 0xC1, 0xFC, 0xFF, 0x83, 0x06, 0x0F, 0xF8,
  0x30, 0x60, 0xC1, 0x80, 0x3C, 0x8F, 0x16, 0x08, 0x13, 0xF1, 0xE3, 0xC6,
  0xFC, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8, 0xF1, 0xE3, 0xC7, 0x8C, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x7C, 0x10, 0x41, 0x04, 0x10,
  0x61, 0xCD, 0xE0, 0xC7, 0xC4, 0xCC, 0xD8, 0xF0, 0xF8, 0xCC, 0xCC, 0xC6,
  0xC3, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xC7, 0xCF, 0xBD,
  0xDB, 0xB2, 0x64, 0xC1, 0x83, 0x04, 0xC7, 0xCF, 0x9F, 0xBD, 0x7A, 0xF7,
  0xE7, 0xCF, 0x8C, 0x7D, 0x8F, 0x1C, 0x18, 0x30, 0x60, 0xE3, 0xC6, 0xF8,
  0xFD, 0x8F, 0x1E, 0x3C, 0x7F, 0xB0, 0x60, 0xC1, 0x80, 0x7D, 0x8F, 0x1C,
  0x18, 0x30, 0x60, 0xE3, 0xC6, 0xF8, 0x40, 0xF0, 0xFD, 0x8F, 0x1E, 0x3C,
  0x7F, 0xB2, 0x66, 0xC7, 0x8C, 0x7D, 0x8F, 0x06, 0x07, 0x81, 0xC1, 0x81,
  0xC6, 0xF8, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x00, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xF8, 0xC1,
  0xB1, 0x98, 0xCC, 0x62, 0x21, 0xB0, 0xD8, 0x28, 0x1C, 0x0E, 0x00, 0xC1,
  0xE0, 0xD2, 0x4B, 0xA5, 0x52, 0xA9, 0x54, 0xAA, 0x77, 0x31, 0x80, 0xE3,
  0xB1, 0x8D, 0x82, 0x81, 0xC0, 0xE0, 0xD8, 0x6C, 0x63, 0x60, 0xC0, 0xC1,
  0xB1, 0x98, 0xC6, 0xC1, 0x40, 0xE0, 0x20, 0x10, 0x08, 0x04, 0x00, 0xFE,
  0x0C, 0x30, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0xFC, 0xFC, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x0F, 0x80, 0xC0, 0x81, 0x81, 0x02, 0x06, 0x04, 0x0C,
  0x08, 0x10, 0x30, 0x20, 0x60, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x1F, 0x80, 0x38, 0x51, 0xB2, 0x2C, 0x70, 0x40, 0xFE, 0xB4, 0x79, 0x98,
  0x13, 0xEC, 0x58, 0xB3, 0x3B, 0xC1, 0x83, 0x06, 0xEE, 0x78, 0xF0, 0xE1,
  0xC7, 0x8F, 0xF0, 0x3C, 0x8F, 0x06, 0x0C, 0x18, 0x11, 0x9E, 0x06, 0x0C,
  0x1B, 0xBC, 0xF8, 0xE1, 0xC3, 0xC7, 0x8D, 0xF8, 0x3C, 0x8F, 0x1F, 0xFC,
  0x18, 0x91, 0x9E, 0x1E, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x23,
  0xF8, 0x06, 0x7C, 0x44, 0xC6, 0xC6, 0x44, 0x78, 0xC0, 0x7E, 0x83, 0xC2,
  0x7E, 0xC1, 0x83, 0x06, 0xEE, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x30,
  0xC0, 0x3C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x0C, 0x30, 0x3F, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0B, 0xE0, 0xC0, 0xC0, 0xC0, 0xC6, 0xCC,
  0xD8, 0xF0, 0xF8, 0xCC, 0xC6, 0xC7, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x23, 0xF8, 0xB7, 0xB6, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xDD,
  0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x39, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0x9C, 0xDD, 0xCF, 0x1E, 0x1C, 0x38, 0xF1, 0xFE, 0xC1, 0x83, 0x00, 0x77,
  0x9F, 0x1C, 0x38, 0x78, 0xF1, 0xBF, 0x06, 0x0C, 0x18, 0xF6, 0x70, 0xC1,
  0x83, 0x06, 0x0C, 0x7F, 0x7D, 0x8F, 0x03, 0xC1, 0xE0, 0xF1, 0xBE, 0x30,
  0x63, 0xF9, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x3C, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xBF, 0xC7, 0x8D, 0x13, 0x26, 0xC5, 0x0A, 0x1C, 0xC9, 0xEE,
  0xD5, 0x4A, 0xA5, 0x52, 0xA9, 0x54, 0xC6, 0xC6, 0xD8, 0xA1, 0xC3, 0x8D,
  0x93, 0x63, 0x83, 0x8D, 0x13, 0x66, 0xC5, 0x0E, 0x08, 0x30, 0x63, 0x80,
  0xFE, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0x7F, 0x1E, 0x60, 0xC0, 0x81, 0x83,
  0x38, 0x0C, 0x18, 0x20, 0xC1, 0x81, 0xE0, 0xFF, 0xF8, 0xF0, 0x30, 0x60,
  0x83, 0x06, 0x03, 0x98, 0x30, 0x20, 0x60, 0xCF, 0x00, 0x63, 0x26, 0x30,
};

const GFXglyph IBMPlexMono_Medium15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 5, 4, 9, 2, -11 },
  { 8, 9, 10, 9, 0, -10 },
  { 20, 7, 14, 9, 1, -12 },
  { 33, 9, 10, 9, 0, -10 },
  { 45, 9, 10, 9, 0, -10 },
  { 57, 1, 4, 9, 4, -11 },
  { 58, 5, 13, 9, 3, -11 },
  { 67, 5, 13, 9, 1, -11 },
  { 76, 7, 8, 9, 1, -8 },
  { 83, 7, 7, 9, 1, -8 },
  { 90, 3, 4, 9, 3, -2 },
  { 92, 5, 1, 9, 2, -5 },
  { 93, 3, 2, 9, 3, -2 },
  { 94, 7, 13, 9, 1, -11 },
  { 106, 7, 10, 9, 1, -10 },
  { 115, 7, 10, 9, 1, -10 },
  { 124, 7, 10, 9, 1, -10 },
  { 133, 7, 10, 9, 1, -10 },
  { 142, 9, 10, 9, 0, -10 },
  { 154, 7, 10, 9, 1, -10 },
  { 163, 7, 10, 9, 1, -10 },
  { 172, 7, 10, 9, 1, -10 },
  { 181, 7, 10, 9, 1, -10 },
  { 190, 7, 10, 9, 1, -10 },
  { 199, 3, 8, 9, 3, -8 },
  { 202, 3, 10, 9, 3, -8 },
  { 206, 7, 9, 9, 1, -9 },
  { 214, 7, 5, 9, 1, -7 },
  { 219, 7, 9, 9, 1, -9 },
  { 227, 7, 10, 9, 1, -10 },
  { 236, 7, 12, 9, 1, -10 },
  { 247, 9, 10, 9, 0, -10 },
  { 259, 7, 10, 9, 1, -10 },
  { 268, 7, 10, 9, 1, -10 },
  { 277, 7, 10, 9, 1, -10 },
  { 286, 7, 10, 9, 1, -10 },
  { 295, 7, 10, 9, 1, -10 },
  { 304, 7, 10, 9, 1, -10 },
  { 313, 7, 10, 9, 1, -10 },
  { 322, 7, 10, 9, 1, -10 },
  { 331, 6, 10, 9, 1, -10 },
  { 339, 8, 10, 9, 1, -10 },
  { 349, 6, 10, 9, 2, -10 },
  { 357, 7, 10, 9, 1, -10 },
  { 366, 7, 10, 9, 1, -10 },
  { 375, 7, 10, 9, 1, -10 },
  { 384, 7, 10, 9, 1, -10 },
  { 393, 7, 12, 9, 1, -10 },
  { 404, 7, 10, 9, 1, -10 },
  { 413, 7, 10, 9, 1, -10 },
  { 422, 9, 10, 9, 0, -10 },
  { 434, 7, 10, 9, 1, -10 },
  { 443, 9, 10, 9, 0, -10 },
  { 455, 9, 10, 9, 0, -10 },
  { 467, 9, 10, 9, 0, -10 },
  { 479, 9, 10, 9, 0, -10 },
  { 491, 7, 10, 9, 1, -10 },
  { 500, 5, 13, 9, 3, -11 },
  { 509, 7, 13, 9, 1, -11 },
  { 521, 5, 13, 9, 1, -11 },
  { 530, 7, 6, 9, 1, -10 },
  { 536, 7, 1, 9, 1, 1 },
  { 537, 2, 3, 9, 3, -12 },
  { 538, 7, 8, 9, 1, -8 },
  { 545, 7, 11, 9, 1, -11 },
  { 555, 7, 8, 9, 1, -8 },
  { 562, 7, 11, 9, 1, -11 },
  { 572, 7, 8, 9, 1, -8 },
  { 579, 7, 11, 9, 1, -11 },
  { 589, 8, 12, 9, 1, -9 },
  { 601, 7, 11, 9, 1, -11 },
  { 611, 6, 11, 9, 2, -11 },
  { 620, 6, 14, 9, 1, -11 },
  { 631, 8, 11, 9, 1, -11 },
  { 642, 7, 11, 9, 1, -11 },
  { 652, 7, 8, 9, 1, -8 },
  { 659, 7, 8, 9, 1, -8 },
  { 666, 7, 8, 9, 1, -8 },
  { 673, 7, 11, 9, 1, -8 },
  { 683, 7, 11, 9, 1, -8 },
  { 693, 7, 8, 9, 1, -8 },
  { 700, 7, 8, 9, 1, -8 },
  { 707, 7, 10, 9, 1, -10 },
  { 716, 7, 8, 9, 1, -8 },
  { 723, 7, 8, 9, 1, -8 },
  { 730, 9, 8, 9, 0, -8 },
  { 739, 7, 8, 9, 1, -8 },
  { 746, 7, 11, 9, 1, -8 },
  { 756, 7, 8, 9, 1, -8 },
  { 763, 7, 13, 9, 1, -11 },
  { 775, 1, 13, 9, 4, -11 },
  { 777, 7, 13, 9, 1, -11 },
  { 789, 7, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_Medium15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_MEDIUM15PT7B_H_
