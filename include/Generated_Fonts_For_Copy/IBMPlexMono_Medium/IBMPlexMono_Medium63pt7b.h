#ifndef _IBMPLEXMONO_MEDIUM63PT7B_H_
#define _IBMPLEXMONO_MEDIUM63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium63pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x00, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x3F,
  0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xFF, 0x03, 0xFF,
  0xF3, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xFF, 0x03, 0xFF, 0xF3, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF,
  0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF,
  0xCF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF3, 0xE7, 0xFE, 0x3F, 0xC3, 0xE1, 0xFF, 0x3F, 0x83, 0xE0, 0x7C, 0x7F,
  0x03, 0xE0, 0x30, 0x7F, 0x03, 0xE0, 0x20, 0x7F, 0x03, 0xE0, 0x00, 0x7F,
  0x03, 0xE0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7F,
  0x83, 0xE0, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x3F, 0xE3, 0xE0, 0x00, 0x3F,
  0xFB, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xEF, 0xFE, 0x00,
  0x03, 0xE1, 0xFE, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x03, 0xE0, 0x7F, 0x00,
  0x03, 0xE0, 0x7F, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x03, 0xE0, 0x7F, 0x10, 0x03, 0xE0, 0x7F, 0x18, 0x03, 0xE0, 0x7F, 0x3C,
  0x03, 0xE0, 0x7F, 0x7F, 0x03, 0xE0, 0xFE, 0xFF, 0x83, 0xE1, 0xFE, 0xFF,
  0xF3, 0xE7, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0x1F, 0xFF, 0x00, 0x03, 0xE3, 0xFF, 0xF8, 0x00, 0x7E, 0x7F, 0x0F, 0xC0,
  0x07, 0xC7, 0xC0, 0x7C, 0x00, 0xFC, 0x7C, 0x07, 0xC0, 0x0F, 0x8F, 0x80,
  0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x03, 0xF0,
  0xF8, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0x80,
  0x3E, 0x1F, 0x80, 0x7C, 0x07, 0xC3, 0xF0, 0x07, 0xC0, 0x7C, 0x3F, 0x00,
  0x7E, 0x0F, 0xC7, 0xE0, 0x03, 0xFF, 0xF8, 0x7C, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7E, 0x1F, 0xFF, 0xC0, 0x07, 0xC3, 0xF0, 0xFC, 0x00, 0xFC, 0x3E,
  0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x1F,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x7C,
  0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x1F, 0x1F, 0x80, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0xE0, 0x3E, 0x3F, 0x00, 0x3E, 0x07, 0xE7, 0xE0, 0x03, 0xF0, 0xFC,
  0x7E, 0x00, 0x1F, 0xFF, 0xCF, 0xC0, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0xFE,
  0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xFC, 0x07, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xE1, 0xFC,
  0xFF, 0x07, 0xFE, 0x3F, 0x8F, 0xF0, 0x7C, 0x07, 0xF0, 0x7F, 0x87, 0xC0,
  0x7F, 0x03, 0xFC, 0x7C, 0x07, 0xE0, 0x1F, 0xEF, 0xC0, 0x7E, 0x00, 0xFE,
  0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xE0,
  0x03, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F,
  0xFC, 0x03, 0xFE, 0x07, 0xDF, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0x01, 0xFF,
  0xFF, 0x87, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0x01, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1C,
  0x01, 0xF8, 0x03, 0x8F, 0xC0, 0xFC, 0x0F, 0xCF, 0xFC, 0x7E, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x8F, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC3, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F,
  0xE0, 0x7F, 0xFE, 0x07, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xF7, 0xF0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x1F,
  0xF0, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x0F,
  0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xF0, 0x07, 0xF0, 0x00,
  0x30, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x1F, 0xE0, 0x60,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x1F, 0x80, 0x03, 0xFC, 0x07, 0x00, 0x01, 0xFE, 0x03,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x04,
  0x00, 0x00, 0xFF, 0x0E, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0xF8, 0x7F,
  0xFC, 0x03, 0xE3, 0xFF, 0xF8, 0x0F, 0x9F, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF,
  0xE1, 0xFB, 0xFF, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x9F, 0xE0, 0x03, 0xFE,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x20, 0x00,
  0x07, 0xF1, 0xC0, 0x00, 0x3F, 0xCF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0x8F, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0xE0, 0x3F,
  0x3F, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x7F,
  0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x07,
  0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xFB,
  0xF8, 0x1F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x7F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFE, 0x1F,
  0x80, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF,
  0xC7, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xC3, 0xFE,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x03,
  0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFC,
  0x1C, 0x00, 0x0F, 0xF0, 0x40, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x1F,
  0x8F, 0xDF, 0x80, 0xFF, 0x9F, 0xBE, 0x03, 0xFF, 0xBF, 0x7C, 0x07, 0xFF,
  0xFE, 0xF8, 0x1F, 0xC3, 0xFD, 0xF0, 0x3F, 0x03, 0xFF, 0xE0, 0xFC, 0x03,
  0xFF, 0xC1, 0xF8, 0x07, 0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0x07, 0xC0, 0x1F,
  0xFE, 0x0F, 0x80, 0x3F, 0xFC, 0x1F, 0x00, 0x7F, 0xF8, 0x3E, 0x00, 0xFF,
  0xF0, 0x7C, 0x01, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0xC1, 0xF0, 0x07, 0xFF,
  0x83, 0xE0, 0x0F, 0xFF, 0x07, 0xC0, 0x1F, 0xFE, 0x0F, 0xC0, 0x3F, 0x7C,
  0x1F, 0x80, 0x7E, 0xF8, 0x1F, 0x00, 0xFD, 0xF0, 0x3F, 0x03, 0xFB, 0xE0,
  0x7F, 0x9F, 0xF7, 0xC0, 0x7F, 0xFF, 0xEF, 0xC0, 0x7F, 0xEF, 0xDF, 0x80,
  0x7F, 0x9F, 0x9F, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x07,
  0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x00, 0x7F,
  0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xD7, 0xF0, 0x00, 0x0C, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0x81, 0xFC, 0x00, 0x03, 0xE3,
  0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xFC, 0x3F, 0x80, 0x0F,
  0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00,
  0x3F, 0xE3, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x0F, 0xD7, 0xF0, 0x00, 0x0C, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x01,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xF9,
  0xFC, 0x1F, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x3F,
  0xF1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0xFE, 0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xF8,
  0x00, 0xFF, 0xE7, 0xF8, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0x81, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xEF, 0xFF, 0x7E, 0x0F, 0xBF, 0xFD, 0xF8, 0x7E, 0xFF, 0xF3,
  0xE1, 0xF3, 0xFF, 0xCF, 0xCF, 0xCF, 0xFF, 0x3F, 0x3E, 0x3F, 0xFC, 0x7E,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F,
  0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3E, 0x03, 0xFF,
  0xC0, 0x78, 0x0F, 0xFF, 0x01, 0xE0, 0x3F, 0xFC, 0x03, 0x00, 0xFF, 0xF0,
  0x0C, 0x03, 0xFF, 0xC0, 0x30, 0x0F, 0xFF, 0x00, 0x80, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0x80,
  0x3F, 0xFD, 0xF8, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0xFC, 0x03, 0xFF,
  0xCF, 0xE0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xC7, 0xE0, 0x3F, 0xFC, 0x7F,
  0x03, 0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xFC, 0x3F, 0xFC, 0x0F, 0xC3, 0xFF, 0xC0,
  0xFC, 0x3F, 0xFC, 0x07, 0xE3, 0xFF, 0xC0, 0x7E, 0x3F, 0xFC, 0x07, 0xE3,
  0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x03, 0xF3, 0xFF, 0xC0, 0x3F, 0xBF, 0xFC,
  0x01, 0xFB, 0xFF, 0xC0, 0x1F, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0x3F,
  0x80, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x01, 0xFE,
  0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x1F,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x7C, 0x1F, 0xE0, 0x00, 0x1C, 0x0F, 0xE0, 0x00, 0x04,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x82,
  0x00, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0xF0, 0x0F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x1F,
  0xE0, 0x3E, 0xFE, 0x07, 0xF8, 0x1F, 0x9F, 0x81, 0xFE, 0x07, 0xE7, 0xE0,
  0x7F, 0x81, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E, 0x0F, 0xFC, 0x1F, 0x9F,
  0x83, 0xFF, 0x07, 0xE7, 0xE0, 0xFF, 0xC1, 0xF9, 0xF8, 0x3F, 0xF0, 0x7E,
  0x7E, 0x0F, 0x7C, 0x1F, 0x9F, 0x87, 0xCF, 0x87, 0xE7, 0xE1, 0xF3, 0xE1,
  0xF9, 0xF8, 0x7C, 0xF8, 0x7E, 0x7E, 0x1F, 0x3E, 0x1F, 0x1F, 0x87, 0x8F,
  0x87, 0xC7, 0xE1, 0xE1, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3F, 0x3E,
  0x1F, 0x3F, 0x0F, 0xCF, 0x87, 0xCF, 0xC3, 0xF3, 0xE1, 0xF3, 0xF0, 0xFC,
  0xF0, 0x7C, 0xFC, 0x3F, 0x7C, 0x0F, 0xBF, 0x0F, 0xDF, 0x03, 0xEF, 0xC3,
  0xF7, 0xC0, 0xFB, 0xF0, 0xFD, 0xF0, 0x3E, 0xFC, 0x3F, 0x7C, 0x0F, 0xBF,
  0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0x9E, 0x00, 0x00, 0x0F, 0x83, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x07, 0xC3,
  0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xE0, 0x10, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3E, 0x00,
  0x1F, 0xE0, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x87,
  0xFC, 0x07, 0xBF, 0xF7, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFC, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0x80, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x3F,
  0x87, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0x03, 0xF9, 0xFF, 0xFF, 0x0F, 0xEF,
  0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0xF3, 0xFE, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x1F,
  0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xEF, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xF0,
  0xFE, 0x7F, 0xFF, 0x83, 0xF8, 0xFF, 0xFC, 0x0F, 0xE1, 0xFF, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF0, 0x3F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF7, 0xF0,
  0x00, 0x38, 0xFF, 0x00, 0x02, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x10, 0x7F, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0,
  0x0F, 0xF3, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0xF8, 0x7F, 0x07, 0xFF, 0xF1, 0xFC, 0x3F, 0xFF, 0xE7, 0xF1, 0xFF, 0xFF,
  0xDF, 0xC7, 0xFF, 0xFF, 0x7F, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFC,
  0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0x7F, 0x0F,
  0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xC7, 0xF0, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x20, 0x7F, 0x00, 0x00, 0xC1,
  0xFE, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x3F, 0x0F, 0xFC, 0x07, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE7,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x01,
  0xFF, 0x7C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF,
  0x0F, 0xE7, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xCF, 0xEF, 0xFF, 0xFC, 0xFE,
  0xE0, 0x7F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x7E, 0x00,
  0x0F, 0xF8, 0xFC, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0xFF, 0x83, 0xF0, 0x03,
  0xFE, 0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0x80, 0xFF,
  0x80, 0x3F, 0x03, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0xFC, 0x3F, 0xC0,
  0x01, 0xF8, 0xFF, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x07, 0xEF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xEF, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F,
  0x80, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x7F, 0x87, 0xE0,
  0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0xFF, 0x3F, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0xFF, 0x07, 0xFC, 0xFD, 0xFF, 0x8F, 0xFC,
  0xFD, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xF8, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFE, 0x03, 0xF0, 0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x0F, 0xE7,
  0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xCF, 0xEF, 0xFF, 0xFC, 0xFE, 0xE0, 0x7F,
  0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x03,
  0xF8, 0x7F, 0xF8, 0x0F, 0xE3, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0xF0, 0xFE,
  0xFF, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x3F, 0xE0,
  0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x01,
  0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFE, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF,
  0x0F, 0xE7, 0xFF, 0xF8, 0x3F, 0x8F, 0xFF, 0xC0, 0xFE, 0x1F, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xFF, 0x87, 0xF0, 0x7F, 0xFF, 0x1F,
  0xC3, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xF7, 0xF3,
  0xFF, 0x01, 0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x07, 0xFF, 0x1F, 0xFF,
  0xFD, 0xFC, 0x7F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xFC,
  0x7F, 0x01, 0xFF, 0xE1, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xEF, 0x80, 0x00, 0x3F, 0xB8, 0x00,
  0x00, 0xFE, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xC7,
  0xF0, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0xC1, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x18, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFE, 0x07,
  0xFF, 0x7F, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xE7, 0xF0,
  0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0x87, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x3E, 0x7C, 0x03, 0xFC, 0x03, 0xE7,
  0xE0, 0x3F, 0xC0, 0x3E, 0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xC0,
  0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0xE0, 0x7E, 0x7E, 0x07,
  0xBE, 0x07, 0xC3, 0xE0, 0x79, 0xE0, 0x7C, 0x3E, 0x07, 0x9E, 0x07, 0xC3,
  0xE0, 0x79, 0xE0, 0x7C, 0x3F, 0x07, 0x9F, 0x0F, 0xC3, 0xF0, 0xF9, 0xF0,
  0xFC, 0x3F, 0x0F, 0x1F, 0x0F, 0xC3, 0xF0, 0xF0, 0xF0, 0xF8, 0x1F, 0x0F,
  0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0xF8, 0xF8, 0x1F, 0x1E, 0x0F, 0x8F, 0x81, 0xF9, 0xE0, 0x79,
  0xF8, 0x1F, 0x9E, 0x07, 0x9F, 0x01, 0xF9, 0xE0, 0x79, 0xF0, 0x0F, 0xBE,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x7D, 0xF0, 0x0F, 0xBC, 0x07, 0xDF, 0x00,
  0xFB, 0xC0, 0x3D, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x07, 0xFC, 0x00, 0x1F,
  0x0F, 0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x3E,
  0x3F, 0xFF, 0xC0, 0x3E, 0x3F, 0x1F, 0xE0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7C,
  0x7E, 0x07, 0xF8, 0xFC, 0x7C, 0x03, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF8,
  0xFC, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xE0,
  0x38, 0x00, 0x1F, 0x80,
};

const GFXglyph IBMPlexMono_Medium63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 10, 45, 38, 14, -44 },
  { 58, 18, 19, 38, 10, -47 },
  { 101, 36, 44, 38, 1, -44 },
  { 299, 32, 58, 38, 3, -51 },
  { 531, 36, 46, 38, 1, -45 },
  { 738, 36, 46, 38, 1, -45 },
  { 945, 6, 19, 38, 16, -47 },
  { 960, 20, 57, 38, 12, -48 },
  { 1103, 20, 57, 38, 6, -48 },
  { 1246, 33, 32, 38, 2, -35 },
  { 1378, 30, 32, 38, 4, -35 },
  { 1498, 13, 19, 38, 12, -10 },
  { 1529, 19, 6, 38, 9, -22 },
  { 1544, 11, 10, 38, 13, -10 },
  { 1558, 28, 57, 38, 5, -48 },
  { 1758, 32, 46, 38, 3, -45 },
  { 1942, 33, 44, 38, 3, -44 },
  { 2124, 31, 45, 38, 3, -45 },
  { 2299, 32, 46, 38, 2, -45 },
  { 2483, 34, 44, 38, 2, -44 },
  { 2670, 30, 45, 38, 4, -44 },
  { 2839, 32, 45, 38, 3, -44 },
  { 3019, 30, 44, 38, 4, -44 },
  { 3184, 32, 46, 38, 3, -45 },
  { 3368, 31, 45, 38, 3, -45 },
  { 3543, 11, 33, 38, 13, -33 },
  { 3589, 13, 42, 38, 12, -33 },
  { 3658, 27, 37, 38, 5, -38 },
  { 3783, 30, 19, 38, 4, -29 },
  { 3855, 27, 37, 38, 5, -38 },
  { 3980, 29, 46, 38, 4, -45 },
  { 4147, 31, 52, 38, 3, -45 },
  { 4349, 36, 44, 38, 1, -44 },
  { 4547, 30, 44, 38, 5, -44 },
  { 4712, 31, 46, 38, 4, -45 },
  { 4891, 30, 44, 38, 5, -44 },
  { 5056, 28, 44, 38, 5, -44 },
  { 5210, 29, 44, 38, 5, -44 },
  { 5370, 31, 46, 38, 3, -45 },
  { 5549, 28, 44, 38, 5, -44 },
  { 5703, 28, 44, 38, 5, -44 },
  { 5857, 27, 45, 38, 4, -44 },
  { 6009, 32, 44, 38, 5, -44 },
  { 6185, 27, 44, 38, 7, -44 },
  { 6334, 30, 44, 38, 4, -44 },
  { 6499, 28, 44, 38, 5, -44 },
  { 6653, 32, 46, 38, 3, -45 },
  { 6837, 30, 44, 38, 5, -44 },
  { 7002, 32, 57, 38, 3, -45 },
  { 7230, 30, 44, 38, 5, -44 },
  { 7395, 33, 46, 38, 2, -45 },
  { 7585, 34, 44, 38, 2, -44 },
  { 7772, 29, 45, 38, 4, -44 },
  { 7936, 34, 44, 38, 2, -44 },
  { 8123, 34, 44, 38, 2, -44 },
  { 8310, 36, 44, 38, 1, -44 },
  { 8508, 36, 44, 38, 1, -44 },
  { 8706, 32, 44, 38, 3, -44 },
  { 8882, 19, 57, 38, 13, -48 },
  { 9018, 28, 57, 38, 5, -48 },
  { 9218, 19, 57, 38, 6, -48 },
  { 9354, 33, 27, 38, 2, -44 },
  { 9466, 30, 6, 38, 4, 5 },
  { 9489, 11, 13, 38, 11, -49 },
  { 9507, 31, 34, 38, 4, -33 },
  { 9639, 30, 48, 38, 5, -47 },
  { 9819, 28, 34, 38, 5, -33 },
  { 9938, 30, 48, 38, 3, -47 },
  { 10118, 30, 34, 38, 4, -33 },
  { 10246, 31, 47, 38, 4, -47 },
  { 10429, 32, 51, 38, 4, -38 },
  { 10633, 28, 47, 38, 5, -47 },
  { 10798, 29, 48, 38, 6, -48 },
  { 10972, 23, 61, 38, 6, -48 },
  { 11148, 31, 47, 38, 6, -47 },
  { 11331, 28, 47, 38, 5, -47 },
  { 11496, 32, 33, 38, 3, -33 },
  { 11628, 28, 33, 38, 5, -33 },
  { 11744, 31, 34, 38, 3, -33 },
  { 11876, 30, 46, 38, 5, -33 },
  { 12049, 30, 46, 38, 3, -33 },
  { 12222, 30, 33, 38, 5, -33 },
  { 12346, 29, 34, 38, 4, -33 },
  { 12470, 30, 44, 38, 3, -44 },
  { 12635, 28, 34, 38, 5, -33 },
  { 12754, 32, 33, 38, 3, -33 },
  { 12886, 36, 33, 38, 1, -33 },
  { 13035, 32, 33, 38, 3, -33 },
  { 13167, 33, 46, 38, 2, -33 },
  { 13357, 28, 33, 38, 5, -33 },
  { 13473, 26, 57, 38, 6, -48 },
  { 13659, 6, 57, 38, 16, -48 },
  { 13702, 26, 57, 38, 6, -48 },
  { 13888, 32, 15, 38, 3, -27 },
};

const GFXfont IBMPlexMono_Medium63pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium63pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium63pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _IBMPLEXMONO_MEDIUM63PT7B_H_
