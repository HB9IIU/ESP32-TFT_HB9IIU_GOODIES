#ifndef _IBMPLEXMONO_MEDIUM51PT7B_H_
#define _IBMPLEXMONO_MEDIUM51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFD,
  0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xE3, 0xE0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x78, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0x83, 0xFF, 0x9F,
  0xFC, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF, 0xE0, 0x1E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x80, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0x83, 0xFF, 0x9F,
  0xFC, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0x00, 0xF0,
  0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0x3D, 0xFF,
  0x1F, 0x87, 0x87, 0xC3, 0xE0, 0xF0, 0x70, 0xFC, 0x1E, 0x04, 0x1F, 0x83,
  0xC0, 0x03, 0xF0, 0x78, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0xFC, 0x3C, 0x00, 0x1F, 0xE7, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3D, 0xFF, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0xF0,
  0xFC, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3F, 0x10,
  0x0F, 0x07, 0xC3, 0x01, 0xE0, 0xF8, 0xF0, 0x3C, 0x3F, 0x3F, 0x07, 0x8F,
  0xEF, 0xFC, 0xF7, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFF, 0x80, 0x07, 0x8F, 0xFE, 0x00,
  0x7C, 0xF8, 0xF8, 0x03, 0xCF, 0x83, 0xC0, 0x3E, 0x78, 0x0F, 0x01, 0xE3,
  0xC0, 0x78, 0x1F, 0x1E, 0x03, 0xC0, 0xF0, 0xF0, 0x1E, 0x0F, 0x87, 0x80,
  0xF0, 0x78, 0x3C, 0x07, 0x87, 0xC1, 0xE0, 0x3C, 0x3C, 0x0F, 0x01, 0xE3,
  0xE0, 0x3C, 0x1F, 0x1E, 0x01, 0xF1, 0xF1, 0xF0, 0x07, 0xFF, 0x0F, 0x00,
  0x1F, 0xF0, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0x1F, 0xFE, 0x00, 0xF0, 0xF0, 0xF0, 0x0F, 0x8F,
  0x03, 0xC0, 0x78, 0x78, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x3C, 0x3E, 0x03,
  0xC3, 0xE1, 0xF0, 0x1E, 0x1E, 0x0F, 0x80, 0xF1, 0xF0, 0x7C, 0x07, 0x8F,
  0x03, 0xE0, 0x3C, 0xF8, 0x0F, 0x03, 0xE7, 0x80, 0x78, 0x1E, 0x7C, 0x03,
  0xC0, 0xF3, 0xC0, 0x0F, 0x0F, 0x3E, 0x00, 0x7F, 0xF9, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x0E, 0x00, 0x1F, 0x00,
  0x40, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFF,
  0x03, 0xFC, 0x3F, 0xFC, 0x1F, 0xE3, 0xF7, 0xF0, 0xFF, 0x3F, 0x1F, 0x87,
  0x81, 0xF0, 0x7E, 0x3C, 0x1F, 0x81, 0xF9, 0xE0, 0xFC, 0x0F, 0xFF, 0x07,
  0xC0, 0x3F, 0xF0, 0x3E, 0x00, 0xFF, 0x81, 0xF0, 0x03, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xDF, 0xC1, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xC1, 0xF8,
  0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00, 0xF8,
  0x04, 0x7C, 0x1F, 0x07, 0xCF, 0xF3, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x04, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x1F,
  0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x7F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE7, 0xE0,
  0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x78, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3,
  0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x07,
  0x83, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x03, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFB, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x1C, 0x07, 0xE0, 0x01, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF1,
  0xF8, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x1C, 0x00, 0x1F,
  0x82, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE1, 0xFE, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x3C, 0x00, 0x7E, 0x0C,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE2, 0x00,
  0x03, 0xF3, 0x80, 0x01, 0xFB, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0xFF,
  0x03, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7C, 0xFC,
  0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0,
  0x0F, 0x80, 0xFC, 0x01, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00,
  0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0xFE, 0x00, 0xF1, 0xFF, 0xC0, 0x79, 0xFF, 0xF0, 0x7D, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xCF, 0xC0, 0x0F, 0xE0, 0xC0,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE2, 0x00, 0x03, 0xF3,
  0x80, 0x03, 0xF3, 0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFC, 0xFF, 0x03, 0xFC,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0xFE, 0x01,
  0xF9, 0xFF, 0xC0, 0xF9, 0xFF, 0xF0, 0x7D, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x3F, 0xE0, 0x7F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0,
  0x01, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0x7E, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x1F, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F,
  0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xF8, 0xFF, 0x01,
  0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F,
  0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xBF,
  0xC0, 0xFF, 0xDF, 0xFF, 0xF7, 0xC7, 0xFF, 0xFB, 0xE1, 0xFF, 0xFB, 0xF0,
  0x7F, 0xF9, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3E,
  0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x80, 0x1F, 0x1F, 0xE7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFC, 0x0F,
  0xEF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0xE0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x0F, 0x8F, 0xF8,
  0x1F, 0xCF, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7C, 0x3F, 0xF0,
  0x78, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0,
  0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0,
  0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x1F, 0xF0,
  0x7F, 0x7F, 0xF8, 0x3F, 0xEF, 0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0xCF, 0x78,
  0x02, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x3E, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x03,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0x9F, 0x80, 0x02, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x0F, 0xC0, 0x03, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x07, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x07, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0x07, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0x9F, 0x80, 0x02, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFD, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF3, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0xC1, 0xFF, 0x1F,
  0xFF, 0xEF, 0x87, 0xFF, 0xE7, 0xC1, 0xFF, 0xF3, 0xE0, 0x7F, 0xF1, 0xF0,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xCF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0xE0, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0,
  0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83,
  0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF,
  0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xE7, 0xF0,
  0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xEF, 0xFD, 0xE0, 0xF7, 0xFE, 0xF8, 0xF3, 0xFF, 0x3C, 0x79, 0xFF, 0x9E,
  0x3C, 0xFF, 0xCF, 0xBC, 0x7F, 0xE3, 0xDE, 0x3F, 0xF1, 0xFF, 0x1F, 0xF8,
  0xFF, 0x0F, 0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0x83, 0xFF, 0x0F, 0xC1, 0xFF,
  0x83, 0xE0, 0xFF, 0xC1, 0xE0, 0x7F, 0xE0, 0x70, 0x3F, 0xF0, 0x38, 0x1F,
  0xF8, 0x18, 0x0F, 0xFC, 0x04, 0x07, 0xFE, 0x02, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF0, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xF7, 0xC0, 0x7F, 0xEF, 0x80, 0xFF, 0xDF, 0x01,
  0xFF, 0x9F, 0x03, 0xFF, 0x3E, 0x07, 0xFE, 0x7C, 0x0F, 0xFC, 0x7C, 0x1F,
  0xF8, 0xF8, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF,
  0x83, 0xE3, 0xFF, 0x07, 0xC7, 0xFE, 0x0F, 0x8F, 0xFC, 0x0F, 0x9F, 0xF8,
  0x1F, 0x3F, 0xF0, 0x1F, 0x7F, 0xE0, 0x3E, 0xFF, 0xC0, 0x7D, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F,
  0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F,
  0xF0, 0x1F, 0xF3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x1C, 0x7E, 0x00, 0x02,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x40,
  0x00, 0x3F, 0x38, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xE0, 0x03, 0xF9,
  0xFF, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0xBF, 0x80, 0x3F, 0x3F, 0x81, 0xFE, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC1, 0xF8, 0x1F, 0x7C, 0x1F, 0x81, 0xF7, 0xC1, 0xFC,
  0x1F, 0x7C, 0x1F, 0xC1, 0xE7, 0xC1, 0xFC, 0x1E, 0x7C, 0x3F, 0xC1, 0xE7,
  0xC3, 0xDC, 0x1E, 0x7C, 0x3D, 0xE3, 0xE3, 0xC3, 0xDE, 0x3E, 0x3C, 0x3D,
  0xE3, 0xE3, 0xC3, 0x9E, 0x3E, 0x3E, 0x79, 0xE3, 0xE3, 0xE7, 0x8F, 0x3E,
  0x3E, 0x78, 0xF3, 0xE3, 0xE7, 0x8F, 0x3E, 0x3E, 0x78, 0xF3, 0xE3, 0xEF,
  0x0F, 0x3E, 0x3E, 0xF0, 0xFB, 0xC3, 0xEF, 0x07, 0xBC, 0x3E, 0xF0, 0x7B,
  0xC3, 0xEF, 0x07, 0xBC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03,
  0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x8F, 0x80,
  0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3F, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7A, 0x20, 0x00, 0x04, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x08, 0x1C, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x83, 0xC1, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF,
  0x03, 0xC0, 0x1F, 0xC0, 0x60, 0x03, 0xF0, 0x10, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x3F, 0xFD, 0xFF, 0xFD, 0xFF, 0x7F,
  0xFF, 0x3F, 0xCF, 0xFF, 0x8F, 0xF1, 0xFF, 0xC0, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x7F, 0xE0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0x83, 0xFC, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xF8,
  0xFC, 0xFF, 0xF0, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3C, 0xFC, 0x00, 0x21, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0x87, 0xE0, 0x03, 0xCF, 0xE0, 0x0F,
  0xCF, 0xE0, 0x7F, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x3F, 0x0F, 0xFE, 0x3F, 0x1F, 0xFF, 0x3F,
  0x3F, 0xFF, 0xBF, 0x3F, 0xFF, 0xBF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x81, 0xFF,
  0x3F, 0xFF, 0xBF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x0F, 0xFE, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xE0, 0xFC, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xBF, 0x00,
  0x07, 0xDF, 0x80, 0x03, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x02, 0x07, 0xE0, 0x01, 0x81, 0xF8, 0x01, 0xF0,
  0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x7C, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0xC7, 0xFE,
  0x1F, 0x9F, 0xFE, 0x3F, 0x7F, 0xFE, 0x7E, 0xFF, 0xFC, 0xFF, 0x83, 0xFD,
  0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F,
  0x8F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x03,
  0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x3F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xF9, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x3E,
  0x3E, 0x7F, 0x1F, 0xEF, 0xBF, 0xCF, 0xFB, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xE3, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8,
  0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F,
  0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C,
  0x0F, 0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0,
  0x7C, 0x0F, 0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F,
  0xE0, 0x7C, 0x0F, 0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0,
  0x3C, 0x00, 0x1F, 0x81, 0xF8, 0xFF, 0xC3, 0xF3, 0xFF, 0xC7, 0xEF, 0xFF,
  0xCF, 0xDF, 0xFF, 0x9F, 0xF0, 0x7F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFC,
  0x0F, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF8, 0x03, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x7F, 0xE0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0xFC, 0xFD,
  0xFF, 0xF8, 0xFC, 0xFF, 0xF0, 0xFC, 0x7F, 0xE0, 0xFC, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0x1F, 0xFF, 0x3F, 0x3F,
  0xFF, 0xBF, 0x3F, 0xFF, 0xBF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x81, 0xFF, 0x3F,
  0xFF, 0xBF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x0F, 0xFE, 0x3F, 0x03,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F, 0xB8, 0x00,
  0x07, 0xD8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0x80, 0xFC, 0x3E, 0x00, 0x1C,
  0x3E, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x30, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFF, 0x00, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xFF, 0xF7, 0xCF,
  0xFF, 0xDF, 0x1F, 0xFE, 0x7C, 0x3F, 0xF1, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0xFC, 0x07, 0xBE, 0x07, 0xF0, 0x3C, 0xF0,
  0x3F, 0x81, 0xE7, 0x81, 0xFC, 0x0F, 0x3C, 0x0F, 0xE0, 0xF9, 0xF0, 0x77,
  0x07, 0xCF, 0x87, 0xB8, 0x3E, 0x7C, 0x3D, 0xE1, 0xE3, 0xE1, 0xCF, 0x0F,
  0x1F, 0x0E, 0x78, 0x78, 0x78, 0x71, 0xC3, 0xC3, 0xC7, 0x8E, 0x1E, 0x1E,
  0x3C, 0x71, 0xF0, 0xF1, 0xE3, 0xCF, 0x87, 0xCE, 0x1E, 0x78, 0x3E, 0x70,
  0xF3, 0xC1, 0xF3, 0x83, 0x9E, 0x07, 0xBC, 0x1C, 0xF0, 0x3D, 0xE0, 0xF7,
  0x81, 0xEF, 0x07, 0xBC, 0x0F, 0x70, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x81, 0xF8,
  0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xF0,
  0xFC, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x03, 0xE0, 0x03, 0x83, 0xFC, 0x00, 0xF1, 0xFF, 0xC0, 0x3C, 0x7F, 0xF0,
  0x1F, 0x3F, 0xFE, 0x07, 0xCF, 0x8F, 0xC1, 0xE7, 0xC1, 0xF8, 0xF9, 0xF0,
  0x7F, 0xFE, 0x78, 0x0F, 0xFF, 0x1E, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xC0,
  0xC0, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_Medium51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 37, 31, 11, -36 },
  { 43, 15, 15, 31, 8, -38 },
  { 72, 29, 36, 31, 1, -36 },
  { 203, 27, 47, 31, 2, -41 },
  { 362, 29, 37, 31, 1, -36 },
  { 497, 29, 37, 31, 1, -36 },
  { 632, 5, 15, 31, 13, -38 },
  { 642, 16, 46, 31, 10, -39 },
  { 734, 16, 46, 31, 5, -39 },
  { 826, 27, 26, 31, 2, -28 },
  { 914, 24, 25, 31, 3, -28 },
  { 989, 10, 15, 31, 10, -8 },
  { 1008, 15, 5, 31, 8, -18 },
  { 1018, 9, 8, 31, 11, -8 },
  { 1027, 22, 46, 31, 4, -39 },
  { 1154, 26, 37, 31, 2, -36 },
  { 1275, 27, 36, 31, 2, -36 },
  { 1397, 25, 36, 31, 3, -36 },
  { 1510, 25, 37, 31, 2, -36 },
  { 1626, 27, 36, 31, 2, -36 },
  { 1748, 25, 37, 31, 3, -36 },
  { 1864, 25, 37, 31, 3, -36 },
  { 1980, 25, 36, 31, 3, -36 },
  { 2093, 26, 37, 31, 2, -36 },
  { 2214, 25, 36, 31, 3, -36 },
  { 2327, 9, 27, 31, 11, -27 },
  { 2358, 10, 34, 31, 10, -27 },
  { 2401, 22, 30, 31, 4, -31 },
  { 2484, 24, 15, 31, 3, -23 },
  { 2529, 22, 30, 31, 4, -31 },
  { 2612, 22, 37, 31, 4, -36 },
  { 2714, 24, 42, 31, 3, -36 },
  { 2840, 29, 36, 31, 1, -36 },
  { 2971, 24, 36, 31, 4, -36 },
  { 3079, 25, 37, 31, 3, -36 },
  { 3195, 24, 36, 31, 4, -36 },
  { 3303, 23, 36, 31, 4, -36 },
  { 3407, 23, 36, 31, 4, -36 },
  { 3511, 25, 37, 31, 2, -36 },
  { 3627, 23, 36, 31, 4, -36 },
  { 3731, 23, 36, 31, 4, -36 },
  { 3835, 22, 37, 31, 3, -36 },
  { 3937, 26, 36, 31, 4, -36 },
  { 4054, 21, 36, 31, 6, -36 },
  { 4149, 25, 36, 31, 3, -36 },
  { 4262, 23, 36, 31, 4, -36 },
  { 4366, 26, 37, 31, 2, -36 },
  { 4487, 24, 36, 31, 4, -36 },
  { 4595, 26, 45, 31, 2, -36 },
  { 4742, 25, 36, 31, 4, -36 },
  { 4855, 26, 37, 31, 2, -36 },
  { 4976, 28, 36, 31, 1, -36 },
  { 5102, 23, 37, 31, 4, -36 },
  { 5209, 28, 36, 31, 1, -36 },
  { 5335, 28, 36, 31, 1, -36 },
  { 5461, 29, 36, 31, 1, -36 },
  { 5592, 29, 36, 31, 1, -36 },
  { 5723, 26, 36, 31, 2, -36 },
  { 5840, 15, 46, 31, 11, -39 },
  { 5927, 22, 46, 31, 4, -39 },
  { 6054, 15, 46, 31, 5, -39 },
  { 6141, 27, 22, 31, 2, -36 },
  { 6216, 25, 5, 31, 3, 4 },
  { 6232, 9, 11, 31, 9, -41 },
  { 6245, 26, 28, 31, 3, -27 },
  { 6336, 24, 39, 31, 4, -38 },
  { 6453, 23, 28, 31, 4, -27 },
  { 6534, 24, 39, 31, 3, -38 },
  { 6651, 25, 28, 31, 3, -27 },
  { 6739, 25, 38, 31, 3, -38 },
  { 6858, 26, 42, 31, 3, -31 },
  { 6995, 23, 38, 31, 4, -38 },
  { 7105, 23, 38, 31, 5, -38 },
  { 7215, 18, 48, 31, 5, -38 },
  { 7323, 26, 38, 31, 4, -38 },
  { 7447, 23, 38, 31, 4, -38 },
  { 7557, 26, 27, 31, 2, -27 },
  { 7645, 23, 27, 31, 4, -27 },
  { 7723, 25, 28, 31, 3, -27 },
  { 7811, 24, 37, 31, 4, -27 },
  { 7922, 24, 37, 31, 3, -27 },
  { 8033, 25, 26, 31, 4, -26 },
  { 8115, 24, 28, 31, 3, -27 },
  { 8199, 25, 36, 31, 2, -36 },
  { 8312, 22, 27, 31, 4, -26 },
  { 8387, 26, 26, 31, 2, -26 },
  { 8472, 29, 26, 31, 1, -26 },
  { 8567, 26, 26, 31, 2, -26 },
  { 8652, 27, 36, 31, 2, -26 },
  { 8774, 23, 26, 31, 4, -26 },
  { 8849, 21, 46, 31, 5, -39 },
  { 8970, 5, 46, 31, 13, -39 },
  { 8999, 21, 46, 31, 5, -39 },
  { 9120, 26, 12, 31, 2, -22 },
};

const GFXfont IBMPlexMono_Medium51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_MEDIUM51PT7B_H_
