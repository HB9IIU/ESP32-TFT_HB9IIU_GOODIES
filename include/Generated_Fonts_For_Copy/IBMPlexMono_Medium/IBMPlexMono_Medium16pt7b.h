#ifndef _IBMPLEXMONO_MEDIUM16PT7B_H_
#define _IBMPLEXMONO_MEDIUM16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium16pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x80, 0x7D, 0x80, 0xCE, 0x73, 0x9C, 0x80, 0x1B, 0x0D,
  0x86, 0xCE, 0x71, 0x20, 0x90, 0xD9, 0xEF, 0x26, 0x12, 0x09, 0x00, 0x18,
  0x18, 0x7E, 0xDB, 0xD8, 0xD8, 0x78, 0x3E, 0x1B, 0x1B, 0x1B, 0xDA, 0x7C,
  0x18, 0x18, 0x70, 0xE4, 0xB2, 0xD9, 0x4C, 0xC3, 0xB8, 0x12, 0x69, 0x2C,
  0xB2, 0x71, 0xC0, 0x3C, 0x13, 0x18, 0x0C, 0x03, 0x01, 0x8D, 0x25, 0x9E,
  0xC6, 0x33, 0x8E, 0x60, 0xFF, 0xC0, 0x19, 0x18, 0x8C, 0x63, 0x18, 0xC6,
  0x10, 0xC2, 0x0C, 0xE0, 0xC1, 0x06, 0x08, 0x20, 0xC3, 0x08, 0x21, 0x84,
  0x33, 0x80, 0x18, 0x18, 0x99, 0xFF, 0x38, 0x3C, 0x64, 0x46, 0x18, 0x18,
  0x18, 0xFF, 0x18, 0x18, 0x18, 0x6F, 0x60, 0xF8, 0x7D, 0x80, 0x02, 0x0C,
  0x10, 0x60, 0xC1, 0x06, 0x08, 0x30, 0x60, 0x83, 0x04, 0x18, 0x00, 0x3C,
  0x46, 0xC2, 0xC3, 0xDB, 0xDB, 0xC3, 0xC3, 0xC2, 0x46, 0x3C, 0x38, 0x68,
  0xC8, 0x88, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x7C, 0xC6, 0x46,
  0x06, 0x06, 0x04, 0x08, 0x30, 0x60, 0xC0, 0xFF, 0x7C, 0xC6, 0x06, 0x06,
  0x06, 0x38, 0x06, 0x02, 0x83, 0xC6, 0x7C, 0x07, 0x07, 0x82, 0xC3, 0x63,
  0x31, 0x19, 0x8D, 0x86, 0xFF, 0x81, 0x80, 0xC0, 0x7E, 0x40, 0x40, 0xC0,
  0xDC, 0xE6, 0x03, 0x03, 0x83, 0xC6, 0x7C, 0x1C, 0x30, 0x60, 0x60, 0xDC,
  0xE6, 0xC3, 0xC3, 0xC3, 0x46, 0x3C, 0xFF, 0xC3, 0xC6, 0x06, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x7C, 0xC6, 0xC2, 0xC3, 0x46, 0x3C, 0xC6,
  0xC3, 0xC3, 0xC6, 0x7C, 0x3C, 0xC6, 0xC2, 0xC3, 0xC3, 0xC7, 0x7E, 0x06,
  0x0C, 0x18, 0x70, 0x7D, 0x80, 0x1F, 0x60, 0x7D, 0x80, 0x03, 0x7B, 0x00,
  0x02, 0x1C, 0x73, 0x8C, 0x0E, 0x07, 0x07, 0x02, 0xFF, 0x00, 0x00, 0xFF,
  0x81, 0xC0, 0xE0, 0x70, 0x21, 0xCE, 0x70, 0x80, 0x7D, 0x8D, 0x18, 0x31,
  0xC2, 0x00, 0x00, 0x38, 0x70, 0xE0, 0x3C, 0x46, 0xC2, 0x9F, 0x93, 0x93,
  0xB3, 0x93, 0x93, 0x9F, 0xC0, 0x60, 0x3C, 0x1C, 0x0E, 0x07, 0x82, 0xC3,
  0x21, 0x98, 0x8C, 0xFE, 0x61, 0xB0, 0xF0, 0x60, 0xFC, 0xC6, 0xC2, 0xC2,
  0xC6, 0xFC, 0xC2, 0xC3, 0xC3, 0xC2, 0xFC, 0x3C, 0x66, 0xC3, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC2, 0x67, 0x3C, 0xFC, 0xC6, 0xC2, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC2, 0xC6, 0xFC, 0xFF, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60,
  0xC1, 0x83, 0xF8, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x3C, 0x66, 0xC3, 0xC0, 0xC0, 0xCF, 0xC3, 0xC3, 0xC3, 0x67,
  0x7B, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xF0, 0xE1, 0xC3, 0x87, 0x08, 0xFE,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xF8, 0x7E, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x47, 0x89, 0xE0, 0xC3, 0xC6, 0xCC, 0xDC, 0xD8,
  0xF8, 0xEC, 0xCC, 0xC6, 0xC3, 0xC3, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0xF8, 0xC7, 0xE7, 0xA7, 0xBF, 0xBB, 0x9B, 0x93, 0x93,
  0x83, 0x83, 0x83, 0xE3, 0xC7, 0x8F, 0x9D, 0x3B, 0x76, 0xE5, 0xCF, 0x8F,
  0x18, 0x3C, 0x46, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x46, 0x3C,
  0xFE, 0xC2, 0xC3, 0xC3, 0xC2, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C,
  0x46, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x46, 0x3C, 0x18, 0x1E,
  0xFE, 0xC2, 0xC3, 0xC3, 0xC2, 0xFE, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0x7E,
  0xC3, 0xC0, 0xC0, 0xE0, 0x3C, 0x06, 0x03, 0x03, 0xC6, 0x7C, 0xFF, 0x86,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0xC2, 0xC2, 0x46, 0x7C, 0xC1, 0xB0,
  0xD8, 0x4C, 0x63, 0x31, 0x98, 0xC8, 0x2C, 0x1E, 0x0E, 0x07, 0x00, 0xC0,
  0xA0, 0x50, 0x29, 0xB4, 0xDA, 0xED, 0x56, 0xAF, 0x73, 0xB9, 0xDC, 0xC0,
  0x61, 0xB1, 0x8C, 0xC3, 0xC1, 0xC0, 0x60, 0x78, 0x6C, 0x33, 0x31, 0xB8,
  0x60, 0xC1, 0xB0, 0xCC, 0xC6, 0x41, 0xE0, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xFF, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0,
  0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7C, 0xC0, 0x81,
  0x81, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0x40, 0xF8,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x18, 0x3C, 0x2C, 0x66,
  0x46, 0xC3, 0x82, 0xFF, 0xC9, 0x80, 0x7C, 0xC6, 0x06, 0x7E, 0xC6, 0xC6,
  0xC6, 0x7B, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC6, 0xFC, 0x3C, 0xCF, 0x06, 0x0C, 0x18, 0x18, 0x9E, 0x02, 0x04, 0x08,
  0x17, 0xB9, 0x71, 0xE1, 0xC3, 0x87, 0x3B, 0xD0, 0x3C, 0x46, 0xC3, 0xFF,
  0xC0, 0xC4, 0x66, 0x3C, 0x0F, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFE, 0x07, 0x3C, 0x46, 0xC6, 0xC6, 0x46, 0x7C, 0xC0,
  0x7E, 0xC3, 0xC3, 0x7E, 0xC1, 0x83, 0x06, 0x0D, 0xDC, 0xF0, 0xE1, 0xC3,
  0x87, 0x0E, 0x10, 0x30, 0x70, 0x00, 0x0F, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC7, 0xF0, 0x0C, 0x30, 0x00, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x37, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xCC, 0xD8, 0xF8, 0xEC, 0xCC,
  0xC6, 0xC3, 0xF8, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x67,
  0xF0, 0xB6, 0xDB, 0x9B, 0x9B, 0x9B, 0x9B, 0x9B, 0x9B, 0xDD, 0xCF, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0x3C, 0x46, 0xC3, 0xC3, 0xC3, 0xC3, 0x46, 0x3C,
  0xDC, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFC, 0xC0, 0xC0, 0xC0, 0x7B,
  0x97, 0x1E, 0x1C, 0x38, 0x73, 0xBD, 0x02, 0x04, 0x08, 0xF3, 0x3C, 0x30,
  0x30, 0x30, 0x30, 0x30, 0xFE, 0x3C, 0x87, 0x03, 0xC1, 0xE0, 0x71, 0xBE,
  0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x78, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x53, 0xBD, 0xC3, 0xC2, 0x46, 0x66, 0x64, 0x2C, 0x38,
  0x18, 0xCC, 0xA6, 0x53, 0x2A, 0xB5, 0x5A, 0x99, 0xCC, 0xE6, 0xC3, 0x66,
  0x3C, 0x38, 0x38, 0x2C, 0x66, 0xC7, 0xC3, 0xC2, 0x46, 0x64, 0x2C, 0x3C,
  0x38, 0x18, 0x10, 0x30, 0xE0, 0xFE, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x7F,
  0x3C, 0x82, 0x0C, 0x10, 0x4E, 0x04, 0x10, 0xC2, 0x08, 0x20, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x41, 0x0C, 0x61, 0x81, 0xD8, 0x60, 0x83, 0x04,
  0x13, 0xC0, 0x73, 0x9B, 0x8E,
};

const GFXglyph IBMPlexMono_Medium16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 11, 10, 3, -11 },
  { 6, 5, 5, 10, 2, -12 },
  { 10, 9, 11, 10, 0, -11 },
  { 23, 8, 15, 10, 1, -13 },
  { 38, 9, 11, 10, 0, -11 },
  { 51, 9, 11, 10, 0, -11 },
  { 64, 2, 5, 10, 4, -12 },
  { 66, 5, 14, 10, 3, -12 },
  { 75, 6, 14, 10, 1, -12 },
  { 86, 8, 8, 10, 1, -9 },
  { 94, 8, 7, 10, 1, -8 },
  { 101, 3, 4, 10, 3, -2 },
  { 103, 5, 1, 10, 2, -5 },
  { 104, 3, 3, 10, 3, -3 },
  { 106, 7, 14, 10, 1, -12 },
  { 119, 8, 11, 10, 1, -11 },
  { 130, 8, 11, 10, 1, -11 },
  { 141, 8, 11, 10, 1, -11 },
  { 152, 8, 11, 10, 1, -11 },
  { 163, 9, 11, 10, 0, -11 },
  { 176, 8, 11, 10, 1, -11 },
  { 187, 8, 11, 10, 1, -11 },
  { 198, 8, 11, 10, 1, -11 },
  { 209, 8, 11, 10, 1, -11 },
  { 220, 8, 11, 10, 1, -11 },
  { 231, 3, 9, 10, 3, -9 },
  { 235, 3, 11, 10, 3, -9 },
  { 240, 7, 9, 10, 1, -9 },
  { 248, 8, 4, 10, 1, -7 },
  { 252, 7, 9, 10, 1, -9 },
  { 260, 7, 11, 10, 1, -11 },
  { 270, 8, 13, 10, 1, -11 },
  { 283, 9, 11, 10, 0, -11 },
  { 296, 8, 11, 10, 1, -11 },
  { 307, 8, 11, 10, 1, -11 },
  { 318, 8, 11, 10, 1, -11 },
  { 329, 7, 11, 10, 1, -11 },
  { 339, 8, 11, 10, 1, -11 },
  { 350, 8, 11, 10, 1, -11 },
  { 361, 7, 11, 10, 1, -11 },
  { 371, 7, 11, 10, 1, -11 },
  { 381, 7, 11, 10, 1, -11 },
  { 391, 8, 11, 10, 1, -11 },
  { 402, 7, 11, 10, 2, -11 },
  { 412, 8, 11, 10, 1, -11 },
  { 423, 7, 11, 10, 1, -11 },
  { 433, 8, 11, 10, 1, -11 },
  { 444, 8, 11, 10, 1, -11 },
  { 455, 8, 13, 10, 1, -11 },
  { 468, 8, 11, 10, 1, -11 },
  { 479, 8, 11, 10, 1, -11 },
  { 490, 9, 11, 10, 0, -11 },
  { 503, 8, 11, 10, 1, -11 },
  { 514, 9, 11, 10, 0, -11 },
  { 527, 9, 11, 10, 0, -11 },
  { 540, 9, 11, 10, 0, -11 },
  { 553, 9, 11, 10, 0, -11 },
  { 566, 8, 11, 10, 1, -11 },
  { 577, 5, 14, 10, 3, -12 },
  { 586, 7, 14, 10, 1, -12 },
  { 599, 5, 14, 10, 1, -12 },
  { 608, 8, 7, 10, 1, -11 },
  { 615, 8, 1, 10, 1, 2 },
  { 616, 3, 3, 10, 3, -12 },
  { 618, 8, 8, 10, 1, -8 },
  { 626, 8, 12, 10, 1, -12 },
  { 638, 7, 8, 10, 1, -8 },
  { 645, 7, 12, 10, 1, -12 },
  { 656, 8, 8, 10, 1, -8 },
  { 664, 8, 12, 10, 1, -12 },
  { 676, 8, 12, 10, 1, -9 },
  { 688, 7, 12, 10, 1, -12 },
  { 699, 7, 12, 10, 2, -12 },
  { 710, 6, 15, 10, 1, -12 },
  { 722, 8, 12, 10, 1, -12 },
  { 734, 7, 12, 10, 1, -12 },
  { 745, 8, 8, 10, 1, -8 },
  { 753, 7, 8, 10, 1, -8 },
  { 760, 8, 8, 10, 1, -8 },
  { 768, 8, 11, 10, 1, -8 },
  { 779, 7, 11, 10, 1, -8 },
  { 789, 8, 8, 10, 1, -8 },
  { 797, 7, 8, 10, 1, -8 },
  { 804, 7, 11, 10, 1, -11 },
  { 814, 7, 8, 10, 1, -8 },
  { 821, 8, 8, 10, 1, -8 },
  { 829, 9, 8, 10, 0, -8 },
  { 838, 8, 8, 10, 1, -8 },
  { 846, 8, 11, 10, 1, -8 },
  { 857, 7, 8, 10, 1, -8 },
  { 864, 6, 14, 10, 2, -12 },
  { 875, 2, 14, 10, 4, -12 },
  { 879, 6, 14, 10, 2, -12 },
  { 890, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Medium16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_MEDIUM16PT7B_H_
