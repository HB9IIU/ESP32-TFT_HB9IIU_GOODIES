#ifndef _IBMPLEXMONO_MEDIUM9PT7B_H_
#define _IBMPLEXMONO_MEDIUM9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x3F, 0xD5, 0xB5, 0x30, 0x23, 0x9E, 0xC3, 0xD5,
  0xC4, 0xED, 0xB8, 0x36, 0xCC, 0x72, 0x93, 0xE9, 0x34, 0xE0, 0x72, 0x49,
  0x23, 0x89, 0x12, 0x94, 0x25, 0x5C, 0xA5, 0x00, 0x44, 0xF4, 0x40, 0xE0,
  0xE0, 0x80, 0x32, 0x24, 0x44, 0x88, 0x72, 0x63, 0x54, 0xB8, 0x32, 0xA4,
  0x21, 0x3C, 0x72, 0x66, 0x64, 0x3C, 0x74, 0x4C, 0x18, 0xB8, 0x11, 0x95,
  0x2F, 0x88, 0xF8, 0xE9, 0x9E, 0x32, 0x1D, 0x94, 0xB8, 0xF9, 0x22, 0x44,
  0x72, 0x4C, 0x9C, 0xB8, 0x72, 0x72, 0xF1, 0x30, 0x90, 0x83, 0x80, 0x16,
  0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE9, 0x24, 0x04, 0x72, 0x6F,
  0x5B, 0xA1, 0xC0, 0x31, 0x94, 0xA7, 0xC4, 0xE9, 0xE9, 0x9E, 0xE9, 0x88,
  0x9E, 0xE9, 0x99, 0x9E, 0xF8, 0xF8, 0x8F, 0xF8, 0xF8, 0x88, 0x72, 0x71,
  0xB4, 0xBC, 0x99, 0xF9, 0x99, 0xF4, 0x44, 0x4F, 0xE4, 0x9B, 0xC0, 0x9A,
  0xCA, 0xA9, 0x88, 0x88, 0x8F, 0xDF, 0xEB, 0x58, 0xC4, 0x9D, 0xDD, 0xBB,
  0x72, 0x63, 0x14, 0xB8, 0xE9, 0x9E, 0x88, 0x72, 0x63, 0x14, 0xB8, 0x87,
  0xE9, 0x9E, 0xA9, 0x72, 0xD8, 0x38, 0xB8, 0xF9, 0x08, 0x42, 0x10, 0x99,
  0x99, 0x9E, 0x8A, 0x54, 0xA3, 0x18, 0x8D, 0x6B, 0xBD, 0xAC, 0xCA, 0x8C,
  0x65, 0x64, 0x8A, 0xD4, 0x42, 0x10, 0x78, 0x8C, 0x44, 0x7C, 0xF2, 0x49,
  0x27, 0x88, 0x44, 0x42, 0x23, 0xE4, 0x92, 0x4F, 0x22, 0x93, 0x10, 0xF0,
  0xC0, 0xEA, 0xEA, 0xD0, 0x88, 0xE9, 0x99, 0xE0, 0xEB, 0x8A, 0xF0, 0x08,
  0x5A, 0xBC, 0xA5, 0xE0, 0xE9, 0xFA, 0xF0, 0x74, 0xF4, 0x44, 0xF0, 0x1E,
  0x9E, 0x8F, 0x9F, 0x88, 0xE9, 0x99, 0x90, 0x60, 0xC4, 0x44, 0xF0, 0x23,
  0x92, 0x49, 0xE0, 0x88, 0xBE, 0xCA, 0x90, 0xC4, 0x44, 0x44, 0xF0, 0xFD,
  0x6B, 0x5A, 0x80, 0xE9, 0x99, 0x90, 0x72, 0x72, 0x97, 0x00, 0xE9, 0x99,
  0xE8, 0x80, 0x6A, 0xF2, 0x97, 0x84, 0x20, 0xD6, 0x44, 0xF0, 0xE9, 0xE9,
  0xE0, 0x27, 0xC8, 0x42, 0x1C, 0x99, 0x99, 0xF0, 0xCA, 0x94, 0xA2, 0x00,
  0xAD, 0x77, 0xB5, 0x80, 0xCB, 0x88, 0xAC, 0x80, 0xCA, 0x94, 0x62, 0x11,
  0x80, 0xF2, 0x48, 0xF0, 0x74, 0x2C, 0x24, 0x47, 0xFF, 0xC4, 0x43, 0x44,
  0x4C, 0x6D, 0xC0,
};

const GFXglyph IBMPlexMono_Medium9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 5, 6, 5, 0, -6 },
  { 17, 5, 6, 5, 0, -6 },
  { 21, 1, 3, 5, 2, -7 },
  { 22, 3, 8, 5, 2, -7 },
  { 25, 3, 8, 5, 1, -7 },
  { 28, 5, 5, 5, 0, -5 },
  { 32, 4, 5, 5, 1, -5 },
  { 35, 2, 2, 5, 2, -1 },
  { 36, 3, 1, 5, 1, -3 },
  { 37, 1, 1, 5, 2, -1 },
  { 38, 4, 8, 5, 1, -7 },
  { 42, 5, 6, 5, 0, -6 },
  { 46, 5, 6, 5, 0, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 5, 6, 5, 0, -6 },
  { 62, 4, 6, 5, 1, -6 },
  { 65, 5, 6, 5, 0, -6 },
  { 69, 4, 6, 5, 1, -6 },
  { 72, 5, 6, 5, 0, -6 },
  { 76, 5, 6, 5, 0, -6 },
  { 80, 1, 4, 5, 2, -4 },
  { 81, 2, 5, 5, 2, -4 },
  { 83, 4, 5, 5, 1, -5 },
  { 86, 4, 3, 5, 1, -4 },
  { 88, 4, 5, 5, 1, -5 },
  { 91, 4, 6, 5, 1, -6 },
  { 94, 5, 7, 5, 0, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 4, 6, 5, 1, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 4, 6, 5, 1, -6 },
  { 115, 4, 6, 5, 1, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 4, 6, 5, 1, -6 },
  { 125, 4, 6, 5, 1, -6 },
  { 128, 3, 6, 5, 1, -6 },
  { 131, 4, 6, 5, 1, -6 },
  { 134, 4, 6, 5, 1, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 4, 6, 5, 1, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 4, 6, 5, 1, -6 },
  { 151, 5, 8, 5, 0, -6 },
  { 156, 4, 6, 5, 1, -6 },
  { 159, 5, 6, 5, 0, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 4, 6, 5, 1, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 5, 6, 5, 0, -6 },
  { 178, 5, 6, 5, 0, -6 },
  { 182, 5, 6, 5, 0, -6 },
  { 186, 5, 6, 5, 0, -6 },
  { 190, 3, 8, 5, 2, -7 },
  { 193, 4, 8, 5, 1, -7 },
  { 197, 3, 8, 5, 1, -7 },
  { 200, 5, 4, 5, 0, -6 },
  { 203, 4, 1, 5, 1, 1 },
  { 204, 1, 2, 5, 2, -8 },
  { 205, 4, 5, 5, 1, -5 },
  { 208, 4, 7, 5, 1, -7 },
  { 212, 4, 5, 5, 1, -5 },
  { 215, 5, 7, 5, 0, -7 },
  { 220, 4, 5, 5, 1, -5 },
  { 223, 4, 7, 5, 1, -7 },
  { 227, 4, 8, 5, 1, -6 },
  { 231, 4, 7, 5, 1, -7 },
  { 235, 4, 7, 5, 1, -7 },
  { 239, 3, 9, 5, 1, -7 },
  { 243, 4, 7, 5, 1, -7 },
  { 247, 4, 7, 5, 1, -7 },
  { 251, 5, 5, 5, 0, -5 },
  { 255, 4, 5, 5, 1, -5 },
  { 258, 5, 5, 5, 0, -5 },
  { 262, 4, 7, 5, 1, -5 },
  { 266, 5, 7, 5, 0, -5 },
  { 271, 4, 5, 5, 1, -5 },
  { 274, 4, 5, 5, 1, -5 },
  { 277, 5, 6, 5, 0, -6 },
  { 281, 4, 5, 5, 1, -5 },
  { 284, 5, 5, 5, 0, -5 },
  { 288, 5, 5, 5, 0, -5 },
  { 292, 5, 5, 5, 0, -5 },
  { 296, 5, 7, 5, 0, -5 },
  { 301, 4, 5, 5, 1, -5 },
  { 304, 4, 8, 5, 1, -7 },
  { 308, 1, 8, 5, 2, -7 },
  { 309, 4, 8, 5, 1, -7 },
  { 313, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_Medium9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_MEDIUM9PT7B_H_
