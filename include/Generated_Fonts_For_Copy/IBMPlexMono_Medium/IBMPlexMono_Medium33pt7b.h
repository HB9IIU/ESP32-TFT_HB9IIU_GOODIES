#ifndef _IBMPLEXMONO_MEDIUM33PT7B_H_
#define _IBMPLEXMONO_MEDIUM33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium33pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC3, 0x0C, 0x30, 0xC3,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x01, 0xC7, 0x80, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE3,
  0x81, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0x1C, 0x38, 0x03, 0x8F,
  0x00, 0x71, 0xC1, 0xFE, 0x3F, 0xBF, 0xC7, 0xF7, 0xF8, 0xFE, 0x0E, 0x1C,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x70,
  0x07, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xFF, 0x01,
  0xFF, 0xE1, 0xFF, 0xF8, 0xF3, 0x3E, 0xF1, 0x86, 0x78, 0xC2, 0x3C, 0x60,
  0x1E, 0x30, 0x07, 0x98, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFE, 0x00, 0xCF, 0x80, 0x63, 0xC0, 0x30, 0xE0, 0x18, 0x72, 0x0C, 0x3B,
  0x86, 0x3F, 0xF3, 0x3E, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0xE7, 0xF0, 0x1D, 0xFF, 0x07,
  0x38, 0xE1, 0xC6, 0x0C, 0x39, 0xC1, 0xCE, 0x18, 0x39, 0xC3, 0x06, 0x70,
  0x71, 0xCE, 0x0F, 0xFA, 0x00, 0xFE, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0xC1, 0xCE, 0x38, 0x3B, 0x87, 0x0E, 0x70, 0x61, 0x8E, 0x0C,
  0x71, 0xC3, 0x9C, 0x1C, 0x73, 0x83, 0xFE, 0xE0, 0x3F, 0xBC, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xF1, 0xE0, 0x38, 0x1C, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x7C, 0xFE, 0x1F, 0x7F, 0xCF, 0xFC, 0xF3, 0x8F, 0x1E, 0xE3, 0x83, 0xF8,
  0xE0, 0x7E, 0x38, 0x0F, 0x0F, 0x03, 0xE3, 0xE1, 0xF8, 0x7F, 0xEF, 0x0F,
  0xF1, 0xE1, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x1C, 0x70, 0xE7, 0xFD, 0xFB, 0xFF, 0xFF, 0x0F,
  0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x3C, 0x07, 0x87,
  0x01, 0xE1, 0xE0, 0xF0, 0x30, 0x08, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x7C, 0xF3, 0xE7, 0x8F, 0x1E,
  0x38, 0x71, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFF, 0x78, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3,
  0xE3, 0xC0, 0xF3, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0xF8,
  0xF1, 0xFC, 0x78, 0xFE, 0x3C, 0x7F, 0x1E, 0x3B, 0x80, 0x1D, 0xC0, 0x1E,
  0xE0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xCF, 0x03, 0xC7, 0xC3, 0xE1, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x3E, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0x01, 0xC3, 0xC0, 0x30,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F,
  0xF8, 0x7F, 0xFC, 0x78, 0x3E, 0xF0, 0x1E, 0xE0, 0x1E, 0x20, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x83, 0xE3, 0x80, 0xF0, 0x80, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x90, 0x03, 0xDC, 0x03, 0xDF,
  0x83, 0xE7, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC0,
  0x1C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x38,
  0x1C, 0x1E, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x71, 0xF0, 0x77, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E,
  0x30, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x20, 0x0F,
  0x70, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x07, 0xE0, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x71, 0xF0, 0x77, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F,
  0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE,
  0x78, 0x3E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x3C,
  0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xFC, 0x78, 0x3E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E,
  0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x3F, 0xEE, 0x0F, 0x9E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B,
  0xFF, 0xFF, 0x78, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0xCF, 0x3E, 0x78, 0xF1, 0xE3, 0x87, 0x1C, 0x00, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x80, 0xF8, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x70, 0x07,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0x80,
  0x08, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xF7, 0x01,
  0xFE, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x1F, 0xE0,
  0x3F, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x70, 0x0E, 0x70, 0x0E, 0xE0,
  0x07, 0xE0, 0xE7, 0xE3, 0xF7, 0xE3, 0xFF, 0xE7, 0x8F, 0xE7, 0x07, 0xE7,
  0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x87, 0xE3, 0xFF, 0xE3,
  0xF7, 0xE1, 0xF7, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0x78, 0x01, 0xDE, 0x00, 0xF3, 0x80, 0x3C, 0xF0, 0x0E,
  0x3C, 0x03, 0x87, 0x01, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x0F, 0x03,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1E, 0x01, 0xE7, 0x80, 0x79,
  0xC0, 0x1E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3C, 0xFF, 0xE1, 0xFF,
  0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1E,
  0xE0, 0x3D, 0xC0, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x9C, 0x07, 0xB8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xEF, 0xFF,
  0xDF, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C,
  0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x04, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x04, 0x78, 0x0F, 0x78, 0x0F, 0x3C, 0x1E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xF0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xCE, 0x03,
  0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3B, 0x80, 0xF7, 0x03, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x0F,
  0xF0, 0x08, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xEF, 0x1F, 0xEF, 0x0F, 0x8F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1F, 0xC0, 0xFF, 0x03, 0xDE, 0x1F, 0x7F, 0xF8,
  0xFF, 0xC0, 0xFC, 0x00, 0xE0, 0x1F, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78,
  0xE0, 0xF8, 0xE0, 0xF0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE7, 0x80, 0xE7, 0x80,
  0xEF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0,
  0xE0, 0xF8, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x37, 0xEE, 0x77, 0xEE, 0x77, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFB, 0x87, 0xF7, 0x0F, 0xE7, 0x1F,
  0xCE, 0x3F, 0x9E, 0x7F, 0x1C, 0xFE, 0x39, 0xFC, 0x7B, 0xF8, 0x77, 0xF0,
  0xEF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0xF3,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x70, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xCF, 0x03, 0xC7, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xC0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x01, 0xEE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xF7, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0x70, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03,
  0xCF, 0x03, 0xC7, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x01, 0xEE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xF7, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFC, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0xF1, 0xC1, 0xE3, 0x81, 0xE7,
  0x03, 0xCE, 0x03, 0xDC, 0x03, 0xF8, 0x07, 0x80, 0x03, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC7, 0xC1, 0xF7, 0x80, 0x73, 0xC0, 0x11, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x90, 0x03, 0xDC, 0x01,
  0xFF, 0x83, 0xE7, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70,
  0x0E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0xF0,
  0x03, 0xFC, 0x00, 0xF7, 0x00, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x03, 0x81, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x38, 0x01, 0xCE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x1E, 0x3F, 0xC7, 0x8E, 0xF1, 0xE3, 0x9C,
  0xF8, 0xE7, 0x3F, 0x39, 0xCF, 0xCE, 0x73, 0x73, 0x9C, 0xCC, 0xE7, 0x73,
  0x39, 0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0x8E, 0xE7, 0x61, 0xB9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x9F, 0x87, 0xC7, 0xE1, 0xF0, 0xF8, 0x03, 0xDE, 0x01, 0xE3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x3C,
  0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x83,
  0xC1, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x3C, 0xF8,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0x38,
  0x03, 0xCF, 0x00, 0xE1, 0xC0, 0x70, 0x78, 0x1C, 0x0E, 0x0E, 0x03, 0xC7,
  0x80, 0x71, 0xC0, 0x1E, 0xF0, 0x03, 0x98, 0x00, 0xD0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x23, 0xCF, 0x1E, 0x38, 0xF1, 0x80, 0x0F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF8, 0x78, 0x7C, 0x20, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x0F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xF8, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0,
  0x7C, 0x7F, 0xFF, 0x7F, 0xDF, 0x1F, 0x0F, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x71, 0xF0, 0xE7, 0xF9,
  0xDF, 0xFB, 0xE1, 0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0x87, 0xDD, 0xFF,
  0xB9, 0xFE, 0x71, 0xF0, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE0, 0xF7,
  0x80, 0xCE, 0x02, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x47, 0x80, 0xE7, 0x83, 0xCF, 0xFF, 0x0F, 0xFC, 0x07, 0xF0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x87, 0xC7, 0x3F, 0xCE, 0xFF, 0xDD, 0xE0, 0xFF, 0x80, 0xFF, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xF7, 0xC3, 0xEF, 0xFD, 0xCF, 0xF3, 0x87, 0xC7, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x70, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x04, 0x7C,
  0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xF0, 0xF0, 0xF0, 0x3C,
  0x70, 0x1E, 0x38, 0x0F, 0x1E, 0x07, 0x0F, 0x87, 0x83, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE7, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0x07, 0xFC, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0xF8, 0xE7, 0xF3, 0xBF, 0xEE, 0x87,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x8F, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFE, 0x3C, 0x7F, 0x1E, 0x3F, 0x8E, 0x1F, 0xC7, 0x0F, 0xE3, 0x87,
  0xF1, 0xC3, 0xF8, 0xE1, 0xFC, 0x70, 0xFE, 0x38, 0x7F, 0x1C, 0x3F, 0x8E,
  0x1F, 0xC7, 0x0F, 0xE3, 0x87, 0xF1, 0xC3, 0x80, 0xE3, 0xE3, 0x9F, 0xCE,
  0xFF, 0xBA, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1C, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x70, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0xE3, 0xE1, 0xCF, 0xF3, 0xBF, 0xF7, 0xC3, 0xEF, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x03,
  0xFF, 0x0F, 0xBB, 0xFF, 0x73, 0xFC, 0xE3, 0xE1, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0x8E, 0x7F,
  0x9D, 0xFF, 0xBB, 0xC1, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xEF, 0x87, 0xDF,
  0xFB, 0x9F, 0xE7, 0x0F, 0x8E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0x1F, 0xFE, 0x7F, 0xFD, 0xF8,
  0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x3F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xFB, 0xC0, 0xE7, 0x00, 0x8F,
  0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xF8, 0x00,
  0x76, 0x00, 0xFF, 0x03, 0xDF, 0xFF, 0x9F, 0xFE, 0x0F, 0xE0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE1, 0xF7, 0xFF, 0xDF, 0xEF,
  0x1F, 0x3C, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E,
  0x38, 0x1C, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE3, 0xF1, 0xF8,
  0xDC, 0x67, 0x33, 0x39, 0xCC, 0xCE, 0x73, 0x33, 0x9D, 0xCC, 0xE7, 0x73,
  0xB9, 0xD8, 0xEE, 0x76, 0x1B, 0x0D, 0x86, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x00, 0x78, 0x07, 0x9E, 0x07, 0x87, 0x87, 0x83, 0xC3, 0x80,
  0xF3, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0xEF, 0x00, 0xF3, 0xC0, 0xF0, 0xF0, 0xF0, 0x7C, 0x70,
  0x1E, 0xF8, 0x07, 0x80, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x78, 0xE0,
  0x1C, 0x3C, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x78, 0x78, 0x0E, 0x1C,
  0x03, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC3, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0xF0, 0x1F, 0xC1,
  0xFF, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xE0, 0xFF, 0x83,
  0xFC, 0x00, 0x0F, 0x01, 0x8F, 0xC1, 0xCF, 0xF0, 0xEF, 0x38, 0x77, 0x1E,
  0x73, 0x87, 0xF9, 0x81, 0xF9, 0xC0, 0x78,
};

const GFXglyph IBMPlexMono_Medium33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 23, 20, 7, -23 },
  { 19, 10, 10, 20, 5, -24 },
  { 32, 19, 23, 20, 0, -23 },
  { 87, 17, 29, 20, 1, -26 },
  { 149, 19, 23, 20, 0, -23 },
  { 204, 18, 23, 20, 1, -23 },
  { 256, 4, 10, 20, 8, -24 },
  { 261, 11, 30, 20, 6, -25 },
  { 303, 10, 30, 20, 3, -25 },
  { 341, 18, 17, 20, 1, -18 },
  { 380, 16, 17, 20, 2, -19 },
  { 414, 7, 10, 20, 6, -5 },
  { 423, 10, 3, 20, 5, -12 },
  { 427, 6, 5, 20, 7, -5 },
  { 431, 14, 30, 20, 3, -25 },
  { 484, 17, 23, 20, 1, -23 },
  { 533, 18, 23, 20, 1, -23 },
  { 585, 16, 23, 20, 2, -23 },
  { 631, 17, 23, 20, 1, -23 },
  { 680, 18, 23, 20, 1, -23 },
  { 732, 16, 23, 20, 2, -23 },
  { 778, 16, 23, 20, 2, -23 },
  { 824, 16, 23, 20, 2, -23 },
  { 870, 16, 23, 20, 2, -23 },
  { 916, 16, 23, 20, 2, -23 },
  { 962, 6, 17, 20, 7, -17 },
  { 975, 7, 22, 20, 6, -17 },
  { 995, 14, 19, 20, 3, -20 },
  { 1029, 16, 10, 20, 2, -15 },
  { 1049, 14, 19, 20, 3, -20 },
  { 1083, 15, 23, 20, 2, -23 },
  { 1127, 16, 27, 20, 2, -23 },
  { 1181, 18, 23, 20, 1, -23 },
  { 1233, 15, 23, 20, 3, -23 },
  { 1277, 16, 23, 20, 2, -23 },
  { 1323, 15, 23, 20, 3, -23 },
  { 1367, 14, 23, 20, 3, -23 },
  { 1408, 15, 23, 20, 3, -23 },
  { 1452, 16, 23, 20, 2, -23 },
  { 1498, 15, 23, 20, 2, -23 },
  { 1542, 14, 23, 20, 3, -23 },
  { 1583, 14, 23, 20, 2, -23 },
  { 1624, 16, 23, 20, 3, -23 },
  { 1670, 14, 23, 20, 4, -23 },
  { 1711, 16, 23, 20, 2, -23 },
  { 1757, 15, 23, 20, 2, -23 },
  { 1801, 17, 23, 20, 1, -23 },
  { 1850, 15, 23, 20, 3, -23 },
  { 1894, 17, 29, 20, 1, -23 },
  { 1956, 15, 23, 20, 3, -23 },
  { 2000, 17, 23, 20, 1, -23 },
  { 2049, 18, 23, 20, 1, -23 },
  { 2101, 16, 23, 20, 2, -23 },
  { 2147, 18, 23, 20, 1, -23 },
  { 2199, 18, 23, 20, 1, -23 },
  { 2251, 18, 23, 20, 1, -23 },
  { 2303, 19, 23, 20, 0, -23 },
  { 2358, 16, 23, 20, 2, -23 },
  { 2404, 10, 30, 20, 7, -25 },
  { 2442, 14, 30, 20, 3, -25 },
  { 2495, 10, 30, 20, 3, -25 },
  { 2533, 18, 14, 20, 1, -23 },
  { 2565, 16, 3, 20, 2, 3 },
  { 2571, 6, 7, 20, 6, -26 },
  { 2577, 16, 17, 20, 2, -17 },
  { 2611, 15, 24, 20, 3, -24 },
  { 2656, 15, 17, 20, 2, -17 },
  { 2688, 15, 24, 20, 2, -24 },
  { 2733, 16, 17, 20, 2, -17 },
  { 2767, 16, 24, 20, 2, -24 },
  { 2815, 17, 27, 20, 2, -20 },
  { 2873, 14, 24, 20, 3, -24 },
  { 2915, 15, 25, 20, 3, -25 },
  { 2962, 12, 32, 20, 3, -25 },
  { 3010, 16, 24, 20, 3, -24 },
  { 3058, 15, 24, 20, 2, -24 },
  { 3103, 17, 17, 20, 1, -17 },
  { 3140, 14, 17, 20, 3, -17 },
  { 3170, 16, 17, 20, 2, -17 },
  { 3204, 15, 24, 20, 3, -17 },
  { 3249, 15, 24, 20, 2, -17 },
  { 3294, 15, 17, 20, 3, -17 },
  { 3326, 15, 17, 20, 2, -17 },
  { 3358, 16, 23, 20, 1, -23 },
  { 3404, 14, 17, 20, 3, -17 },
  { 3434, 16, 17, 20, 2, -17 },
  { 3468, 18, 17, 20, 1, -17 },
  { 3507, 17, 17, 20, 1, -17 },
  { 3544, 18, 24, 20, 1, -17 },
  { 3598, 14, 17, 20, 3, -17 },
  { 3628, 14, 30, 20, 3, -25 },
  { 3681, 3, 30, 20, 8, -25 },
  { 3693, 14, 30, 20, 3, -25 },
  { 3746, 17, 8, 20, 1, -14 },
};

const GFXfont IBMPlexMono_Medium33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_MEDIUM33PT7B_H_
