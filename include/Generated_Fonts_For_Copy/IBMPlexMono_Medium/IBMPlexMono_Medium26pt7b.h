#ifndef _IBMPLEXMONO_MEDIUM26PT7B_H_
#define _IBMPLEXMONO_MEDIUM26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium26pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x40, 0x00, 0xFF, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x03, 0x18, 0x0E, 0x70, 0x1C, 0xE0,
  0x39, 0x80, 0x63, 0x0F, 0xC7, 0xDF, 0x9F, 0x87, 0x38, 0x0E, 0x60, 0x18,
  0xC3, 0xF1, 0xF7, 0xE3, 0xE1, 0xCE, 0x03, 0x9C, 0x07, 0x30, 0x0C, 0x60,
  0x18, 0xC0, 0x33, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xF0, 0x3F,
  0xF1, 0xEC, 0xE7, 0x31, 0x18, 0xC0, 0x73, 0x01, 0xCC, 0x07, 0xF0, 0x0F,
  0xF8, 0x07, 0xF0, 0x0D, 0xE0, 0x33, 0x80, 0xC7, 0x03, 0x19, 0x8C, 0xEF,
  0x37, 0x9F, 0xFC, 0x1F, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3C, 0x06,
  0xFC, 0x1D, 0x8C, 0x37, 0x18, 0xEE, 0x31, 0x9C, 0x67, 0x18, 0xCC, 0x3F,
  0x38, 0x3C, 0x00, 0x00, 0xF0, 0x3B, 0xF0, 0x66, 0x31, 0x9C, 0x63, 0x30,
  0xCC, 0x61, 0x98, 0x63, 0x60, 0xFD, 0xC0, 0xF0, 0x0F, 0x00, 0xFF, 0x07,
  0x1C, 0x1C, 0x28, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x3D,
  0xF8, 0xFE, 0x73, 0x30, 0xCC, 0xC3, 0xE3, 0x07, 0x8E, 0x0E, 0x38, 0x7C,
  0x7F, 0x38, 0xF8, 0x70, 0xFF, 0xFF, 0xFF, 0x07, 0x0C, 0x1C, 0x38, 0x30,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x60, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x07, 0xF0, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE1, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0xF3, 0x3B, 0xFF, 0xF3, 0xFF, 0x01, 0xE0,
  0x0F, 0xC0, 0x77, 0x01, 0xCE, 0x0E, 0x1C, 0x10, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x7B, 0xDC, 0xE7, 0x73, 0x98, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x0F, 0xC1, 0xFF,
  0x0E, 0x1C, 0xE0, 0x67, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE7, 0x3F,
  0x39, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x1D, 0xC0, 0xC7, 0x0E, 0x3F,
  0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x0E, 0xE0, 0x73, 0x83,
  0x8E, 0x04, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F,
  0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xEA, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x1F, 0x81, 0xFF, 0x1C, 0x3C, 0x40, 0xE0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x0F, 0xC0, 0x7F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1D, 0x81, 0xFE, 0x1E, 0x7F, 0xE0, 0xFC, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x0E, 0xE0, 0x33, 0x81, 0xCE, 0x0E,
  0x38, 0x38, 0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x7F, 0xE7, 0xFE, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xFF, 0xEF, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x0E, 0x7F, 0xC1, 0xF8, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x78, 0x77,
  0xF7, 0x43, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xB0, 0x1D, 0xC0, 0xE7, 0x0E,
  0x3F, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x0F, 0xC0, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x0F, 0xC1, 0xFF, 0x9E, 0x1C,
  0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xC7, 0x0E, 0x1F, 0xC0, 0xFF, 0x1E,
  0x1C, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xEF, 0x0F, 0x3F, 0xF0, 0x7E,
  0x00, 0x0F, 0xC1, 0xFF, 0x1E, 0x1C, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xEE, 0x07, 0x78, 0x79, 0xFD, 0xC7, 0xDE, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x7B, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF7, 0x39, 0xDC,
  0xE6, 0x00, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x07,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xC0, 0x08, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0x01, 0xE0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x1F, 0x8F, 0xFB, 0xC3,
  0xF0, 0x74, 0x0E, 0x01, 0xC0, 0x78, 0x7E, 0x0F, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x0F, 0xC0, 0xFF,
  0x0E, 0x1C, 0xE0, 0x66, 0x01, 0xB1, 0xED, 0x9F, 0x7C, 0xE7, 0xE6, 0x1F,
  0x30, 0xF9, 0x87, 0xCC, 0x3E, 0x61, 0xF3, 0x1D, 0x9F, 0x6C, 0x7B, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0x70, 0x1D, 0xC0, 0x73, 0x01, 0xCE, 0x06, 0x38, 0x38, 0xE0,
  0xE1, 0xC3, 0x87, 0x1F, 0xFC, 0x7F, 0xF1, 0xC0, 0xE6, 0x03, 0xB8, 0x0E,
  0xE0, 0x1F, 0x80, 0x70, 0xFF, 0x8F, 0xFC, 0xE0, 0xEE, 0x0E, 0xE0, 0x7E,
  0x07, 0xE0, 0xEE, 0x0E, 0xFF, 0x8F, 0xFC, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF, 0xFC, 0x0F, 0x83, 0xFE, 0x70, 0xFE,
  0x07, 0xE0, 0x6E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x06, 0xE0, 0x77, 0x0F, 0x3F, 0xE0, 0xF8, 0xFF, 0x0F,
  0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C,
  0xE0, 0x77, 0x03, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xF8,
  0x7F, 0xC0, 0x7E, 0x03, 0xB8, 0x1D, 0xC0, 0xE7, 0x0F, 0x3F, 0xB8, 0x79,
  0xC0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x3F, 0xE7, 0xFC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x81, 0xF8, 0x3F, 0x0E, 0x7F, 0x87, 0xE0, 0xE0, 0x7F, 0x03, 0xB8,
  0x39, 0xC3, 0x8E, 0x3C, 0x73, 0xC3, 0x9C, 0x1D, 0xC0, 0xFF, 0x07, 0xF8,
  0x3F, 0xE1, 0xE7, 0x0E, 0x1C, 0x70, 0xF3, 0x83, 0x9C, 0x1E, 0xE0, 0x77,
  0x01, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFC, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0xCD, 0xF6,
  0x6F, 0xBE, 0x7C, 0xF3, 0xE7, 0x9F, 0x38, 0xF8, 0xC7, 0xC4, 0x3E, 0x21,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xC0, 0xF0, 0x7F, 0x07,
  0xF8, 0x7F, 0x87, 0xD8, 0x7D, 0xC7, 0xCC, 0x7C, 0xE7, 0xCE, 0x7C, 0x67,
  0xC7, 0x7C, 0x77, 0xC3, 0x7C, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F,
  0x0F, 0xC1, 0xFF, 0x0E, 0x1C, 0xE0, 0x67, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x1D, 0xC0,
  0xC7, 0x0E, 0x3F, 0xE0, 0x7C, 0x00, 0xFF, 0xCF, 0xFE, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF, 0xFC, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xC0, 0xFF,
  0x0E, 0x1C, 0xE0, 0x67, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x1D, 0xC0, 0xE7, 0x0E, 0x3F,
  0xE0, 0x7E, 0x01, 0xC0, 0x06, 0x00, 0x3F, 0x00, 0xF8, 0xFF, 0xC7, 0xFF,
  0x38, 0x3D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xFF, 0xE7,
  0xFE, 0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0,
  0x77, 0x03, 0xC0, 0x0F, 0xC1, 0xFF, 0x9E, 0x1E, 0xE0, 0x27, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1D, 0x80, 0xFE, 0x0E, 0x7F, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x67, 0x0E, 0x7F, 0xC1, 0xF8, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE3, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x77, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x1E, 0x00, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC7,
  0x1F, 0x9E, 0x7E, 0x79, 0xF9, 0xE6, 0xE5, 0x9B, 0xB6, 0x6E, 0xD9, 0xBB,
  0x36, 0x6C, 0xD9, 0xB3, 0x67, 0x8D, 0x9E, 0x3E, 0x78, 0x79, 0xE1, 0xE0,
  0x70, 0x1E, 0x70, 0x38, 0xF0, 0xE0, 0xE1, 0xC0, 0xE7, 0x01, 0xCE, 0x01,
  0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x77, 0x00, 0xE7,
  0x03, 0x8E, 0x07, 0x0E, 0x1C, 0x1E, 0x78, 0x1D, 0xE0, 0x1C, 0xF0, 0x0E,
  0xE0, 0x38, 0xE0, 0x71, 0xC1, 0xC1, 0xC3, 0x83, 0x8E, 0x03, 0x9C, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0xFF,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x07,
  0x80, 0x3E, 0x00, 0xFC, 0x07, 0x70, 0x1C, 0xE0, 0xE3, 0x83, 0x87, 0x1C,
  0x1C, 0x70, 0x3B, 0x80, 0xE6, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x23, 0x3C,
  0x63, 0x8C, 0x3F, 0x03, 0xFE, 0x38, 0x70, 0x81, 0xC0, 0x0E, 0x00, 0x70,
  0xFF, 0x9F, 0xFC, 0xE0, 0xE6, 0x07, 0x38, 0x79, 0xFF, 0xF7, 0xE7, 0x80,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E, 0xFE,
  0xF0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0xEE, 0xFE, 0xE7, 0x80, 0x0F, 0x83, 0xFE, 0x70, 0xEE, 0x05, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x06, 0x70, 0xF3, 0xFE, 0x1F,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7C,
  0xE7, 0xF7, 0x78, 0x7B, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xEE, 0x07, 0x78, 0x79, 0xFD, 0xC7, 0xCE, 0x1F, 0x83, 0xFC, 0x70,
  0xEE, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x0E, 0x06, 0x70,
  0xF3, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x07,
  0x87, 0xE0, 0xFF, 0x87, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0x70, 0xE1,
  0xFE, 0x0F, 0xC0, 0xC0, 0x0E, 0x00, 0x3F, 0xF0, 0xFF, 0xD8, 0x07, 0xC0,
  0x3F, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE7, 0x8E, 0xFE, 0xF0, 0xEE, 0x0E, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x0E,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0x80, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFB, 0xFE,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE7, 0xF9, 0xFC, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xDC, 0x1C, 0xE3, 0xC7, 0x3C,
  0x3B, 0xC1, 0xFC, 0x0F, 0xF0, 0x79, 0xC3, 0x8F, 0x1C, 0x38, 0xE0, 0xE7,
  0x03, 0xB8, 0x1E, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xF0, 0xEE, 0x77, 0xF7, 0xF9,
  0xC7, 0xC6, 0x3E, 0x31, 0xF1, 0x8F, 0x8C, 0x7C, 0x63, 0xE3, 0x1F, 0x18,
  0xF8, 0xC7, 0xC6, 0x3E, 0x31, 0x80, 0xE7, 0x8E, 0xFE, 0xF0, 0xEE, 0x0E,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x70, 0x0F, 0xC1, 0xFF, 0x0E, 0x1C, 0xE0, 0x76, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0x60, 0x3B, 0x81, 0xCE, 0x1C, 0x7F, 0xC0, 0xFC, 0x00,
  0xE7, 0x8E, 0xFE, 0xF0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0xEE, 0xFE, 0xE7, 0x8E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x1F, 0x39, 0xFD, 0xDE, 0x1E, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0xDE, 0x1E, 0x7F, 0x71, 0xF3,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xFC, 0x7F, 0xE7,
  0xC3, 0x40, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0x87, 0xFE, 0x70, 0xFE,
  0x04, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0x74, 0x07, 0xE0, 0xE7,
  0xFE, 0x1F, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0xC3,
  0xBF, 0xB3, 0xE6, 0xE0, 0x3B, 0x81, 0xDC, 0x0C, 0x60, 0xE3, 0x87, 0x1C,
  0x30, 0x63, 0x83, 0x9C, 0x1C, 0xC0, 0x6E, 0x03, 0xE0, 0x0F, 0x00, 0x78,
  0x00, 0xC7, 0x0F, 0x1E, 0x3C, 0x79, 0xF1, 0xE7, 0xC5, 0x9B, 0xB6, 0x6E,
  0xC9, 0x9B, 0x36, 0x6C, 0xD9, 0xB3, 0x66, 0x8F, 0x9E, 0x3C, 0x78, 0x70,
  0xF0, 0x3B, 0xC3, 0x8E, 0x38, 0x39, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x01,
  0xF0, 0x0D, 0xC0, 0xE7, 0x0E, 0x3C, 0xE0, 0xEF, 0x03, 0x80, 0xE0, 0x1D,
  0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x38, 0x70, 0xE1, 0x81, 0xCE, 0x07, 0x30,
  0x0D, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0xE3, 0xF0, 0xFC, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x0E, 0x01, 0x80, 0x3F, 0x0F, 0xC6, 0x03, 0x80, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xE3, 0xF0, 0x1C, 0x19, 0xF0, 0xD9,
  0xC6, 0xC7, 0x7E, 0x1F, 0x60, 0x70,
};

const GFXglyph IBMPlexMono_Medium26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 18, 16, 6, -18 },
  { 10, 8, 8, 16, 4, -19 },
  { 18, 15, 18, 16, 0, -18 },
  { 52, 14, 24, 16, 1, -21 },
  { 94, 15, 18, 16, 0, -18 },
  { 128, 14, 18, 16, 1, -18 },
  { 160, 3, 8, 16, 6, -19 },
  { 163, 8, 24, 16, 5, -20 },
  { 187, 9, 24, 16, 2, -20 },
  { 214, 14, 13, 16, 1, -14 },
  { 237, 12, 12, 16, 2, -14 },
  { 255, 5, 8, 16, 5, -4 },
  { 260, 8, 2, 16, 4, -9 },
  { 262, 4, 4, 16, 6, -4 },
  { 264, 11, 24, 16, 2, -20 },
  { 297, 13, 18, 16, 1, -18 },
  { 327, 14, 18, 16, 1, -18 },
  { 359, 13, 18, 16, 1, -18 },
  { 389, 13, 18, 16, 1, -18 },
  { 419, 14, 18, 16, 1, -18 },
  { 451, 12, 18, 16, 2, -18 },
  { 478, 13, 18, 16, 1, -18 },
  { 508, 12, 18, 16, 2, -18 },
  { 535, 13, 18, 16, 1, -18 },
  { 565, 13, 18, 16, 1, -18 },
  { 595, 4, 14, 16, 6, -14 },
  { 602, 5, 18, 16, 5, -14 },
  { 614, 11, 15, 16, 2, -15 },
  { 635, 12, 8, 16, 2, -12 },
  { 647, 11, 15, 16, 2, -15 },
  { 668, 11, 18, 16, 2, -18 },
  { 693, 13, 21, 16, 1, -18 },
  { 728, 14, 18, 16, 1, -18 },
  { 760, 12, 18, 16, 2, -18 },
  { 787, 12, 18, 16, 2, -18 },
  { 814, 12, 18, 16, 2, -18 },
  { 841, 12, 18, 16, 2, -18 },
  { 868, 12, 18, 16, 2, -18 },
  { 895, 13, 18, 16, 1, -18 },
  { 925, 12, 18, 16, 2, -18 },
  { 952, 12, 18, 16, 2, -18 },
  { 979, 11, 18, 16, 2, -18 },
  { 1004, 13, 18, 16, 2, -18 },
  { 1034, 11, 18, 16, 3, -18 },
  { 1059, 13, 18, 16, 1, -18 },
  { 1089, 12, 18, 16, 2, -18 },
  { 1116, 13, 18, 16, 1, -18 },
  { 1146, 12, 18, 16, 2, -18 },
  { 1173, 13, 22, 16, 1, -18 },
  { 1209, 13, 18, 16, 2, -18 },
  { 1239, 13, 18, 16, 1, -18 },
  { 1269, 14, 18, 16, 1, -18 },
  { 1301, 12, 18, 16, 2, -18 },
  { 1328, 14, 18, 16, 1, -18 },
  { 1360, 14, 18, 16, 1, -18 },
  { 1392, 15, 18, 16, 0, -18 },
  { 1426, 15, 18, 16, 0, -18 },
  { 1460, 13, 18, 16, 1, -18 },
  { 1490, 8, 24, 16, 5, -20 },
  { 1514, 11, 24, 16, 2, -20 },
  { 1547, 8, 24, 16, 2, -20 },
  { 1571, 14, 11, 16, 1, -18 },
  { 1591, 12, 2, 16, 2, 2 },
  { 1594, 5, 6, 16, 4, -21 },
  { 1598, 13, 13, 16, 2, -13 },
  { 1620, 12, 19, 16, 2, -19 },
  { 1649, 12, 13, 16, 2, -13 },
  { 1669, 13, 19, 16, 1, -19 },
  { 1700, 12, 13, 16, 2, -13 },
  { 1720, 12, 19, 16, 2, -19 },
  { 1749, 13, 20, 16, 2, -15 },
  { 1782, 12, 19, 16, 2, -19 },
  { 1811, 11, 19, 16, 3, -19 },
  { 1838, 10, 24, 16, 2, -19 },
  { 1868, 13, 19, 16, 2, -19 },
  { 1899, 12, 19, 16, 2, -19 },
  { 1928, 13, 13, 16, 1, -13 },
  { 1950, 12, 13, 16, 2, -13 },
  { 1970, 13, 13, 16, 1, -13 },
  { 1992, 12, 18, 16, 2, -13 },
  { 2019, 13, 18, 16, 1, -13 },
  { 2049, 13, 13, 16, 2, -13 },
  { 2071, 12, 13, 16, 2, -13 },
  { 2091, 13, 18, 16, 1, -18 },
  { 2121, 11, 13, 16, 2, -13 },
  { 2139, 13, 13, 16, 1, -13 },
  { 2161, 14, 13, 16, 1, -13 },
  { 2184, 13, 13, 16, 1, -13 },
  { 2206, 14, 18, 16, 1, -13 },
  { 2238, 12, 13, 16, 2, -13 },
  { 2258, 10, 24, 16, 3, -20 },
  { 2288, 2, 24, 16, 7, -20 },
  { 2294, 10, 24, 16, 3, -20 },
  { 2324, 13, 6, 16, 1, -11 },
};

const GFXfont IBMPlexMono_Medium26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_MEDIUM26PT7B_H_
