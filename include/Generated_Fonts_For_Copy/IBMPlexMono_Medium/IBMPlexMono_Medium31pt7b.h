#ifndef _IBMPLEXMONO_MEDIUM31PT7B_H_
#define _IBMPLEXMONO_MEDIUM31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium31pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x73, 0x98, 0xC6, 0x10, 0x00, 0x07,
  0xBF, 0xFF, 0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0x80, 0x01, 0xC7, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x83, 0xF8, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0xC1, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x3F, 0x8F, 0xEF, 0xE3, 0xFB,
  0xF8, 0xFE, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x31, 0xC0, 0x1C,
  0x70, 0x07, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFE, 0x3D, 0xDF, 0x79, 0xC6, 0x71, 0xC0, 0x71, 0xC0,
  0x79, 0xC0, 0x7D, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x01, 0xCF, 0x01, 0xC7, 0x01, 0xC7, 0x21, 0xC7, 0x71, 0xC7, 0xFD, 0xDF,
  0x7F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x1E, 0x01, 0xCF, 0xE0, 0x77, 0xF8, 0x39, 0xC7, 0x0E, 0xE1, 0xC7, 0x38,
  0x71, 0xC6, 0x1C, 0xE1, 0xC7, 0x38, 0x7F, 0x9C, 0x0F, 0xE7, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x07, 0x3F, 0x83, 0x9F, 0xF0, 0xE7, 0x1C, 0x71, 0x83,
  0x1C, 0x60, 0xC6, 0x18, 0x73, 0x87, 0x1C, 0xC1, 0xFF, 0x70, 0x3F, 0xB8,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0x8F, 0x03, 0x83,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x07, 0xCF,
  0xC3, 0xEF, 0xF1, 0xF7, 0x78, 0xC7, 0x1E, 0x63, 0x87, 0xF1, 0xC1, 0xF8,
  0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x1F, 0x0F, 0xFB, 0xC7, 0xFC, 0xF0, 0xF8,
  0x3C, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x83, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41,
  0xC1, 0x79, 0xCF, 0xFF, 0xFF, 0x3F, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x38, 0x18, 0x08, 0x10, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x7D, 0xF7, 0x9E, 0x79, 0xCF, 0x3C, 0xE3, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3C, 0x3E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07,
  0xF1, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF1, 0xC7, 0xF0, 0x07, 0x70, 0x07,
  0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x3C, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xDC, 0x03, 0xCE,
  0x03, 0xC7, 0x03, 0xC3, 0x80, 0x41, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDC, 0x07,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7C, 0x3E, 0x30, 0x1E, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x20, 0x0F, 0x70, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F,
  0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3B, 0xC0, 0x1D, 0xE0, 0x1C, 0xF0, 0x1C, 0x78, 0x0E, 0x3C, 0x0E, 0x1E,
  0x07, 0x0F, 0x07, 0x07, 0x87, 0x03, 0xC3, 0x81, 0xE3, 0x80, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x73, 0xE0, 0xEF, 0xF1, 0xBF, 0xF3, 0xC3,
  0xE3, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x20, 0x1E, 0xE0, 0x3B,
  0xE1, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x73,
  0xE1, 0xEF, 0xF3, 0xBF, 0xF7, 0xC1, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3D, 0xE0, 0xF3, 0xFF, 0xC3, 0xFF, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xDC,
  0x07, 0xB8, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x0E,
  0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x78, 0x0F,
  0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xFE,
  0x1F, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC1, 0xEF,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0xFB, 0xFF, 0xF3, 0xFD, 0xC3, 0xF3, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF7, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xF0, 0x79, 0xF7, 0xDF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xF7, 0x9E, 0x79, 0xCF, 0x3C,
  0xE3, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x00, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x78, 0x03, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x1E, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x9E, 0x1F, 0xF0, 0x3D, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x0F,
  0xC0, 0x7E, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x01, 0xB8, 0x7B, 0xF1,
  0xF7, 0xE7, 0xFF, 0x8E, 0x3F, 0x1C, 0x3E, 0x38, 0x7C, 0x70, 0xF8, 0xE1,
  0xF1, 0xC3, 0xE3, 0x87, 0xE7, 0xFF, 0xC7, 0xDF, 0x8F, 0xBF, 0x00, 0x07,
  0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x39, 0xE0,
  0x1C, 0xF0, 0x1E, 0x38, 0x0E, 0x1C, 0x07, 0x0F, 0x03, 0x83, 0x83, 0xC1,
  0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x78, 0x0E, 0x38, 0x07, 0x9C,
  0x03, 0xDE, 0x00, 0xEF, 0x00, 0x7F, 0x00, 0x3C, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73,
  0xFF, 0x8F, 0xFC, 0x3F, 0xFC, 0xE0, 0x7B, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x07,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x81, 0xEE, 0x03, 0xFC, 0x04,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x08, 0x70, 0x1E, 0xF0, 0x3D, 0xF0, 0xF1, 0xFF,
  0xC1, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x3E,
  0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x81,
  0xEE, 0x0F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE1, 0xF3, 0x81, 0xEF, 0x01, 0xDC, 0x04,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xEE,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0x78, 0x0E, 0xF0, 0x1C, 0xF0, 0xF9, 0xFF,
  0xF1, 0xFE, 0xE0, 0xF9, 0xC0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xE0, 0x3F, 0x83, 0xFE, 0x3E, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0xF0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1,
  0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFD,
  0xE0, 0xFD, 0xE0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x8D, 0xFB, 0x3B, 0xF7,
  0x77, 0xEE, 0xCF, 0xCF, 0x9F, 0x9E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x61,
  0xF8, 0x43, 0xF0, 0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xC0, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xB8, 0x7E, 0xE1, 0xFB, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x39, 0xF8,
  0xE7, 0xE3, 0x9F, 0x87, 0x7E, 0x1D, 0xF8, 0x77, 0xE0, 0xFF, 0x83, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70,
  0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x1F, 0xFC, 0x0F,
  0xF8, 0x07, 0xE0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xE3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F,
  0x70, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7E, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xC3, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x07, 0x38,
  0x1E, 0xE0, 0x3F, 0x80, 0xF0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C,
  0x1F, 0x78, 0x06, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x20, 0x0F, 0x70, 0x0F, 0xFC, 0x1E, 0x7F, 0xFE, 0x1F, 0xFC, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x87, 0xDF, 0xFE, 0x3F,
  0xF0, 0x3F, 0x80, 0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x01, 0xCE, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E,
  0x07, 0x0F, 0x03, 0x87, 0x81, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x1C,
  0xF0, 0x0F, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x0E, 0x1B, 0x8F, 0x1D, 0xC7, 0xCE, 0xE3, 0xE7, 0x71, 0xB3, 0x98,
  0xD9, 0xCE, 0xEC, 0xE7, 0x76, 0x73, 0xB3, 0xB9, 0xD9, 0xDC, 0xEC, 0x6E,
  0x76, 0x37, 0x3F, 0x1B, 0x9F, 0x8F, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE0,
  0xF0, 0xF0, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0x87, 0x83, 0xC1, 0xC3, 0xC0,
  0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3D, 0xE0, 0x3C, 0xF0, 0x1C,
  0x3C, 0x1E, 0x0E, 0x0E, 0x07, 0x8F, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x3C,
  0xF8, 0x03, 0xDE, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E,
  0x70, 0x0E, 0x38, 0x1C, 0x3C, 0x1C, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70,
  0x0F, 0xF0, 0x07, 0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x21,
  0xCF, 0x1E, 0x38, 0x70, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0x83,
  0xC2, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3,
  0xC0, 0xE7, 0x01, 0xCF, 0x07, 0x9F, 0xFF, 0xDF, 0xE7, 0x8F, 0x8F, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x79, 0xF0, 0xF7, 0xF9, 0xFF, 0xFB, 0xE0, 0xF7, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1,
  0xEF, 0xFF, 0xDE, 0xFF, 0x3C, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF,
  0x9F, 0x0F, 0x78, 0x19, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x01, 0x1E, 0x07, 0x7C, 0x3C, 0xFF, 0xE1, 0xFF, 0x01, 0xF8, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC7,
  0xC7, 0x3F, 0xDD, 0xFF, 0x7F, 0x87, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xFE, 0x1F, 0x7F, 0xDC,
  0xFF, 0x71, 0xF1, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xEF,
  0x01, 0xDC, 0x03, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x47, 0x83, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x0F,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF8, 0x78, 0x78, 0x70, 0x3C, 0x70, 0x3C,
  0x70, 0x3C, 0x78, 0x78, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x70, 0x00,
  0x70, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFE, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xF0, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x78, 0xEF, 0xF7, 0x7F,
  0xBC, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0xFF, 0xDF, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3B, 0xFF, 0x7F, 0xEF, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x1E, 0xE0, 0x79,
  0xC1, 0xE3, 0x87, 0x87, 0x1E, 0x0E, 0x78, 0x1D, 0xE0, 0x3F, 0xE0, 0x7D,
  0xC0, 0xF3, 0xC1, 0xC3, 0xC3, 0x83, 0xC7, 0x07, 0x8E, 0x07, 0x9C, 0x07,
  0xB8, 0x07, 0x80, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7, 0x1E, 0xEF, 0xBF,
  0xEF, 0xBF, 0xF3, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7,
  0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7,
  0xE1, 0xC7, 0xE1, 0xC7, 0xE3, 0xC7, 0x7F, 0xBB, 0xFD, 0xE1, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3,
  0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xE7, 0x83, 0xCF, 0xFF, 0x0F, 0xFC, 0x07, 0xE0,
  0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xC1, 0xEF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83,
  0xDF, 0xFF, 0xBD, 0xFE, 0x79, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x1C, 0xFF, 0x77, 0xFD, 0xFE,
  0x1F, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0x73, 0xFD, 0xC7, 0xC7, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xFF, 0x1F, 0xFE,
  0x7F, 0xFD, 0xF8, 0x3A, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x1F, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0xDE, 0x0E, 0x70, 0x01,
  0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xD0, 0x07,
  0xF0, 0x3F, 0xFF, 0xF7, 0xFF, 0x83, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x0F, 0x78, 0x7D,
  0xFF, 0x73, 0xFD, 0xC7, 0xC7, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x0E, 0x38,
  0x0E, 0x38, 0x1E, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0xE1, 0xC3, 0xF1, 0xE1, 0xF8, 0xF0, 0xFC, 0x7C, 0x7E, 0x36, 0x37,
  0x1B, 0x19, 0x8D, 0x9C, 0xCE, 0xCE, 0x76, 0x77, 0x3B, 0x3B, 0x9D, 0x8D,
  0xCE, 0xC6, 0xC7, 0xE3, 0x61, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x78,
  0x0F, 0x3C, 0x1E, 0x3C, 0x1C, 0x1E, 0x38, 0x0F, 0x78, 0x07, 0xF0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1C,
  0x3C, 0x3C, 0x1C, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0x70, 0x0F, 0x78,
  0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x3C, 0x1C, 0x1C, 0x3C, 0x1E, 0x38, 0x0E,
  0x38, 0x0E, 0x78, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x0F, 0xF0, 0x7E, 0x03, 0xFC, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xFF, 0x80, 0xFC, 0x3F, 0xE3, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x87, 0xFC, 0x3F, 0xC1,
  0xFE, 0x00, 0x1E, 0x03, 0x3F, 0x07, 0x3F, 0x87, 0x73, 0xC7, 0x71, 0xCE,
  0x60, 0xFE, 0x60, 0xFC, 0xE0, 0x38,
};

const GFXglyph IBMPlexMono_Medium31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 22, 19, 7, -22 },
  { 15, 9, 9, 19, 5, -23 },
  { 26, 18, 22, 19, 0, -22 },
  { 76, 16, 28, 19, 1, -25 },
  { 132, 18, 22, 19, 0, -22 },
  { 182, 17, 22, 19, 1, -22 },
  { 229, 3, 9, 19, 8, -23 },
  { 233, 10, 28, 19, 6, -24 },
  { 268, 10, 28, 19, 3, -24 },
  { 303, 16, 16, 19, 1, -17 },
  { 335, 15, 15, 19, 2, -17 },
  { 364, 6, 10, 19, 6, -5 },
  { 372, 9, 3, 19, 5, -11 },
  { 376, 5, 5, 19, 7, -5 },
  { 380, 13, 28, 19, 3, -24 },
  { 426, 16, 22, 19, 1, -22 },
  { 470, 17, 22, 19, 1, -22 },
  { 517, 15, 22, 19, 2, -22 },
  { 559, 16, 22, 19, 1, -22 },
  { 603, 17, 22, 19, 1, -22 },
  { 650, 15, 22, 19, 2, -22 },
  { 692, 15, 22, 19, 2, -22 },
  { 734, 15, 22, 19, 2, -22 },
  { 776, 16, 22, 19, 1, -22 },
  { 820, 15, 22, 19, 2, -22 },
  { 862, 5, 17, 19, 7, -17 },
  { 873, 6, 22, 19, 6, -17 },
  { 890, 13, 18, 19, 3, -18 },
  { 920, 15, 9, 19, 2, -14 },
  { 937, 13, 18, 19, 3, -18 },
  { 967, 14, 22, 19, 2, -22 },
  { 1006, 15, 25, 19, 2, -22 },
  { 1053, 17, 22, 19, 1, -22 },
  { 1100, 14, 22, 19, 3, -22 },
  { 1139, 15, 22, 19, 2, -22 },
  { 1181, 14, 22, 19, 3, -22 },
  { 1220, 13, 22, 19, 3, -22 },
  { 1256, 14, 22, 19, 3, -22 },
  { 1295, 15, 22, 19, 1, -22 },
  { 1337, 14, 22, 19, 2, -22 },
  { 1376, 14, 22, 19, 2, -22 },
  { 1415, 13, 22, 19, 2, -22 },
  { 1451, 16, 22, 19, 2, -22 },
  { 1495, 14, 22, 19, 3, -22 },
  { 1534, 15, 22, 19, 2, -22 },
  { 1576, 14, 22, 19, 2, -22 },
  { 1615, 16, 22, 19, 1, -22 },
  { 1659, 14, 22, 19, 3, -22 },
  { 1698, 16, 28, 19, 1, -22 },
  { 1754, 14, 22, 19, 3, -22 },
  { 1793, 16, 22, 19, 1, -22 },
  { 1837, 17, 22, 19, 1, -22 },
  { 1884, 14, 22, 19, 2, -22 },
  { 1923, 17, 22, 19, 1, -22 },
  { 1970, 17, 22, 19, 1, -22 },
  { 2017, 17, 22, 19, 1, -22 },
  { 2064, 18, 22, 19, 0, -22 },
  { 2114, 16, 22, 19, 1, -22 },
  { 2158, 10, 28, 19, 6, -24 },
  { 2193, 13, 28, 19, 3, -24 },
  { 2239, 9, 28, 19, 3, -24 },
  { 2271, 16, 13, 19, 1, -22 },
  { 2297, 15, 3, 19, 2, 3 },
  { 2303, 6, 7, 19, 5, -25 },
  { 2309, 15, 16, 19, 2, -16 },
  { 2339, 15, 23, 19, 2, -23 },
  { 2383, 14, 16, 19, 2, -16 },
  { 2411, 14, 23, 19, 2, -23 },
  { 2452, 15, 16, 19, 2, -16 },
  { 2482, 15, 23, 19, 2, -23 },
  { 2526, 16, 25, 19, 2, -19 },
  { 2576, 13, 23, 19, 3, -23 },
  { 2614, 14, 23, 19, 3, -23 },
  { 2655, 11, 29, 19, 3, -23 },
  { 2695, 15, 23, 19, 3, -23 },
  { 2739, 14, 23, 19, 2, -23 },
  { 2780, 16, 16, 19, 1, -16 },
  { 2812, 13, 16, 19, 3, -16 },
  { 2838, 15, 16, 19, 2, -16 },
  { 2868, 15, 22, 19, 2, -16 },
  { 2910, 14, 22, 19, 2, -16 },
  { 2949, 15, 16, 19, 2, -16 },
  { 2979, 14, 16, 19, 2, -16 },
  { 3007, 15, 22, 19, 1, -22 },
  { 3049, 14, 16, 19, 2, -16 },
  { 3077, 16, 16, 19, 1, -16 },
  { 3109, 17, 16, 19, 1, -16 },
  { 3143, 16, 16, 19, 1, -16 },
  { 3175, 16, 22, 19, 1, -16 },
  { 3219, 14, 16, 19, 2, -16 },
  { 3247, 13, 28, 19, 3, -24 },
  { 3293, 3, 28, 19, 8, -24 },
  { 3304, 13, 28, 19, 3, -24 },
  { 3350, 16, 8, 19, 1, -13 },
};

const GFXfont IBMPlexMono_Medium31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_MEDIUM31PT7B_H_
