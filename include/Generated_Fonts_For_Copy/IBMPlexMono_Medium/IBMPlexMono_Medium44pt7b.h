#ifndef _IBMPLEXMONO_MEDIUM44PT7B_H_
#define _IBMPLEXMONO_MEDIUM44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium44pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x3F, 0xF0,
  0xFF, 0xDF, 0xF8, 0x7F, 0xEF, 0xFC, 0x3F, 0xF7, 0xFE, 0x1F, 0xF8, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x3F, 0xF0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x7F, 0xE7,
  0xFC, 0x3F, 0xF0, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7E, 0x73, 0xF9,
  0xF8, 0xE1, 0xE3, 0xE1, 0xC1, 0x87, 0xC3, 0x80, 0x0F, 0x87, 0x00, 0x1F,
  0x0E, 0x00, 0x3E, 0x1C, 0x00, 0x7E, 0x38, 0x00, 0x7F, 0x70, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1C, 0x7E, 0x00, 0x38, 0x7C, 0x00, 0x70, 0x78, 0x00, 0xE0,
  0xF8, 0x01, 0xC1, 0xF1, 0x03, 0x83, 0xCE, 0x07, 0x0F, 0xBF, 0x0E, 0x1F,
  0x7F, 0x9C, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0xC0, 0x03, 0xC7, 0xFC, 0x01, 0xE3, 0xFF, 0x80, 0x78,
  0xFF, 0xE0, 0x3C, 0x78, 0x7C, 0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x03, 0xC1,
  0xE1, 0xC0, 0xF0, 0xF0, 0x70, 0x3C, 0x3C, 0x1C, 0x0F, 0x1E, 0x07, 0x83,
  0xC7, 0x81, 0xE1, 0xF3, 0xC0, 0x7F, 0xF8, 0xF0, 0x0F, 0xFE, 0x78, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x1E, 0x3F, 0xF0, 0x07, 0x9F, 0xFE, 0x03, 0xC7, 0x87, 0x80, 0xE1,
  0xC0, 0xE0, 0x78, 0xF0, 0x3C, 0x3C, 0x3C, 0x0F, 0x0F, 0x0F, 0x03, 0xC7,
  0x83, 0xC0, 0xF1, 0xE0, 0x70, 0x3C, 0xF0, 0x1E, 0x1E, 0x3C, 0x07, 0xFF,
  0x9E, 0x00, 0xFF, 0xC7, 0x80, 0x1F, 0xE2, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x04, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x1F, 0xF0, 0x7F, 0x1F, 0x7C, 0x3F, 0x9F, 0x3F, 0x1E, 0x0F, 0x0F, 0xCF,
  0x0F, 0x83, 0xE7, 0x07, 0xC0, 0xFB, 0x83, 0xE0, 0x3F, 0xC1, 0xF0, 0x0F,
  0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC1,
  0xDF, 0x87, 0xFF, 0xE7, 0xC1, 0xFF, 0xE1, 0xF0, 0x7F, 0xE0, 0x7C, 0x0F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x10, 0x1E, 0x03, 0x7C,
  0x3C, 0x3E, 0xFF, 0x7B, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xF7,
  0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xE0, 0x1E, 0x00, 0x80, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xCF, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xF0, 0xF8,
  0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xE1, 0xFF,
  0x87, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE1, 0xF1, 0xFF, 0x87,
  0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x8F,
  0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x3F, 0x1F, 0x00,
  0xFC, 0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xC0, 0xF8, 0x01, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF1, 0xF8, 0x07, 0xC7,
  0xC0, 0x1F, 0xBE, 0x00, 0x3E, 0x08, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xF0, 0xF0,
  0x07, 0xE1, 0x80, 0x1F, 0x84, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x30, 0x00, 0xF9, 0xE0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF,
  0x81, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x79,
  0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xC1,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0xE0, 0x3C, 0xFF, 0xC1, 0xEF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x07, 0xF3, 0xE0, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x30, 0x00, 0xFB, 0x80, 0x0F, 0xBE, 0x00, 0xFD, 0xFC, 0x0F, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x01, 0xF3, 0xFF,
  0x07, 0xDF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x83, 0xFB, 0xF8, 0x03, 0xEF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80,
  0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF3, 0xE0, 0x0F,
  0x8F, 0xC0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x7C, 0xF0,
  0x03, 0xE7, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0x03, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x7C, 0x00,
  0x79, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3C, 0x1F, 0x03, 0xF0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0xFC,
  0x0F, 0xC7, 0xE0, 0x0F, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF7,
  0xE0, 0x0F, 0xDF, 0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xDF,
  0x3F, 0xFF, 0x7C, 0x7F, 0xFB, 0xE0, 0xFF, 0xCF, 0x80, 0xFC, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x1F, 0x0F, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xCF, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xE7, 0xC0, 0x3E,
  0xF8, 0x03, 0xF3, 0x80, 0x1F, 0x10, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0x83, 0xF0, 0xF8, 0x03, 0xE3, 0xC0, 0x07, 0x9F, 0x00,
  0x1E, 0x78, 0x00, 0x39, 0xE0, 0x7C, 0xF7, 0x83, 0xFB, 0xDC, 0x1F, 0xEF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xE1, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0,
  0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0,
  0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x07, 0xDC, 0x3F, 0xFF, 0x70, 0x7F, 0xBD,
  0xE1, 0xFE, 0xF7, 0x83, 0xF3, 0xDE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE7, 0xC0, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x0F, 0xCF, 0x00, 0x7E, 0xF0, 0x03,
  0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00,
  0x7C, 0xF0, 0x0F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF8, 0x7F, 0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00,
  0x47, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x08, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x7C,
  0x7F, 0x0F, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0,
  0x1F, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xFC, 0xF8, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0x63, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0xFB, 0xF0, 0x07, 0xCF,
  0xC0, 0x7E, 0x7F, 0x06, 0xF1, 0xFF, 0xF7, 0x87, 0xFF, 0x3C, 0x1F, 0xF1,
  0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFB, 0xF0, 0x1F, 0x3F, 0x0F, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0xC0, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7,
  0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC7,
  0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFC, 0xFC, 0x07, 0xF1, 0xF8,
  0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0,
  0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xEF, 0xFB, 0xC7, 0xBF,
  0xEF, 0x1C, 0xFF, 0xBC, 0xF3, 0xFE, 0x7B, 0xCF, 0xF9, 0xEE, 0x3F, 0xE3,
  0xF8, 0xFF, 0x8F, 0xC3, 0xFE, 0x3F, 0x0F, 0xF8, 0x7C, 0x3F, 0xE1, 0xE0,
  0xFF, 0x87, 0x83, 0xFE, 0x0E, 0x0F, 0xF8, 0x30, 0x3F, 0xE0, 0x40, 0xFF,
  0x82, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xC0, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x78, 0x0F, 0xF7, 0xC0, 0xFF,
  0x3C, 0x0F, 0xF3, 0xC0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1F, 0x0F,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF8, 0xFF, 0x07, 0x8F, 0xF0, 0x78,
  0xFF, 0x03, 0xCF, 0xF0, 0x3C, 0xFF, 0x03, 0xEF, 0xF0, 0x1E, 0xFF, 0x01,
  0xEF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xF0, 0xF8, 0x07, 0xE7,
  0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xE0, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xF8, 0x07, 0xEF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xF0, 0xF8, 0x07, 0xE7, 0xE0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x7C,
  0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0x80, 0x3F, 0x7C, 0x03, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFB,
  0xE0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0x01, 0xFD, 0xF8, 0x01, 0xE7, 0xC0, 0x03, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x20, 0x00, 0x7D,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7,
  0xF0, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xC0,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xE0,
  0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0,
  0x01, 0xF7, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x3E, 0x0F,
  0x78, 0x7E, 0x0F, 0x78, 0x7E, 0x1F, 0x78, 0x7F, 0x1E, 0x78, 0x7F, 0x1E,
  0x78, 0x77, 0x1E, 0x78, 0xF7, 0x1E, 0x78, 0xF7, 0x1E, 0x78, 0xE7, 0x1E,
  0x78, 0xE7, 0x9E, 0x7C, 0xE7, 0x9E, 0x7C, 0xE3, 0x9E, 0x3D, 0xE3, 0x9E,
  0x3D, 0xE3, 0x9E, 0x3D, 0xC3, 0xDE, 0x3D, 0xC3, 0xDE, 0x3D, 0xC3, 0xDE,
  0x3F, 0xC1, 0xDE, 0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE3, 0xE0, 0x01, 0xF3,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF8,
  0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0xC7, 0xE0, 0x03,
  0xE3, 0xE0, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF8,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF0,
  0x0F, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1F, 0x1F, 0x00, 0x1E, 0x3C, 0x00,
  0x3E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7C, 0xC0, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0xF8, 0xF8,
  0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x0C, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC1, 0xE0, 0x1F, 0x03, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7F, 0xFE,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xC0, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x03,
  0xFF, 0xFF, 0xFD, 0xFD, 0xFF, 0xE7, 0xF3, 0xFF, 0x0F, 0xC3, 0xF0, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x81, 0xF1, 0xFF, 0x0F, 0x9F, 0xFC, 0x7D, 0xFF,
  0xF3, 0xFC, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xEF, 0xC0, 0x3F, 0x7F, 0x83, 0xFB, 0xEF, 0xFF, 0x9F, 0x3F, 0xF8,
  0xF8, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x07, 0xE3, 0xE0, 0x1F, 0x7C, 0x00, 0xC7,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x87, 0xC0, 0x0C, 0x3E, 0x01, 0xF3, 0xF0, 0x3F, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x3E, 0x1F,
  0xF9, 0xF1, 0xFF, 0xEF, 0x9F, 0xFF, 0x7C, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x9F, 0x81,
  0xFC, 0xFF, 0xFB, 0xE3, 0xFF, 0xDF, 0x0F, 0xFC, 0xF8, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0,
  0x7E, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x83, 0xE0, 0x06, 0x1F,
  0x00, 0x78, 0x7E, 0x07, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x9E, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x78,
  0xFF, 0x8F, 0x3F, 0xF9, 0xEF, 0xFF, 0xBD, 0x83, 0xF7, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0xBE, 0x01, 0xF8,
  0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x1F, 0x80, 0xF8,
  0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x1F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xFC, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xE1, 0xF3,
  0xDF, 0xCF, 0xEF, 0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF,
  0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07,
  0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83,
  0xC0, 0xF0, 0x7C, 0x1E, 0x3F, 0xE3, 0xCF, 0xFE, 0x7B, 0xFF, 0xEF, 0x60,
  0xFD, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xF0, 0xF8, 0x07,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xE3, 0xE0, 0x1F,
  0x8F, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x80, 0xF8, 0x3E, 0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF1, 0xF7, 0xFF,
  0xCF, 0xF0, 0x7F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xBF, 0x00, 0xFD, 0xFE, 0x0F, 0xEF, 0xBF, 0xFE, 0x7C, 0xFF, 0xE3,
  0xE3, 0xFE, 0x1F, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0xF8, 0x7F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F, 0xFD,
  0xF3, 0xF0, 0x3F, 0xBF, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x80, 0x7E, 0x7E, 0x07, 0xF3, 0xFF, 0xEF, 0x8F, 0xFF, 0x7C,
  0x3F, 0xF3, 0xE0, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0x03, 0xEE, 0x00, 0x0F, 0xA0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x7E, 0x03, 0xE7, 0xC0, 0x0C, 0x7C, 0x00, 0x87,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF2, 0x00, 0x1F, 0x78, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x03, 0xF7, 0xF0, 0xFF, 0x3F, 0xFD, 0xF3, 0xFF, 0x9F, 0x1F,
  0xF1, 0xF0, 0x7E, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x07,
  0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xE0,
  0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x3E, 0x07, 0xF8,
  0x1F, 0x07, 0xBC, 0x1F, 0x83, 0xDE, 0x0F, 0xC1, 0xE7, 0x07, 0xE0, 0xF3,
  0xC3, 0xF8, 0x79, 0xE1, 0xDC, 0x3C, 0xF0, 0xEE, 0x1E, 0x78, 0xE7, 0x0E,
  0x3C, 0x73, 0x8F, 0x1E, 0x39, 0xC7, 0x8F, 0x1C, 0x73, 0xC3, 0x8E, 0x39,
  0xE1, 0xE7, 0x1C, 0xF0, 0xF7, 0x0E, 0x78, 0x7B, 0x87, 0x38, 0x3D, 0xC3,
  0xDC, 0x1E, 0xE0, 0xEE, 0x0F, 0x70, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x7D, 0xF8,
  0x03, 0xE3, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xE0, 0x3F, 0x1F,
  0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x3E, 0x1F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC0, 0xFC, 0x3E, 0x01, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xC0,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xEF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0x80,
  0x18, 0x7F, 0x80, 0x73, 0xFF, 0x03, 0xCF, 0xFE, 0x0F, 0x78, 0xF8, 0x3D,
  0xE1, 0xF1, 0xE7, 0x03, 0xFF, 0xBC, 0x07, 0xFC, 0xF0, 0x0F, 0xE1, 0xC0,
  0x1F, 0x00,
};

const GFXglyph IBMPlexMono_Medium44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 31, 26, 9, -31 },
  { 32, 13, 13, 26, 7, -33 },
  { 54, 25, 31, 26, 1, -31 },
  { 151, 23, 40, 26, 2, -36 },
  { 266, 26, 32, 26, 0, -31 },
  { 370, 25, 32, 26, 1, -31 },
  { 470, 4, 13, 26, 11, -33 },
  { 477, 14, 39, 26, 8, -33 },
  { 546, 14, 39, 26, 4, -33 },
  { 615, 23, 22, 26, 2, -24 },
  { 679, 21, 22, 26, 3, -24 },
  { 737, 10, 13, 26, 8, -7 },
  { 754, 13, 4, 26, 7, -15 },
  { 761, 8, 7, 26, 9, -7 },
  { 768, 19, 39, 26, 4, -33 },
  { 861, 22, 32, 26, 2, -31 },
  { 949, 23, 31, 26, 2, -31 },
  { 1039, 22, 31, 26, 2, -31 },
  { 1125, 22, 32, 26, 2, -31 },
  { 1213, 24, 31, 26, 1, -31 },
  { 1306, 21, 32, 26, 3, -31 },
  { 1390, 22, 32, 26, 2, -31 },
  { 1478, 21, 31, 26, 3, -31 },
  { 1560, 22, 32, 26, 2, -31 },
  { 1648, 22, 31, 26, 2, -31 },
  { 1734, 8, 23, 26, 9, -23 },
  { 1757, 10, 29, 26, 8, -23 },
  { 1794, 19, 26, 26, 4, -26 },
  { 1856, 21, 13, 26, 3, -20 },
  { 1891, 19, 26, 26, 4, -26 },
  { 1953, 20, 31, 26, 3, -31 },
  { 2031, 22, 36, 26, 2, -31 },
  { 2130, 25, 31, 26, 1, -31 },
  { 2227, 20, 31, 26, 4, -31 },
  { 2305, 21, 32, 26, 3, -31 },
  { 2389, 20, 31, 26, 4, -31 },
  { 2467, 19, 31, 26, 4, -31 },
  { 2541, 20, 31, 26, 4, -31 },
  { 2619, 21, 32, 26, 2, -31 },
  { 2703, 20, 31, 26, 3, -31 },
  { 2781, 19, 31, 26, 4, -31 },
  { 2855, 19, 32, 26, 3, -31 },
  { 2931, 23, 31, 26, 3, -31 },
  { 3021, 19, 31, 26, 5, -31 },
  { 3095, 22, 31, 26, 2, -31 },
  { 3181, 20, 31, 26, 3, -31 },
  { 3259, 22, 32, 26, 2, -31 },
  { 3347, 20, 31, 26, 4, -31 },
  { 3425, 22, 39, 26, 2, -31 },
  { 3533, 21, 31, 26, 4, -31 },
  { 3615, 22, 32, 26, 2, -31 },
  { 3703, 24, 31, 26, 1, -31 },
  { 3796, 20, 32, 26, 3, -31 },
  { 3876, 24, 31, 26, 1, -31 },
  { 3969, 24, 31, 26, 1, -31 },
  { 4062, 25, 31, 26, 1, -31 },
  { 4159, 25, 31, 26, 1, -31 },
  { 4256, 22, 31, 26, 2, -31 },
  { 4342, 13, 39, 26, 9, -33 },
  { 4406, 19, 39, 26, 4, -33 },
  { 4499, 13, 39, 26, 4, -33 },
  { 4563, 23, 19, 26, 2, -31 },
  { 4618, 21, 4, 26, 3, 4 },
  { 4629, 8, 9, 26, 8, -34 },
  { 4638, 22, 24, 26, 3, -23 },
  { 4704, 21, 34, 26, 3, -33 },
  { 4794, 20, 24, 26, 3, -23 },
  { 4854, 21, 34, 26, 2, -33 },
  { 4944, 21, 24, 26, 3, -23 },
  { 5007, 21, 33, 26, 3, -33 },
  { 5094, 22, 36, 26, 3, -27 },
  { 5193, 19, 33, 26, 4, -33 },
  { 5272, 20, 33, 26, 4, -33 },
  { 5355, 16, 42, 26, 4, -33 },
  { 5439, 22, 33, 26, 4, -33 },
  { 5530, 20, 33, 26, 3, -33 },
  { 5613, 22, 23, 26, 2, -23 },
  { 5677, 19, 23, 26, 4, -23 },
  { 5732, 22, 24, 26, 2, -23 },
  { 5798, 21, 32, 26, 3, -23 },
  { 5882, 21, 32, 26, 2, -23 },
  { 5966, 22, 23, 26, 3, -23 },
  { 6030, 20, 24, 26, 3, -23 },
  { 6090, 21, 31, 26, 2, -31 },
  { 6172, 20, 24, 26, 3, -23 },
  { 6232, 22, 23, 26, 2, -23 },
  { 6296, 25, 23, 26, 1, -23 },
  { 6368, 22, 23, 26, 2, -23 },
  { 6432, 23, 32, 26, 2, -23 },
  { 6524, 20, 23, 26, 3, -23 },
  { 6582, 18, 39, 26, 4, -33 },
  { 6670, 4, 39, 26, 11, -33 },
  { 6690, 18, 39, 26, 4, -33 },
  { 6778, 22, 10, 26, 2, -19 },
};

const GFXfont IBMPlexMono_Medium44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_MEDIUM44PT7B_H_
